N 9000 -6630 9010 -6620 {
lab=row_n[30]}
N 9000 -6410 9000 -6390 {
lab=row_n[30]}
N 9000 -6650 9000 -6630 {
lab=row_n[30]}
N 8880 -6550 8890 -6560 {
lab=col_n[21]}
N 8890 -6560 9090 -6560 {
lab=col_n[21]}
N 9090 -6560 9100 -6550 {
lab=col_n[21]}
N 8880 -6530 8890 -6540 {
lab=colon_n[21]}
N 8890 -6540 9090 -6540 {
lab=colon_n[21]}
N 9090 -6540 9100 -6530 {
lab=colon_n[21]}
N 8880 -6510 8890 -6520 {
lab=#net43}
N 8890 -6520 9090 -6520 {
lab=#net43}
N 9090 -6520 9100 -6510 {
lab=#net43}
N 8880 -6490 8890 -6500 {
lab=#net44}
N 8890 -6500 9090 -6500 {
lab=#net44}
N 9090 -6500 9100 -6490 {
lab=#net44}
N 8940 -6650 8940 -6630 {
lab=vcom}
N 8980 -6650 8980 -6630 {
lab=ctop}
N 8860 -6550 8880 -6550 {
lab=col_n[21]}
N 8860 -6530 8880 -6530 {
lab=colon_n[21]}
N 8860 -6510 8880 -6510 {
lab=#net43}
N 8860 -6490 8880 -6490 {
lab=#net44}
N 9100 -6490 9120 -6490 {
lab=#net44}
N 9100 -6510 9120 -6510 {
lab=#net43}
N 9100 -6530 9120 -6530 {
lab=colon_n[21]}
N 9100 -6550 9120 -6550 {
lab=col_n[21]}
N 8920 -6410 8920 -6400 {
lab=VSS}
N 8920 -6640 8920 -6630 {
lab=VDD}
N 9260 -6410 9270 -6420 {
lab=row_n[31]}
N 9270 -6620 9270 -6420 {
lab=row_n[31]}
N 9260 -6630 9270 -6620 {
lab=row_n[31]}
N 9260 -6410 9260 -6390 {
lab=row_n[31]}
N 9260 -6650 9260 -6630 {
lab=row_n[31]}
N 9140 -6550 9150 -6560 {
lab=col_n[21]}
N 9150 -6560 9350 -6560 {
lab=col_n[21]}
N 9350 -6560 9360 -6550 {
lab=col_n[21]}
N 9140 -6530 9150 -6540 {
lab=colon_n[21]}
N 9150 -6540 9350 -6540 {
lab=colon_n[21]}
N 9350 -6540 9360 -6530 {
lab=colon_n[21]}
N 9140 -6510 9150 -6520 {
lab=#net43}
N 9150 -6520 9350 -6520 {
lab=#net43}
N 9350 -6520 9360 -6510 {
lab=#net43}
N 9140 -6490 9150 -6500 {
lab=#net44}
N 9150 -6500 9350 -6500 {
lab=#net44}
N 9350 -6500 9360 -6490 {
lab=#net44}
N 9200 -6650 9200 -6630 {
lab=vcom}
N 9240 -6650 9240 -6630 {
lab=ctop}
N 9120 -6550 9140 -6550 {
lab=col_n[21]}
N 9120 -6530 9140 -6530 {
lab=colon_n[21]}
N 9120 -6510 9140 -6510 {
lab=#net43}
N 9120 -6490 9140 -6490 {
lab=#net44}
N 9360 -6490 9380 -6490 {
lab=#net44}
N 9360 -6510 9380 -6510 {
lab=#net43}
N 9360 -6530 9380 -6530 {
lab=colon_n[21]}
N 9360 -6550 9380 -6550 {
lab=col_n[21]}
N 9180 -6410 9180 -6400 {
lab=VSS}
N 9180 -6640 9180 -6630 {
lab=VDD}
N 1200 -6670 1210 -6680 {
lab=row_n[0]}
N 1210 -6880 1210 -6680 {
lab=row_n[0]}
N 1200 -6890 1210 -6880 {
lab=row_n[0]}
N 1200 -6670 1200 -6650 {
lab=row_n[0]}
N 1200 -6910 1200 -6890 {
lab=row_n[0]}
N 1080 -6810 1090 -6820 {
lab=col_n[22]}
N 1090 -6820 1290 -6820 {
lab=col_n[22]}
N 1290 -6820 1300 -6810 {
lab=col_n[22]}
N 1080 -6790 1090 -6800 {
lab=colon_n[22]}
N 1090 -6800 1290 -6800 {
lab=colon_n[22]}
N 1290 -6800 1300 -6790 {
lab=colon_n[22]}
N 1080 -6770 1090 -6780 {
lab=#net45}
N 1090 -6780 1290 -6780 {
lab=#net45}
N 1290 -6780 1300 -6770 {
lab=#net45}
N 1080 -6750 1090 -6760 {
lab=#net46}
N 1090 -6760 1290 -6760 {
lab=#net46}
N 1290 -6760 1300 -6750 {
lab=#net46}
N 1140 -6910 1140 -6890 {
lab=vcom}
N 1180 -6910 1180 -6890 {
lab=ctop}
N 1060 -6810 1080 -6810 {
lab=col_n[22]}
N 1060 -6790 1080 -6790 {
lab=colon_n[22]}
N 1060 -6770 1080 -6770 {
lab=#net45}
N 1060 -6750 1080 -6750 {
lab=#net46}
N 1300 -6750 1320 -6750 {
lab=#net46}
N 1300 -6770 1320 -6770 {
lab=#net45}
N 1300 -6790 1320 -6790 {
lab=colon_n[22]}
N 1300 -6810 1320 -6810 {
lab=col_n[22]}
N 1120 -6670 1120 -6660 {
lab=VSS}
N 1120 -6900 1120 -6890 {
lab=VDD}
N 1460 -6670 1470 -6680 {
lab=row_n[1]}
N 1470 -6880 1470 -6680 {
lab=row_n[1]}
N 1460 -6890 1470 -6880 {
lab=row_n[1]}
N 1460 -6670 1460 -6650 {
lab=row_n[1]}
N 1460 -6910 1460 -6890 {
lab=row_n[1]}
N 1340 -6810 1350 -6820 {
lab=col_n[22]}
N 1350 -6820 1550 -6820 {
lab=col_n[22]}
N 1550 -6820 1560 -6810 {
lab=col_n[22]}
N 1340 -6790 1350 -6800 {
lab=colon_n[22]}
N 1350 -6800 1550 -6800 {
lab=colon_n[22]}
N 1550 -6800 1560 -6790 {
lab=colon_n[22]}
N 1340 -6770 1350 -6780 {
lab=#net45}
N 1350 -6780 1550 -6780 {
lab=#net45}
N 1550 -6780 1560 -6770 {
lab=#net45}
N 1340 -6750 1350 -6760 {
lab=#net46}
N 1350 -6760 1550 -6760 {
lab=#net46}
N 1550 -6760 1560 -6750 {
lab=#net46}
N 1400 -6910 1400 -6890 {
lab=vcom}
N 1440 -6910 1440 -6890 {
lab=ctop}
N 1320 -6810 1340 -6810 {
lab=col_n[22]}
N 1320 -6790 1340 -6790 {
lab=colon_n[22]}
N 1320 -6770 1340 -6770 {
lab=#net45}
N 1320 -6750 1340 -6750 {
lab=#net46}
N 1560 -6750 1580 -6750 {
lab=#net46}
N 1560 -6770 1580 -6770 {
lab=#net45}
N 1560 -6790 1580 -6790 {
lab=colon_n[22]}
N 1560 -6810 1580 -6810 {
lab=col_n[22]}
N 1380 -6670 1380 -6660 {
lab=VSS}
N 1380 -6900 1380 -6890 {
lab=VDD}
N 1720 -6670 1730 -6680 {
lab=row_n[2]}
N 1730 -6880 1730 -6680 {
lab=row_n[2]}
N 1720 -6890 1730 -6880 {
lab=row_n[2]}
N 1720 -6670 1720 -6650 {
lab=row_n[2]}
N 1720 -6910 1720 -6890 {
lab=row_n[2]}
N 1600 -6810 1610 -6820 {
lab=col_n[22]}
N 1610 -6820 1810 -6820 {
lab=col_n[22]}
N 1810 -6820 1820 -6810 {
lab=col_n[22]}
N 1600 -6790 1610 -6800 {
lab=colon_n[22]}
N 1610 -6800 1810 -6800 {
lab=colon_n[22]}
N 1810 -6800 1820 -6790 {
lab=colon_n[22]}
N 1600 -6770 1610 -6780 {
lab=#net45}
N 1610 -6780 1810 -6780 {
lab=#net45}
N 1810 -6780 1820 -6770 {
lab=#net45}
N 1600 -6750 1610 -6760 {
lab=#net46}
N 1610 -6760 1810 -6760 {
lab=#net46}
N 1810 -6760 1820 -6750 {
lab=#net46}
N 1660 -6910 1660 -6890 {
lab=vcom}
N 1700 -6910 1700 -6890 {
lab=ctop}
N 1580 -6810 1600 -6810 {
lab=col_n[22]}
N 1580 -6790 1600 -6790 {
lab=colon_n[22]}
N 1580 -6770 1600 -6770 {
lab=#net45}
N 1580 -6750 1600 -6750 {
lab=#net46}
N 1820 -6750 1840 -6750 {
lab=#net46}
N 1820 -6770 1840 -6770 {
lab=#net45}
N 1820 -6790 1840 -6790 {
lab=colon_n[22]}
N 1820 -6810 1840 -6810 {
lab=col_n[22]}
N 1640 -6670 1640 -6660 {
lab=VSS}
N 1640 -6900 1640 -6890 {
lab=VDD}
N 1980 -6670 1990 -6680 {
lab=row_n[3]}
N 1990 -6880 1990 -6680 {
lab=row_n[3]}
N 1980 -6890 1990 -6880 {
lab=row_n[3]}
N 1980 -6670 1980 -6650 {
lab=row_n[3]}
N 1980 -6910 1980 -6890 {
lab=row_n[3]}
N 1860 -6810 1870 -6820 {
lab=col_n[22]}
N 1870 -6820 2070 -6820 {
lab=col_n[22]}
N 2070 -6820 2080 -6810 {
lab=col_n[22]}
N 1860 -6790 1870 -6800 {
lab=colon_n[22]}
N 1870 -6800 2070 -6800 {
lab=colon_n[22]}
N 2070 -6800 2080 -6790 {
lab=colon_n[22]}
N 1860 -6770 1870 -6780 {
lab=#net45}
N 1870 -6780 2070 -6780 {
lab=#net45}
N 2070 -6780 2080 -6770 {
lab=#net45}
N 1860 -6750 1870 -6760 {
lab=#net46}
N 1870 -6760 2070 -6760 {
lab=#net46}
N 2070 -6760 2080 -6750 {
lab=#net46}
N 1920 -6910 1920 -6890 {
lab=vcom}
N 1960 -6910 1960 -6890 {
lab=ctop}
N 1840 -6810 1860 -6810 {
lab=col_n[22]}
N 1840 -6790 1860 -6790 {
lab=colon_n[22]}
N 1840 -6770 1860 -6770 {
lab=#net45}
N 1840 -6750 1860 -6750 {
lab=#net46}
N 2080 -6750 2100 -6750 {
lab=#net46}
N 2080 -6770 2100 -6770 {
lab=#net45}
N 2080 -6790 2100 -6790 {
lab=colon_n[22]}
N 2080 -6810 2100 -6810 {
lab=col_n[22]}
N 1900 -6670 1900 -6660 {
lab=VSS}
N 1900 -6900 1900 -6890 {
lab=VDD}
N 2240 -6670 2250 -6680 {
lab=row_n[4]}
N 2250 -6880 2250 -6680 {
lab=row_n[4]}
N 2240 -6890 2250 -6880 {
lab=row_n[4]}
N 2240 -6670 2240 -6650 {
lab=row_n[4]}
N 2240 -6910 2240 -6890 {
lab=row_n[4]}
N 2120 -6810 2130 -6820 {
lab=col_n[22]}
N 2130 -6820 2330 -6820 {
lab=col_n[22]}
N 2330 -6820 2340 -6810 {
lab=col_n[22]}
N 2120 -6790 2130 -6800 {
lab=colon_n[22]}
N 2130 -6800 2330 -6800 {
lab=colon_n[22]}
N 2330 -6800 2340 -6790 {
lab=colon_n[22]}
N 2120 -6770 2130 -6780 {
lab=#net45}
N 2130 -6780 2330 -6780 {
lab=#net45}
N 2330 -6780 2340 -6770 {
lab=#net45}
N 2120 -6750 2130 -6760 {
lab=#net46}
N 2130 -6760 2330 -6760 {
lab=#net46}
N 2330 -6760 2340 -6750 {
lab=#net46}
N 2180 -6910 2180 -6890 {
lab=vcom}
N 2220 -6910 2220 -6890 {
lab=ctop}
N 2100 -6810 2120 -6810 {
lab=col_n[22]}
N 2100 -6790 2120 -6790 {
lab=colon_n[22]}
N 2100 -6770 2120 -6770 {
lab=#net45}
N 2100 -6750 2120 -6750 {
lab=#net46}
N 2340 -6750 2360 -6750 {
lab=#net46}
N 2340 -6770 2360 -6770 {
lab=#net45}
N 2340 -6790 2360 -6790 {
lab=colon_n[22]}
N 2340 -6810 2360 -6810 {
lab=col_n[22]}
N 2160 -6670 2160 -6660 {
lab=VSS}
N 2160 -6900 2160 -6890 {
lab=VDD}
N 2500 -6670 2510 -6680 {
lab=row_n[5]}
N 2510 -6880 2510 -6680 {
lab=row_n[5]}
N 2500 -6890 2510 -6880 {
lab=row_n[5]}
N 2500 -6670 2500 -6650 {
lab=row_n[5]}
N 2500 -6910 2500 -6890 {
lab=row_n[5]}
N 2380 -6810 2390 -6820 {
lab=col_n[22]}
N 2390 -6820 2590 -6820 {
lab=col_n[22]}
N 2590 -6820 2600 -6810 {
lab=col_n[22]}
N 2380 -6790 2390 -6800 {
lab=colon_n[22]}
N 2390 -6800 2590 -6800 {
lab=colon_n[22]}
N 2590 -6800 2600 -6790 {
lab=colon_n[22]}
N 2380 -6770 2390 -6780 {
lab=#net45}
N 2390 -6780 2590 -6780 {
lab=#net45}
N 2590 -6780 2600 -6770 {
lab=#net45}
N 2380 -6750 2390 -6760 {
lab=#net46}
N 2390 -6760 2590 -6760 {
lab=#net46}
N 2590 -6760 2600 -6750 {
lab=#net46}
N 2440 -6910 2440 -6890 {
lab=vcom}
N 2480 -6910 2480 -6890 {
lab=ctop}
N 2360 -6810 2380 -6810 {
lab=col_n[22]}
N 2360 -6790 2380 -6790 {
lab=colon_n[22]}
N 2360 -6770 2380 -6770 {
lab=#net45}
N 2360 -6750 2380 -6750 {
lab=#net46}
N 2600 -6750 2620 -6750 {
lab=#net46}
N 2600 -6770 2620 -6770 {
lab=#net45}
N 2600 -6790 2620 -6790 {
lab=colon_n[22]}
N 2600 -6810 2620 -6810 {
lab=col_n[22]}
N 2420 -6670 2420 -6660 {
lab=VSS}
N 2420 -6900 2420 -6890 {
lab=VDD}
N 2760 -6670 2770 -6680 {
lab=row_n[6]}
N 2770 -6880 2770 -6680 {
lab=row_n[6]}
N 2760 -6890 2770 -6880 {
lab=row_n[6]}
N 2760 -6670 2760 -6650 {
lab=row_n[6]}
N 2760 -6910 2760 -6890 {
lab=row_n[6]}
N 2640 -6810 2650 -6820 {
lab=col_n[22]}
N 2650 -6820 2850 -6820 {
lab=col_n[22]}
N 2850 -6820 2860 -6810 {
lab=col_n[22]}
N 2640 -6790 2650 -6800 {
lab=colon_n[22]}
N 2650 -6800 2850 -6800 {
lab=colon_n[22]}
N 2850 -6800 2860 -6790 {
lab=colon_n[22]}
N 2640 -6770 2650 -6780 {
lab=#net45}
N 2650 -6780 2850 -6780 {
lab=#net45}
N 2850 -6780 2860 -6770 {
lab=#net45}
N 2640 -6750 2650 -6760 {
lab=#net46}
N 2650 -6760 2850 -6760 {
lab=#net46}
N 2850 -6760 2860 -6750 {
lab=#net46}
N 2700 -6910 2700 -6890 {
lab=vcom}
N 2740 -6910 2740 -6890 {
lab=ctop}
N 2620 -6810 2640 -6810 {
lab=col_n[22]}
N 2620 -6790 2640 -6790 {
lab=colon_n[22]}
N 2620 -6770 2640 -6770 {
lab=#net45}
N 2620 -6750 2640 -6750 {
lab=#net46}
N 2860 -6750 2880 -6750 {
lab=#net46}
N 2860 -6770 2880 -6770 {
lab=#net45}
N 2860 -6790 2880 -6790 {
lab=colon_n[22]}
N 2860 -6810 2880 -6810 {
lab=col_n[22]}
N 2680 -6670 2680 -6660 {
lab=VSS}
N 2680 -6900 2680 -6890 {
lab=VDD}
N 3020 -6670 3030 -6680 {
lab=row_n[7]}
N 3030 -6880 3030 -6680 {
lab=row_n[7]}
N 3020 -6890 3030 -6880 {
lab=row_n[7]}
N 3020 -6670 3020 -6650 {
lab=row_n[7]}
N 3020 -6910 3020 -6890 {
lab=row_n[7]}
N 2900 -6810 2910 -6820 {
lab=col_n[22]}
N 2910 -6820 3110 -6820 {
lab=col_n[22]}
N 3110 -6820 3120 -6810 {
lab=col_n[22]}
N 2900 -6790 2910 -6800 {
lab=colon_n[22]}
N 2910 -6800 3110 -6800 {
lab=colon_n[22]}
N 3110 -6800 3120 -6790 {
lab=colon_n[22]}
N 2900 -6770 2910 -6780 {
lab=#net45}
N 2910 -6780 3110 -6780 {
lab=#net45}
N 3110 -6780 3120 -6770 {
lab=#net45}
N 2900 -6750 2910 -6760 {
lab=#net46}
N 2910 -6760 3110 -6760 {
lab=#net46}
N 3110 -6760 3120 -6750 {
lab=#net46}
N 2960 -6910 2960 -6890 {
lab=vcom}
N 3000 -6910 3000 -6890 {
lab=ctop}
N 2880 -6810 2900 -6810 {
lab=col_n[22]}
N 2880 -6790 2900 -6790 {
lab=colon_n[22]}
N 2880 -6770 2900 -6770 {
lab=#net45}
N 2880 -6750 2900 -6750 {
lab=#net46}
N 3120 -6750 3140 -6750 {
lab=#net46}
N 3120 -6770 3140 -6770 {
lab=#net45}
N 3120 -6790 3140 -6790 {
lab=colon_n[22]}
N 3120 -6810 3140 -6810 {
lab=col_n[22]}
N 2940 -6670 2940 -6660 {
lab=VSS}
N 2940 -6900 2940 -6890 {
lab=VDD}
N 3280 -6670 3290 -6680 {
lab=row_n[8]}
N 3290 -6880 3290 -6680 {
lab=row_n[8]}
N 3280 -6890 3290 -6880 {
lab=row_n[8]}
N 3280 -6670 3280 -6650 {
lab=row_n[8]}
N 3280 -6910 3280 -6890 {
lab=row_n[8]}
N 3160 -6810 3170 -6820 {
lab=col_n[22]}
N 3170 -6820 3370 -6820 {
lab=col_n[22]}
N 3370 -6820 3380 -6810 {
lab=col_n[22]}
N 3160 -6790 3170 -6800 {
lab=colon_n[22]}
N 3170 -6800 3370 -6800 {
lab=colon_n[22]}
N 3370 -6800 3380 -6790 {
lab=colon_n[22]}
N 3160 -6770 3170 -6780 {
lab=#net45}
N 3170 -6780 3370 -6780 {
lab=#net45}
N 3370 -6780 3380 -6770 {
lab=#net45}
N 3160 -6750 3170 -6760 {
lab=#net46}
N 3170 -6760 3370 -6760 {
lab=#net46}
N 3370 -6760 3380 -6750 {
lab=#net46}
N 3220 -6910 3220 -6890 {
lab=vcom}
N 3260 -6910 3260 -6890 {
lab=ctop}
N 3140 -6810 3160 -6810 {
lab=col_n[22]}
N 3140 -6790 3160 -6790 {
lab=colon_n[22]}
N 3140 -6770 3160 -6770 {
lab=#net45}
N 3140 -6750 3160 -6750 {
lab=#net46}
N 3380 -6750 3400 -6750 {
lab=#net46}
N 3380 -6770 3400 -6770 {
lab=#net45}
N 3380 -6790 3400 -6790 {
lab=colon_n[22]}
N 3380 -6810 3400 -6810 {
lab=col_n[22]}
N 3200 -6670 3200 -6660 {
lab=VSS}
N 3200 -6900 3200 -6890 {
lab=VDD}
N 3540 -6670 3550 -6680 {
lab=row_n[9]}
N 3550 -6880 3550 -6680 {
lab=row_n[9]}
N 3540 -6890 3550 -6880 {
lab=row_n[9]}
N 3540 -6670 3540 -6650 {
lab=row_n[9]}
N 3540 -6910 3540 -6890 {
lab=row_n[9]}
N 3420 -6810 3430 -6820 {
lab=col_n[22]}
N 3430 -6820 3630 -6820 {
lab=col_n[22]}
N 3630 -6820 3640 -6810 {
lab=col_n[22]}
N 3420 -6790 3430 -6800 {
lab=colon_n[22]}
N 3430 -6800 3630 -6800 {
lab=colon_n[22]}
N 3630 -6800 3640 -6790 {
lab=colon_n[22]}
N 3420 -6770 3430 -6780 {
lab=#net45}
N 3430 -6780 3630 -6780 {
lab=#net45}
N 3630 -6780 3640 -6770 {
lab=#net45}
N 3420 -6750 3430 -6760 {
lab=#net46}
N 3430 -6760 3630 -6760 {
lab=#net46}
N 3630 -6760 3640 -6750 {
lab=#net46}
N 3480 -6910 3480 -6890 {
lab=vcom}
N 3520 -6910 3520 -6890 {
lab=ctop}
N 3400 -6810 3420 -6810 {
lab=col_n[22]}
N 3400 -6790 3420 -6790 {
lab=colon_n[22]}
N 3400 -6770 3420 -6770 {
lab=#net45}
N 3400 -6750 3420 -6750 {
lab=#net46}
N 3640 -6750 3660 -6750 {
lab=#net46}
N 3640 -6770 3660 -6770 {
lab=#net45}
N 3640 -6790 3660 -6790 {
lab=colon_n[22]}
N 3640 -6810 3660 -6810 {
lab=col_n[22]}
N 3460 -6670 3460 -6660 {
lab=VSS}
N 3460 -6900 3460 -6890 {
lab=VDD}
N 3800 -6670 3810 -6680 {
lab=row_n[10]}
N 3810 -6880 3810 -6680 {
lab=row_n[10]}
N 3800 -6890 3810 -6880 {
lab=row_n[10]}
N 3800 -6670 3800 -6650 {
lab=row_n[10]}
N 3800 -6910 3800 -6890 {
lab=row_n[10]}
N 3680 -6810 3690 -6820 {
lab=col_n[22]}
N 3690 -6820 3890 -6820 {
lab=col_n[22]}
N 3890 -6820 3900 -6810 {
lab=col_n[22]}
N 3680 -6790 3690 -6800 {
lab=colon_n[22]}
N 3690 -6800 3890 -6800 {
lab=colon_n[22]}
N 3890 -6800 3900 -6790 {
lab=colon_n[22]}
N 3680 -6770 3690 -6780 {
lab=#net45}
N 3690 -6780 3890 -6780 {
lab=#net45}
N 3890 -6780 3900 -6770 {
lab=#net45}
N 3680 -6750 3690 -6760 {
lab=#net46}
N 3690 -6760 3890 -6760 {
lab=#net46}
N 3890 -6760 3900 -6750 {
lab=#net46}
N 3740 -6910 3740 -6890 {
lab=vcom}
N 3780 -6910 3780 -6890 {
lab=ctop}
N 3660 -6810 3680 -6810 {
lab=col_n[22]}
N 3660 -6790 3680 -6790 {
lab=colon_n[22]}
N 3660 -6770 3680 -6770 {
lab=#net45}
N 3660 -6750 3680 -6750 {
lab=#net46}
N 3900 -6750 3920 -6750 {
lab=#net46}
N 3900 -6770 3920 -6770 {
lab=#net45}
N 3900 -6790 3920 -6790 {
lab=colon_n[22]}
N 3900 -6810 3920 -6810 {
lab=col_n[22]}
N 3720 -6670 3720 -6660 {
lab=VSS}
N 3720 -6900 3720 -6890 {
lab=VDD}
N 4060 -6670 4070 -6680 {
lab=row_n[11]}
N 4070 -6880 4070 -6680 {
lab=row_n[11]}
N 4060 -6890 4070 -6880 {
lab=row_n[11]}
N 4060 -6670 4060 -6650 {
lab=row_n[11]}
N 4060 -6910 4060 -6890 {
lab=row_n[11]}
N 3940 -6810 3950 -6820 {
lab=col_n[22]}
N 3950 -6820 4150 -6820 {
lab=col_n[22]}
N 4150 -6820 4160 -6810 {
lab=col_n[22]}
N 3940 -6790 3950 -6800 {
lab=colon_n[22]}
N 3950 -6800 4150 -6800 {
lab=colon_n[22]}
N 4150 -6800 4160 -6790 {
lab=colon_n[22]}
N 3940 -6770 3950 -6780 {
lab=#net45}
N 3950 -6780 4150 -6780 {
lab=#net45}
N 4150 -6780 4160 -6770 {
lab=#net45}
N 3940 -6750 3950 -6760 {
lab=#net46}
N 3950 -6760 4150 -6760 {
lab=#net46}
N 4150 -6760 4160 -6750 {
lab=#net46}
N 4000 -6910 4000 -6890 {
lab=vcom}
N 4040 -6910 4040 -6890 {
lab=ctop}
N 3920 -6810 3940 -6810 {
lab=col_n[22]}
N 3920 -6790 3940 -6790 {
lab=colon_n[22]}
N 3920 -6770 3940 -6770 {
lab=#net45}
N 3920 -6750 3940 -6750 {
lab=#net46}
N 4160 -6750 4180 -6750 {
lab=#net46}
N 4160 -6770 4180 -6770 {
lab=#net45}
N 4160 -6790 4180 -6790 {
lab=colon_n[22]}
N 4160 -6810 4180 -6810 {
lab=col_n[22]}
N 3980 -6670 3980 -6660 {
lab=VSS}
N 3980 -6900 3980 -6890 {
lab=VDD}
N 4320 -6670 4330 -6680 {
lab=row_n[12]}
N 4330 -6880 4330 -6680 {
lab=row_n[12]}
N 4320 -6890 4330 -6880 {
lab=row_n[12]}
N 4320 -6670 4320 -6650 {
lab=row_n[12]}
N 4320 -6910 4320 -6890 {
lab=row_n[12]}
N 4200 -6810 4210 -6820 {
lab=col_n[22]}
N 4210 -6820 4410 -6820 {
lab=col_n[22]}
N 4410 -6820 4420 -6810 {
lab=col_n[22]}
N 4200 -6790 4210 -6800 {
lab=colon_n[22]}
N 4210 -6800 4410 -6800 {
lab=colon_n[22]}
N 4410 -6800 4420 -6790 {
lab=colon_n[22]}
N 4200 -6770 4210 -6780 {
lab=#net45}
N 4210 -6780 4410 -6780 {
lab=#net45}
N 4410 -6780 4420 -6770 {
lab=#net45}
N 4200 -6750 4210 -6760 {
lab=#net46}
N 4210 -6760 4410 -6760 {
lab=#net46}
N 4410 -6760 4420 -6750 {
lab=#net46}
N 4260 -6910 4260 -6890 {
lab=vcom}
N 4300 -6910 4300 -6890 {
lab=ctop}
N 4180 -6810 4200 -6810 {
lab=col_n[22]}
N 4180 -6790 4200 -6790 {
lab=colon_n[22]}
N 4180 -6770 4200 -6770 {
lab=#net45}
N 4180 -6750 4200 -6750 {
lab=#net46}
N 4420 -6750 4440 -6750 {
lab=#net46}
N 4420 -6770 4440 -6770 {
lab=#net45}
N 4420 -6790 4440 -6790 {
lab=colon_n[22]}
N 4420 -6810 4440 -6810 {
lab=col_n[22]}
N 4240 -6670 4240 -6660 {
lab=VSS}
N 4240 -6900 4240 -6890 {
lab=VDD}
N 4580 -6670 4590 -6680 {
lab=row_n[13]}
N 4590 -6880 4590 -6680 {
lab=row_n[13]}
N 4580 -6890 4590 -6880 {
lab=row_n[13]}
N 4580 -6670 4580 -6650 {
lab=row_n[13]}
N 4580 -6910 4580 -6890 {
lab=row_n[13]}
N 4460 -6810 4470 -6820 {
lab=col_n[22]}
N 4470 -6820 4670 -6820 {
lab=col_n[22]}
N 4670 -6820 4680 -6810 {
lab=col_n[22]}
N 4460 -6790 4470 -6800 {
lab=colon_n[22]}
N 4470 -6800 4670 -6800 {
lab=colon_n[22]}
N 4670 -6800 4680 -6790 {
lab=colon_n[22]}
N 4460 -6770 4470 -6780 {
lab=#net45}
N 4470 -6780 4670 -6780 {
lab=#net45}
N 4670 -6780 4680 -6770 {
lab=#net45}
N 4460 -6750 4470 -6760 {
lab=#net46}
N 4470 -6760 4670 -6760 {
lab=#net46}
N 4670 -6760 4680 -6750 {
lab=#net46}
N 4520 -6910 4520 -6890 {
lab=vcom}
N 4560 -6910 4560 -6890 {
lab=ctop}
N 4440 -6810 4460 -6810 {
lab=col_n[22]}
N 4440 -6790 4460 -6790 {
lab=colon_n[22]}
N 4440 -6770 4460 -6770 {
lab=#net45}
N 4440 -6750 4460 -6750 {
lab=#net46}
N 4680 -6750 4700 -6750 {
lab=#net46}
N 4680 -6770 4700 -6770 {
lab=#net45}
N 4680 -6790 4700 -6790 {
lab=colon_n[22]}
N 4680 -6810 4700 -6810 {
lab=col_n[22]}
N 4500 -6670 4500 -6660 {
lab=VSS}
N 4500 -6900 4500 -6890 {
lab=VDD}
N 4840 -6670 4850 -6680 {
lab=row_n[14]}
N 4850 -6880 4850 -6680 {
lab=row_n[14]}
N 4840 -6890 4850 -6880 {
lab=row_n[14]}
N 4840 -6670 4840 -6650 {
lab=row_n[14]}
N 4840 -6910 4840 -6890 {
lab=row_n[14]}
N 4720 -6810 4730 -6820 {
lab=col_n[22]}
N 4730 -6820 4930 -6820 {
lab=col_n[22]}
N 4930 -6820 4940 -6810 {
lab=col_n[22]}
N 4720 -6790 4730 -6800 {
lab=colon_n[22]}
N 4730 -6800 4930 -6800 {
lab=colon_n[22]}
N 4930 -6800 4940 -6790 {
lab=colon_n[22]}
N 4720 -6770 4730 -6780 {
lab=#net45}
N 4730 -6780 4930 -6780 {
lab=#net45}
N 4930 -6780 4940 -6770 {
lab=#net45}
N 4720 -6750 4730 -6760 {
lab=#net46}
N 4730 -6760 4930 -6760 {
lab=#net46}
N 4930 -6760 4940 -6750 {
lab=#net46}
N 4780 -6910 4780 -6890 {
lab=vcom}
N 4820 -6910 4820 -6890 {
lab=ctop}
N 4700 -6810 4720 -6810 {
lab=col_n[22]}
N 4700 -6790 4720 -6790 {
lab=colon_n[22]}
N 4700 -6770 4720 -6770 {
lab=#net45}
N 4700 -6750 4720 -6750 {
lab=#net46}
N 4940 -6750 4960 -6750 {
lab=#net46}
N 4940 -6770 4960 -6770 {
lab=#net45}
N 4940 -6790 4960 -6790 {
lab=colon_n[22]}
N 4940 -6810 4960 -6810 {
lab=col_n[22]}
N 4760 -6670 4760 -6660 {
lab=VSS}
N 4760 -6900 4760 -6890 {
lab=VDD}
N 5100 -6670 5110 -6680 {
lab=row_n[15]}
N 5110 -6880 5110 -6680 {
lab=row_n[15]}
N 5100 -6890 5110 -6880 {
lab=row_n[15]}
N 5100 -6670 5100 -6650 {
lab=row_n[15]}
N 5100 -6910 5100 -6890 {
lab=row_n[15]}
N 4980 -6810 4990 -6820 {
lab=col_n[22]}
N 4990 -6820 5190 -6820 {
lab=col_n[22]}
N 5190 -6820 5200 -6810 {
lab=col_n[22]}
N 4980 -6790 4990 -6800 {
lab=colon_n[22]}
N 4990 -6800 5190 -6800 {
lab=colon_n[22]}
N 5190 -6800 5200 -6790 {
lab=colon_n[22]}
N 4980 -6770 4990 -6780 {
lab=#net45}
N 4990 -6780 5190 -6780 {
lab=#net45}
N 5190 -6780 5200 -6770 {
lab=#net45}
N 4980 -6750 4990 -6760 {
lab=#net46}
N 4990 -6760 5190 -6760 {
lab=#net46}
N 5190 -6760 5200 -6750 {
lab=#net46}
N 5040 -6910 5040 -6890 {
lab=vcom}
N 5080 -6910 5080 -6890 {
lab=ctop}
N 4960 -6810 4980 -6810 {
lab=col_n[22]}
N 4960 -6790 4980 -6790 {
lab=colon_n[22]}
N 4960 -6770 4980 -6770 {
lab=#net45}
N 4960 -6750 4980 -6750 {
lab=#net46}
N 5200 -6750 5220 -6750 {
lab=#net46}
N 5200 -6770 5220 -6770 {
lab=#net45}
N 5200 -6790 5220 -6790 {
lab=colon_n[22]}
N 5200 -6810 5220 -6810 {
lab=col_n[22]}
N 5020 -6670 5020 -6660 {
lab=VSS}
N 5020 -6900 5020 -6890 {
lab=VDD}
N 5360 -6670 5370 -6680 {
lab=row_n[16]}
N 5370 -6880 5370 -6680 {
lab=row_n[16]}
N 5360 -6890 5370 -6880 {
lab=row_n[16]}
N 5360 -6670 5360 -6650 {
lab=row_n[16]}
N 5360 -6910 5360 -6890 {
lab=row_n[16]}
N 5240 -6810 5250 -6820 {
lab=col_n[22]}
N 5250 -6820 5450 -6820 {
lab=col_n[22]}
N 5450 -6820 5460 -6810 {
lab=col_n[22]}
N 5240 -6790 5250 -6800 {
lab=colon_n[22]}
N 5250 -6800 5450 -6800 {
lab=colon_n[22]}
N 5450 -6800 5460 -6790 {
lab=colon_n[22]}
N 5240 -6770 5250 -6780 {
lab=#net45}
N 5250 -6780 5450 -6780 {
lab=#net45}
N 5450 -6780 5460 -6770 {
lab=#net45}
N 5240 -6750 5250 -6760 {
lab=#net46}
N 5250 -6760 5450 -6760 {
lab=#net46}
N 5450 -6760 5460 -6750 {
lab=#net46}
N 5300 -6910 5300 -6890 {
lab=vcom}
N 5340 -6910 5340 -6890 {
lab=ctop}
N 5220 -6810 5240 -6810 {
lab=col_n[22]}
N 5220 -6790 5240 -6790 {
lab=colon_n[22]}
N 5220 -6770 5240 -6770 {
lab=#net45}
N 5220 -6750 5240 -6750 {
lab=#net46}
N 5460 -6750 5480 -6750 {
lab=#net46}
N 5460 -6770 5480 -6770 {
lab=#net45}
N 5460 -6790 5480 -6790 {
lab=colon_n[22]}
N 5460 -6810 5480 -6810 {
lab=col_n[22]}
N 5280 -6670 5280 -6660 {
lab=VSS}
N 5280 -6900 5280 -6890 {
lab=VDD}
N 5620 -6670 5630 -6680 {
lab=row_n[17]}
N 5630 -6880 5630 -6680 {
lab=row_n[17]}
N 5620 -6890 5630 -6880 {
lab=row_n[17]}
N 5620 -6670 5620 -6650 {
lab=row_n[17]}
N 5620 -6910 5620 -6890 {
lab=row_n[17]}
N 5500 -6810 5510 -6820 {
lab=col_n[22]}
N 5510 -6820 5710 -6820 {
lab=col_n[22]}
N 5710 -6820 5720 -6810 {
lab=col_n[22]}
N 5500 -6790 5510 -6800 {
lab=colon_n[22]}
N 5510 -6800 5710 -6800 {
lab=colon_n[22]}
N 5710 -6800 5720 -6790 {
lab=colon_n[22]}
N 5500 -6770 5510 -6780 {
lab=#net45}
N 5510 -6780 5710 -6780 {
lab=#net45}
N 5710 -6780 5720 -6770 {
lab=#net45}
N 5500 -6750 5510 -6760 {
lab=#net46}
N 5510 -6760 5710 -6760 {
lab=#net46}
N 5710 -6760 5720 -6750 {
lab=#net46}
N 5560 -6910 5560 -6890 {
lab=vcom}
N 5600 -6910 5600 -6890 {
lab=ctop}
N 5480 -6810 5500 -6810 {
lab=col_n[22]}
N 5480 -6790 5500 -6790 {
lab=colon_n[22]}
N 5480 -6770 5500 -6770 {
lab=#net45}
N 5480 -6750 5500 -6750 {
lab=#net46}
N 5720 -6750 5740 -6750 {
lab=#net46}
N 5720 -6770 5740 -6770 {
lab=#net45}
N 5720 -6790 5740 -6790 {
lab=colon_n[22]}
N 5720 -6810 5740 -6810 {
lab=col_n[22]}
N 5540 -6670 5540 -6660 {
lab=VSS}
N 5540 -6900 5540 -6890 {
lab=VDD}
N 5880 -6670 5890 -6680 {
lab=row_n[18]}
N 5890 -6880 5890 -6680 {
lab=row_n[18]}
N 5880 -6890 5890 -6880 {
lab=row_n[18]}
N 5880 -6670 5880 -6650 {
lab=row_n[18]}
N 5880 -6910 5880 -6890 {
lab=row_n[18]}
N 5760 -6810 5770 -6820 {
lab=col_n[22]}
N 5770 -6820 5970 -6820 {
lab=col_n[22]}
N 5970 -6820 5980 -6810 {
lab=col_n[22]}
N 5760 -6790 5770 -6800 {
lab=colon_n[22]}
N 5770 -6800 5970 -6800 {
lab=colon_n[22]}
N 5970 -6800 5980 -6790 {
lab=colon_n[22]}
N 5760 -6770 5770 -6780 {
lab=#net45}
N 5770 -6780 5970 -6780 {
lab=#net45}
N 5970 -6780 5980 -6770 {
lab=#net45}
N 5760 -6750 5770 -6760 {
lab=#net46}
N 5770 -6760 5970 -6760 {
lab=#net46}
N 5970 -6760 5980 -6750 {
lab=#net46}
N 5820 -6910 5820 -6890 {
lab=vcom}
N 5860 -6910 5860 -6890 {
lab=ctop}
N 5740 -6810 5760 -6810 {
lab=col_n[22]}
N 5740 -6790 5760 -6790 {
lab=colon_n[22]}
N 5740 -6770 5760 -6770 {
lab=#net45}
N 5740 -6750 5760 -6750 {
lab=#net46}
N 5980 -6750 6000 -6750 {
lab=#net46}
N 5980 -6770 6000 -6770 {
lab=#net45}
N 5980 -6790 6000 -6790 {
lab=colon_n[22]}
N 5980 -6810 6000 -6810 {
lab=col_n[22]}
N 5800 -6670 5800 -6660 {
lab=VSS}
N 5800 -6900 5800 -6890 {
lab=VDD}
N 6140 -6670 6150 -6680 {
lab=row_n[19]}
N 6150 -6880 6150 -6680 {
lab=row_n[19]}
N 6140 -6890 6150 -6880 {
lab=row_n[19]}
N 6140 -6670 6140 -6650 {
lab=row_n[19]}
N 6140 -6910 6140 -6890 {
lab=row_n[19]}
N 6020 -6810 6030 -6820 {
lab=col_n[22]}
N 6030 -6820 6230 -6820 {
lab=col_n[22]}
N 6230 -6820 6240 -6810 {
lab=col_n[22]}
N 6020 -6790 6030 -6800 {
lab=colon_n[22]}
N 6030 -6800 6230 -6800 {
lab=colon_n[22]}
N 6230 -6800 6240 -6790 {
lab=colon_n[22]}
N 6020 -6770 6030 -6780 {
lab=#net45}
N 6030 -6780 6230 -6780 {
lab=#net45}
N 6230 -6780 6240 -6770 {
lab=#net45}
N 6020 -6750 6030 -6760 {
lab=#net46}
N 6030 -6760 6230 -6760 {
lab=#net46}
N 6230 -6760 6240 -6750 {
lab=#net46}
N 6080 -6910 6080 -6890 {
lab=vcom}
N 6120 -6910 6120 -6890 {
lab=ctop}
N 6000 -6810 6020 -6810 {
lab=col_n[22]}
N 6000 -6790 6020 -6790 {
lab=colon_n[22]}
N 6000 -6770 6020 -6770 {
lab=#net45}
N 6000 -6750 6020 -6750 {
lab=#net46}
N 6240 -6750 6260 -6750 {
lab=#net46}
N 6240 -6770 6260 -6770 {
lab=#net45}
N 6240 -6790 6260 -6790 {
lab=colon_n[22]}
N 6240 -6810 6260 -6810 {
lab=col_n[22]}
N 6060 -6670 6060 -6660 {
lab=VSS}
N 6060 -6900 6060 -6890 {
lab=VDD}
N 6400 -6670 6410 -6680 {
lab=row_n[20]}
N 6410 -6880 6410 -6680 {
lab=row_n[20]}
N 6400 -6890 6410 -6880 {
lab=row_n[20]}
N 6400 -6670 6400 -6650 {
lab=row_n[20]}
N 6400 -6910 6400 -6890 {
lab=row_n[20]}
N 6280 -6810 6290 -6820 {
lab=col_n[22]}
N 6290 -6820 6490 -6820 {
lab=col_n[22]}
N 6490 -6820 6500 -6810 {
lab=col_n[22]}
N 6280 -6790 6290 -6800 {
lab=colon_n[22]}
N 6290 -6800 6490 -6800 {
lab=colon_n[22]}
N 6490 -6800 6500 -6790 {
lab=colon_n[22]}
N 6280 -6770 6290 -6780 {
lab=#net45}
N 6290 -6780 6490 -6780 {
lab=#net45}
N 6490 -6780 6500 -6770 {
lab=#net45}
N 6280 -6750 6290 -6760 {
lab=#net46}
N 6290 -6760 6490 -6760 {
lab=#net46}
N 6490 -6760 6500 -6750 {
lab=#net46}
N 6340 -6910 6340 -6890 {
lab=vcom}
N 6380 -6910 6380 -6890 {
lab=ctop}
N 6260 -6810 6280 -6810 {
lab=col_n[22]}
N 6260 -6790 6280 -6790 {
lab=colon_n[22]}
N 6260 -6770 6280 -6770 {
lab=#net45}
N 6260 -6750 6280 -6750 {
lab=#net46}
N 6500 -6750 6520 -6750 {
lab=#net46}
N 6500 -6770 6520 -6770 {
lab=#net45}
N 6500 -6790 6520 -6790 {
lab=colon_n[22]}
N 6500 -6810 6520 -6810 {
lab=col_n[22]}
N 6320 -6670 6320 -6660 {
lab=VSS}
N 6320 -6900 6320 -6890 {
lab=VDD}
N 6660 -6670 6670 -6680 {
lab=row_n[21]}
N 6670 -6880 6670 -6680 {
lab=row_n[21]}
N 6660 -6890 6670 -6880 {
lab=row_n[21]}
N 6660 -6670 6660 -6650 {
lab=row_n[21]}
N 6660 -6910 6660 -6890 {
lab=row_n[21]}
N 6540 -6810 6550 -6820 {
lab=col_n[22]}
N 6550 -6820 6750 -6820 {
lab=col_n[22]}
N 6750 -6820 6760 -6810 {
lab=col_n[22]}
N 6540 -6790 6550 -6800 {
lab=colon_n[22]}
N 6550 -6800 6750 -6800 {
lab=colon_n[22]}
N 6750 -6800 6760 -6790 {
lab=colon_n[22]}
N 6540 -6770 6550 -6780 {
lab=#net45}
N 6550 -6780 6750 -6780 {
lab=#net45}
N 6750 -6780 6760 -6770 {
lab=#net45}
N 6540 -6750 6550 -6760 {
lab=#net46}
N 6550 -6760 6750 -6760 {
lab=#net46}
N 6750 -6760 6760 -6750 {
lab=#net46}
N 6600 -6910 6600 -6890 {
lab=vcom}
N 6640 -6910 6640 -6890 {
lab=ctop}
N 6520 -6810 6540 -6810 {
lab=col_n[22]}
N 6520 -6790 6540 -6790 {
lab=colon_n[22]}
N 6520 -6770 6540 -6770 {
lab=#net45}
N 6520 -6750 6540 -6750 {
lab=#net46}
N 6760 -6750 6780 -6750 {
lab=#net46}
N 6760 -6770 6780 -6770 {
lab=#net45}
N 6760 -6790 6780 -6790 {
lab=colon_n[22]}
N 6760 -6810 6780 -6810 {
lab=col_n[22]}
N 6580 -6670 6580 -6660 {
lab=VSS}
N 6580 -6900 6580 -6890 {
lab=VDD}
N 6920 -6670 6930 -6680 {
lab=row_n[22]}
N 6930 -6880 6930 -6680 {
lab=row_n[22]}
N 6920 -6890 6930 -6880 {
lab=row_n[22]}
N 6920 -6670 6920 -6650 {
lab=row_n[22]}
N 6920 -6910 6920 -6890 {
lab=row_n[22]}
N 6800 -6810 6810 -6820 {
lab=col_n[22]}
N 6810 -6820 7010 -6820 {
lab=col_n[22]}
N 7010 -6820 7020 -6810 {
lab=col_n[22]}
N 6800 -6790 6810 -6800 {
lab=colon_n[22]}
N 6810 -6800 7010 -6800 {
lab=colon_n[22]}
N 7010 -6800 7020 -6790 {
lab=colon_n[22]}
N 6800 -6770 6810 -6780 {
lab=#net45}
N 6810 -6780 7010 -6780 {
lab=#net45}
N 7010 -6780 7020 -6770 {
lab=#net45}
N 6800 -6750 6810 -6760 {
lab=#net46}
N 6810 -6760 7010 -6760 {
lab=#net46}
N 7010 -6760 7020 -6750 {
lab=#net46}
N 6860 -6910 6860 -6890 {
lab=vcom}
N 6900 -6910 6900 -6890 {
lab=ctop}
N 6780 -6810 6800 -6810 {
lab=col_n[22]}
N 6780 -6790 6800 -6790 {
lab=colon_n[22]}
N 6780 -6770 6800 -6770 {
lab=#net45}
N 6780 -6750 6800 -6750 {
lab=#net46}
N 7020 -6750 7040 -6750 {
lab=#net46}
N 7020 -6770 7040 -6770 {
lab=#net45}
N 7020 -6790 7040 -6790 {
lab=colon_n[22]}
N 7020 -6810 7040 -6810 {
lab=col_n[22]}
N 6840 -6670 6840 -6660 {
lab=VSS}
N 6840 -6900 6840 -6890 {
lab=VDD}
N 7180 -6670 7190 -6680 {
lab=row_n[23]}
N 7190 -6880 7190 -6680 {
lab=row_n[23]}
N 7180 -6890 7190 -6880 {
lab=row_n[23]}
N 7180 -6670 7180 -6650 {
lab=row_n[23]}
N 7180 -6910 7180 -6890 {
lab=row_n[23]}
N 7060 -6810 7070 -6820 {
lab=col_n[22]}
N 7070 -6820 7270 -6820 {
lab=col_n[22]}
N 7270 -6820 7280 -6810 {
lab=col_n[22]}
N 7060 -6790 7070 -6800 {
lab=colon_n[22]}
N 7070 -6800 7270 -6800 {
lab=colon_n[22]}
N 7270 -6800 7280 -6790 {
lab=colon_n[22]}
N 7060 -6770 7070 -6780 {
lab=#net45}
N 7070 -6780 7270 -6780 {
lab=#net45}
N 7270 -6780 7280 -6770 {
lab=#net45}
N 7060 -6750 7070 -6760 {
lab=#net46}
N 7070 -6760 7270 -6760 {
lab=#net46}
N 7270 -6760 7280 -6750 {
lab=#net46}
N 7120 -6910 7120 -6890 {
lab=vcom}
N 7160 -6910 7160 -6890 {
lab=ctop}
N 7040 -6810 7060 -6810 {
lab=col_n[22]}
N 7040 -6790 7060 -6790 {
lab=colon_n[22]}
N 7040 -6770 7060 -6770 {
lab=#net45}
N 7040 -6750 7060 -6750 {
lab=#net46}
N 7280 -6750 7300 -6750 {
lab=#net46}
N 7280 -6770 7300 -6770 {
lab=#net45}
N 7280 -6790 7300 -6790 {
lab=colon_n[22]}
N 7280 -6810 7300 -6810 {
lab=col_n[22]}
N 7100 -6670 7100 -6660 {
lab=VSS}
N 7100 -6900 7100 -6890 {
lab=VDD}
N 7440 -6670 7450 -6680 {
lab=row_n[24]}
N 7450 -6880 7450 -6680 {
lab=row_n[24]}
N 7440 -6890 7450 -6880 {
lab=row_n[24]}
N 7440 -6670 7440 -6650 {
lab=row_n[24]}
N 7440 -6910 7440 -6890 {
lab=row_n[24]}
N 7320 -6810 7330 -6820 {
lab=col_n[22]}
N 7330 -6820 7530 -6820 {
lab=col_n[22]}
N 7530 -6820 7540 -6810 {
lab=col_n[22]}
N 7320 -6790 7330 -6800 {
lab=colon_n[22]}
N 7330 -6800 7530 -6800 {
lab=colon_n[22]}
N 7530 -6800 7540 -6790 {
lab=colon_n[22]}
N 7320 -6770 7330 -6780 {
lab=#net45}
N 7330 -6780 7530 -6780 {
lab=#net45}
N 7530 -6780 7540 -6770 {
lab=#net45}
N 7320 -6750 7330 -6760 {
lab=#net46}
N 7330 -6760 7530 -6760 {
lab=#net46}
N 7530 -6760 7540 -6750 {
lab=#net46}
N 7380 -6910 7380 -6890 {
lab=vcom}
N 7420 -6910 7420 -6890 {
lab=ctop}
N 7300 -6810 7320 -6810 {
lab=col_n[22]}
N 7300 -6790 7320 -6790 {
lab=colon_n[22]}
N 7300 -6770 7320 -6770 {
lab=#net45}
N 7300 -6750 7320 -6750 {
lab=#net46}
N 7540 -6750 7560 -6750 {
lab=#net46}
N 7540 -6770 7560 -6770 {
lab=#net45}
N 7540 -6790 7560 -6790 {
lab=colon_n[22]}
N 7540 -6810 7560 -6810 {
lab=col_n[22]}
N 7360 -6670 7360 -6660 {
lab=VSS}
N 7360 -6900 7360 -6890 {
lab=VDD}
N 7700 -6670 7710 -6680 {
lab=row_n[25]}
N 7710 -6880 7710 -6680 {
lab=row_n[25]}
N 7700 -6890 7710 -6880 {
lab=row_n[25]}
N 7700 -6670 7700 -6650 {
lab=row_n[25]}
N 7700 -6910 7700 -6890 {
lab=row_n[25]}
N 7580 -6810 7590 -6820 {
lab=col_n[22]}
N 7590 -6820 7790 -6820 {
lab=col_n[22]}
N 7790 -6820 7800 -6810 {
lab=col_n[22]}
N 7580 -6790 7590 -6800 {
lab=colon_n[22]}
N 7590 -6800 7790 -6800 {
lab=colon_n[22]}
N 7790 -6800 7800 -6790 {
lab=colon_n[22]}
N 7580 -6770 7590 -6780 {
lab=#net45}
N 7590 -6780 7790 -6780 {
lab=#net45}
N 7790 -6780 7800 -6770 {
lab=#net45}
N 7580 -6750 7590 -6760 {
lab=#net46}
N 7590 -6760 7790 -6760 {
lab=#net46}
N 7790 -6760 7800 -6750 {
lab=#net46}
N 7640 -6910 7640 -6890 {
lab=vcom}
N 7680 -6910 7680 -6890 {
lab=ctop}
N 7560 -6810 7580 -6810 {
lab=col_n[22]}
N 7560 -6790 7580 -6790 {
lab=colon_n[22]}
N 7560 -6770 7580 -6770 {
lab=#net45}
N 7560 -6750 7580 -6750 {
lab=#net46}
N 7800 -6750 7820 -6750 {
lab=#net46}
N 7800 -6770 7820 -6770 {
lab=#net45}
N 7800 -6790 7820 -6790 {
lab=colon_n[22]}
N 7800 -6810 7820 -6810 {
lab=col_n[22]}
N 7620 -6670 7620 -6660 {
lab=VSS}
N 7620 -6900 7620 -6890 {
lab=VDD}
N 7960 -6670 7970 -6680 {
lab=row_n[26]}
N 7970 -6880 7970 -6680 {
lab=row_n[26]}
N 7960 -6890 7970 -6880 {
lab=row_n[26]}
N 7960 -6670 7960 -6650 {
lab=row_n[26]}
N 7960 -6910 7960 -6890 {
lab=row_n[26]}
N 7840 -6810 7850 -6820 {
lab=col_n[22]}
N 7850 -6820 8050 -6820 {
lab=col_n[22]}
N 8050 -6820 8060 -6810 {
lab=col_n[22]}
N 7840 -6790 7850 -6800 {
lab=colon_n[22]}
N 7850 -6800 8050 -6800 {
lab=colon_n[22]}
N 8050 -6800 8060 -6790 {
lab=colon_n[22]}
N 7840 -6770 7850 -6780 {
lab=#net45}
N 7850 -6780 8050 -6780 {
lab=#net45}
N 8050 -6780 8060 -6770 {
lab=#net45}
N 7840 -6750 7850 -6760 {
lab=#net46}
N 7850 -6760 8050 -6760 {
lab=#net46}
N 8050 -6760 8060 -6750 {
lab=#net46}
N 7900 -6910 7900 -6890 {
lab=vcom}
N 7940 -6910 7940 -6890 {
lab=ctop}
N 7820 -6810 7840 -6810 {
lab=col_n[22]}
N 7820 -6790 7840 -6790 {
lab=colon_n[22]}
N 7820 -6770 7840 -6770 {
lab=#net45}
N 7820 -6750 7840 -6750 {
lab=#net46}
N 8060 -6750 8080 -6750 {
lab=#net46}
N 8060 -6770 8080 -6770 {
lab=#net45}
N 8060 -6790 8080 -6790 {
lab=colon_n[22]}
N 8060 -6810 8080 -6810 {
lab=col_n[22]}
N 7880 -6670 7880 -6660 {
lab=VSS}
N 7880 -6900 7880 -6890 {
lab=VDD}
N 8220 -6670 8230 -6680 {
lab=row_n[27]}
N 8230 -6880 8230 -6680 {
lab=row_n[27]}
N 8220 -6890 8230 -6880 {
lab=row_n[27]}
N 8220 -6670 8220 -6650 {
lab=row_n[27]}
N 8220 -6910 8220 -6890 {
lab=row_n[27]}
N 8100 -6810 8110 -6820 {
lab=col_n[22]}
N 8110 -6820 8310 -6820 {
lab=col_n[22]}
N 8310 -6820 8320 -6810 {
lab=col_n[22]}
N 8100 -6790 8110 -6800 {
lab=colon_n[22]}
N 8110 -6800 8310 -6800 {
lab=colon_n[22]}
N 8310 -6800 8320 -6790 {
lab=colon_n[22]}
N 8100 -6770 8110 -6780 {
lab=#net45}
N 8110 -6780 8310 -6780 {
lab=#net45}
N 8310 -6780 8320 -6770 {
lab=#net45}
N 8100 -6750 8110 -6760 {
lab=#net46}
N 8110 -6760 8310 -6760 {
lab=#net46}
N 8310 -6760 8320 -6750 {
lab=#net46}
N 8160 -6910 8160 -6890 {
lab=vcom}
N 8200 -6910 8200 -6890 {
lab=ctop}
N 8080 -6810 8100 -6810 {
lab=col_n[22]}
N 8080 -6790 8100 -6790 {
lab=colon_n[22]}
N 8080 -6770 8100 -6770 {
lab=#net45}
N 8080 -6750 8100 -6750 {
lab=#net46}
N 8320 -6750 8340 -6750 {
lab=#net46}
N 8320 -6770 8340 -6770 {
lab=#net45}
N 8320 -6790 8340 -6790 {
lab=colon_n[22]}
N 8320 -6810 8340 -6810 {
lab=col_n[22]}
N 8140 -6670 8140 -6660 {
lab=VSS}
N 8140 -6900 8140 -6890 {
lab=VDD}
N 8480 -6670 8490 -6680 {
lab=row_n[28]}
N 8490 -6880 8490 -6680 {
lab=row_n[28]}
N 8480 -6890 8490 -6880 {
lab=row_n[28]}
N 8480 -6670 8480 -6650 {
lab=row_n[28]}
N 8480 -6910 8480 -6890 {
lab=row_n[28]}
N 8360 -6810 8370 -6820 {
lab=col_n[22]}
N 8370 -6820 8570 -6820 {
lab=col_n[22]}
N 8570 -6820 8580 -6810 {
lab=col_n[22]}
N 8360 -6790 8370 -6800 {
lab=colon_n[22]}
N 8370 -6800 8570 -6800 {
lab=colon_n[22]}
N 8570 -6800 8580 -6790 {
lab=colon_n[22]}
N 8360 -6770 8370 -6780 {
lab=#net45}
N 8370 -6780 8570 -6780 {
lab=#net45}
N 8570 -6780 8580 -6770 {
lab=#net45}
N 8360 -6750 8370 -6760 {
lab=#net46}
N 8370 -6760 8570 -6760 {
lab=#net46}
N 8570 -6760 8580 -6750 {
lab=#net46}
N 8420 -6910 8420 -6890 {
lab=vcom}
N 8460 -6910 8460 -6890 {
lab=ctop}
N 8340 -6810 8360 -6810 {
lab=col_n[22]}
N 8340 -6790 8360 -6790 {
lab=colon_n[22]}
N 8340 -6770 8360 -6770 {
lab=#net45}
N 8340 -6750 8360 -6750 {
lab=#net46}
N 8580 -6750 8600 -6750 {
lab=#net46}
N 8580 -6770 8600 -6770 {
lab=#net45}
N 8580 -6790 8600 -6790 {
lab=colon_n[22]}
N 8580 -6810 8600 -6810 {
lab=col_n[22]}
N 8400 -6670 8400 -6660 {
lab=VSS}
N 8400 -6900 8400 -6890 {
lab=VDD}
N 8740 -6670 8750 -6680 {
lab=row_n[29]}
N 8750 -6880 8750 -6680 {
lab=row_n[29]}
N 8740 -6890 8750 -6880 {
lab=row_n[29]}
N 8740 -6670 8740 -6650 {
lab=row_n[29]}
N 8740 -6910 8740 -6890 {
lab=row_n[29]}
N 8620 -6810 8630 -6820 {
lab=col_n[22]}
N 8630 -6820 8830 -6820 {
lab=col_n[22]}
N 8830 -6820 8840 -6810 {
lab=col_n[22]}
N 8620 -6790 8630 -6800 {
lab=colon_n[22]}
N 8630 -6800 8830 -6800 {
lab=colon_n[22]}
N 8830 -6800 8840 -6790 {
lab=colon_n[22]}
N 8620 -6770 8630 -6780 {
lab=#net45}
N 8630 -6780 8830 -6780 {
lab=#net45}
N 8830 -6780 8840 -6770 {
lab=#net45}
N 8620 -6750 8630 -6760 {
lab=#net46}
N 8630 -6760 8830 -6760 {
lab=#net46}
N 8830 -6760 8840 -6750 {
lab=#net46}
N 8680 -6910 8680 -6890 {
lab=vcom}
N 8720 -6910 8720 -6890 {
lab=ctop}
N 8600 -6810 8620 -6810 {
lab=col_n[22]}
N 8600 -6790 8620 -6790 {
lab=colon_n[22]}
N 8600 -6770 8620 -6770 {
lab=#net45}
N 8600 -6750 8620 -6750 {
lab=#net46}
N 8840 -6750 8860 -6750 {
lab=#net46}
N 8840 -6770 8860 -6770 {
lab=#net45}
N 8840 -6790 8860 -6790 {
lab=colon_n[22]}
N 8840 -6810 8860 -6810 {
lab=col_n[22]}
N 8660 -6670 8660 -6660 {
lab=VSS}
N 8660 -6900 8660 -6890 {
lab=VDD}
N 9000 -6670 9010 -6680 {
lab=row_n[30]}
N 9010 -6880 9010 -6680 {
lab=row_n[30]}
N 9000 -6890 9010 -6880 {
lab=row_n[30]}
N 9000 -6670 9000 -6650 {
lab=row_n[30]}
N 9000 -6910 9000 -6890 {
lab=row_n[30]}
N 8880 -6810 8890 -6820 {
lab=col_n[22]}
N 8890 -6820 9090 -6820 {
lab=col_n[22]}
N 9090 -6820 9100 -6810 {
lab=col_n[22]}
N 8880 -6790 8890 -6800 {
lab=colon_n[22]}
N 8890 -6800 9090 -6800 {
lab=colon_n[22]}
N 9090 -6800 9100 -6790 {
lab=colon_n[22]}
N 8880 -6770 8890 -6780 {
lab=#net45}
N 8890 -6780 9090 -6780 {
lab=#net45}
N 9090 -6780 9100 -6770 {
lab=#net45}
N 8880 -6750 8890 -6760 {
lab=#net46}
N 8890 -6760 9090 -6760 {
lab=#net46}
N 9090 -6760 9100 -6750 {
lab=#net46}
N 8940 -6910 8940 -6890 {
lab=vcom}
N 8980 -6910 8980 -6890 {
lab=ctop}
N 8860 -6810 8880 -6810 {
lab=col_n[22]}
N 8860 -6790 8880 -6790 {
lab=colon_n[22]}
N 8860 -6770 8880 -6770 {
lab=#net45}
N 8860 -6750 8880 -6750 {
lab=#net46}
N 9100 -6750 9120 -6750 {
lab=#net46}
N 9100 -6770 9120 -6770 {
lab=#net45}
N 9100 -6790 9120 -6790 {
lab=colon_n[22]}
N 9100 -6810 9120 -6810 {
lab=col_n[22]}
N 8920 -6670 8920 -6660 {
lab=VSS}
N 8920 -6900 8920 -6890 {
lab=VDD}
N 9260 -6670 9270 -6680 {
lab=row_n[31]}
N 9270 -6880 9270 -6680 {
lab=row_n[31]}
N 9260 -6890 9270 -6880 {
lab=row_n[31]}
N 9260 -6670 9260 -6650 {
lab=row_n[31]}
N 9260 -6910 9260 -6890 {
lab=row_n[31]}
N 9140 -6810 9150 -6820 {
lab=col_n[22]}
N 9150 -6820 9350 -6820 {
lab=col_n[22]}
N 9350 -6820 9360 -6810 {
lab=col_n[22]}
N 9140 -6790 9150 -6800 {
lab=colon_n[22]}
N 9150 -6800 9350 -6800 {
lab=colon_n[22]}
N 9350 -6800 9360 -6790 {
lab=colon_n[22]}
N 9140 -6770 9150 -6780 {
lab=#net45}
N 9150 -6780 9350 -6780 {
lab=#net45}
N 9350 -6780 9360 -6770 {
lab=#net45}
N 9140 -6750 9150 -6760 {
lab=#net46}
N 9150 -6760 9350 -6760 {
lab=#net46}
N 9350 -6760 9360 -6750 {
lab=#net46}
N 9200 -6910 9200 -6890 {
lab=vcom}
N 9240 -6910 9240 -6890 {
lab=ctop}
N 9120 -6810 9140 -6810 {
lab=col_n[22]}
N 9120 -6790 9140 -6790 {
lab=colon_n[22]}
N 9120 -6770 9140 -6770 {
lab=#net45}
N 9120 -6750 9140 -6750 {
lab=#net46}
N 9360 -6750 9380 -6750 {
lab=#net46}
N 9360 -6770 9380 -6770 {
lab=#net45}
N 9360 -6790 9380 -6790 {
lab=colon_n[22]}
N 9360 -6810 9380 -6810 {
lab=col_n[22]}
N 9180 -6670 9180 -6660 {
lab=VSS}
N 9180 -6900 9180 -6890 {
lab=VDD}
N 1200 -6930 1210 -6940 {
lab=row_n[0]}
N 1210 -7140 1210 -6940 {
lab=row_n[0]}
N 1200 -7150 1210 -7140 {
lab=row_n[0]}
N 1200 -6930 1200 -6910 {
lab=row_n[0]}
N 1200 -7170 1200 -7150 {
lab=row_n[0]}
N 1080 -7070 1090 -7080 {
lab=col_n[23]}
N 1090 -7080 1290 -7080 {
lab=col_n[23]}
N 1290 -7080 1300 -7070 {
lab=col_n[23]}
N 1080 -7050 1090 -7060 {
lab=colon_n[23]}
N 1090 -7060 1290 -7060 {
lab=colon_n[23]}
N 1290 -7060 1300 -7050 {
lab=colon_n[23]}
N 1080 -7030 1090 -7040 {
lab=#net47}
N 1090 -7040 1290 -7040 {
lab=#net47}
N 1290 -7040 1300 -7030 {
lab=#net47}
N 1080 -7010 1090 -7020 {
lab=#net48}
N 1090 -7020 1290 -7020 {
lab=#net48}
N 1290 -7020 1300 -7010 {
lab=#net48}
N 1140 -7170 1140 -7150 {
lab=vcom}
N 1180 -7170 1180 -7150 {
lab=ctop}
N 1060 -7070 1080 -7070 {
lab=col_n[23]}
N 1060 -7050 1080 -7050 {
lab=colon_n[23]}
N 1060 -7030 1080 -7030 {
lab=#net47}
N 1060 -7010 1080 -7010 {
lab=#net48}
N 1300 -7010 1320 -7010 {
lab=#net48}
N 1300 -7030 1320 -7030 {
lab=#net47}
N 1300 -7050 1320 -7050 {
lab=colon_n[23]}
N 1300 -7070 1320 -7070 {
lab=col_n[23]}
N 1120 -6930 1120 -6920 {
lab=VSS}
N 1120 -7160 1120 -7150 {
lab=VDD}
N 1460 -6930 1470 -6940 {
lab=row_n[1]}
N 1470 -7140 1470 -6940 {
lab=row_n[1]}
N 1460 -7150 1470 -7140 {
lab=row_n[1]}
N 1460 -6930 1460 -6910 {
lab=row_n[1]}
N 1460 -7170 1460 -7150 {
lab=row_n[1]}
N 1340 -7070 1350 -7080 {
lab=col_n[23]}
N 1350 -7080 1550 -7080 {
lab=col_n[23]}
N 1550 -7080 1560 -7070 {
lab=col_n[23]}
N 1340 -7050 1350 -7060 {
lab=colon_n[23]}
N 1350 -7060 1550 -7060 {
lab=colon_n[23]}
N 1550 -7060 1560 -7050 {
lab=colon_n[23]}
N 1340 -7030 1350 -7040 {
lab=#net47}
N 1350 -7040 1550 -7040 {
lab=#net47}
N 1550 -7040 1560 -7030 {
lab=#net47}
N 1340 -7010 1350 -7020 {
lab=#net48}
N 1350 -7020 1550 -7020 {
lab=#net48}
N 1550 -7020 1560 -7010 {
lab=#net48}
N 1400 -7170 1400 -7150 {
lab=vcom}
N 1440 -7170 1440 -7150 {
lab=ctop}
N 1320 -7070 1340 -7070 {
lab=col_n[23]}
N 1320 -7050 1340 -7050 {
lab=colon_n[23]}
N 1320 -7030 1340 -7030 {
lab=#net47}
N 1320 -7010 1340 -7010 {
lab=#net48}
N 1560 -7010 1580 -7010 {
lab=#net48}
N 1560 -7030 1580 -7030 {
lab=#net47}
N 1560 -7050 1580 -7050 {
lab=colon_n[23]}
N 1560 -7070 1580 -7070 {
lab=col_n[23]}
N 1380 -6930 1380 -6920 {
lab=VSS}
N 1380 -7160 1380 -7150 {
lab=VDD}
N 1720 -6930 1730 -6940 {
lab=row_n[2]}
N 1730 -7140 1730 -6940 {
lab=row_n[2]}
N 1720 -7150 1730 -7140 {
lab=row_n[2]}
N 1720 -6930 1720 -6910 {
lab=row_n[2]}
N 1720 -7170 1720 -7150 {
lab=row_n[2]}
N 1600 -7070 1610 -7080 {
lab=col_n[23]}
N 1610 -7080 1810 -7080 {
lab=col_n[23]}
N 1810 -7080 1820 -7070 {
lab=col_n[23]}
N 1600 -7050 1610 -7060 {
lab=colon_n[23]}
N 1610 -7060 1810 -7060 {
lab=colon_n[23]}
N 1810 -7060 1820 -7050 {
lab=colon_n[23]}
N 1600 -7030 1610 -7040 {
lab=#net47}
N 1610 -7040 1810 -7040 {
lab=#net47}
N 1810 -7040 1820 -7030 {
lab=#net47}
N 1600 -7010 1610 -7020 {
lab=#net48}
N 1610 -7020 1810 -7020 {
lab=#net48}
N 1810 -7020 1820 -7010 {
lab=#net48}
N 1660 -7170 1660 -7150 {
lab=vcom}
N 1700 -7170 1700 -7150 {
lab=ctop}
N 1580 -7070 1600 -7070 {
lab=col_n[23]}
N 1580 -7050 1600 -7050 {
lab=colon_n[23]}
N 1580 -7030 1600 -7030 {
lab=#net47}
N 1580 -7010 1600 -7010 {
lab=#net48}
N 1820 -7010 1840 -7010 {
lab=#net48}
N 1820 -7030 1840 -7030 {
lab=#net47}
N 1820 -7050 1840 -7050 {
lab=colon_n[23]}
N 1820 -7070 1840 -7070 {
lab=col_n[23]}
N 1640 -6930 1640 -6920 {
lab=VSS}
N 1640 -7160 1640 -7150 {
lab=VDD}
N 1980 -6930 1990 -6940 {
lab=row_n[3]}
N 1990 -7140 1990 -6940 {
lab=row_n[3]}
N 1980 -7150 1990 -7140 {
lab=row_n[3]}
N 1980 -6930 1980 -6910 {
lab=row_n[3]}
N 1980 -7170 1980 -7150 {
lab=row_n[3]}
N 1860 -7070 1870 -7080 {
lab=col_n[23]}
N 1870 -7080 2070 -7080 {
lab=col_n[23]}
N 2070 -7080 2080 -7070 {
lab=col_n[23]}
N 1860 -7050 1870 -7060 {
lab=colon_n[23]}
N 1870 -7060 2070 -7060 {
lab=colon_n[23]}
N 2070 -7060 2080 -7050 {
lab=colon_n[23]}
N 1860 -7030 1870 -7040 {
lab=#net47}
N 1870 -7040 2070 -7040 {
lab=#net47}
N 2070 -7040 2080 -7030 {
lab=#net47}
N 1860 -7010 1870 -7020 {
lab=#net48}
N 1870 -7020 2070 -7020 {
lab=#net48}
N 2070 -7020 2080 -7010 {
lab=#net48}
N 1920 -7170 1920 -7150 {
lab=vcom}
N 1960 -7170 1960 -7150 {
lab=ctop}
N 1840 -7070 1860 -7070 {
lab=col_n[23]}
N 1840 -7050 1860 -7050 {
lab=colon_n[23]}
N 1840 -7030 1860 -7030 {
lab=#net47}
N 1840 -7010 1860 -7010 {
lab=#net48}
N 2080 -7010 2100 -7010 {
lab=#net48}
N 2080 -7030 2100 -7030 {
lab=#net47}
N 2080 -7050 2100 -7050 {
lab=colon_n[23]}
N 2080 -7070 2100 -7070 {
lab=col_n[23]}
N 1900 -6930 1900 -6920 {
lab=VSS}
N 1900 -7160 1900 -7150 {
lab=VDD}
N 2240 -6930 2250 -6940 {
lab=row_n[4]}
N 2250 -7140 2250 -6940 {
lab=row_n[4]}
N 2240 -7150 2250 -7140 {
lab=row_n[4]}
N 2240 -6930 2240 -6910 {
lab=row_n[4]}
N 2240 -7170 2240 -7150 {
lab=row_n[4]}
N 2120 -7070 2130 -7080 {
lab=col_n[23]}
N 2130 -7080 2330 -7080 {
lab=col_n[23]}
N 2330 -7080 2340 -7070 {
lab=col_n[23]}
N 2120 -7050 2130 -7060 {
lab=colon_n[23]}
N 2130 -7060 2330 -7060 {
lab=colon_n[23]}
N 2330 -7060 2340 -7050 {
lab=colon_n[23]}
N 2120 -7030 2130 -7040 {
lab=#net47}
N 2130 -7040 2330 -7040 {
lab=#net47}
N 2330 -7040 2340 -7030 {
lab=#net47}
N 2120 -7010 2130 -7020 {
lab=#net48}
N 2130 -7020 2330 -7020 {
lab=#net48}
N 2330 -7020 2340 -7010 {
lab=#net48}
N 2180 -7170 2180 -7150 {
lab=vcom}
N 2220 -7170 2220 -7150 {
lab=ctop}
N 2100 -7070 2120 -7070 {
lab=col_n[23]}
N 2100 -7050 2120 -7050 {
lab=colon_n[23]}
N 2100 -7030 2120 -7030 {
lab=#net47}
N 2100 -7010 2120 -7010 {
lab=#net48}
N 2340 -7010 2360 -7010 {
lab=#net48}
N 2340 -7030 2360 -7030 {
lab=#net47}
N 2340 -7050 2360 -7050 {
lab=colon_n[23]}
N 2340 -7070 2360 -7070 {
lab=col_n[23]}
N 2160 -6930 2160 -6920 {
lab=VSS}
N 2160 -7160 2160 -7150 {
lab=VDD}
N 2500 -6930 2510 -6940 {
lab=row_n[5]}
N 2510 -7140 2510 -6940 {
lab=row_n[5]}
N 2500 -7150 2510 -7140 {
lab=row_n[5]}
N 2500 -6930 2500 -6910 {
lab=row_n[5]}
N 2500 -7170 2500 -7150 {
lab=row_n[5]}
N 2380 -7070 2390 -7080 {
lab=col_n[23]}
N 2390 -7080 2590 -7080 {
lab=col_n[23]}
N 2590 -7080 2600 -7070 {
lab=col_n[23]}
N 2380 -7050 2390 -7060 {
lab=colon_n[23]}
N 2390 -7060 2590 -7060 {
lab=colon_n[23]}
N 2590 -7060 2600 -7050 {
lab=colon_n[23]}
N 2380 -7030 2390 -7040 {
lab=#net47}
N 2390 -7040 2590 -7040 {
lab=#net47}
N 2590 -7040 2600 -7030 {
lab=#net47}
N 2380 -7010 2390 -7020 {
lab=#net48}
N 2390 -7020 2590 -7020 {
lab=#net48}
N 2590 -7020 2600 -7010 {
lab=#net48}
N 2440 -7170 2440 -7150 {
lab=vcom}
N 2480 -7170 2480 -7150 {
lab=ctop}
N 2360 -7070 2380 -7070 {
lab=col_n[23]}
N 2360 -7050 2380 -7050 {
lab=colon_n[23]}
N 2360 -7030 2380 -7030 {
lab=#net47}
N 2360 -7010 2380 -7010 {
lab=#net48}
N 2600 -7010 2620 -7010 {
lab=#net48}
N 2600 -7030 2620 -7030 {
lab=#net47}
N 2600 -7050 2620 -7050 {
lab=colon_n[23]}
N 2600 -7070 2620 -7070 {
lab=col_n[23]}
N 2420 -6930 2420 -6920 {
lab=VSS}
N 2420 -7160 2420 -7150 {
lab=VDD}
N 2760 -6930 2770 -6940 {
lab=row_n[6]}
N 2770 -7140 2770 -6940 {
lab=row_n[6]}
N 2760 -7150 2770 -7140 {
lab=row_n[6]}
N 2760 -6930 2760 -6910 {
lab=row_n[6]}
N 2760 -7170 2760 -7150 {
lab=row_n[6]}
N 2640 -7070 2650 -7080 {
lab=col_n[23]}
N 2650 -7080 2850 -7080 {
lab=col_n[23]}
N 2850 -7080 2860 -7070 {
lab=col_n[23]}
N 2640 -7050 2650 -7060 {
lab=colon_n[23]}
N 2650 -7060 2850 -7060 {
lab=colon_n[23]}
N 2850 -7060 2860 -7050 {
lab=colon_n[23]}
N 2640 -7030 2650 -7040 {
lab=#net47}
N 2650 -7040 2850 -7040 {
lab=#net47}
N 2850 -7040 2860 -7030 {
lab=#net47}
N 2640 -7010 2650 -7020 {
lab=#net48}
N 2650 -7020 2850 -7020 {
lab=#net48}
N 2850 -7020 2860 -7010 {
lab=#net48}
N 2700 -7170 2700 -7150 {
lab=vcom}
N 2740 -7170 2740 -7150 {
lab=ctop}
N 2620 -7070 2640 -7070 {
lab=col_n[23]}
N 2620 -7050 2640 -7050 {
lab=colon_n[23]}
N 2620 -7030 2640 -7030 {
lab=#net47}
N 2620 -7010 2640 -7010 {
lab=#net48}
N 2860 -7010 2880 -7010 {
lab=#net48}
N 2860 -7030 2880 -7030 {
lab=#net47}
N 2860 -7050 2880 -7050 {
lab=colon_n[23]}
N 2860 -7070 2880 -7070 {
lab=col_n[23]}
N 2680 -6930 2680 -6920 {
lab=VSS}
N 2680 -7160 2680 -7150 {
lab=VDD}
N 3020 -6930 3030 -6940 {
lab=row_n[7]}
N 3030 -7140 3030 -6940 {
lab=row_n[7]}
N 3020 -7150 3030 -7140 {
lab=row_n[7]}
N 3020 -6930 3020 -6910 {
lab=row_n[7]}
N 3020 -7170 3020 -7150 {
lab=row_n[7]}
N 2900 -7070 2910 -7080 {
lab=col_n[23]}
N 2910 -7080 3110 -7080 {
lab=col_n[23]}
N 3110 -7080 3120 -7070 {
lab=col_n[23]}
N 2900 -7050 2910 -7060 {
lab=colon_n[23]}
N 2910 -7060 3110 -7060 {
lab=colon_n[23]}
N 3110 -7060 3120 -7050 {
lab=colon_n[23]}
N 2900 -7030 2910 -7040 {
lab=#net47}
N 2910 -7040 3110 -7040 {
lab=#net47}
N 3110 -7040 3120 -7030 {
lab=#net47}
N 2900 -7010 2910 -7020 {
lab=#net48}
N 2910 -7020 3110 -7020 {
lab=#net48}
N 3110 -7020 3120 -7010 {
lab=#net48}
N 2960 -7170 2960 -7150 {
lab=vcom}
N 3000 -7170 3000 -7150 {
lab=ctop}
N 2880 -7070 2900 -7070 {
lab=col_n[23]}
N 2880 -7050 2900 -7050 {
lab=colon_n[23]}
N 2880 -7030 2900 -7030 {
lab=#net47}
N 2880 -7010 2900 -7010 {
lab=#net48}
N 3120 -7010 3140 -7010 {
lab=#net48}
N 3120 -7030 3140 -7030 {
lab=#net47}
N 3120 -7050 3140 -7050 {
lab=colon_n[23]}
N 3120 -7070 3140 -7070 {
lab=col_n[23]}
N 2940 -6930 2940 -6920 {
lab=VSS}
N 2940 -7160 2940 -7150 {
lab=VDD}
N 3280 -6930 3290 -6940 {
lab=row_n[8]}
N 3290 -7140 3290 -6940 {
lab=row_n[8]}
N 3280 -7150 3290 -7140 {
lab=row_n[8]}
N 3280 -6930 3280 -6910 {
lab=row_n[8]}
N 3280 -7170 3280 -7150 {
lab=row_n[8]}
N 3160 -7070 3170 -7080 {
lab=col_n[23]}
N 3170 -7080 3370 -7080 {
lab=col_n[23]}
N 3370 -7080 3380 -7070 {
lab=col_n[23]}
N 3160 -7050 3170 -7060 {
lab=colon_n[23]}
N 3170 -7060 3370 -7060 {
lab=colon_n[23]}
N 3370 -7060 3380 -7050 {
lab=colon_n[23]}
N 3160 -7030 3170 -7040 {
lab=#net47}
N 3170 -7040 3370 -7040 {
lab=#net47}
N 3370 -7040 3380 -7030 {
lab=#net47}
N 3160 -7010 3170 -7020 {
lab=#net48}
N 3170 -7020 3370 -7020 {
lab=#net48}
N 3370 -7020 3380 -7010 {
lab=#net48}
N 3220 -7170 3220 -7150 {
lab=vcom}
N 3260 -7170 3260 -7150 {
lab=ctop}
N 3140 -7070 3160 -7070 {
lab=col_n[23]}
N 3140 -7050 3160 -7050 {
lab=colon_n[23]}
N 3140 -7030 3160 -7030 {
lab=#net47}
N 3140 -7010 3160 -7010 {
lab=#net48}
N 3380 -7010 3400 -7010 {
lab=#net48}
N 3380 -7030 3400 -7030 {
lab=#net47}
N 3380 -7050 3400 -7050 {
lab=colon_n[23]}
N 3380 -7070 3400 -7070 {
lab=col_n[23]}
N 3200 -6930 3200 -6920 {
lab=VSS}
N 3200 -7160 3200 -7150 {
lab=VDD}
N 3540 -6930 3550 -6940 {
lab=row_n[9]}
N 3550 -7140 3550 -6940 {
lab=row_n[9]}
N 3540 -7150 3550 -7140 {
lab=row_n[9]}
N 3540 -6930 3540 -6910 {
lab=row_n[9]}
N 3540 -7170 3540 -7150 {
lab=row_n[9]}
N 3420 -7070 3430 -7080 {
lab=col_n[23]}
N 3430 -7080 3630 -7080 {
lab=col_n[23]}
N 3630 -7080 3640 -7070 {
lab=col_n[23]}
N 3420 -7050 3430 -7060 {
lab=colon_n[23]}
N 3430 -7060 3630 -7060 {
lab=colon_n[23]}
N 3630 -7060 3640 -7050 {
lab=colon_n[23]}
N 3420 -7030 3430 -7040 {
lab=#net47}
N 3430 -7040 3630 -7040 {
lab=#net47}
N 3630 -7040 3640 -7030 {
lab=#net47}
N 3420 -7010 3430 -7020 {
lab=#net48}
N 3430 -7020 3630 -7020 {
lab=#net48}
N 3630 -7020 3640 -7010 {
lab=#net48}
N 3480 -7170 3480 -7150 {
lab=vcom}
N 3520 -7170 3520 -7150 {
lab=ctop}
N 3400 -7070 3420 -7070 {
lab=col_n[23]}
N 3400 -7050 3420 -7050 {
lab=colon_n[23]}
N 3400 -7030 3420 -7030 {
lab=#net47}
N 3400 -7010 3420 -7010 {
lab=#net48}
N 3640 -7010 3660 -7010 {
lab=#net48}
N 3640 -7030 3660 -7030 {
lab=#net47}
N 3640 -7050 3660 -7050 {
lab=colon_n[23]}
N 3640 -7070 3660 -7070 {
lab=col_n[23]}
N 3460 -6930 3460 -6920 {
lab=VSS}
N 3460 -7160 3460 -7150 {
lab=VDD}
N 3800 -6930 3810 -6940 {
lab=row_n[10]}
N 3810 -7140 3810 -6940 {
lab=row_n[10]}
N 3800 -7150 3810 -7140 {
lab=row_n[10]}
N 3800 -6930 3800 -6910 {
lab=row_n[10]}
N 3800 -7170 3800 -7150 {
lab=row_n[10]}
N 3680 -7070 3690 -7080 {
lab=col_n[23]}
N 3690 -7080 3890 -7080 {
lab=col_n[23]}
N 3890 -7080 3900 -7070 {
lab=col_n[23]}
N 3680 -7050 3690 -7060 {
lab=colon_n[23]}
N 3690 -7060 3890 -7060 {
lab=colon_n[23]}
N 3890 -7060 3900 -7050 {
lab=colon_n[23]}
N 3680 -7030 3690 -7040 {
lab=#net47}
N 3690 -7040 3890 -7040 {
lab=#net47}
N 3890 -7040 3900 -7030 {
lab=#net47}
N 3680 -7010 3690 -7020 {
lab=#net48}
N 3690 -7020 3890 -7020 {
lab=#net48}
N 3890 -7020 3900 -7010 {
lab=#net48}
N 3740 -7170 3740 -7150 {
lab=vcom}
N 3780 -7170 3780 -7150 {
lab=ctop}
N 3660 -7070 3680 -7070 {
lab=col_n[23]}
N 3660 -7050 3680 -7050 {
lab=colon_n[23]}
N 3660 -7030 3680 -7030 {
lab=#net47}
N 3660 -7010 3680 -7010 {
lab=#net48}
N 3900 -7010 3920 -7010 {
lab=#net48}
N 3900 -7030 3920 -7030 {
lab=#net47}
N 3900 -7050 3920 -7050 {
lab=colon_n[23]}
N 3900 -7070 3920 -7070 {
lab=col_n[23]}
N 3720 -6930 3720 -6920 {
lab=VSS}
N 3720 -7160 3720 -7150 {
lab=VDD}
N 4060 -6930 4070 -6940 {
lab=row_n[11]}
N 4070 -7140 4070 -6940 {
lab=row_n[11]}
N 4060 -7150 4070 -7140 {
lab=row_n[11]}
N 4060 -6930 4060 -6910 {
lab=row_n[11]}
N 4060 -7170 4060 -7150 {
lab=row_n[11]}
N 3940 -7070 3950 -7080 {
lab=col_n[23]}
N 3950 -7080 4150 -7080 {
lab=col_n[23]}
N 4150 -7080 4160 -7070 {
lab=col_n[23]}
N 3940 -7050 3950 -7060 {
lab=colon_n[23]}
N 3950 -7060 4150 -7060 {
lab=colon_n[23]}
N 4150 -7060 4160 -7050 {
lab=colon_n[23]}
N 3940 -7030 3950 -7040 {
lab=#net47}
N 3950 -7040 4150 -7040 {
lab=#net47}
N 4150 -7040 4160 -7030 {
lab=#net47}
N 3940 -7010 3950 -7020 {
lab=#net48}
N 3950 -7020 4150 -7020 {
lab=#net48}
N 4150 -7020 4160 -7010 {
lab=#net48}
N 4000 -7170 4000 -7150 {
lab=vcom}
N 4040 -7170 4040 -7150 {
lab=ctop}
N 3920 -7070 3940 -7070 {
lab=col_n[23]}
N 3920 -7050 3940 -7050 {
lab=colon_n[23]}
N 3920 -7030 3940 -7030 {
lab=#net47}
N 3920 -7010 3940 -7010 {
lab=#net48}
N 4160 -7010 4180 -7010 {
lab=#net48}
N 4160 -7030 4180 -7030 {
lab=#net47}
N 4160 -7050 4180 -7050 {
lab=colon_n[23]}
N 4160 -7070 4180 -7070 {
lab=col_n[23]}
N 3980 -6930 3980 -6920 {
lab=VSS}
N 3980 -7160 3980 -7150 {
lab=VDD}
N 4320 -6930 4330 -6940 {
lab=row_n[12]}
N 4330 -7140 4330 -6940 {
lab=row_n[12]}
N 4320 -7150 4330 -7140 {
lab=row_n[12]}
N 4320 -6930 4320 -6910 {
lab=row_n[12]}
N 4320 -7170 4320 -7150 {
lab=row_n[12]}
N 4200 -7070 4210 -7080 {
lab=col_n[23]}
N 4210 -7080 4410 -7080 {
lab=col_n[23]}
N 4410 -7080 4420 -7070 {
lab=col_n[23]}
N 4200 -7050 4210 -7060 {
lab=colon_n[23]}
N 4210 -7060 4410 -7060 {
lab=colon_n[23]}
N 4410 -7060 4420 -7050 {
lab=colon_n[23]}
N 4200 -7030 4210 -7040 {
lab=#net47}
N 4210 -7040 4410 -7040 {
lab=#net47}
N 4410 -7040 4420 -7030 {
lab=#net47}
N 4200 -7010 4210 -7020 {
lab=#net48}
N 4210 -7020 4410 -7020 {
lab=#net48}
N 4410 -7020 4420 -7010 {
lab=#net48}
N 4260 -7170 4260 -7150 {
lab=vcom}
N 4300 -7170 4300 -7150 {
lab=ctop}
N 4180 -7070 4200 -7070 {
lab=col_n[23]}
N 4180 -7050 4200 -7050 {
lab=colon_n[23]}
N 4180 -7030 4200 -7030 {
lab=#net47}
N 4180 -7010 4200 -7010 {
lab=#net48}
N 4420 -7010 4440 -7010 {
lab=#net48}
N 4420 -7030 4440 -7030 {
lab=#net47}
N 4420 -7050 4440 -7050 {
lab=colon_n[23]}
N 4420 -7070 4440 -7070 {
lab=col_n[23]}
N 4240 -6930 4240 -6920 {
lab=VSS}
N 4240 -7160 4240 -7150 {
lab=VDD}
N 4580 -6930 4590 -6940 {
lab=row_n[13]}
N 4590 -7140 4590 -6940 {
lab=row_n[13]}
N 4580 -7150 4590 -7140 {
lab=row_n[13]}
N 4580 -6930 4580 -6910 {
lab=row_n[13]}
N 4580 -7170 4580 -7150 {
lab=row_n[13]}
N 4460 -7070 4470 -7080 {
lab=col_n[23]}
N 4470 -7080 4670 -7080 {
lab=col_n[23]}
N 4670 -7080 4680 -7070 {
lab=col_n[23]}
N 4460 -7050 4470 -7060 {
lab=colon_n[23]}
N 4470 -7060 4670 -7060 {
lab=colon_n[23]}
N 4670 -7060 4680 -7050 {
lab=colon_n[23]}
N 4460 -7030 4470 -7040 {
lab=#net47}
N 4470 -7040 4670 -7040 {
lab=#net47}
N 4670 -7040 4680 -7030 {
lab=#net47}
N 4460 -7010 4470 -7020 {
lab=#net48}
N 4470 -7020 4670 -7020 {
lab=#net48}
N 4670 -7020 4680 -7010 {
lab=#net48}
N 4520 -7170 4520 -7150 {
lab=vcom}
N 4560 -7170 4560 -7150 {
lab=ctop}
N 4440 -7070 4460 -7070 {
lab=col_n[23]}
N 4440 -7050 4460 -7050 {
lab=colon_n[23]}
N 4440 -7030 4460 -7030 {
lab=#net47}
N 4440 -7010 4460 -7010 {
lab=#net48}
N 4680 -7010 4700 -7010 {
lab=#net48}
N 4680 -7030 4700 -7030 {
lab=#net47}
N 4680 -7050 4700 -7050 {
lab=colon_n[23]}
N 4680 -7070 4700 -7070 {
lab=col_n[23]}
N 4500 -6930 4500 -6920 {
lab=VSS}
N 4500 -7160 4500 -7150 {
lab=VDD}
N 4840 -6930 4850 -6940 {
lab=row_n[14]}
N 4850 -7140 4850 -6940 {
lab=row_n[14]}
N 4840 -7150 4850 -7140 {
lab=row_n[14]}
N 4840 -6930 4840 -6910 {
lab=row_n[14]}
N 4840 -7170 4840 -7150 {
lab=row_n[14]}
N 4720 -7070 4730 -7080 {
lab=col_n[23]}
N 4730 -7080 4930 -7080 {
lab=col_n[23]}
N 4930 -7080 4940 -7070 {
lab=col_n[23]}
N 4720 -7050 4730 -7060 {
lab=colon_n[23]}
N 4730 -7060 4930 -7060 {
lab=colon_n[23]}
N 4930 -7060 4940 -7050 {
lab=colon_n[23]}
N 4720 -7030 4730 -7040 {
lab=#net47}
N 4730 -7040 4930 -7040 {
lab=#net47}
N 4930 -7040 4940 -7030 {
lab=#net47}
N 4720 -7010 4730 -7020 {
lab=#net48}
N 4730 -7020 4930 -7020 {
lab=#net48}
N 4930 -7020 4940 -7010 {
lab=#net48}
N 4780 -7170 4780 -7150 {
lab=vcom}
N 4820 -7170 4820 -7150 {
lab=ctop}
N 4700 -7070 4720 -7070 {
lab=col_n[23]}
N 4700 -7050 4720 -7050 {
lab=colon_n[23]}
N 4700 -7030 4720 -7030 {
lab=#net47}
N 4700 -7010 4720 -7010 {
lab=#net48}
N 4940 -7010 4960 -7010 {
lab=#net48}
N 4940 -7030 4960 -7030 {
lab=#net47}
N 4940 -7050 4960 -7050 {
lab=colon_n[23]}
N 4940 -7070 4960 -7070 {
lab=col_n[23]}
N 4760 -6930 4760 -6920 {
lab=VSS}
N 4760 -7160 4760 -7150 {
lab=VDD}
N 5100 -6930 5110 -6940 {
lab=row_n[15]}
N 5110 -7140 5110 -6940 {
lab=row_n[15]}
N 5100 -7150 5110 -7140 {
lab=row_n[15]}
N 5100 -6930 5100 -6910 {
lab=row_n[15]}
N 5100 -7170 5100 -7150 {
lab=row_n[15]}
N 4980 -7070 4990 -7080 {
lab=col_n[23]}
N 4990 -7080 5190 -7080 {
lab=col_n[23]}
N 5190 -7080 5200 -7070 {
lab=col_n[23]}
N 4980 -7050 4990 -7060 {
lab=colon_n[23]}
N 4990 -7060 5190 -7060 {
lab=colon_n[23]}
N 5190 -7060 5200 -7050 {
lab=colon_n[23]}
N 4980 -7030 4990 -7040 {
lab=#net47}
N 4990 -7040 5190 -7040 {
lab=#net47}
N 5190 -7040 5200 -7030 {
lab=#net47}
N 4980 -7010 4990 -7020 {
lab=#net48}
N 4990 -7020 5190 -7020 {
lab=#net48}
N 5190 -7020 5200 -7010 {
lab=#net48}
N 5040 -7170 5040 -7150 {
lab=vcom}
N 5080 -7170 5080 -7150 {
lab=ctop}
N 4960 -7070 4980 -7070 {
lab=col_n[23]}
N 4960 -7050 4980 -7050 {
lab=colon_n[23]}
N 4960 -7030 4980 -7030 {
lab=#net47}
N 4960 -7010 4980 -7010 {
lab=#net48}
N 5200 -7010 5220 -7010 {
lab=#net48}
N 5200 -7030 5220 -7030 {
lab=#net47}
N 5200 -7050 5220 -7050 {
lab=colon_n[23]}
N 5200 -7070 5220 -7070 {
lab=col_n[23]}
N 5020 -6930 5020 -6920 {
lab=VSS}
N 5020 -7160 5020 -7150 {
lab=VDD}
N 5360 -6930 5370 -6940 {
lab=row_n[16]}
N 5370 -7140 5370 -6940 {
lab=row_n[16]}
N 5360 -7150 5370 -7140 {
lab=row_n[16]}
N 5360 -6930 5360 -6910 {
lab=row_n[16]}
N 5360 -7170 5360 -7150 {
lab=row_n[16]}
N 5240 -7070 5250 -7080 {
lab=col_n[23]}
N 5250 -7080 5450 -7080 {
lab=col_n[23]}
N 5450 -7080 5460 -7070 {
lab=col_n[23]}
N 5240 -7050 5250 -7060 {
lab=colon_n[23]}
N 5250 -7060 5450 -7060 {
lab=colon_n[23]}
N 5450 -7060 5460 -7050 {
lab=colon_n[23]}
N 5240 -7030 5250 -7040 {
lab=#net47}
N 5250 -7040 5450 -7040 {
lab=#net47}
N 5450 -7040 5460 -7030 {
lab=#net47}
N 5240 -7010 5250 -7020 {
lab=#net48}
N 5250 -7020 5450 -7020 {
lab=#net48}
N 5450 -7020 5460 -7010 {
lab=#net48}
N 5300 -7170 5300 -7150 {
lab=vcom}
N 5340 -7170 5340 -7150 {
lab=ctop}
N 5220 -7070 5240 -7070 {
lab=col_n[23]}
N 5220 -7050 5240 -7050 {
lab=colon_n[23]}
N 5220 -7030 5240 -7030 {
lab=#net47}
N 5220 -7010 5240 -7010 {
lab=#net48}
N 5460 -7010 5480 -7010 {
lab=#net48}
N 5460 -7030 5480 -7030 {
lab=#net47}
N 5460 -7050 5480 -7050 {
lab=colon_n[23]}
N 5460 -7070 5480 -7070 {
lab=col_n[23]}
N 5280 -6930 5280 -6920 {
lab=VSS}
N 5280 -7160 5280 -7150 {
lab=VDD}
N 5620 -6930 5630 -6940 {
lab=row_n[17]}
N 5630 -7140 5630 -6940 {
lab=row_n[17]}
N 5620 -7150 5630 -7140 {
lab=row_n[17]}
N 5620 -6930 5620 -6910 {
lab=row_n[17]}
N 5620 -7170 5620 -7150 {
lab=row_n[17]}
N 5500 -7070 5510 -7080 {
lab=col_n[23]}
N 5510 -7080 5710 -7080 {
lab=col_n[23]}
N 5710 -7080 5720 -7070 {
lab=col_n[23]}
N 5500 -7050 5510 -7060 {
lab=colon_n[23]}
N 5510 -7060 5710 -7060 {
lab=colon_n[23]}
N 5710 -7060 5720 -7050 {
lab=colon_n[23]}
N 5500 -7030 5510 -7040 {
lab=#net47}
N 5510 -7040 5710 -7040 {
lab=#net47}
N 5710 -7040 5720 -7030 {
lab=#net47}
N 5500 -7010 5510 -7020 {
lab=#net48}
N 5510 -7020 5710 -7020 {
lab=#net48}
N 5710 -7020 5720 -7010 {
lab=#net48}
N 5560 -7170 5560 -7150 {
lab=vcom}
N 5600 -7170 5600 -7150 {
lab=ctop}
N 5480 -7070 5500 -7070 {
lab=col_n[23]}
N 5480 -7050 5500 -7050 {
lab=colon_n[23]}
N 5480 -7030 5500 -7030 {
lab=#net47}
N 5480 -7010 5500 -7010 {
lab=#net48}
N 5720 -7010 5740 -7010 {
lab=#net48}
N 5720 -7030 5740 -7030 {
lab=#net47}
N 5720 -7050 5740 -7050 {
lab=colon_n[23]}
N 5720 -7070 5740 -7070 {
lab=col_n[23]}
N 5540 -6930 5540 -6920 {
lab=VSS}
N 5540 -7160 5540 -7150 {
lab=VDD}
N 5880 -6930 5890 -6940 {
lab=row_n[18]}
N 5890 -7140 5890 -6940 {
lab=row_n[18]}
N 5880 -7150 5890 -7140 {
lab=row_n[18]}
N 5880 -6930 5880 -6910 {
lab=row_n[18]}
N 5880 -7170 5880 -7150 {
lab=row_n[18]}
N 5760 -7070 5770 -7080 {
lab=col_n[23]}
N 5770 -7080 5970 -7080 {
lab=col_n[23]}
N 5970 -7080 5980 -7070 {
lab=col_n[23]}
N 5760 -7050 5770 -7060 {
lab=colon_n[23]}
N 5770 -7060 5970 -7060 {
lab=colon_n[23]}
N 5970 -7060 5980 -7050 {
lab=colon_n[23]}
N 5760 -7030 5770 -7040 {
lab=#net47}
N 5770 -7040 5970 -7040 {
lab=#net47}
N 5970 -7040 5980 -7030 {
lab=#net47}
N 5760 -7010 5770 -7020 {
lab=#net48}
N 5770 -7020 5970 -7020 {
lab=#net48}
N 5970 -7020 5980 -7010 {
lab=#net48}
N 5820 -7170 5820 -7150 {
lab=vcom}
N 5860 -7170 5860 -7150 {
lab=ctop}
N 5740 -7070 5760 -7070 {
lab=col_n[23]}
N 5740 -7050 5760 -7050 {
lab=colon_n[23]}
N 5740 -7030 5760 -7030 {
lab=#net47}
N 5740 -7010 5760 -7010 {
lab=#net48}
N 5980 -7010 6000 -7010 {
lab=#net48}
N 5980 -7030 6000 -7030 {
lab=#net47}
N 5980 -7050 6000 -7050 {
lab=colon_n[23]}
N 5980 -7070 6000 -7070 {
lab=col_n[23]}
N 5800 -6930 5800 -6920 {
lab=VSS}
N 5800 -7160 5800 -7150 {
lab=VDD}
N 6140 -6930 6150 -6940 {
lab=row_n[19]}
N 6150 -7140 6150 -6940 {
lab=row_n[19]}
N 6140 -7150 6150 -7140 {
lab=row_n[19]}
N 6140 -6930 6140 -6910 {
lab=row_n[19]}
N 6140 -7170 6140 -7150 {
lab=row_n[19]}
N 6020 -7070 6030 -7080 {
lab=col_n[23]}
N 6030 -7080 6230 -7080 {
lab=col_n[23]}
N 6230 -7080 6240 -7070 {
lab=col_n[23]}
N 6020 -7050 6030 -7060 {
lab=colon_n[23]}
N 6030 -7060 6230 -7060 {
lab=colon_n[23]}
N 6230 -7060 6240 -7050 {
lab=colon_n[23]}
N 6020 -7030 6030 -7040 {
lab=#net47}
N 6030 -7040 6230 -7040 {
lab=#net47}
N 6230 -7040 6240 -7030 {
lab=#net47}
N 6020 -7010 6030 -7020 {
lab=#net48}
N 6030 -7020 6230 -7020 {
lab=#net48}
N 6230 -7020 6240 -7010 {
lab=#net48}
N 6080 -7170 6080 -7150 {
lab=vcom}
N 6120 -7170 6120 -7150 {
lab=ctop}
N 6000 -7070 6020 -7070 {
lab=col_n[23]}
N 6000 -7050 6020 -7050 {
lab=colon_n[23]}
N 6000 -7030 6020 -7030 {
lab=#net47}
N 6000 -7010 6020 -7010 {
lab=#net48}
N 6240 -7010 6260 -7010 {
lab=#net48}
N 6240 -7030 6260 -7030 {
lab=#net47}
N 6240 -7050 6260 -7050 {
lab=colon_n[23]}
N 6240 -7070 6260 -7070 {
lab=col_n[23]}
N 6060 -6930 6060 -6920 {
lab=VSS}
N 6060 -7160 6060 -7150 {
lab=VDD}
N 6400 -6930 6410 -6940 {
lab=row_n[20]}
N 6410 -7140 6410 -6940 {
lab=row_n[20]}
N 6400 -7150 6410 -7140 {
lab=row_n[20]}
N 6400 -6930 6400 -6910 {
lab=row_n[20]}
N 6400 -7170 6400 -7150 {
lab=row_n[20]}
N 6280 -7070 6290 -7080 {
lab=col_n[23]}
N 6290 -7080 6490 -7080 {
lab=col_n[23]}
N 6490 -7080 6500 -7070 {
lab=col_n[23]}
N 6280 -7050 6290 -7060 {
lab=colon_n[23]}
N 6290 -7060 6490 -7060 {
lab=colon_n[23]}
N 6490 -7060 6500 -7050 {
lab=colon_n[23]}
N 6280 -7030 6290 -7040 {
lab=#net47}
N 6290 -7040 6490 -7040 {
lab=#net47}
N 6490 -7040 6500 -7030 {
lab=#net47}
N 6280 -7010 6290 -7020 {
lab=#net48}
N 6290 -7020 6490 -7020 {
lab=#net48}
N 6490 -7020 6500 -7010 {
lab=#net48}
N 6340 -7170 6340 -7150 {
lab=vcom}
N 6380 -7170 6380 -7150 {
lab=ctop}
N 6260 -7070 6280 -7070 {
lab=col_n[23]}
N 6260 -7050 6280 -7050 {
lab=colon_n[23]}
N 6260 -7030 6280 -7030 {
lab=#net47}
N 6260 -7010 6280 -7010 {
lab=#net48}
N 6500 -7010 6520 -7010 {
lab=#net48}
N 6500 -7030 6520 -7030 {
lab=#net47}
N 6500 -7050 6520 -7050 {
lab=colon_n[23]}
N 6500 -7070 6520 -7070 {
lab=col_n[23]}
N 6320 -6930 6320 -6920 {
lab=VSS}
N 6320 -7160 6320 -7150 {
lab=VDD}
N 6660 -6930 6670 -6940 {
lab=row_n[21]}
N 6670 -7140 6670 -6940 {
lab=row_n[21]}
N 6660 -7150 6670 -7140 {
lab=row_n[21]}
N 6660 -6930 6660 -6910 {
lab=row_n[21]}
N 6660 -7170 6660 -7150 {
lab=row_n[21]}
N 6540 -7070 6550 -7080 {
lab=col_n[23]}
N 6550 -7080 6750 -7080 {
lab=col_n[23]}
N 6750 -7080 6760 -7070 {
lab=col_n[23]}
N 6540 -7050 6550 -7060 {
lab=colon_n[23]}
N 6550 -7060 6750 -7060 {
lab=colon_n[23]}
N 6750 -7060 6760 -7050 {
lab=colon_n[23]}
N 6540 -7030 6550 -7040 {
lab=#net47}
N 6550 -7040 6750 -7040 {
lab=#net47}
N 6750 -7040 6760 -7030 {
lab=#net47}
N 6540 -7010 6550 -7020 {
lab=#net48}
N 6550 -7020 6750 -7020 {
lab=#net48}
N 6750 -7020 6760 -7010 {
lab=#net48}
N 6600 -7170 6600 -7150 {
lab=vcom}
N 6640 -7170 6640 -7150 {
lab=ctop}
N 6520 -7070 6540 -7070 {
lab=col_n[23]}
N 6520 -7050 6540 -7050 {
lab=colon_n[23]}
N 6520 -7030 6540 -7030 {
lab=#net47}
N 6520 -7010 6540 -7010 {
lab=#net48}
N 6760 -7010 6780 -7010 {
lab=#net48}
N 6760 -7030 6780 -7030 {
lab=#net47}
N 6760 -7050 6780 -7050 {
lab=colon_n[23]}
N 6760 -7070 6780 -7070 {
lab=col_n[23]}
N 6580 -6930 6580 -6920 {
lab=VSS}
N 6580 -7160 6580 -7150 {
lab=VDD}
N 6920 -6930 6930 -6940 {
lab=row_n[22]}
N 6930 -7140 6930 -6940 {
lab=row_n[22]}
N 6920 -7150 6930 -7140 {
lab=row_n[22]}
N 6920 -6930 6920 -6910 {
lab=row_n[22]}
N 6920 -7170 6920 -7150 {
lab=row_n[22]}
N 6800 -7070 6810 -7080 {
lab=col_n[23]}
N 6810 -7080 7010 -7080 {
lab=col_n[23]}
N 7010 -7080 7020 -7070 {
lab=col_n[23]}
N 6800 -7050 6810 -7060 {
lab=colon_n[23]}
N 6810 -7060 7010 -7060 {
lab=colon_n[23]}
N 7010 -7060 7020 -7050 {
lab=colon_n[23]}
N 6800 -7030 6810 -7040 {
lab=#net47}
N 6810 -7040 7010 -7040 {
lab=#net47}
N 7010 -7040 7020 -7030 {
lab=#net47}
N 6800 -7010 6810 -7020 {
lab=#net48}
N 6810 -7020 7010 -7020 {
lab=#net48}
N 7010 -7020 7020 -7010 {
lab=#net48}
N 6860 -7170 6860 -7150 {
lab=vcom}
N 6900 -7170 6900 -7150 {
lab=ctop}
N 6780 -7070 6800 -7070 {
lab=col_n[23]}
N 6780 -7050 6800 -7050 {
lab=colon_n[23]}
N 6780 -7030 6800 -7030 {
lab=#net47}
N 6780 -7010 6800 -7010 {
lab=#net48}
N 7020 -7010 7040 -7010 {
lab=#net48}
N 7020 -7030 7040 -7030 {
lab=#net47}
N 7020 -7050 7040 -7050 {
lab=colon_n[23]}
N 7020 -7070 7040 -7070 {
lab=col_n[23]}
N 6840 -6930 6840 -6920 {
lab=VSS}
N 6840 -7160 6840 -7150 {
lab=VDD}
N 7180 -6930 7190 -6940 {
lab=row_n[23]}
N 7190 -7140 7190 -6940 {
lab=row_n[23]}
N 7180 -7150 7190 -7140 {
lab=row_n[23]}
N 7180 -6930 7180 -6910 {
lab=row_n[23]}
N 7180 -7170 7180 -7150 {
lab=row_n[23]}
N 7060 -7070 7070 -7080 {
lab=col_n[23]}
N 7070 -7080 7270 -7080 {
lab=col_n[23]}
N 7270 -7080 7280 -7070 {
lab=col_n[23]}
N 7060 -7050 7070 -7060 {
lab=colon_n[23]}
N 7070 -7060 7270 -7060 {
lab=colon_n[23]}
N 7270 -7060 7280 -7050 {
lab=colon_n[23]}
N 7060 -7030 7070 -7040 {
lab=#net47}
N 7070 -7040 7270 -7040 {
lab=#net47}
N 7270 -7040 7280 -7030 {
lab=#net47}
N 7060 -7010 7070 -7020 {
lab=#net48}
N 7070 -7020 7270 -7020 {
lab=#net48}
N 7270 -7020 7280 -7010 {
lab=#net48}
N 7120 -7170 7120 -7150 {
lab=vcom}
N 7160 -7170 7160 -7150 {
lab=ctop}
N 7040 -7070 7060 -7070 {
lab=col_n[23]}
N 7040 -7050 7060 -7050 {
lab=colon_n[23]}
N 7040 -7030 7060 -7030 {
lab=#net47}
N 7040 -7010 7060 -7010 {
lab=#net48}
N 7280 -7010 7300 -7010 {
lab=#net48}
N 7280 -7030 7300 -7030 {
lab=#net47}
N 7280 -7050 7300 -7050 {
lab=colon_n[23]}
N 7280 -7070 7300 -7070 {
lab=col_n[23]}
N 7100 -6930 7100 -6920 {
lab=VSS}
N 7100 -7160 7100 -7150 {
lab=VDD}
N 7440 -6930 7450 -6940 {
lab=row_n[24]}
N 7450 -7140 7450 -6940 {
lab=row_n[24]}
N 7440 -7150 7450 -7140 {
lab=row_n[24]}
N 7440 -6930 7440 -6910 {
lab=row_n[24]}
N 7440 -7170 7440 -7150 {
lab=row_n[24]}
N 7320 -7070 7330 -7080 {
lab=col_n[23]}
N 7330 -7080 7530 -7080 {
lab=col_n[23]}
N 7530 -7080 7540 -7070 {
lab=col_n[23]}
N 7320 -7050 7330 -7060 {
lab=colon_n[23]}
N 7330 -7060 7530 -7060 {
lab=colon_n[23]}
N 7530 -7060 7540 -7050 {
lab=colon_n[23]}
N 7320 -7030 7330 -7040 {
lab=#net47}
N 7330 -7040 7530 -7040 {
lab=#net47}
N 7530 -7040 7540 -7030 {
lab=#net47}
N 7320 -7010 7330 -7020 {
lab=#net48}
N 7330 -7020 7530 -7020 {
lab=#net48}
N 7530 -7020 7540 -7010 {
lab=#net48}
N 7380 -7170 7380 -7150 {
lab=vcom}
N 7420 -7170 7420 -7150 {
lab=ctop}
N 7300 -7070 7320 -7070 {
lab=col_n[23]}
N 7300 -7050 7320 -7050 {
lab=colon_n[23]}
N 7300 -7030 7320 -7030 {
lab=#net47}
N 7300 -7010 7320 -7010 {
lab=#net48}
N 7540 -7010 7560 -7010 {
lab=#net48}
N 7540 -7030 7560 -7030 {
lab=#net47}
N 7540 -7050 7560 -7050 {
lab=colon_n[23]}
N 7540 -7070 7560 -7070 {
lab=col_n[23]}
N 7360 -6930 7360 -6920 {
lab=VSS}
N 7360 -7160 7360 -7150 {
lab=VDD}
N 7700 -6930 7710 -6940 {
lab=row_n[25]}
N 7710 -7140 7710 -6940 {
lab=row_n[25]}
N 7700 -7150 7710 -7140 {
lab=row_n[25]}
N 7700 -6930 7700 -6910 {
lab=row_n[25]}
N 7700 -7170 7700 -7150 {
lab=row_n[25]}
N 7580 -7070 7590 -7080 {
lab=col_n[23]}
N 7590 -7080 7790 -7080 {
lab=col_n[23]}
N 7790 -7080 7800 -7070 {
lab=col_n[23]}
N 7580 -7050 7590 -7060 {
lab=colon_n[23]}
N 7590 -7060 7790 -7060 {
lab=colon_n[23]}
N 7790 -7060 7800 -7050 {
lab=colon_n[23]}
N 7580 -7030 7590 -7040 {
lab=#net47}
N 7590 -7040 7790 -7040 {
lab=#net47}
N 7790 -7040 7800 -7030 {
lab=#net47}
N 7580 -7010 7590 -7020 {
lab=#net48}
N 7590 -7020 7790 -7020 {
lab=#net48}
N 7790 -7020 7800 -7010 {
lab=#net48}
N 7640 -7170 7640 -7150 {
lab=vcom}
N 7680 -7170 7680 -7150 {
lab=ctop}
N 7560 -7070 7580 -7070 {
lab=col_n[23]}
N 7560 -7050 7580 -7050 {
lab=colon_n[23]}
N 7560 -7030 7580 -7030 {
lab=#net47}
N 7560 -7010 7580 -7010 {
lab=#net48}
N 7800 -7010 7820 -7010 {
lab=#net48}
N 7800 -7030 7820 -7030 {
lab=#net47}
N 7800 -7050 7820 -7050 {
lab=colon_n[23]}
N 7800 -7070 7820 -7070 {
lab=col_n[23]}
N 7620 -6930 7620 -6920 {
lab=VSS}
N 7620 -7160 7620 -7150 {
lab=VDD}
N 7960 -6930 7970 -6940 {
lab=row_n[26]}
N 7970 -7140 7970 -6940 {
lab=row_n[26]}
N 7960 -7150 7970 -7140 {
lab=row_n[26]}
N 7960 -6930 7960 -6910 {
lab=row_n[26]}
N 7960 -7170 7960 -7150 {
lab=row_n[26]}
N 7840 -7070 7850 -7080 {
lab=col_n[23]}
N 7850 -7080 8050 -7080 {
lab=col_n[23]}
N 8050 -7080 8060 -7070 {
lab=col_n[23]}
N 7840 -7050 7850 -7060 {
lab=colon_n[23]}
N 7850 -7060 8050 -7060 {
lab=colon_n[23]}
N 8050 -7060 8060 -7050 {
lab=colon_n[23]}
N 7840 -7030 7850 -7040 {
lab=#net47}
N 7850 -7040 8050 -7040 {
lab=#net47}
N 8050 -7040 8060 -7030 {
lab=#net47}
N 7840 -7010 7850 -7020 {
lab=#net48}
N 7850 -7020 8050 -7020 {
lab=#net48}
N 8050 -7020 8060 -7010 {
lab=#net48}
N 7900 -7170 7900 -7150 {
lab=vcom}
N 7940 -7170 7940 -7150 {
lab=ctop}
N 7820 -7070 7840 -7070 {
lab=col_n[23]}
N 7820 -7050 7840 -7050 {
lab=colon_n[23]}
N 7820 -7030 7840 -7030 {
lab=#net47}
N 7820 -7010 7840 -7010 {
lab=#net48}
N 8060 -7010 8080 -7010 {
lab=#net48}
N 8060 -7030 8080 -7030 {
lab=#net47}
N 8060 -7050 8080 -7050 {
lab=colon_n[23]}
N 8060 -7070 8080 -7070 {
lab=col_n[23]}
N 7880 -6930 7880 -6920 {
lab=VSS}
N 7880 -7160 7880 -7150 {
lab=VDD}
N 8220 -6930 8230 -6940 {
lab=row_n[27]}
N 8230 -7140 8230 -6940 {
lab=row_n[27]}
N 8220 -7150 8230 -7140 {
lab=row_n[27]}
N 8220 -6930 8220 -6910 {
lab=row_n[27]}
N 8220 -7170 8220 -7150 {
lab=row_n[27]}
N 8100 -7070 8110 -7080 {
lab=col_n[23]}
N 8110 -7080 8310 -7080 {
lab=col_n[23]}
N 8310 -7080 8320 -7070 {
lab=col_n[23]}
N 8100 -7050 8110 -7060 {
lab=colon_n[23]}
N 8110 -7060 8310 -7060 {
lab=colon_n[23]}
N 8310 -7060 8320 -7050 {
lab=colon_n[23]}
N 8100 -7030 8110 -7040 {
lab=#net47}
N 8110 -7040 8310 -7040 {
lab=#net47}
N 8310 -7040 8320 -7030 {
lab=#net47}
N 8100 -7010 8110 -7020 {
lab=#net48}
N 8110 -7020 8310 -7020 {
lab=#net48}
N 8310 -7020 8320 -7010 {
lab=#net48}
N 8160 -7170 8160 -7150 {
lab=vcom}
N 8200 -7170 8200 -7150 {
lab=ctop}
N 8080 -7070 8100 -7070 {
lab=col_n[23]}
N 8080 -7050 8100 -7050 {
lab=colon_n[23]}
N 8080 -7030 8100 -7030 {
lab=#net47}
N 8080 -7010 8100 -7010 {
lab=#net48}
N 8320 -7010 8340 -7010 {
lab=#net48}
N 8320 -7030 8340 -7030 {
lab=#net47}
N 8320 -7050 8340 -7050 {
lab=colon_n[23]}
N 8320 -7070 8340 -7070 {
lab=col_n[23]}
N 8140 -6930 8140 -6920 {
lab=VSS}
N 8140 -7160 8140 -7150 {
lab=VDD}
N 8480 -6930 8490 -6940 {
lab=row_n[28]}
N 8490 -7140 8490 -6940 {
lab=row_n[28]}
N 8480 -7150 8490 -7140 {
lab=row_n[28]}
N 8480 -6930 8480 -6910 {
lab=row_n[28]}
N 8480 -7170 8480 -7150 {
lab=row_n[28]}
N 8360 -7070 8370 -7080 {
lab=col_n[23]}
N 8370 -7080 8570 -7080 {
lab=col_n[23]}
N 8570 -7080 8580 -7070 {
lab=col_n[23]}
N 8360 -7050 8370 -7060 {
lab=colon_n[23]}
N 8370 -7060 8570 -7060 {
lab=colon_n[23]}
N 8570 -7060 8580 -7050 {
lab=colon_n[23]}
N 8360 -7030 8370 -7040 {
lab=#net47}
N 8370 -7040 8570 -7040 {
lab=#net47}
N 8570 -7040 8580 -7030 {
lab=#net47}
N 8360 -7010 8370 -7020 {
lab=#net48}
N 8370 -7020 8570 -7020 {
lab=#net48}
N 8570 -7020 8580 -7010 {
lab=#net48}
N 8420 -7170 8420 -7150 {
lab=vcom}
N 8460 -7170 8460 -7150 {
lab=ctop}
N 8340 -7070 8360 -7070 {
lab=col_n[23]}
N 8340 -7050 8360 -7050 {
lab=colon_n[23]}
N 8340 -7030 8360 -7030 {
lab=#net47}
N 8340 -7010 8360 -7010 {
lab=#net48}
N 8580 -7010 8600 -7010 {
lab=#net48}
N 8580 -7030 8600 -7030 {
lab=#net47}
N 8580 -7050 8600 -7050 {
lab=colon_n[23]}
N 8580 -7070 8600 -7070 {
lab=col_n[23]}
N 8400 -6930 8400 -6920 {
lab=VSS}
N 8400 -7160 8400 -7150 {
lab=VDD}
N 8740 -6930 8750 -6940 {
lab=row_n[29]}
N 8750 -7140 8750 -6940 {
lab=row_n[29]}
N 8740 -7150 8750 -7140 {
lab=row_n[29]}
N 8740 -6930 8740 -6910 {
lab=row_n[29]}
N 8740 -7170 8740 -7150 {
lab=row_n[29]}
N 8620 -7070 8630 -7080 {
lab=col_n[23]}
N 8630 -7080 8830 -7080 {
lab=col_n[23]}
N 8830 -7080 8840 -7070 {
lab=col_n[23]}
N 8620 -7050 8630 -7060 {
lab=colon_n[23]}
N 8630 -7060 8830 -7060 {
lab=colon_n[23]}
N 8830 -7060 8840 -7050 {
lab=colon_n[23]}
N 8620 -7030 8630 -7040 {
lab=#net47}
N 8630 -7040 8830 -7040 {
lab=#net47}
N 8830 -7040 8840 -7030 {
lab=#net47}
N 8620 -7010 8630 -7020 {
lab=#net48}
N 8630 -7020 8830 -7020 {
lab=#net48}
N 8830 -7020 8840 -7010 {
lab=#net48}
N 8680 -7170 8680 -7150 {
lab=vcom}
N 8720 -7170 8720 -7150 {
lab=ctop}
N 8600 -7070 8620 -7070 {
lab=col_n[23]}
N 8600 -7050 8620 -7050 {
lab=colon_n[23]}
N 8600 -7030 8620 -7030 {
lab=#net47}
N 8600 -7010 8620 -7010 {
lab=#net48}
N 8840 -7010 8860 -7010 {
lab=#net48}
N 8840 -7030 8860 -7030 {
lab=#net47}
N 8840 -7050 8860 -7050 {
lab=colon_n[23]}
N 8840 -7070 8860 -7070 {
lab=col_n[23]}
N 8660 -6930 8660 -6920 {
lab=VSS}
N 8660 -7160 8660 -7150 {
lab=VDD}
N 9000 -6930 9010 -6940 {
lab=row_n[30]}
N 9010 -7140 9010 -6940 {
lab=row_n[30]}
N 9000 -7150 9010 -7140 {
lab=row_n[30]}
N 9000 -6930 9000 -6910 {
lab=row_n[30]}
N 9000 -7170 9000 -7150 {
lab=row_n[30]}
N 8880 -7070 8890 -7080 {
lab=col_n[23]}
N 8890 -7080 9090 -7080 {
lab=col_n[23]}
N 9090 -7080 9100 -7070 {
lab=col_n[23]}
N 8880 -7050 8890 -7060 {
lab=colon_n[23]}
N 8890 -7060 9090 -7060 {
lab=colon_n[23]}
N 9090 -7060 9100 -7050 {
lab=colon_n[23]}
N 8880 -7030 8890 -7040 {
lab=#net47}
N 8890 -7040 9090 -7040 {
lab=#net47}
N 9090 -7040 9100 -7030 {
lab=#net47}
N 8880 -7010 8890 -7020 {
lab=#net48}
N 8890 -7020 9090 -7020 {
lab=#net48}
N 9090 -7020 9100 -7010 {
lab=#net48}
N 8940 -7170 8940 -7150 {
lab=vcom}
N 8980 -7170 8980 -7150 {
lab=ctop}
N 8860 -7070 8880 -7070 {
lab=col_n[23]}
N 8860 -7050 8880 -7050 {
lab=colon_n[23]}
N 8860 -7030 8880 -7030 {
lab=#net47}
N 8860 -7010 8880 -7010 {
lab=#net48}
N 9100 -7010 9120 -7010 {
lab=#net48}
N 9100 -7030 9120 -7030 {
lab=#net47}
N 9100 -7050 9120 -7050 {
lab=colon_n[23]}
N 9100 -7070 9120 -7070 {
lab=col_n[23]}
N 8920 -6930 8920 -6920 {
lab=VSS}
N 8920 -7160 8920 -7150 {
lab=VDD}
N 9260 -6930 9270 -6940 {
lab=row_n[31]}
N 9270 -7140 9270 -6940 {
lab=row_n[31]}
N 9260 -7150 9270 -7140 {
lab=row_n[31]}
N 9260 -6930 9260 -6910 {
lab=row_n[31]}
N 9260 -7170 9260 -7150 {
lab=row_n[31]}
N 9140 -7070 9150 -7080 {
lab=col_n[23]}
N 9150 -7080 9350 -7080 {
lab=col_n[23]}
N 9350 -7080 9360 -7070 {
lab=col_n[23]}
N 9140 -7050 9150 -7060 {
lab=colon_n[23]}
N 9150 -7060 9350 -7060 {
lab=colon_n[23]}
N 9350 -7060 9360 -7050 {
lab=colon_n[23]}
N 9140 -7030 9150 -7040 {
lab=#net47}
N 9150 -7040 9350 -7040 {
lab=#net47}
N 9350 -7040 9360 -7030 {
lab=#net47}
N 9140 -7010 9150 -7020 {
lab=#net48}
N 9150 -7020 9350 -7020 {
lab=#net48}
N 9350 -7020 9360 -7010 {
lab=#net48}
N 9200 -7170 9200 -7150 {
lab=vcom}
N 9240 -7170 9240 -7150 {
lab=ctop}
N 9120 -7070 9140 -7070 {
lab=col_n[23]}
N 9120 -7050 9140 -7050 {
lab=colon_n[23]}
N 9120 -7030 9140 -7030 {
lab=#net47}
N 9120 -7010 9140 -7010 {
lab=#net48}
N 9360 -7010 9380 -7010 {
lab=#net48}
N 9360 -7030 9380 -7030 {
lab=#net47}
N 9360 -7050 9380 -7050 {
lab=colon_n[23]}
N 9360 -7070 9380 -7070 {
lab=col_n[23]}
N 9180 -6930 9180 -6920 {
lab=VSS}
N 9180 -7160 9180 -7150 {
lab=VDD}
N 1200 -7190 1210 -7200 {
lab=row_n[0]}
N 1210 -7400 1210 -7200 {
lab=row_n[0]}
N 1200 -7410 1210 -7400 {
lab=row_n[0]}
N 1200 -7190 1200 -7170 {
lab=row_n[0]}
N 1200 -7430 1200 -7410 {
lab=row_n[0]}
N 1080 -7330 1090 -7340 {
lab=col_n[24]}
N 1090 -7340 1290 -7340 {
lab=col_n[24]}
N 1290 -7340 1300 -7330 {
lab=col_n[24]}
N 1080 -7310 1090 -7320 {
lab=colon_n[24]}
N 1090 -7320 1290 -7320 {
lab=colon_n[24]}
N 1290 -7320 1300 -7310 {
lab=colon_n[24]}
N 1080 -7290 1090 -7300 {
lab=#net49}
N 1090 -7300 1290 -7300 {
lab=#net49}
N 1290 -7300 1300 -7290 {
lab=#net49}
N 1080 -7270 1090 -7280 {
lab=#net50}
N 1090 -7280 1290 -7280 {
lab=#net50}
N 1290 -7280 1300 -7270 {
lab=#net50}
N 1140 -7430 1140 -7410 {
lab=vcom}
N 1180 -7430 1180 -7410 {
lab=ctop}
N 1060 -7330 1080 -7330 {
lab=col_n[24]}
N 1060 -7310 1080 -7310 {
lab=colon_n[24]}
N 1060 -7290 1080 -7290 {
lab=#net49}
N 1060 -7270 1080 -7270 {
lab=#net50}
N 1300 -7270 1320 -7270 {
lab=#net50}
N 1300 -7290 1320 -7290 {
lab=#net49}
N 1300 -7310 1320 -7310 {
lab=colon_n[24]}
N 1300 -7330 1320 -7330 {
lab=col_n[24]}
N 1120 -7190 1120 -7180 {
lab=VSS}
N 1120 -7420 1120 -7410 {
lab=VDD}
N 1460 -7190 1470 -7200 {
lab=row_n[1]}
N 1470 -7400 1470 -7200 {
lab=row_n[1]}
N 1460 -7410 1470 -7400 {
lab=row_n[1]}
N 1460 -7190 1460 -7170 {
lab=row_n[1]}
N 1460 -7430 1460 -7410 {
lab=row_n[1]}
N 1340 -7330 1350 -7340 {
lab=col_n[24]}
N 1350 -7340 1550 -7340 {
lab=col_n[24]}
N 1550 -7340 1560 -7330 {
lab=col_n[24]}
N 1340 -7310 1350 -7320 {
lab=colon_n[24]}
N 1350 -7320 1550 -7320 {
lab=colon_n[24]}
N 1550 -7320 1560 -7310 {
lab=colon_n[24]}
N 1340 -7290 1350 -7300 {
lab=#net49}
N 1350 -7300 1550 -7300 {
lab=#net49}
N 1550 -7300 1560 -7290 {
lab=#net49}
N 1340 -7270 1350 -7280 {
lab=#net50}
N 1350 -7280 1550 -7280 {
lab=#net50}
N 1550 -7280 1560 -7270 {
lab=#net50}
N 1400 -7430 1400 -7410 {
lab=vcom}
N 1440 -7430 1440 -7410 {
lab=ctop}
N 1320 -7330 1340 -7330 {
lab=col_n[24]}
N 1320 -7310 1340 -7310 {
lab=colon_n[24]}
N 1320 -7290 1340 -7290 {
lab=#net49}
N 1320 -7270 1340 -7270 {
lab=#net50}
N 1560 -7270 1580 -7270 {
lab=#net50}
N 1560 -7290 1580 -7290 {
lab=#net49}
N 1560 -7310 1580 -7310 {
lab=colon_n[24]}
N 1560 -7330 1580 -7330 {
lab=col_n[24]}
N 1380 -7190 1380 -7180 {
lab=VSS}
N 1380 -7420 1380 -7410 {
lab=VDD}
N 1720 -7190 1730 -7200 {
lab=row_n[2]}
N 1730 -7400 1730 -7200 {
lab=row_n[2]}
N 1720 -7410 1730 -7400 {
lab=row_n[2]}
N 1720 -7190 1720 -7170 {
lab=row_n[2]}
N 1720 -7430 1720 -7410 {
lab=row_n[2]}
N 1600 -7330 1610 -7340 {
lab=col_n[24]}
N 1610 -7340 1810 -7340 {
lab=col_n[24]}
N 1810 -7340 1820 -7330 {
lab=col_n[24]}
N 1600 -7310 1610 -7320 {
lab=colon_n[24]}
N 1610 -7320 1810 -7320 {
lab=colon_n[24]}
N 1810 -7320 1820 -7310 {
lab=colon_n[24]}
N 1600 -7290 1610 -7300 {
lab=#net49}
N 1610 -7300 1810 -7300 {
lab=#net49}
N 1810 -7300 1820 -7290 {
lab=#net49}
N 1600 -7270 1610 -7280 {
lab=#net50}
N 1610 -7280 1810 -7280 {
lab=#net50}
N 1810 -7280 1820 -7270 {
lab=#net50}
N 1660 -7430 1660 -7410 {
lab=vcom}
N 1700 -7430 1700 -7410 {
lab=ctop}
N 1580 -7330 1600 -7330 {
lab=col_n[24]}
N 1580 -7310 1600 -7310 {
lab=colon_n[24]}
N 1580 -7290 1600 -7290 {
lab=#net49}
N 1580 -7270 1600 -7270 {
lab=#net50}
N 1820 -7270 1840 -7270 {
lab=#net50}
N 1820 -7290 1840 -7290 {
lab=#net49}
N 1820 -7310 1840 -7310 {
lab=colon_n[24]}
N 1820 -7330 1840 -7330 {
lab=col_n[24]}
N 1640 -7190 1640 -7180 {
lab=VSS}
N 1640 -7420 1640 -7410 {
lab=VDD}
N 1980 -7190 1990 -7200 {
lab=row_n[3]}
N 1990 -7400 1990 -7200 {
lab=row_n[3]}
N 1980 -7410 1990 -7400 {
lab=row_n[3]}
N 1980 -7190 1980 -7170 {
lab=row_n[3]}
N 1980 -7430 1980 -7410 {
lab=row_n[3]}
N 1860 -7330 1870 -7340 {
lab=col_n[24]}
N 1870 -7340 2070 -7340 {
lab=col_n[24]}
N 2070 -7340 2080 -7330 {
lab=col_n[24]}
N 1860 -7310 1870 -7320 {
lab=colon_n[24]}
N 1870 -7320 2070 -7320 {
lab=colon_n[24]}
N 2070 -7320 2080 -7310 {
lab=colon_n[24]}
N 1860 -7290 1870 -7300 {
lab=#net49}
N 1870 -7300 2070 -7300 {
lab=#net49}
N 2070 -7300 2080 -7290 {
lab=#net49}
N 1860 -7270 1870 -7280 {
lab=#net50}
N 1870 -7280 2070 -7280 {
lab=#net50}
N 2070 -7280 2080 -7270 {
lab=#net50}
N 1920 -7430 1920 -7410 {
lab=vcom}
N 1960 -7430 1960 -7410 {
lab=ctop}
N 1840 -7330 1860 -7330 {
lab=col_n[24]}
N 1840 -7310 1860 -7310 {
lab=colon_n[24]}
N 1840 -7290 1860 -7290 {
lab=#net49}
N 1840 -7270 1860 -7270 {
lab=#net50}
N 2080 -7270 2100 -7270 {
lab=#net50}
N 2080 -7290 2100 -7290 {
lab=#net49}
N 2080 -7310 2100 -7310 {
lab=colon_n[24]}
N 2080 -7330 2100 -7330 {
lab=col_n[24]}
N 1900 -7190 1900 -7180 {
lab=VSS}
N 1900 -7420 1900 -7410 {
lab=VDD}
N 2240 -7190 2250 -7200 {
lab=row_n[4]}
N 2250 -7400 2250 -7200 {
lab=row_n[4]}
N 2240 -7410 2250 -7400 {
lab=row_n[4]}
N 2240 -7190 2240 -7170 {
lab=row_n[4]}
N 2240 -7430 2240 -7410 {
lab=row_n[4]}
N 2120 -7330 2130 -7340 {
lab=col_n[24]}
N 2130 -7340 2330 -7340 {
lab=col_n[24]}
N 2330 -7340 2340 -7330 {
lab=col_n[24]}
N 2120 -7310 2130 -7320 {
lab=colon_n[24]}
N 2130 -7320 2330 -7320 {
lab=colon_n[24]}
N 2330 -7320 2340 -7310 {
lab=colon_n[24]}
N 2120 -7290 2130 -7300 {
lab=#net49}
N 2130 -7300 2330 -7300 {
lab=#net49}
N 2330 -7300 2340 -7290 {
lab=#net49}
N 2120 -7270 2130 -7280 {
lab=#net50}
N 2130 -7280 2330 -7280 {
lab=#net50}
N 2330 -7280 2340 -7270 {
lab=#net50}
N 2180 -7430 2180 -7410 {
lab=vcom}
N 2220 -7430 2220 -7410 {
lab=ctop}
N 2100 -7330 2120 -7330 {
lab=col_n[24]}
N 2100 -7310 2120 -7310 {
lab=colon_n[24]}
N 2100 -7290 2120 -7290 {
lab=#net49}
N 2100 -7270 2120 -7270 {
lab=#net50}
N 2340 -7270 2360 -7270 {
lab=#net50}
N 2340 -7290 2360 -7290 {
lab=#net49}
N 2340 -7310 2360 -7310 {
lab=colon_n[24]}
N 2340 -7330 2360 -7330 {
lab=col_n[24]}
N 2160 -7190 2160 -7180 {
lab=VSS}
N 2160 -7420 2160 -7410 {
lab=VDD}
N 2500 -7190 2510 -7200 {
lab=row_n[5]}
N 2510 -7400 2510 -7200 {
lab=row_n[5]}
N 2500 -7410 2510 -7400 {
lab=row_n[5]}
N 2500 -7190 2500 -7170 {
lab=row_n[5]}
N 2500 -7430 2500 -7410 {
lab=row_n[5]}
N 2380 -7330 2390 -7340 {
lab=col_n[24]}
N 2390 -7340 2590 -7340 {
lab=col_n[24]}
N 2590 -7340 2600 -7330 {
lab=col_n[24]}
N 2380 -7310 2390 -7320 {
lab=colon_n[24]}
N 2390 -7320 2590 -7320 {
lab=colon_n[24]}
N 2590 -7320 2600 -7310 {
lab=colon_n[24]}
N 2380 -7290 2390 -7300 {
lab=#net49}
N 2390 -7300 2590 -7300 {
lab=#net49}
N 2590 -7300 2600 -7290 {
lab=#net49}
N 2380 -7270 2390 -7280 {
lab=#net50}
N 2390 -7280 2590 -7280 {
lab=#net50}
N 2590 -7280 2600 -7270 {
lab=#net50}
N 2440 -7430 2440 -7410 {
lab=vcom}
N 2480 -7430 2480 -7410 {
lab=ctop}
N 2360 -7330 2380 -7330 {
lab=col_n[24]}
N 2360 -7310 2380 -7310 {
lab=colon_n[24]}
N 2360 -7290 2380 -7290 {
lab=#net49}
N 2360 -7270 2380 -7270 {
lab=#net50}
N 2600 -7270 2620 -7270 {
lab=#net50}
N 2600 -7290 2620 -7290 {
lab=#net49}
N 2600 -7310 2620 -7310 {
lab=colon_n[24]}
N 2600 -7330 2620 -7330 {
lab=col_n[24]}
N 2420 -7190 2420 -7180 {
lab=VSS}
N 2420 -7420 2420 -7410 {
lab=VDD}
N 2760 -7190 2770 -7200 {
lab=row_n[6]}
N 2770 -7400 2770 -7200 {
lab=row_n[6]}
N 2760 -7410 2770 -7400 {
lab=row_n[6]}
N 2760 -7190 2760 -7170 {
lab=row_n[6]}
N 2760 -7430 2760 -7410 {
lab=row_n[6]}
N 2640 -7330 2650 -7340 {
lab=col_n[24]}
N 2650 -7340 2850 -7340 {
lab=col_n[24]}
N 2850 -7340 2860 -7330 {
lab=col_n[24]}
N 2640 -7310 2650 -7320 {
lab=colon_n[24]}
N 2650 -7320 2850 -7320 {
lab=colon_n[24]}
N 2850 -7320 2860 -7310 {
lab=colon_n[24]}
N 2640 -7290 2650 -7300 {
lab=#net49}
N 2650 -7300 2850 -7300 {
lab=#net49}
N 2850 -7300 2860 -7290 {
lab=#net49}
N 2640 -7270 2650 -7280 {
lab=#net50}
N 2650 -7280 2850 -7280 {
lab=#net50}
N 2850 -7280 2860 -7270 {
lab=#net50}
N 2700 -7430 2700 -7410 {
lab=vcom}
N 2740 -7430 2740 -7410 {
lab=ctop}
N 2620 -7330 2640 -7330 {
lab=col_n[24]}
N 2620 -7310 2640 -7310 {
lab=colon_n[24]}
N 2620 -7290 2640 -7290 {
lab=#net49}
N 2620 -7270 2640 -7270 {
lab=#net50}
N 2860 -7270 2880 -7270 {
lab=#net50}
N 2860 -7290 2880 -7290 {
lab=#net49}
N 2860 -7310 2880 -7310 {
lab=colon_n[24]}
N 2860 -7330 2880 -7330 {
lab=col_n[24]}
N 2680 -7190 2680 -7180 {
lab=VSS}
N 2680 -7420 2680 -7410 {
lab=VDD}
N 3020 -7190 3030 -7200 {
lab=row_n[7]}
N 3030 -7400 3030 -7200 {
lab=row_n[7]}
N 3020 -7410 3030 -7400 {
lab=row_n[7]}
N 3020 -7190 3020 -7170 {
lab=row_n[7]}
N 3020 -7430 3020 -7410 {
lab=row_n[7]}
N 2900 -7330 2910 -7340 {
lab=col_n[24]}
N 2910 -7340 3110 -7340 {
lab=col_n[24]}
N 3110 -7340 3120 -7330 {
lab=col_n[24]}
N 2900 -7310 2910 -7320 {
lab=colon_n[24]}
N 2910 -7320 3110 -7320 {
lab=colon_n[24]}
N 3110 -7320 3120 -7310 {
lab=colon_n[24]}
N 2900 -7290 2910 -7300 {
lab=#net49}
N 2910 -7300 3110 -7300 {
lab=#net49}
N 3110 -7300 3120 -7290 {
lab=#net49}
N 2900 -7270 2910 -7280 {
lab=#net50}
N 2910 -7280 3110 -7280 {
lab=#net50}
N 3110 -7280 3120 -7270 {
lab=#net50}
N 2960 -7430 2960 -7410 {
lab=vcom}
N 3000 -7430 3000 -7410 {
lab=ctop}
N 2880 -7330 2900 -7330 {
lab=col_n[24]}
N 2880 -7310 2900 -7310 {
lab=colon_n[24]}
N 2880 -7290 2900 -7290 {
lab=#net49}
N 2880 -7270 2900 -7270 {
lab=#net50}
N 3120 -7270 3140 -7270 {
lab=#net50}
N 3120 -7290 3140 -7290 {
lab=#net49}
N 3120 -7310 3140 -7310 {
lab=colon_n[24]}
N 3120 -7330 3140 -7330 {
lab=col_n[24]}
N 2940 -7190 2940 -7180 {
lab=VSS}
N 2940 -7420 2940 -7410 {
lab=VDD}
N 3280 -7190 3290 -7200 {
lab=row_n[8]}
N 3290 -7400 3290 -7200 {
lab=row_n[8]}
N 3280 -7410 3290 -7400 {
lab=row_n[8]}
N 3280 -7190 3280 -7170 {
lab=row_n[8]}
N 3280 -7430 3280 -7410 {
lab=row_n[8]}
N 3160 -7330 3170 -7340 {
lab=col_n[24]}
N 3170 -7340 3370 -7340 {
lab=col_n[24]}
N 3370 -7340 3380 -7330 {
lab=col_n[24]}
N 3160 -7310 3170 -7320 {
lab=colon_n[24]}
N 3170 -7320 3370 -7320 {
lab=colon_n[24]}
N 3370 -7320 3380 -7310 {
lab=colon_n[24]}
N 3160 -7290 3170 -7300 {
lab=#net49}
N 3170 -7300 3370 -7300 {
lab=#net49}
N 3370 -7300 3380 -7290 {
lab=#net49}
N 3160 -7270 3170 -7280 {
lab=#net50}
N 3170 -7280 3370 -7280 {
lab=#net50}
N 3370 -7280 3380 -7270 {
lab=#net50}
N 3220 -7430 3220 -7410 {
lab=vcom}
N 3260 -7430 3260 -7410 {
lab=ctop}
N 3140 -7330 3160 -7330 {
lab=col_n[24]}
N 3140 -7310 3160 -7310 {
lab=colon_n[24]}
N 3140 -7290 3160 -7290 {
lab=#net49}
N 3140 -7270 3160 -7270 {
lab=#net50}
N 3380 -7270 3400 -7270 {
lab=#net50}
N 3380 -7290 3400 -7290 {
lab=#net49}
N 3380 -7310 3400 -7310 {
lab=colon_n[24]}
N 3380 -7330 3400 -7330 {
lab=col_n[24]}
N 3200 -7190 3200 -7180 {
lab=VSS}
N 3200 -7420 3200 -7410 {
lab=VDD}
N 3540 -7190 3550 -7200 {
lab=row_n[9]}
N 3550 -7400 3550 -7200 {
lab=row_n[9]}
N 3540 -7410 3550 -7400 {
lab=row_n[9]}
N 3540 -7190 3540 -7170 {
lab=row_n[9]}
N 3540 -7430 3540 -7410 {
lab=row_n[9]}
N 3420 -7330 3430 -7340 {
lab=col_n[24]}
N 3430 -7340 3630 -7340 {
lab=col_n[24]}
N 3630 -7340 3640 -7330 {
lab=col_n[24]}
N 3420 -7310 3430 -7320 {
lab=colon_n[24]}
N 3430 -7320 3630 -7320 {
lab=colon_n[24]}
N 3630 -7320 3640 -7310 {
lab=colon_n[24]}
N 3420 -7290 3430 -7300 {
lab=#net49}
N 3430 -7300 3630 -7300 {
lab=#net49}
N 3630 -7300 3640 -7290 {
lab=#net49}
N 3420 -7270 3430 -7280 {
lab=#net50}
N 3430 -7280 3630 -7280 {
lab=#net50}
N 3630 -7280 3640 -7270 {
lab=#net50}
N 3480 -7430 3480 -7410 {
lab=vcom}
N 3520 -7430 3520 -7410 {
lab=ctop}
N 3400 -7330 3420 -7330 {
lab=col_n[24]}
N 3400 -7310 3420 -7310 {
lab=colon_n[24]}
N 3400 -7290 3420 -7290 {
lab=#net49}
N 3400 -7270 3420 -7270 {
lab=#net50}
N 3640 -7270 3660 -7270 {
lab=#net50}
N 3640 -7290 3660 -7290 {
lab=#net49}
N 3640 -7310 3660 -7310 {
lab=colon_n[24]}
N 3640 -7330 3660 -7330 {
lab=col_n[24]}
N 3460 -7190 3460 -7180 {
lab=VSS}
N 3460 -7420 3460 -7410 {
lab=VDD}
N 3800 -7190 3810 -7200 {
lab=row_n[10]}
N 3810 -7400 3810 -7200 {
lab=row_n[10]}
N 3800 -7410 3810 -7400 {
lab=row_n[10]}
N 3800 -7190 3800 -7170 {
lab=row_n[10]}
N 3800 -7430 3800 -7410 {
lab=row_n[10]}
N 3680 -7330 3690 -7340 {
lab=col_n[24]}
N 3690 -7340 3890 -7340 {
lab=col_n[24]}
N 3890 -7340 3900 -7330 {
lab=col_n[24]}
N 3680 -7310 3690 -7320 {
lab=colon_n[24]}
N 3690 -7320 3890 -7320 {
lab=colon_n[24]}
N 3890 -7320 3900 -7310 {
lab=colon_n[24]}
N 3680 -7290 3690 -7300 {
lab=#net49}
N 3690 -7300 3890 -7300 {
lab=#net49}
N 3890 -7300 3900 -7290 {
lab=#net49}
N 3680 -7270 3690 -7280 {
lab=#net50}
N 3690 -7280 3890 -7280 {
lab=#net50}
N 3890 -7280 3900 -7270 {
lab=#net50}
N 3740 -7430 3740 -7410 {
lab=vcom}
N 3780 -7430 3780 -7410 {
lab=ctop}
N 3660 -7330 3680 -7330 {
lab=col_n[24]}
N 3660 -7310 3680 -7310 {
lab=colon_n[24]}
N 3660 -7290 3680 -7290 {
lab=#net49}
N 3660 -7270 3680 -7270 {
lab=#net50}
N 3900 -7270 3920 -7270 {
lab=#net50}
N 3900 -7290 3920 -7290 {
lab=#net49}
N 3900 -7310 3920 -7310 {
lab=colon_n[24]}
N 3900 -7330 3920 -7330 {
lab=col_n[24]}
N 3720 -7190 3720 -7180 {
lab=VSS}
N 3720 -7420 3720 -7410 {
lab=VDD}
N 4060 -7190 4070 -7200 {
lab=row_n[11]}
N 4070 -7400 4070 -7200 {
lab=row_n[11]}
N 4060 -7410 4070 -7400 {
lab=row_n[11]}
N 4060 -7190 4060 -7170 {
lab=row_n[11]}
N 4060 -7430 4060 -7410 {
lab=row_n[11]}
N 3940 -7330 3950 -7340 {
lab=col_n[24]}
N 3950 -7340 4150 -7340 {
lab=col_n[24]}
N 4150 -7340 4160 -7330 {
lab=col_n[24]}
N 3940 -7310 3950 -7320 {
lab=colon_n[24]}
N 3950 -7320 4150 -7320 {
lab=colon_n[24]}
N 4150 -7320 4160 -7310 {
lab=colon_n[24]}
N 3940 -7290 3950 -7300 {
lab=#net49}
N 3950 -7300 4150 -7300 {
lab=#net49}
N 4150 -7300 4160 -7290 {
lab=#net49}
N 3940 -7270 3950 -7280 {
lab=#net50}
N 3950 -7280 4150 -7280 {
lab=#net50}
N 4150 -7280 4160 -7270 {
lab=#net50}
N 4000 -7430 4000 -7410 {
lab=vcom}
N 4040 -7430 4040 -7410 {
lab=ctop}
N 3920 -7330 3940 -7330 {
lab=col_n[24]}
N 3920 -7310 3940 -7310 {
lab=colon_n[24]}
N 3920 -7290 3940 -7290 {
lab=#net49}
N 3920 -7270 3940 -7270 {
lab=#net50}
N 4160 -7270 4180 -7270 {
lab=#net50}
N 4160 -7290 4180 -7290 {
lab=#net49}
N 4160 -7310 4180 -7310 {
lab=colon_n[24]}
N 4160 -7330 4180 -7330 {
lab=col_n[24]}
N 3980 -7190 3980 -7180 {
lab=VSS}
N 3980 -7420 3980 -7410 {
lab=VDD}
N 4320 -7190 4330 -7200 {
lab=row_n[12]}
N 4330 -7400 4330 -7200 {
lab=row_n[12]}
N 4320 -7410 4330 -7400 {
lab=row_n[12]}
N 4320 -7190 4320 -7170 {
lab=row_n[12]}
N 4320 -7430 4320 -7410 {
lab=row_n[12]}
N 4200 -7330 4210 -7340 {
lab=col_n[24]}
N 4210 -7340 4410 -7340 {
lab=col_n[24]}
N 4410 -7340 4420 -7330 {
lab=col_n[24]}
N 4200 -7310 4210 -7320 {
lab=colon_n[24]}
N 4210 -7320 4410 -7320 {
lab=colon_n[24]}
N 4410 -7320 4420 -7310 {
lab=colon_n[24]}
N 4200 -7290 4210 -7300 {
lab=#net49}
N 4210 -7300 4410 -7300 {
lab=#net49}
N 4410 -7300 4420 -7290 {
lab=#net49}
N 4200 -7270 4210 -7280 {
lab=#net50}
N 4210 -7280 4410 -7280 {
lab=#net50}
N 4410 -7280 4420 -7270 {
lab=#net50}
N 4260 -7430 4260 -7410 {
lab=vcom}
N 4300 -7430 4300 -7410 {
lab=ctop}
N 4180 -7330 4200 -7330 {
lab=col_n[24]}
N 4180 -7310 4200 -7310 {
lab=colon_n[24]}
N 4180 -7290 4200 -7290 {
lab=#net49}
N 4180 -7270 4200 -7270 {
lab=#net50}
N 4420 -7270 4440 -7270 {
lab=#net50}
N 4420 -7290 4440 -7290 {
lab=#net49}
N 4420 -7310 4440 -7310 {
lab=colon_n[24]}
N 4420 -7330 4440 -7330 {
lab=col_n[24]}
N 4240 -7190 4240 -7180 {
lab=VSS}
N 4240 -7420 4240 -7410 {
lab=VDD}
N 4580 -7190 4590 -7200 {
lab=row_n[13]}
N 4590 -7400 4590 -7200 {
lab=row_n[13]}
N 4580 -7410 4590 -7400 {
lab=row_n[13]}
N 4580 -7190 4580 -7170 {
lab=row_n[13]}
N 4580 -7430 4580 -7410 {
lab=row_n[13]}
N 4460 -7330 4470 -7340 {
lab=col_n[24]}
N 4470 -7340 4670 -7340 {
lab=col_n[24]}
N 4670 -7340 4680 -7330 {
lab=col_n[24]}
N 4460 -7310 4470 -7320 {
lab=colon_n[24]}
N 4470 -7320 4670 -7320 {
lab=colon_n[24]}
N 4670 -7320 4680 -7310 {
lab=colon_n[24]}
N 4460 -7290 4470 -7300 {
lab=#net49}
N 4470 -7300 4670 -7300 {
lab=#net49}
N 4670 -7300 4680 -7290 {
lab=#net49}
N 4460 -7270 4470 -7280 {
lab=#net50}
N 4470 -7280 4670 -7280 {
lab=#net50}
N 4670 -7280 4680 -7270 {
lab=#net50}
N 4520 -7430 4520 -7410 {
lab=vcom}
N 4560 -7430 4560 -7410 {
lab=ctop}
N 4440 -7330 4460 -7330 {
lab=col_n[24]}
N 4440 -7310 4460 -7310 {
lab=colon_n[24]}
N 4440 -7290 4460 -7290 {
lab=#net49}
N 4440 -7270 4460 -7270 {
lab=#net50}
N 4680 -7270 4700 -7270 {
lab=#net50}
N 4680 -7290 4700 -7290 {
lab=#net49}
N 4680 -7310 4700 -7310 {
lab=colon_n[24]}
N 4680 -7330 4700 -7330 {
lab=col_n[24]}
N 4500 -7190 4500 -7180 {
lab=VSS}
N 4500 -7420 4500 -7410 {
lab=VDD}
N 4840 -7190 4850 -7200 {
lab=row_n[14]}
N 4850 -7400 4850 -7200 {
lab=row_n[14]}
N 4840 -7410 4850 -7400 {
lab=row_n[14]}
N 4840 -7190 4840 -7170 {
lab=row_n[14]}
N 4840 -7430 4840 -7410 {
lab=row_n[14]}
N 4720 -7330 4730 -7340 {
lab=col_n[24]}
N 4730 -7340 4930 -7340 {
lab=col_n[24]}
N 4930 -7340 4940 -7330 {
lab=col_n[24]}
N 4720 -7310 4730 -7320 {
lab=colon_n[24]}
N 4730 -7320 4930 -7320 {
lab=colon_n[24]}
N 4930 -7320 4940 -7310 {
lab=colon_n[24]}
N 4720 -7290 4730 -7300 {
lab=#net49}
N 4730 -7300 4930 -7300 {
lab=#net49}
N 4930 -7300 4940 -7290 {
lab=#net49}
N 4720 -7270 4730 -7280 {
lab=#net50}
N 4730 -7280 4930 -7280 {
lab=#net50}
N 4930 -7280 4940 -7270 {
lab=#net50}
N 4780 -7430 4780 -7410 {
lab=vcom}
N 4820 -7430 4820 -7410 {
lab=ctop}
N 4700 -7330 4720 -7330 {
lab=col_n[24]}
N 4700 -7310 4720 -7310 {
lab=colon_n[24]}
N 4700 -7290 4720 -7290 {
lab=#net49}
N 4700 -7270 4720 -7270 {
lab=#net50}
N 4940 -7270 4960 -7270 {
lab=#net50}
N 4940 -7290 4960 -7290 {
lab=#net49}
N 4940 -7310 4960 -7310 {
lab=colon_n[24]}
N 4940 -7330 4960 -7330 {
lab=col_n[24]}
N 4760 -7190 4760 -7180 {
lab=VSS}
N 4760 -7420 4760 -7410 {
lab=VDD}
N 5100 -7190 5110 -7200 {
lab=row_n[15]}
N 5110 -7400 5110 -7200 {
lab=row_n[15]}
N 5100 -7410 5110 -7400 {
lab=row_n[15]}
N 5100 -7190 5100 -7170 {
lab=row_n[15]}
N 5100 -7430 5100 -7410 {
lab=row_n[15]}
N 4980 -7330 4990 -7340 {
lab=col_n[24]}
N 4990 -7340 5190 -7340 {
lab=col_n[24]}
N 5190 -7340 5200 -7330 {
lab=col_n[24]}
N 4980 -7310 4990 -7320 {
lab=colon_n[24]}
N 4990 -7320 5190 -7320 {
lab=colon_n[24]}
N 5190 -7320 5200 -7310 {
lab=colon_n[24]}
N 4980 -7290 4990 -7300 {
lab=#net49}
N 4990 -7300 5190 -7300 {
lab=#net49}
N 5190 -7300 5200 -7290 {
lab=#net49}
N 4980 -7270 4990 -7280 {
lab=#net50}
N 4990 -7280 5190 -7280 {
lab=#net50}
N 5190 -7280 5200 -7270 {
lab=#net50}
N 5040 -7430 5040 -7410 {
lab=vcom}
N 5080 -7430 5080 -7410 {
lab=ctop}
N 4960 -7330 4980 -7330 {
lab=col_n[24]}
N 4960 -7310 4980 -7310 {
lab=colon_n[24]}
N 4960 -7290 4980 -7290 {
lab=#net49}
N 4960 -7270 4980 -7270 {
lab=#net50}
N 5200 -7270 5220 -7270 {
lab=#net50}
N 5200 -7290 5220 -7290 {
lab=#net49}
N 5200 -7310 5220 -7310 {
lab=colon_n[24]}
N 5200 -7330 5220 -7330 {
lab=col_n[24]}
N 5020 -7190 5020 -7180 {
lab=VSS}
N 5020 -7420 5020 -7410 {
lab=VDD}
N 5360 -7190 5370 -7200 {
lab=row_n[16]}
N 5370 -7400 5370 -7200 {
lab=row_n[16]}
N 5360 -7410 5370 -7400 {
lab=row_n[16]}
N 5360 -7190 5360 -7170 {
lab=row_n[16]}
N 5360 -7430 5360 -7410 {
lab=row_n[16]}
N 5240 -7330 5250 -7340 {
lab=col_n[24]}
N 5250 -7340 5450 -7340 {
lab=col_n[24]}
N 5450 -7340 5460 -7330 {
lab=col_n[24]}
N 5240 -7310 5250 -7320 {
lab=colon_n[24]}
N 5250 -7320 5450 -7320 {
lab=colon_n[24]}
N 5450 -7320 5460 -7310 {
lab=colon_n[24]}
N 5240 -7290 5250 -7300 {
lab=#net49}
N 5250 -7300 5450 -7300 {
lab=#net49}
N 5450 -7300 5460 -7290 {
lab=#net49}
N 5240 -7270 5250 -7280 {
lab=#net50}
N 5250 -7280 5450 -7280 {
lab=#net50}
N 5450 -7280 5460 -7270 {
lab=#net50}
N 5300 -7430 5300 -7410 {
lab=vcom}
N 5340 -7430 5340 -7410 {
lab=ctop}
N 5220 -7330 5240 -7330 {
lab=col_n[24]}
N 5220 -7310 5240 -7310 {
lab=colon_n[24]}
N 5220 -7290 5240 -7290 {
lab=#net49}
N 5220 -7270 5240 -7270 {
lab=#net50}
N 5460 -7270 5480 -7270 {
lab=#net50}
N 5460 -7290 5480 -7290 {
lab=#net49}
N 5460 -7310 5480 -7310 {
lab=colon_n[24]}
N 5460 -7330 5480 -7330 {
lab=col_n[24]}
N 5280 -7190 5280 -7180 {
lab=VSS}
N 5280 -7420 5280 -7410 {
lab=VDD}
N 5620 -7190 5630 -7200 {
lab=row_n[17]}
N 5630 -7400 5630 -7200 {
lab=row_n[17]}
N 5620 -7410 5630 -7400 {
lab=row_n[17]}
N 5620 -7190 5620 -7170 {
lab=row_n[17]}
N 5620 -7430 5620 -7410 {
lab=row_n[17]}
N 5500 -7330 5510 -7340 {
lab=col_n[24]}
N 5510 -7340 5710 -7340 {
lab=col_n[24]}
N 5710 -7340 5720 -7330 {
lab=col_n[24]}
N 5500 -7310 5510 -7320 {
lab=colon_n[24]}
N 5510 -7320 5710 -7320 {
lab=colon_n[24]}
N 5710 -7320 5720 -7310 {
lab=colon_n[24]}
N 5500 -7290 5510 -7300 {
lab=#net49}
N 5510 -7300 5710 -7300 {
lab=#net49}
N 5710 -7300 5720 -7290 {
lab=#net49}
N 5500 -7270 5510 -7280 {
lab=#net50}
N 5510 -7280 5710 -7280 {
lab=#net50}
N 5710 -7280 5720 -7270 {
lab=#net50}
N 5560 -7430 5560 -7410 {
lab=vcom}
N 5600 -7430 5600 -7410 {
lab=ctop}
N 5480 -7330 5500 -7330 {
lab=col_n[24]}
N 5480 -7310 5500 -7310 {
lab=colon_n[24]}
N 5480 -7290 5500 -7290 {
lab=#net49}
N 5480 -7270 5500 -7270 {
lab=#net50}
N 5720 -7270 5740 -7270 {
lab=#net50}
N 5720 -7290 5740 -7290 {
lab=#net49}
N 5720 -7310 5740 -7310 {
lab=colon_n[24]}
N 5720 -7330 5740 -7330 {
lab=col_n[24]}
N 5540 -7190 5540 -7180 {
lab=VSS}
N 5540 -7420 5540 -7410 {
lab=VDD}
N 5880 -7190 5890 -7200 {
lab=row_n[18]}
N 5890 -7400 5890 -7200 {
lab=row_n[18]}
N 5880 -7410 5890 -7400 {
lab=row_n[18]}
N 5880 -7190 5880 -7170 {
lab=row_n[18]}
N 5880 -7430 5880 -7410 {
lab=row_n[18]}
N 5760 -7330 5770 -7340 {
lab=col_n[24]}
N 5770 -7340 5970 -7340 {
lab=col_n[24]}
N 5970 -7340 5980 -7330 {
lab=col_n[24]}
N 5760 -7310 5770 -7320 {
lab=colon_n[24]}
N 5770 -7320 5970 -7320 {
lab=colon_n[24]}
N 5970 -7320 5980 -7310 {
lab=colon_n[24]}
N 5760 -7290 5770 -7300 {
lab=#net49}
N 5770 -7300 5970 -7300 {
lab=#net49}
N 5970 -7300 5980 -7290 {
lab=#net49}
N 5760 -7270 5770 -7280 {
lab=#net50}
N 5770 -7280 5970 -7280 {
lab=#net50}
N 5970 -7280 5980 -7270 {
lab=#net50}
N 5820 -7430 5820 -7410 {
lab=vcom}
N 5860 -7430 5860 -7410 {
lab=ctop}
N 5740 -7330 5760 -7330 {
lab=col_n[24]}
N 5740 -7310 5760 -7310 {
lab=colon_n[24]}
N 5740 -7290 5760 -7290 {
lab=#net49}
N 5740 -7270 5760 -7270 {
lab=#net50}
N 5980 -7270 6000 -7270 {
lab=#net50}
N 5980 -7290 6000 -7290 {
lab=#net49}
N 5980 -7310 6000 -7310 {
lab=colon_n[24]}
N 5980 -7330 6000 -7330 {
lab=col_n[24]}
N 5800 -7190 5800 -7180 {
lab=VSS}
N 5800 -7420 5800 -7410 {
lab=VDD}
N 6140 -7190 6150 -7200 {
lab=row_n[19]}
N 6150 -7400 6150 -7200 {
lab=row_n[19]}
N 6140 -7410 6150 -7400 {
lab=row_n[19]}
N 6140 -7190 6140 -7170 {
lab=row_n[19]}
N 6140 -7430 6140 -7410 {
lab=row_n[19]}
N 6020 -7330 6030 -7340 {
lab=col_n[24]}
N 6030 -7340 6230 -7340 {
lab=col_n[24]}
N 6230 -7340 6240 -7330 {
lab=col_n[24]}
N 6020 -7310 6030 -7320 {
lab=colon_n[24]}
N 6030 -7320 6230 -7320 {
lab=colon_n[24]}
N 6230 -7320 6240 -7310 {
lab=colon_n[24]}
N 6020 -7290 6030 -7300 {
lab=#net49}
N 6030 -7300 6230 -7300 {
lab=#net49}
N 6230 -7300 6240 -7290 {
lab=#net49}
N 6020 -7270 6030 -7280 {
lab=#net50}
N 6030 -7280 6230 -7280 {
lab=#net50}
N 6230 -7280 6240 -7270 {
lab=#net50}
N 6080 -7430 6080 -7410 {
lab=vcom}
N 6120 -7430 6120 -7410 {
lab=ctop}
N 6000 -7330 6020 -7330 {
lab=col_n[24]}
N 6000 -7310 6020 -7310 {
lab=colon_n[24]}
N 6000 -7290 6020 -7290 {
lab=#net49}
N 6000 -7270 6020 -7270 {
lab=#net50}
N 6240 -7270 6260 -7270 {
lab=#net50}
N 6240 -7290 6260 -7290 {
lab=#net49}
N 6240 -7310 6260 -7310 {
lab=colon_n[24]}
N 6240 -7330 6260 -7330 {
lab=col_n[24]}
N 6060 -7190 6060 -7180 {
lab=VSS}
N 6060 -7420 6060 -7410 {
lab=VDD}
N 6400 -7190 6410 -7200 {
lab=row_n[20]}
N 6410 -7400 6410 -7200 {
lab=row_n[20]}
N 6400 -7410 6410 -7400 {
lab=row_n[20]}
N 6400 -7190 6400 -7170 {
lab=row_n[20]}
N 6400 -7430 6400 -7410 {
lab=row_n[20]}
N 6280 -7330 6290 -7340 {
lab=col_n[24]}
N 6290 -7340 6490 -7340 {
lab=col_n[24]}
N 6490 -7340 6500 -7330 {
lab=col_n[24]}
N 6280 -7310 6290 -7320 {
lab=colon_n[24]}
N 6290 -7320 6490 -7320 {
lab=colon_n[24]}
N 6490 -7320 6500 -7310 {
lab=colon_n[24]}
N 6280 -7290 6290 -7300 {
lab=#net49}
N 6290 -7300 6490 -7300 {
lab=#net49}
N 6490 -7300 6500 -7290 {
lab=#net49}
N 6280 -7270 6290 -7280 {
lab=#net50}
N 6290 -7280 6490 -7280 {
lab=#net50}
N 6490 -7280 6500 -7270 {
lab=#net50}
N 6340 -7430 6340 -7410 {
lab=vcom}
N 6380 -7430 6380 -7410 {
lab=ctop}
N 6260 -7330 6280 -7330 {
lab=col_n[24]}
N 6260 -7310 6280 -7310 {
lab=colon_n[24]}
N 6260 -7290 6280 -7290 {
lab=#net49}
N 6260 -7270 6280 -7270 {
lab=#net50}
N 6500 -7270 6520 -7270 {
lab=#net50}
N 6500 -7290 6520 -7290 {
lab=#net49}
N 6500 -7310 6520 -7310 {
lab=colon_n[24]}
N 6500 -7330 6520 -7330 {
lab=col_n[24]}
N 6320 -7190 6320 -7180 {
lab=VSS}
N 6320 -7420 6320 -7410 {
lab=VDD}
N 6660 -7190 6670 -7200 {
lab=row_n[21]}
N 6670 -7400 6670 -7200 {
lab=row_n[21]}
N 6660 -7410 6670 -7400 {
lab=row_n[21]}
N 6660 -7190 6660 -7170 {
lab=row_n[21]}
N 6660 -7430 6660 -7410 {
lab=row_n[21]}
N 6540 -7330 6550 -7340 {
lab=col_n[24]}
N 6550 -7340 6750 -7340 {
lab=col_n[24]}
N 6750 -7340 6760 -7330 {
lab=col_n[24]}
N 6540 -7310 6550 -7320 {
lab=colon_n[24]}
N 6550 -7320 6750 -7320 {
lab=colon_n[24]}
N 6750 -7320 6760 -7310 {
lab=colon_n[24]}
N 6540 -7290 6550 -7300 {
lab=#net49}
N 6550 -7300 6750 -7300 {
lab=#net49}
N 6750 -7300 6760 -7290 {
lab=#net49}
N 6540 -7270 6550 -7280 {
lab=#net50}
N 6550 -7280 6750 -7280 {
lab=#net50}
N 6750 -7280 6760 -7270 {
lab=#net50}
N 6600 -7430 6600 -7410 {
lab=vcom}
N 6640 -7430 6640 -7410 {
lab=ctop}
N 6520 -7330 6540 -7330 {
lab=col_n[24]}
N 6520 -7310 6540 -7310 {
lab=colon_n[24]}
N 6520 -7290 6540 -7290 {
lab=#net49}
N 6520 -7270 6540 -7270 {
lab=#net50}
N 6760 -7270 6780 -7270 {
lab=#net50}
N 6760 -7290 6780 -7290 {
lab=#net49}
N 6760 -7310 6780 -7310 {
lab=colon_n[24]}
N 6760 -7330 6780 -7330 {
lab=col_n[24]}
N 6580 -7190 6580 -7180 {
lab=VSS}
N 6580 -7420 6580 -7410 {
lab=VDD}
N 6920 -7190 6930 -7200 {
lab=row_n[22]}
N 6930 -7400 6930 -7200 {
lab=row_n[22]}
N 6920 -7410 6930 -7400 {
lab=row_n[22]}
N 6920 -7190 6920 -7170 {
lab=row_n[22]}
N 6920 -7430 6920 -7410 {
lab=row_n[22]}
N 6800 -7330 6810 -7340 {
lab=col_n[24]}
N 6810 -7340 7010 -7340 {
lab=col_n[24]}
N 7010 -7340 7020 -7330 {
lab=col_n[24]}
N 6800 -7310 6810 -7320 {
lab=colon_n[24]}
N 6810 -7320 7010 -7320 {
lab=colon_n[24]}
N 7010 -7320 7020 -7310 {
lab=colon_n[24]}
N 6800 -7290 6810 -7300 {
lab=#net49}
N 6810 -7300 7010 -7300 {
lab=#net49}
N 7010 -7300 7020 -7290 {
lab=#net49}
N 6800 -7270 6810 -7280 {
lab=#net50}
N 6810 -7280 7010 -7280 {
lab=#net50}
N 7010 -7280 7020 -7270 {
lab=#net50}
N 6860 -7430 6860 -7410 {
lab=vcom}
N 6900 -7430 6900 -7410 {
lab=ctop}
N 6780 -7330 6800 -7330 {
lab=col_n[24]}
N 6780 -7310 6800 -7310 {
lab=colon_n[24]}
N 6780 -7290 6800 -7290 {
lab=#net49}
N 6780 -7270 6800 -7270 {
lab=#net50}
N 7020 -7270 7040 -7270 {
lab=#net50}
N 7020 -7290 7040 -7290 {
lab=#net49}
N 7020 -7310 7040 -7310 {
lab=colon_n[24]}
N 7020 -7330 7040 -7330 {
lab=col_n[24]}
N 6840 -7190 6840 -7180 {
lab=VSS}
N 6840 -7420 6840 -7410 {
lab=VDD}
N 7180 -7190 7190 -7200 {
lab=row_n[23]}
N 7190 -7400 7190 -7200 {
lab=row_n[23]}
N 7180 -7410 7190 -7400 {
lab=row_n[23]}
N 7180 -7190 7180 -7170 {
lab=row_n[23]}
N 7180 -7430 7180 -7410 {
lab=row_n[23]}
N 7060 -7330 7070 -7340 {
lab=col_n[24]}
N 7070 -7340 7270 -7340 {
lab=col_n[24]}
N 7270 -7340 7280 -7330 {
lab=col_n[24]}
N 7060 -7310 7070 -7320 {
lab=colon_n[24]}
N 7070 -7320 7270 -7320 {
lab=colon_n[24]}
N 7270 -7320 7280 -7310 {
lab=colon_n[24]}
N 7060 -7290 7070 -7300 {
lab=#net49}
N 7070 -7300 7270 -7300 {
lab=#net49}
N 7270 -7300 7280 -7290 {
lab=#net49}
N 7060 -7270 7070 -7280 {
lab=#net50}
N 7070 -7280 7270 -7280 {
lab=#net50}
N 7270 -7280 7280 -7270 {
lab=#net50}
N 7120 -7430 7120 -7410 {
lab=vcom}
N 7160 -7430 7160 -7410 {
lab=ctop}
N 7040 -7330 7060 -7330 {
lab=col_n[24]}
N 7040 -7310 7060 -7310 {
lab=colon_n[24]}
N 7040 -7290 7060 -7290 {
lab=#net49}
N 7040 -7270 7060 -7270 {
lab=#net50}
N 7280 -7270 7300 -7270 {
lab=#net50}
N 7280 -7290 7300 -7290 {
lab=#net49}
N 7280 -7310 7300 -7310 {
lab=colon_n[24]}
N 7280 -7330 7300 -7330 {
lab=col_n[24]}
N 7100 -7190 7100 -7180 {
lab=VSS}
N 7100 -7420 7100 -7410 {
lab=VDD}
N 7440 -7190 7450 -7200 {
lab=row_n[24]}
N 7450 -7400 7450 -7200 {
lab=row_n[24]}
N 7440 -7410 7450 -7400 {
lab=row_n[24]}
N 7440 -7190 7440 -7170 {
lab=row_n[24]}
N 7440 -7430 7440 -7410 {
lab=row_n[24]}
N 7320 -7330 7330 -7340 {
lab=col_n[24]}
N 7330 -7340 7530 -7340 {
lab=col_n[24]}
N 7530 -7340 7540 -7330 {
lab=col_n[24]}
N 7320 -7310 7330 -7320 {
lab=colon_n[24]}
N 7330 -7320 7530 -7320 {
lab=colon_n[24]}
N 7530 -7320 7540 -7310 {
lab=colon_n[24]}
N 7320 -7290 7330 -7300 {
lab=#net49}
N 7330 -7300 7530 -7300 {
lab=#net49}
N 7530 -7300 7540 -7290 {
lab=#net49}
N 7320 -7270 7330 -7280 {
lab=#net50}
N 7330 -7280 7530 -7280 {
lab=#net50}
N 7530 -7280 7540 -7270 {
lab=#net50}
N 7380 -7430 7380 -7410 {
lab=vcom}
N 7420 -7430 7420 -7410 {
lab=ctop}
N 7300 -7330 7320 -7330 {
lab=col_n[24]}
N 7300 -7310 7320 -7310 {
lab=colon_n[24]}
N 7300 -7290 7320 -7290 {
lab=#net49}
N 7300 -7270 7320 -7270 {
lab=#net50}
N 7540 -7270 7560 -7270 {
lab=#net50}
N 7540 -7290 7560 -7290 {
lab=#net49}
N 7540 -7310 7560 -7310 {
lab=colon_n[24]}
N 7540 -7330 7560 -7330 {
lab=col_n[24]}
N 7360 -7190 7360 -7180 {
lab=VSS}
N 7360 -7420 7360 -7410 {
lab=VDD}
N 7700 -7190 7710 -7200 {
lab=row_n[25]}
N 7710 -7400 7710 -7200 {
lab=row_n[25]}
N 7700 -7410 7710 -7400 {
lab=row_n[25]}
N 7700 -7190 7700 -7170 {
lab=row_n[25]}
N 7700 -7430 7700 -7410 {
lab=row_n[25]}
N 7580 -7330 7590 -7340 {
lab=col_n[24]}
N 7590 -7340 7790 -7340 {
lab=col_n[24]}
N 7790 -7340 7800 -7330 {
lab=col_n[24]}
N 7580 -7310 7590 -7320 {
lab=colon_n[24]}
N 7590 -7320 7790 -7320 {
lab=colon_n[24]}
N 7790 -7320 7800 -7310 {
lab=colon_n[24]}
N 7580 -7290 7590 -7300 {
lab=#net49}
N 7590 -7300 7790 -7300 {
lab=#net49}
N 7790 -7300 7800 -7290 {
lab=#net49}
N 7580 -7270 7590 -7280 {
lab=#net50}
N 7590 -7280 7790 -7280 {
lab=#net50}
N 7790 -7280 7800 -7270 {
lab=#net50}
N 7640 -7430 7640 -7410 {
lab=vcom}
N 7680 -7430 7680 -7410 {
lab=ctop}
N 7560 -7330 7580 -7330 {
lab=col_n[24]}
N 7560 -7310 7580 -7310 {
lab=colon_n[24]}
N 7560 -7290 7580 -7290 {
lab=#net49}
N 7560 -7270 7580 -7270 {
lab=#net50}
N 7800 -7270 7820 -7270 {
lab=#net50}
N 7800 -7290 7820 -7290 {
lab=#net49}
N 7800 -7310 7820 -7310 {
lab=colon_n[24]}
N 7800 -7330 7820 -7330 {
lab=col_n[24]}
N 7620 -7190 7620 -7180 {
lab=VSS}
N 7620 -7420 7620 -7410 {
lab=VDD}
N 7960 -7190 7970 -7200 {
lab=row_n[26]}
N 7970 -7400 7970 -7200 {
lab=row_n[26]}
N 7960 -7410 7970 -7400 {
lab=row_n[26]}
N 7960 -7190 7960 -7170 {
lab=row_n[26]}
N 7960 -7430 7960 -7410 {
lab=row_n[26]}
N 7840 -7330 7850 -7340 {
lab=col_n[24]}
N 7850 -7340 8050 -7340 {
lab=col_n[24]}
N 8050 -7340 8060 -7330 {
lab=col_n[24]}
N 7840 -7310 7850 -7320 {
lab=colon_n[24]}
N 7850 -7320 8050 -7320 {
lab=colon_n[24]}
N 8050 -7320 8060 -7310 {
lab=colon_n[24]}
N 7840 -7290 7850 -7300 {
lab=#net49}
N 7850 -7300 8050 -7300 {
lab=#net49}
N 8050 -7300 8060 -7290 {
lab=#net49}
N 7840 -7270 7850 -7280 {
lab=#net50}
N 7850 -7280 8050 -7280 {
lab=#net50}
N 8050 -7280 8060 -7270 {
lab=#net50}
N 7900 -7430 7900 -7410 {
lab=vcom}
N 7940 -7430 7940 -7410 {
lab=ctop}
N 7820 -7330 7840 -7330 {
lab=col_n[24]}
N 7820 -7310 7840 -7310 {
lab=colon_n[24]}
N 7820 -7290 7840 -7290 {
lab=#net49}
N 7820 -7270 7840 -7270 {
lab=#net50}
N 8060 -7270 8080 -7270 {
lab=#net50}
N 8060 -7290 8080 -7290 {
lab=#net49}
N 8060 -7310 8080 -7310 {
lab=colon_n[24]}
N 8060 -7330 8080 -7330 {
lab=col_n[24]}
N 7880 -7190 7880 -7180 {
lab=VSS}
N 7880 -7420 7880 -7410 {
lab=VDD}
N 8220 -7190 8230 -7200 {
lab=row_n[27]}
N 8230 -7400 8230 -7200 {
lab=row_n[27]}
N 8220 -7410 8230 -7400 {
lab=row_n[27]}
N 8220 -7190 8220 -7170 {
lab=row_n[27]}
N 8220 -7430 8220 -7410 {
lab=row_n[27]}
N 8100 -7330 8110 -7340 {
lab=col_n[24]}
N 8110 -7340 8310 -7340 {
lab=col_n[24]}
N 8310 -7340 8320 -7330 {
lab=col_n[24]}
N 8100 -7310 8110 -7320 {
lab=colon_n[24]}
N 8110 -7320 8310 -7320 {
lab=colon_n[24]}
N 8310 -7320 8320 -7310 {
lab=colon_n[24]}
N 8100 -7290 8110 -7300 {
lab=#net49}
N 8110 -7300 8310 -7300 {
lab=#net49}
N 8310 -7300 8320 -7290 {
lab=#net49}
N 8100 -7270 8110 -7280 {
lab=#net50}
N 8110 -7280 8310 -7280 {
lab=#net50}
N 8310 -7280 8320 -7270 {
lab=#net50}
N 8160 -7430 8160 -7410 {
lab=vcom}
N 8200 -7430 8200 -7410 {
lab=ctop}
N 8080 -7330 8100 -7330 {
lab=col_n[24]}
N 8080 -7310 8100 -7310 {
lab=colon_n[24]}
N 8080 -7290 8100 -7290 {
lab=#net49}
N 8080 -7270 8100 -7270 {
lab=#net50}
N 8320 -7270 8340 -7270 {
lab=#net50}
N 8320 -7290 8340 -7290 {
lab=#net49}
N 8320 -7310 8340 -7310 {
lab=colon_n[24]}
N 8320 -7330 8340 -7330 {
lab=col_n[24]}
N 8140 -7190 8140 -7180 {
lab=VSS}
N 8140 -7420 8140 -7410 {
lab=VDD}
N 8480 -7190 8490 -7200 {
lab=row_n[28]}
N 8490 -7400 8490 -7200 {
lab=row_n[28]}
N 8480 -7410 8490 -7400 {
lab=row_n[28]}
N 8480 -7190 8480 -7170 {
lab=row_n[28]}
N 8480 -7430 8480 -7410 {
lab=row_n[28]}
N 8360 -7330 8370 -7340 {
lab=col_n[24]}
N 8370 -7340 8570 -7340 {
lab=col_n[24]}
N 8570 -7340 8580 -7330 {
lab=col_n[24]}
N 8360 -7310 8370 -7320 {
lab=colon_n[24]}
N 8370 -7320 8570 -7320 {
lab=colon_n[24]}
N 8570 -7320 8580 -7310 {
lab=colon_n[24]}
N 8360 -7290 8370 -7300 {
lab=#net49}
N 8370 -7300 8570 -7300 {
lab=#net49}
N 8570 -7300 8580 -7290 {
lab=#net49}
N 8360 -7270 8370 -7280 {
lab=#net50}
N 8370 -7280 8570 -7280 {
lab=#net50}
N 8570 -7280 8580 -7270 {
lab=#net50}
N 8420 -7430 8420 -7410 {
lab=vcom}
N 8460 -7430 8460 -7410 {
lab=ctop}
N 8340 -7330 8360 -7330 {
lab=col_n[24]}
N 8340 -7310 8360 -7310 {
lab=colon_n[24]}
N 8340 -7290 8360 -7290 {
lab=#net49}
N 8340 -7270 8360 -7270 {
lab=#net50}
N 8580 -7270 8600 -7270 {
lab=#net50}
N 8580 -7290 8600 -7290 {
lab=#net49}
N 8580 -7310 8600 -7310 {
lab=colon_n[24]}
N 8580 -7330 8600 -7330 {
lab=col_n[24]}
N 8400 -7190 8400 -7180 {
lab=VSS}
N 8400 -7420 8400 -7410 {
lab=VDD}
N 8740 -7190 8750 -7200 {
lab=row_n[29]}
N 8750 -7400 8750 -7200 {
lab=row_n[29]}
N 8740 -7410 8750 -7400 {
lab=row_n[29]}
N 8740 -7190 8740 -7170 {
lab=row_n[29]}
N 8740 -7430 8740 -7410 {
lab=row_n[29]}
N 8620 -7330 8630 -7340 {
lab=col_n[24]}
N 8630 -7340 8830 -7340 {
lab=col_n[24]}
N 8830 -7340 8840 -7330 {
lab=col_n[24]}
N 8620 -7310 8630 -7320 {
lab=colon_n[24]}
N 8630 -7320 8830 -7320 {
lab=colon_n[24]}
N 8830 -7320 8840 -7310 {
lab=colon_n[24]}
N 8620 -7290 8630 -7300 {
lab=#net49}
N 8630 -7300 8830 -7300 {
lab=#net49}
N 8830 -7300 8840 -7290 {
lab=#net49}
N 8620 -7270 8630 -7280 {
lab=#net50}
N 8630 -7280 8830 -7280 {
lab=#net50}
N 8830 -7280 8840 -7270 {
lab=#net50}
N 8680 -7430 8680 -7410 {
lab=vcom}
N 8720 -7430 8720 -7410 {
lab=ctop}
N 8600 -7330 8620 -7330 {
lab=col_n[24]}
N 8600 -7310 8620 -7310 {
lab=colon_n[24]}
N 8600 -7290 8620 -7290 {
lab=#net49}
N 8600 -7270 8620 -7270 {
lab=#net50}
N 8840 -7270 8860 -7270 {
lab=#net50}
N 8840 -7290 8860 -7290 {
lab=#net49}
N 8840 -7310 8860 -7310 {
lab=colon_n[24]}
N 8840 -7330 8860 -7330 {
lab=col_n[24]}
N 8660 -7190 8660 -7180 {
lab=VSS}
N 8660 -7420 8660 -7410 {
lab=VDD}
N 9000 -7190 9010 -7200 {
lab=row_n[30]}
N 9010 -7400 9010 -7200 {
lab=row_n[30]}
N 9000 -7410 9010 -7400 {
lab=row_n[30]}
N 9000 -7190 9000 -7170 {
lab=row_n[30]}
N 9000 -7430 9000 -7410 {
lab=row_n[30]}
N 8880 -7330 8890 -7340 {
lab=col_n[24]}
N 8890 -7340 9090 -7340 {
lab=col_n[24]}
N 9090 -7340 9100 -7330 {
lab=col_n[24]}
N 8880 -7310 8890 -7320 {
lab=colon_n[24]}
N 8890 -7320 9090 -7320 {
lab=colon_n[24]}
N 9090 -7320 9100 -7310 {
lab=colon_n[24]}
N 8880 -7290 8890 -7300 {
lab=#net49}
N 8890 -7300 9090 -7300 {
lab=#net49}
N 9090 -7300 9100 -7290 {
lab=#net49}
N 8880 -7270 8890 -7280 {
lab=#net50}
N 8890 -7280 9090 -7280 {
lab=#net50}
N 9090 -7280 9100 -7270 {
lab=#net50}
N 8940 -7430 8940 -7410 {
lab=vcom}
N 8980 -7430 8980 -7410 {
lab=ctop}
N 8860 -7330 8880 -7330 {
lab=col_n[24]}
N 8860 -7310 8880 -7310 {
lab=colon_n[24]}
N 8860 -7290 8880 -7290 {
lab=#net49}
N 8860 -7270 8880 -7270 {
lab=#net50}
N 9100 -7270 9120 -7270 {
lab=#net50}
N 9100 -7290 9120 -7290 {
lab=#net49}
N 9100 -7310 9120 -7310 {
lab=colon_n[24]}
N 9100 -7330 9120 -7330 {
lab=col_n[24]}
N 8920 -7190 8920 -7180 {
lab=VSS}
N 8920 -7420 8920 -7410 {
lab=VDD}
N 9260 -7190 9270 -7200 {
lab=row_n[31]}
N 9270 -7400 9270 -7200 {
lab=row_n[31]}
N 9260 -7410 9270 -7400 {
lab=row_n[31]}
N 9260 -7190 9260 -7170 {
lab=row_n[31]}
N 9260 -7430 9260 -7410 {
lab=row_n[31]}
N 9140 -7330 9150 -7340 {
lab=col_n[24]}
N 9150 -7340 9350 -7340 {
lab=col_n[24]}
N 9350 -7340 9360 -7330 {
lab=col_n[24]}
N 9140 -7310 9150 -7320 {
lab=colon_n[24]}
N 9150 -7320 9350 -7320 {
lab=colon_n[24]}
N 9350 -7320 9360 -7310 {
lab=colon_n[24]}
N 9140 -7290 9150 -7300 {
lab=#net49}
N 9150 -7300 9350 -7300 {
lab=#net49}
N 9350 -7300 9360 -7290 {
lab=#net49}
N 9140 -7270 9150 -7280 {
lab=#net50}
N 9150 -7280 9350 -7280 {
lab=#net50}
N 9350 -7280 9360 -7270 {
lab=#net50}
N 9200 -7430 9200 -7410 {
lab=vcom}
N 9240 -7430 9240 -7410 {
lab=ctop}
N 9120 -7330 9140 -7330 {
lab=col_n[24]}
N 9120 -7310 9140 -7310 {
lab=colon_n[24]}
N 9120 -7290 9140 -7290 {
lab=#net49}
N 9120 -7270 9140 -7270 {
lab=#net50}
N 9360 -7270 9380 -7270 {
lab=#net50}
N 9360 -7290 9380 -7290 {
lab=#net49}
N 9360 -7310 9380 -7310 {
lab=colon_n[24]}
N 9360 -7330 9380 -7330 {
lab=col_n[24]}
N 9180 -7190 9180 -7180 {
lab=VSS}
N 9180 -7420 9180 -7410 {
lab=VDD}
N 1200 -7450 1210 -7460 {
lab=row_n[0]}
N 1210 -7660 1210 -7460 {
lab=row_n[0]}
N 1200 -7670 1210 -7660 {
lab=row_n[0]}
N 1200 -7450 1200 -7430 {
lab=row_n[0]}
N 1200 -7690 1200 -7670 {
lab=row_n[0]}
N 1080 -7590 1090 -7600 {
lab=col_n[25]}
N 1090 -7600 1290 -7600 {
lab=col_n[25]}
N 1290 -7600 1300 -7590 {
lab=col_n[25]}
N 1080 -7570 1090 -7580 {
lab=colon_n[25]}
N 1090 -7580 1290 -7580 {
lab=colon_n[25]}
N 1290 -7580 1300 -7570 {
lab=colon_n[25]}
N 1080 -7550 1090 -7560 {
lab=#net51}
N 1090 -7560 1290 -7560 {
lab=#net51}
N 1290 -7560 1300 -7550 {
lab=#net51}
N 1080 -7530 1090 -7540 {
lab=#net52}
N 1090 -7540 1290 -7540 {
lab=#net52}
N 1290 -7540 1300 -7530 {
lab=#net52}
N 1140 -7690 1140 -7670 {
lab=vcom}
N 1180 -7690 1180 -7670 {
lab=ctop}
N 1060 -7590 1080 -7590 {
lab=col_n[25]}
N 1060 -7570 1080 -7570 {
lab=colon_n[25]}
N 1060 -7550 1080 -7550 {
lab=#net51}
N 1060 -7530 1080 -7530 {
lab=#net52}
N 1300 -7530 1320 -7530 {
lab=#net52}
N 1300 -7550 1320 -7550 {
lab=#net51}
N 1300 -7570 1320 -7570 {
lab=colon_n[25]}
N 1300 -7590 1320 -7590 {
lab=col_n[25]}
N 1120 -7450 1120 -7440 {
lab=VSS}
N 1120 -7680 1120 -7670 {
lab=VDD}
N 1460 -7450 1470 -7460 {
lab=row_n[1]}
N 1470 -7660 1470 -7460 {
lab=row_n[1]}
N 1460 -7670 1470 -7660 {
lab=row_n[1]}
N 1460 -7450 1460 -7430 {
lab=row_n[1]}
N 1460 -7690 1460 -7670 {
lab=row_n[1]}
N 1340 -7590 1350 -7600 {
lab=col_n[25]}
N 1350 -7600 1550 -7600 {
lab=col_n[25]}
N 1550 -7600 1560 -7590 {
lab=col_n[25]}
N 1340 -7570 1350 -7580 {
lab=colon_n[25]}
N 1350 -7580 1550 -7580 {
lab=colon_n[25]}
N 1550 -7580 1560 -7570 {
lab=colon_n[25]}
N 1340 -7550 1350 -7560 {
lab=#net51}
N 1350 -7560 1550 -7560 {
lab=#net51}
N 1550 -7560 1560 -7550 {
lab=#net51}
N 1340 -7530 1350 -7540 {
lab=#net52}
N 1350 -7540 1550 -7540 {
lab=#net52}
N 1550 -7540 1560 -7530 {
lab=#net52}
N 1400 -7690 1400 -7670 {
lab=vcom}
N 1440 -7690 1440 -7670 {
lab=ctop}
N 1320 -7590 1340 -7590 {
lab=col_n[25]}
N 1320 -7570 1340 -7570 {
lab=colon_n[25]}
N 1320 -7550 1340 -7550 {
lab=#net51}
N 1320 -7530 1340 -7530 {
lab=#net52}
N 1560 -7530 1580 -7530 {
lab=#net52}
N 1560 -7550 1580 -7550 {
lab=#net51}
N 1560 -7570 1580 -7570 {
lab=colon_n[25]}
N 1560 -7590 1580 -7590 {
lab=col_n[25]}
N 1380 -7450 1380 -7440 {
lab=VSS}
N 1380 -7680 1380 -7670 {
lab=VDD}
N 1720 -7450 1730 -7460 {
lab=row_n[2]}
N 1730 -7660 1730 -7460 {
lab=row_n[2]}
N 1720 -7670 1730 -7660 {
lab=row_n[2]}
N 1720 -7450 1720 -7430 {
lab=row_n[2]}
N 1720 -7690 1720 -7670 {
lab=row_n[2]}
N 1600 -7590 1610 -7600 {
lab=col_n[25]}
N 1610 -7600 1810 -7600 {
lab=col_n[25]}
N 1810 -7600 1820 -7590 {
lab=col_n[25]}
N 1600 -7570 1610 -7580 {
lab=colon_n[25]}
N 1610 -7580 1810 -7580 {
lab=colon_n[25]}
N 1810 -7580 1820 -7570 {
lab=colon_n[25]}
N 1600 -7550 1610 -7560 {
lab=#net51}
N 1610 -7560 1810 -7560 {
lab=#net51}
N 1810 -7560 1820 -7550 {
lab=#net51}
N 1600 -7530 1610 -7540 {
lab=#net52}
N 1610 -7540 1810 -7540 {
lab=#net52}
N 1810 -7540 1820 -7530 {
lab=#net52}
N 1660 -7690 1660 -7670 {
lab=vcom}
N 1700 -7690 1700 -7670 {
lab=ctop}
N 1580 -7590 1600 -7590 {
lab=col_n[25]}
N 1580 -7570 1600 -7570 {
lab=colon_n[25]}
N 1580 -7550 1600 -7550 {
lab=#net51}
N 1580 -7530 1600 -7530 {
lab=#net52}
N 1820 -7530 1840 -7530 {
lab=#net52}
N 1820 -7550 1840 -7550 {
lab=#net51}
N 1820 -7570 1840 -7570 {
lab=colon_n[25]}
N 1820 -7590 1840 -7590 {
lab=col_n[25]}
N 1640 -7450 1640 -7440 {
lab=VSS}
N 1640 -7680 1640 -7670 {
lab=VDD}
N 1980 -7450 1990 -7460 {
lab=row_n[3]}
N 1990 -7660 1990 -7460 {
lab=row_n[3]}
N 1980 -7670 1990 -7660 {
lab=row_n[3]}
N 1980 -7450 1980 -7430 {
lab=row_n[3]}
N 1980 -7690 1980 -7670 {
lab=row_n[3]}
N 1860 -7590 1870 -7600 {
lab=col_n[25]}
N 1870 -7600 2070 -7600 {
lab=col_n[25]}
N 2070 -7600 2080 -7590 {
lab=col_n[25]}
N 1860 -7570 1870 -7580 {
lab=colon_n[25]}
N 1870 -7580 2070 -7580 {
lab=colon_n[25]}
N 2070 -7580 2080 -7570 {
lab=colon_n[25]}
N 1860 -7550 1870 -7560 {
lab=#net51}
N 1870 -7560 2070 -7560 {
lab=#net51}
N 2070 -7560 2080 -7550 {
lab=#net51}
N 1860 -7530 1870 -7540 {
lab=#net52}
N 1870 -7540 2070 -7540 {
lab=#net52}
N 2070 -7540 2080 -7530 {
lab=#net52}
N 1920 -7690 1920 -7670 {
lab=vcom}
N 1960 -7690 1960 -7670 {
lab=ctop}
N 1840 -7590 1860 -7590 {
lab=col_n[25]}
N 1840 -7570 1860 -7570 {
lab=colon_n[25]}
N 1840 -7550 1860 -7550 {
lab=#net51}
N 1840 -7530 1860 -7530 {
lab=#net52}
N 2080 -7530 2100 -7530 {
lab=#net52}
N 2080 -7550 2100 -7550 {
lab=#net51}
N 2080 -7570 2100 -7570 {
lab=colon_n[25]}
N 2080 -7590 2100 -7590 {
lab=col_n[25]}
N 1900 -7450 1900 -7440 {
lab=VSS}
N 1900 -7680 1900 -7670 {
lab=VDD}
N 2240 -7450 2250 -7460 {
lab=row_n[4]}
N 2250 -7660 2250 -7460 {
lab=row_n[4]}
N 2240 -7670 2250 -7660 {
lab=row_n[4]}
N 2240 -7450 2240 -7430 {
lab=row_n[4]}
N 2240 -7690 2240 -7670 {
lab=row_n[4]}
N 2120 -7590 2130 -7600 {
lab=col_n[25]}
N 2130 -7600 2330 -7600 {
lab=col_n[25]}
N 2330 -7600 2340 -7590 {
lab=col_n[25]}
N 2120 -7570 2130 -7580 {
lab=colon_n[25]}
N 2130 -7580 2330 -7580 {
lab=colon_n[25]}
N 2330 -7580 2340 -7570 {
lab=colon_n[25]}
N 2120 -7550 2130 -7560 {
lab=#net51}
N 2130 -7560 2330 -7560 {
lab=#net51}
N 2330 -7560 2340 -7550 {
lab=#net51}
N 2120 -7530 2130 -7540 {
lab=#net52}
N 2130 -7540 2330 -7540 {
lab=#net52}
N 2330 -7540 2340 -7530 {
lab=#net52}
N 2180 -7690 2180 -7670 {
lab=vcom}
N 2220 -7690 2220 -7670 {
lab=ctop}
N 2100 -7590 2120 -7590 {
lab=col_n[25]}
N 2100 -7570 2120 -7570 {
lab=colon_n[25]}
N 2100 -7550 2120 -7550 {
lab=#net51}
N 2100 -7530 2120 -7530 {
lab=#net52}
N 2340 -7530 2360 -7530 {
lab=#net52}
N 2340 -7550 2360 -7550 {
lab=#net51}
N 2340 -7570 2360 -7570 {
lab=colon_n[25]}
N 2340 -7590 2360 -7590 {
lab=col_n[25]}
N 2160 -7450 2160 -7440 {
lab=VSS}
N 2160 -7680 2160 -7670 {
lab=VDD}
N 2500 -7450 2510 -7460 {
lab=row_n[5]}
N 2510 -7660 2510 -7460 {
lab=row_n[5]}
N 2500 -7670 2510 -7660 {
lab=row_n[5]}
N 2500 -7450 2500 -7430 {
lab=row_n[5]}
N 2500 -7690 2500 -7670 {
lab=row_n[5]}
N 2380 -7590 2390 -7600 {
lab=col_n[25]}
N 2390 -7600 2590 -7600 {
lab=col_n[25]}
N 2590 -7600 2600 -7590 {
lab=col_n[25]}
N 2380 -7570 2390 -7580 {
lab=colon_n[25]}
N 2390 -7580 2590 -7580 {
lab=colon_n[25]}
N 2590 -7580 2600 -7570 {
lab=colon_n[25]}
N 2380 -7550 2390 -7560 {
lab=#net51}
N 2390 -7560 2590 -7560 {
lab=#net51}
N 2590 -7560 2600 -7550 {
lab=#net51}
N 2380 -7530 2390 -7540 {
lab=#net52}
N 2390 -7540 2590 -7540 {
lab=#net52}
N 2590 -7540 2600 -7530 {
lab=#net52}
N 2440 -7690 2440 -7670 {
lab=vcom}
N 2480 -7690 2480 -7670 {
lab=ctop}
N 2360 -7590 2380 -7590 {
lab=col_n[25]}
N 2360 -7570 2380 -7570 {
lab=colon_n[25]}
N 2360 -7550 2380 -7550 {
lab=#net51}
N 2360 -7530 2380 -7530 {
lab=#net52}
N 2600 -7530 2620 -7530 {
lab=#net52}
N 2600 -7550 2620 -7550 {
lab=#net51}
N 2600 -7570 2620 -7570 {
lab=colon_n[25]}
N 2600 -7590 2620 -7590 {
lab=col_n[25]}
N 2420 -7450 2420 -7440 {
lab=VSS}
N 2420 -7680 2420 -7670 {
lab=VDD}
N 2760 -7450 2770 -7460 {
lab=row_n[6]}
N 2770 -7660 2770 -7460 {
lab=row_n[6]}
N 2760 -7670 2770 -7660 {
lab=row_n[6]}
N 2760 -7450 2760 -7430 {
lab=row_n[6]}
N 2760 -7690 2760 -7670 {
lab=row_n[6]}
N 2640 -7590 2650 -7600 {
lab=col_n[25]}
N 2650 -7600 2850 -7600 {
lab=col_n[25]}
N 2850 -7600 2860 -7590 {
lab=col_n[25]}
N 2640 -7570 2650 -7580 {
lab=colon_n[25]}
N 2650 -7580 2850 -7580 {
lab=colon_n[25]}
N 2850 -7580 2860 -7570 {
lab=colon_n[25]}
N 2640 -7550 2650 -7560 {
lab=#net51}
N 2650 -7560 2850 -7560 {
lab=#net51}
N 2850 -7560 2860 -7550 {
lab=#net51}
N 2640 -7530 2650 -7540 {
lab=#net52}
N 2650 -7540 2850 -7540 {
lab=#net52}
N 2850 -7540 2860 -7530 {
lab=#net52}
N 2700 -7690 2700 -7670 {
lab=vcom}
N 2740 -7690 2740 -7670 {
lab=ctop}
N 2620 -7590 2640 -7590 {
lab=col_n[25]}
N 2620 -7570 2640 -7570 {
lab=colon_n[25]}
N 2620 -7550 2640 -7550 {
lab=#net51}
N 2620 -7530 2640 -7530 {
lab=#net52}
N 2860 -7530 2880 -7530 {
lab=#net52}
N 2860 -7550 2880 -7550 {
lab=#net51}
N 2860 -7570 2880 -7570 {
lab=colon_n[25]}
N 2860 -7590 2880 -7590 {
lab=col_n[25]}
N 2680 -7450 2680 -7440 {
lab=VSS}
N 2680 -7680 2680 -7670 {
lab=VDD}
N 3020 -7450 3030 -7460 {
lab=row_n[7]}
N 3030 -7660 3030 -7460 {
lab=row_n[7]}
N 3020 -7670 3030 -7660 {
lab=row_n[7]}
N 3020 -7450 3020 -7430 {
lab=row_n[7]}
N 3020 -7690 3020 -7670 {
lab=row_n[7]}
N 2900 -7590 2910 -7600 {
lab=col_n[25]}
N 2910 -7600 3110 -7600 {
lab=col_n[25]}
N 3110 -7600 3120 -7590 {
lab=col_n[25]}
N 2900 -7570 2910 -7580 {
lab=colon_n[25]}
N 2910 -7580 3110 -7580 {
lab=colon_n[25]}
N 3110 -7580 3120 -7570 {
lab=colon_n[25]}
N 2900 -7550 2910 -7560 {
lab=#net51}
N 2910 -7560 3110 -7560 {
lab=#net51}
N 3110 -7560 3120 -7550 {
lab=#net51}
N 2900 -7530 2910 -7540 {
lab=#net52}
N 2910 -7540 3110 -7540 {
lab=#net52}
N 3110 -7540 3120 -7530 {
lab=#net52}
N 2960 -7690 2960 -7670 {
lab=vcom}
N 3000 -7690 3000 -7670 {
lab=ctop}
N 2880 -7590 2900 -7590 {
lab=col_n[25]}
N 2880 -7570 2900 -7570 {
lab=colon_n[25]}
N 2880 -7550 2900 -7550 {
lab=#net51}
N 2880 -7530 2900 -7530 {
lab=#net52}
N 3120 -7530 3140 -7530 {
lab=#net52}
N 3120 -7550 3140 -7550 {
lab=#net51}
N 3120 -7570 3140 -7570 {
lab=colon_n[25]}
N 3120 -7590 3140 -7590 {
lab=col_n[25]}
N 2940 -7450 2940 -7440 {
lab=VSS}
N 2940 -7680 2940 -7670 {
lab=VDD}
N 3280 -7450 3290 -7460 {
lab=row_n[8]}
N 3290 -7660 3290 -7460 {
lab=row_n[8]}
N 3280 -7670 3290 -7660 {
lab=row_n[8]}
N 3280 -7450 3280 -7430 {
lab=row_n[8]}
N 3280 -7690 3280 -7670 {
lab=row_n[8]}
N 3160 -7590 3170 -7600 {
lab=col_n[25]}
N 3170 -7600 3370 -7600 {
lab=col_n[25]}
N 3370 -7600 3380 -7590 {
lab=col_n[25]}
N 3160 -7570 3170 -7580 {
lab=colon_n[25]}
N 3170 -7580 3370 -7580 {
lab=colon_n[25]}
N 3370 -7580 3380 -7570 {
lab=colon_n[25]}
N 3160 -7550 3170 -7560 {
lab=#net51}
N 3170 -7560 3370 -7560 {
lab=#net51}
N 3370 -7560 3380 -7550 {
lab=#net51}
N 3160 -7530 3170 -7540 {
lab=#net52}
N 3170 -7540 3370 -7540 {
lab=#net52}
N 3370 -7540 3380 -7530 {
lab=#net52}
N 3220 -7690 3220 -7670 {
lab=vcom}
N 3260 -7690 3260 -7670 {
lab=ctop}
N 3140 -7590 3160 -7590 {
lab=col_n[25]}
N 3140 -7570 3160 -7570 {
lab=colon_n[25]}
N 3140 -7550 3160 -7550 {
lab=#net51}
N 3140 -7530 3160 -7530 {
lab=#net52}
N 3380 -7530 3400 -7530 {
lab=#net52}
N 3380 -7550 3400 -7550 {
lab=#net51}
N 3380 -7570 3400 -7570 {
lab=colon_n[25]}
N 3380 -7590 3400 -7590 {
lab=col_n[25]}
N 3200 -7450 3200 -7440 {
lab=VSS}
N 3200 -7680 3200 -7670 {
lab=VDD}
N 3540 -7450 3550 -7460 {
lab=row_n[9]}
N 3550 -7660 3550 -7460 {
lab=row_n[9]}
N 3540 -7670 3550 -7660 {
lab=row_n[9]}
N 3540 -7450 3540 -7430 {
lab=row_n[9]}
N 3540 -7690 3540 -7670 {
lab=row_n[9]}
N 3420 -7590 3430 -7600 {
lab=col_n[25]}
N 3430 -7600 3630 -7600 {
lab=col_n[25]}
N 3630 -7600 3640 -7590 {
lab=col_n[25]}
N 3420 -7570 3430 -7580 {
lab=colon_n[25]}
N 3430 -7580 3630 -7580 {
lab=colon_n[25]}
N 3630 -7580 3640 -7570 {
lab=colon_n[25]}
N 3420 -7550 3430 -7560 {
lab=#net51}
N 3430 -7560 3630 -7560 {
lab=#net51}
N 3630 -7560 3640 -7550 {
lab=#net51}
N 3420 -7530 3430 -7540 {
lab=#net52}
N 3430 -7540 3630 -7540 {
lab=#net52}
N 3630 -7540 3640 -7530 {
lab=#net52}
N 3480 -7690 3480 -7670 {
lab=vcom}
N 3520 -7690 3520 -7670 {
lab=ctop}
N 3400 -7590 3420 -7590 {
lab=col_n[25]}
N 3400 -7570 3420 -7570 {
lab=colon_n[25]}
N 3400 -7550 3420 -7550 {
lab=#net51}
N 3400 -7530 3420 -7530 {
lab=#net52}
N 3640 -7530 3660 -7530 {
lab=#net52}
N 3640 -7550 3660 -7550 {
lab=#net51}
N 3640 -7570 3660 -7570 {
lab=colon_n[25]}
N 3640 -7590 3660 -7590 {
lab=col_n[25]}
N 3460 -7450 3460 -7440 {
lab=VSS}
N 3460 -7680 3460 -7670 {
lab=VDD}
N 3800 -7450 3810 -7460 {
lab=row_n[10]}
N 3810 -7660 3810 -7460 {
lab=row_n[10]}
N 3800 -7670 3810 -7660 {
lab=row_n[10]}
N 3800 -7450 3800 -7430 {
lab=row_n[10]}
N 3800 -7690 3800 -7670 {
lab=row_n[10]}
N 3680 -7590 3690 -7600 {
lab=col_n[25]}
N 3690 -7600 3890 -7600 {
lab=col_n[25]}
N 3890 -7600 3900 -7590 {
lab=col_n[25]}
N 3680 -7570 3690 -7580 {
lab=colon_n[25]}
N 3690 -7580 3890 -7580 {
lab=colon_n[25]}
N 3890 -7580 3900 -7570 {
lab=colon_n[25]}
N 3680 -7550 3690 -7560 {
lab=#net51}
N 3690 -7560 3890 -7560 {
lab=#net51}
N 3890 -7560 3900 -7550 {
lab=#net51}
N 3680 -7530 3690 -7540 {
lab=#net52}
N 3690 -7540 3890 -7540 {
lab=#net52}
N 3890 -7540 3900 -7530 {
lab=#net52}
N 3740 -7690 3740 -7670 {
lab=vcom}
N 3780 -7690 3780 -7670 {
lab=ctop}
N 3660 -7590 3680 -7590 {
lab=col_n[25]}
N 3660 -7570 3680 -7570 {
lab=colon_n[25]}
N 3660 -7550 3680 -7550 {
lab=#net51}
N 3660 -7530 3680 -7530 {
lab=#net52}
N 3900 -7530 3920 -7530 {
lab=#net52}
N 3900 -7550 3920 -7550 {
lab=#net51}
N 3900 -7570 3920 -7570 {
lab=colon_n[25]}
N 3900 -7590 3920 -7590 {
lab=col_n[25]}
N 3720 -7450 3720 -7440 {
lab=VSS}
N 3720 -7680 3720 -7670 {
lab=VDD}
N 4060 -7450 4070 -7460 {
lab=row_n[11]}
N 4070 -7660 4070 -7460 {
lab=row_n[11]}
N 4060 -7670 4070 -7660 {
lab=row_n[11]}
N 4060 -7450 4060 -7430 {
lab=row_n[11]}
N 4060 -7690 4060 -7670 {
lab=row_n[11]}
N 3940 -7590 3950 -7600 {
lab=col_n[25]}
N 3950 -7600 4150 -7600 {
lab=col_n[25]}
N 4150 -7600 4160 -7590 {
lab=col_n[25]}
N 3940 -7570 3950 -7580 {
lab=colon_n[25]}
N 3950 -7580 4150 -7580 {
lab=colon_n[25]}
N 4150 -7580 4160 -7570 {
lab=colon_n[25]}
N 3940 -7550 3950 -7560 {
lab=#net51}
N 3950 -7560 4150 -7560 {
lab=#net51}
N 4150 -7560 4160 -7550 {
lab=#net51}
N 3940 -7530 3950 -7540 {
lab=#net52}
N 3950 -7540 4150 -7540 {
lab=#net52}
N 4150 -7540 4160 -7530 {
lab=#net52}
N 4000 -7690 4000 -7670 {
lab=vcom}
N 4040 -7690 4040 -7670 {
lab=ctop}
N 3920 -7590 3940 -7590 {
lab=col_n[25]}
N 3920 -7570 3940 -7570 {
lab=colon_n[25]}
N 3920 -7550 3940 -7550 {
lab=#net51}
N 3920 -7530 3940 -7530 {
lab=#net52}
N 4160 -7530 4180 -7530 {
lab=#net52}
N 4160 -7550 4180 -7550 {
lab=#net51}
N 4160 -7570 4180 -7570 {
lab=colon_n[25]}
N 4160 -7590 4180 -7590 {
lab=col_n[25]}
N 3980 -7450 3980 -7440 {
lab=VSS}
N 3980 -7680 3980 -7670 {
lab=VDD}
N 4320 -7450 4330 -7460 {
lab=row_n[12]}
N 4330 -7660 4330 -7460 {
lab=row_n[12]}
N 4320 -7670 4330 -7660 {
lab=row_n[12]}
N 4320 -7450 4320 -7430 {
lab=row_n[12]}
N 4320 -7690 4320 -7670 {
lab=row_n[12]}
N 4200 -7590 4210 -7600 {
lab=col_n[25]}
N 4210 -7600 4410 -7600 {
lab=col_n[25]}
N 4410 -7600 4420 -7590 {
lab=col_n[25]}
N 4200 -7570 4210 -7580 {
lab=colon_n[25]}
N 4210 -7580 4410 -7580 {
lab=colon_n[25]}
N 4410 -7580 4420 -7570 {
lab=colon_n[25]}
N 4200 -7550 4210 -7560 {
lab=#net51}
N 4210 -7560 4410 -7560 {
lab=#net51}
N 4410 -7560 4420 -7550 {
lab=#net51}
N 4200 -7530 4210 -7540 {
lab=#net52}
N 4210 -7540 4410 -7540 {
lab=#net52}
N 4410 -7540 4420 -7530 {
lab=#net52}
N 4260 -7690 4260 -7670 {
lab=vcom}
N 4300 -7690 4300 -7670 {
lab=ctop}
N 4180 -7590 4200 -7590 {
lab=col_n[25]}
N 4180 -7570 4200 -7570 {
lab=colon_n[25]}
N 4180 -7550 4200 -7550 {
lab=#net51}
N 4180 -7530 4200 -7530 {
lab=#net52}
N 4420 -7530 4440 -7530 {
lab=#net52}
N 4420 -7550 4440 -7550 {
lab=#net51}
N 4420 -7570 4440 -7570 {
lab=colon_n[25]}
N 4420 -7590 4440 -7590 {
lab=col_n[25]}
N 4240 -7450 4240 -7440 {
lab=VSS}
N 4240 -7680 4240 -7670 {
lab=VDD}
N 4580 -7450 4590 -7460 {
lab=row_n[13]}
N 4590 -7660 4590 -7460 {
lab=row_n[13]}
N 4580 -7670 4590 -7660 {
lab=row_n[13]}
N 4580 -7450 4580 -7430 {
lab=row_n[13]}
N 4580 -7690 4580 -7670 {
lab=row_n[13]}
N 4460 -7590 4470 -7600 {
lab=col_n[25]}
N 4470 -7600 4670 -7600 {
lab=col_n[25]}
N 4670 -7600 4680 -7590 {
lab=col_n[25]}
N 4460 -7570 4470 -7580 {
lab=colon_n[25]}
N 4470 -7580 4670 -7580 {
lab=colon_n[25]}
N 4670 -7580 4680 -7570 {
lab=colon_n[25]}
N 4460 -7550 4470 -7560 {
lab=#net51}
N 4470 -7560 4670 -7560 {
lab=#net51}
N 4670 -7560 4680 -7550 {
lab=#net51}
N 4460 -7530 4470 -7540 {
lab=#net52}
N 4470 -7540 4670 -7540 {
lab=#net52}
N 4670 -7540 4680 -7530 {
lab=#net52}
N 4520 -7690 4520 -7670 {
lab=vcom}
N 4560 -7690 4560 -7670 {
lab=ctop}
N 4440 -7590 4460 -7590 {
lab=col_n[25]}
N 4440 -7570 4460 -7570 {
lab=colon_n[25]}
N 4440 -7550 4460 -7550 {
lab=#net51}
N 4440 -7530 4460 -7530 {
lab=#net52}
N 4680 -7530 4700 -7530 {
lab=#net52}
N 4680 -7550 4700 -7550 {
lab=#net51}
N 4680 -7570 4700 -7570 {
lab=colon_n[25]}
N 4680 -7590 4700 -7590 {
lab=col_n[25]}
N 4500 -7450 4500 -7440 {
lab=VSS}
N 4500 -7680 4500 -7670 {
lab=VDD}
N 4840 -7450 4850 -7460 {
lab=row_n[14]}
N 4850 -7660 4850 -7460 {
lab=row_n[14]}
N 4840 -7670 4850 -7660 {
lab=row_n[14]}
N 4840 -7450 4840 -7430 {
lab=row_n[14]}
N 4840 -7690 4840 -7670 {
lab=row_n[14]}
N 4720 -7590 4730 -7600 {
lab=col_n[25]}
N 4730 -7600 4930 -7600 {
lab=col_n[25]}
N 4930 -7600 4940 -7590 {
lab=col_n[25]}
N 4720 -7570 4730 -7580 {
lab=colon_n[25]}
N 4730 -7580 4930 -7580 {
lab=colon_n[25]}
N 4930 -7580 4940 -7570 {
lab=colon_n[25]}
N 4720 -7550 4730 -7560 {
lab=#net51}
N 4730 -7560 4930 -7560 {
lab=#net51}
N 4930 -7560 4940 -7550 {
lab=#net51}
N 4720 -7530 4730 -7540 {
lab=#net52}
N 4730 -7540 4930 -7540 {
lab=#net52}
N 4930 -7540 4940 -7530 {
lab=#net52}
N 4780 -7690 4780 -7670 {
lab=vcom}
N 4820 -7690 4820 -7670 {
lab=ctop}
N 4700 -7590 4720 -7590 {
lab=col_n[25]}
N 4700 -7570 4720 -7570 {
lab=colon_n[25]}
N 4700 -7550 4720 -7550 {
lab=#net51}
N 4700 -7530 4720 -7530 {
lab=#net52}
N 4940 -7530 4960 -7530 {
lab=#net52}
N 4940 -7550 4960 -7550 {
lab=#net51}
N 4940 -7570 4960 -7570 {
lab=colon_n[25]}
N 4940 -7590 4960 -7590 {
lab=col_n[25]}
N 4760 -7450 4760 -7440 {
lab=VSS}
N 4760 -7680 4760 -7670 {
lab=VDD}
N 5100 -7450 5110 -7460 {
lab=row_n[15]}
N 5110 -7660 5110 -7460 {
lab=row_n[15]}
N 5100 -7670 5110 -7660 {
lab=row_n[15]}
N 5100 -7450 5100 -7430 {
lab=row_n[15]}
N 5100 -7690 5100 -7670 {
lab=row_n[15]}
N 4980 -7590 4990 -7600 {
lab=col_n[25]}
N 4990 -7600 5190 -7600 {
lab=col_n[25]}
N 5190 -7600 5200 -7590 {
lab=col_n[25]}
N 4980 -7570 4990 -7580 {
lab=colon_n[25]}
N 4990 -7580 5190 -7580 {
lab=colon_n[25]}
N 5190 -7580 5200 -7570 {
lab=colon_n[25]}
N 4980 -7550 4990 -7560 {
lab=#net51}
N 4990 -7560 5190 -7560 {
lab=#net51}
N 5190 -7560 5200 -7550 {
lab=#net51}
N 4980 -7530 4990 -7540 {
lab=#net52}
N 4990 -7540 5190 -7540 {
lab=#net52}
N 5190 -7540 5200 -7530 {
lab=#net52}
N 5040 -7690 5040 -7670 {
lab=vcom}
N 5080 -7690 5080 -7670 {
lab=ctop}
N 4960 -7590 4980 -7590 {
lab=col_n[25]}
N 4960 -7570 4980 -7570 {
lab=colon_n[25]}
N 4960 -7550 4980 -7550 {
lab=#net51}
N 4960 -7530 4980 -7530 {
lab=#net52}
N 5200 -7530 5220 -7530 {
lab=#net52}
N 5200 -7550 5220 -7550 {
lab=#net51}
N 5200 -7570 5220 -7570 {
lab=colon_n[25]}
N 5200 -7590 5220 -7590 {
lab=col_n[25]}
N 5020 -7450 5020 -7440 {
lab=VSS}
N 5020 -7680 5020 -7670 {
lab=VDD}
N 5360 -7450 5370 -7460 {
lab=row_n[16]}
N 5370 -7660 5370 -7460 {
lab=row_n[16]}
N 5360 -7670 5370 -7660 {
lab=row_n[16]}
N 5360 -7450 5360 -7430 {
lab=row_n[16]}
N 5360 -7690 5360 -7670 {
lab=row_n[16]}
N 5240 -7590 5250 -7600 {
lab=col_n[25]}
N 5250 -7600 5450 -7600 {
lab=col_n[25]}
N 5450 -7600 5460 -7590 {
lab=col_n[25]}
N 5240 -7570 5250 -7580 {
lab=colon_n[25]}
N 5250 -7580 5450 -7580 {
lab=colon_n[25]}
N 5450 -7580 5460 -7570 {
lab=colon_n[25]}
N 5240 -7550 5250 -7560 {
lab=#net51}
N 5250 -7560 5450 -7560 {
lab=#net51}
N 5450 -7560 5460 -7550 {
lab=#net51}
N 5240 -7530 5250 -7540 {
lab=#net52}
N 5250 -7540 5450 -7540 {
lab=#net52}
N 5450 -7540 5460 -7530 {
lab=#net52}
N 5300 -7690 5300 -7670 {
lab=vcom}
N 5340 -7690 5340 -7670 {
lab=ctop}
N 5220 -7590 5240 -7590 {
lab=col_n[25]}
N 5220 -7570 5240 -7570 {
lab=colon_n[25]}
N 5220 -7550 5240 -7550 {
lab=#net51}
N 5220 -7530 5240 -7530 {
lab=#net52}
N 5460 -7530 5480 -7530 {
lab=#net52}
N 5460 -7550 5480 -7550 {
lab=#net51}
N 5460 -7570 5480 -7570 {
lab=colon_n[25]}
N 5460 -7590 5480 -7590 {
lab=col_n[25]}
N 5280 -7450 5280 -7440 {
lab=VSS}
N 5280 -7680 5280 -7670 {
lab=VDD}
N 5620 -7450 5630 -7460 {
lab=row_n[17]}
N 5630 -7660 5630 -7460 {
lab=row_n[17]}
N 5620 -7670 5630 -7660 {
lab=row_n[17]}
N 5620 -7450 5620 -7430 {
lab=row_n[17]}
N 5620 -7690 5620 -7670 {
lab=row_n[17]}
N 5500 -7590 5510 -7600 {
lab=col_n[25]}
N 5510 -7600 5710 -7600 {
lab=col_n[25]}
N 5710 -7600 5720 -7590 {
lab=col_n[25]}
N 5500 -7570 5510 -7580 {
lab=colon_n[25]}
N 5510 -7580 5710 -7580 {
lab=colon_n[25]}
N 5710 -7580 5720 -7570 {
lab=colon_n[25]}
N 5500 -7550 5510 -7560 {
lab=#net51}
N 5510 -7560 5710 -7560 {
lab=#net51}
N 5710 -7560 5720 -7550 {
lab=#net51}
N 5500 -7530 5510 -7540 {
lab=#net52}
N 5510 -7540 5710 -7540 {
lab=#net52}
N 5710 -7540 5720 -7530 {
lab=#net52}
N 5560 -7690 5560 -7670 {
lab=vcom}
N 5600 -7690 5600 -7670 {
lab=ctop}
N 5480 -7590 5500 -7590 {
lab=col_n[25]}
N 5480 -7570 5500 -7570 {
lab=colon_n[25]}
N 5480 -7550 5500 -7550 {
lab=#net51}
N 5480 -7530 5500 -7530 {
lab=#net52}
N 5720 -7530 5740 -7530 {
lab=#net52}
N 5720 -7550 5740 -7550 {
lab=#net51}
N 5720 -7570 5740 -7570 {
lab=colon_n[25]}
N 5720 -7590 5740 -7590 {
lab=col_n[25]}
N 5540 -7450 5540 -7440 {
lab=VSS}
N 5540 -7680 5540 -7670 {
lab=VDD}
N 5880 -7450 5890 -7460 {
lab=row_n[18]}
N 5890 -7660 5890 -7460 {
lab=row_n[18]}
N 5880 -7670 5890 -7660 {
lab=row_n[18]}
N 5880 -7450 5880 -7430 {
lab=row_n[18]}
N 5880 -7690 5880 -7670 {
lab=row_n[18]}
N 5760 -7590 5770 -7600 {
lab=col_n[25]}
N 5770 -7600 5970 -7600 {
lab=col_n[25]}
N 5970 -7600 5980 -7590 {
lab=col_n[25]}
N 5760 -7570 5770 -7580 {
lab=colon_n[25]}
N 5770 -7580 5970 -7580 {
lab=colon_n[25]}
N 5970 -7580 5980 -7570 {
lab=colon_n[25]}
N 5760 -7550 5770 -7560 {
lab=#net51}
N 5770 -7560 5970 -7560 {
lab=#net51}
N 5970 -7560 5980 -7550 {
lab=#net51}
N 5760 -7530 5770 -7540 {
lab=#net52}
N 5770 -7540 5970 -7540 {
lab=#net52}
N 5970 -7540 5980 -7530 {
lab=#net52}
N 5820 -7690 5820 -7670 {
lab=vcom}
N 5860 -7690 5860 -7670 {
lab=ctop}
N 5740 -7590 5760 -7590 {
lab=col_n[25]}
N 5740 -7570 5760 -7570 {
lab=colon_n[25]}
N 5740 -7550 5760 -7550 {
lab=#net51}
N 5740 -7530 5760 -7530 {
lab=#net52}
N 5980 -7530 6000 -7530 {
lab=#net52}
N 5980 -7550 6000 -7550 {
lab=#net51}
N 5980 -7570 6000 -7570 {
lab=colon_n[25]}
N 5980 -7590 6000 -7590 {
lab=col_n[25]}
N 5800 -7450 5800 -7440 {
lab=VSS}
N 5800 -7680 5800 -7670 {
lab=VDD}
N 6140 -7450 6150 -7460 {
lab=row_n[19]}
N 6150 -7660 6150 -7460 {
lab=row_n[19]}
N 6140 -7670 6150 -7660 {
lab=row_n[19]}
N 6140 -7450 6140 -7430 {
lab=row_n[19]}
N 6140 -7690 6140 -7670 {
lab=row_n[19]}
N 6020 -7590 6030 -7600 {
lab=col_n[25]}
N 6030 -7600 6230 -7600 {
lab=col_n[25]}
N 6230 -7600 6240 -7590 {
lab=col_n[25]}
N 6020 -7570 6030 -7580 {
lab=colon_n[25]}
N 6030 -7580 6230 -7580 {
lab=colon_n[25]}
N 6230 -7580 6240 -7570 {
lab=colon_n[25]}
N 6020 -7550 6030 -7560 {
lab=#net51}
N 6030 -7560 6230 -7560 {
lab=#net51}
N 6230 -7560 6240 -7550 {
lab=#net51}
N 6020 -7530 6030 -7540 {
lab=#net52}
N 6030 -7540 6230 -7540 {
lab=#net52}
N 6230 -7540 6240 -7530 {
lab=#net52}
N 6080 -7690 6080 -7670 {
lab=vcom}
N 6120 -7690 6120 -7670 {
lab=ctop}
N 6000 -7590 6020 -7590 {
lab=col_n[25]}
N 6000 -7570 6020 -7570 {
lab=colon_n[25]}
N 6000 -7550 6020 -7550 {
lab=#net51}
N 6000 -7530 6020 -7530 {
lab=#net52}
N 6240 -7530 6260 -7530 {
lab=#net52}
N 6240 -7550 6260 -7550 {
lab=#net51}
N 6240 -7570 6260 -7570 {
lab=colon_n[25]}
N 6240 -7590 6260 -7590 {
lab=col_n[25]}
N 6060 -7450 6060 -7440 {
lab=VSS}
N 6060 -7680 6060 -7670 {
lab=VDD}
N 6400 -7450 6410 -7460 {
lab=row_n[20]}
N 6410 -7660 6410 -7460 {
lab=row_n[20]}
N 6400 -7670 6410 -7660 {
lab=row_n[20]}
N 6400 -7450 6400 -7430 {
lab=row_n[20]}
N 6400 -7690 6400 -7670 {
lab=row_n[20]}
N 6280 -7590 6290 -7600 {
lab=col_n[25]}
N 6290 -7600 6490 -7600 {
lab=col_n[25]}
N 6490 -7600 6500 -7590 {
lab=col_n[25]}
N 6280 -7570 6290 -7580 {
lab=colon_n[25]}
N 6290 -7580 6490 -7580 {
lab=colon_n[25]}
N 6490 -7580 6500 -7570 {
lab=colon_n[25]}
N 6280 -7550 6290 -7560 {
lab=#net51}
N 6290 -7560 6490 -7560 {
lab=#net51}
N 6490 -7560 6500 -7550 {
lab=#net51}
N 6280 -7530 6290 -7540 {
lab=#net52}
N 6290 -7540 6490 -7540 {
lab=#net52}
N 6490 -7540 6500 -7530 {
lab=#net52}
N 6340 -7690 6340 -7670 {
lab=vcom}
N 6380 -7690 6380 -7670 {
lab=ctop}
N 6260 -7590 6280 -7590 {
lab=col_n[25]}
N 6260 -7570 6280 -7570 {
lab=colon_n[25]}
N 6260 -7550 6280 -7550 {
lab=#net51}
N 6260 -7530 6280 -7530 {
lab=#net52}
N 6500 -7530 6520 -7530 {
lab=#net52}
N 6500 -7550 6520 -7550 {
lab=#net51}
N 6500 -7570 6520 -7570 {
lab=colon_n[25]}
N 6500 -7590 6520 -7590 {
lab=col_n[25]}
N 6320 -7450 6320 -7440 {
lab=VSS}
N 6320 -7680 6320 -7670 {
lab=VDD}
N 6660 -7450 6670 -7460 {
lab=row_n[21]}
N 6670 -7660 6670 -7460 {
lab=row_n[21]}
N 6660 -7670 6670 -7660 {
lab=row_n[21]}
N 6660 -7450 6660 -7430 {
lab=row_n[21]}
N 6660 -7690 6660 -7670 {
lab=row_n[21]}
N 6540 -7590 6550 -7600 {
lab=col_n[25]}
N 6550 -7600 6750 -7600 {
lab=col_n[25]}
N 6750 -7600 6760 -7590 {
lab=col_n[25]}
N 6540 -7570 6550 -7580 {
lab=colon_n[25]}
N 6550 -7580 6750 -7580 {
lab=colon_n[25]}
N 6750 -7580 6760 -7570 {
lab=colon_n[25]}
N 6540 -7550 6550 -7560 {
lab=#net51}
N 6550 -7560 6750 -7560 {
lab=#net51}
N 6750 -7560 6760 -7550 {
lab=#net51}
N 6540 -7530 6550 -7540 {
lab=#net52}
N 6550 -7540 6750 -7540 {
lab=#net52}
N 6750 -7540 6760 -7530 {
lab=#net52}
N 6600 -7690 6600 -7670 {
lab=vcom}
N 6640 -7690 6640 -7670 {
lab=ctop}
N 6520 -7590 6540 -7590 {
lab=col_n[25]}
N 6520 -7570 6540 -7570 {
lab=colon_n[25]}
N 6520 -7550 6540 -7550 {
lab=#net51}
N 6520 -7530 6540 -7530 {
lab=#net52}
N 6760 -7530 6780 -7530 {
lab=#net52}
N 6760 -7550 6780 -7550 {
lab=#net51}
N 6760 -7570 6780 -7570 {
lab=colon_n[25]}
N 6760 -7590 6780 -7590 {
lab=col_n[25]}
N 6580 -7450 6580 -7440 {
lab=VSS}
N 6580 -7680 6580 -7670 {
lab=VDD}
N 6920 -7450 6930 -7460 {
lab=row_n[22]}
N 6930 -7660 6930 -7460 {
lab=row_n[22]}
N 6920 -7670 6930 -7660 {
lab=row_n[22]}
N 6920 -7450 6920 -7430 {
lab=row_n[22]}
N 6920 -7690 6920 -7670 {
lab=row_n[22]}
N 6800 -7590 6810 -7600 {
lab=col_n[25]}
N 6810 -7600 7010 -7600 {
lab=col_n[25]}
N 7010 -7600 7020 -7590 {
lab=col_n[25]}
N 6800 -7570 6810 -7580 {
lab=colon_n[25]}
N 6810 -7580 7010 -7580 {
lab=colon_n[25]}
N 7010 -7580 7020 -7570 {
lab=colon_n[25]}
N 6800 -7550 6810 -7560 {
lab=#net51}
N 6810 -7560 7010 -7560 {
lab=#net51}
N 7010 -7560 7020 -7550 {
lab=#net51}
N 6800 -7530 6810 -7540 {
lab=#net52}
N 6810 -7540 7010 -7540 {
lab=#net52}
N 7010 -7540 7020 -7530 {
lab=#net52}
N 6860 -7690 6860 -7670 {
lab=vcom}
N 6900 -7690 6900 -7670 {
lab=ctop}
N 6780 -7590 6800 -7590 {
lab=col_n[25]}
N 6780 -7570 6800 -7570 {
lab=colon_n[25]}
N 6780 -7550 6800 -7550 {
lab=#net51}
N 6780 -7530 6800 -7530 {
lab=#net52}
N 7020 -7530 7040 -7530 {
lab=#net52}
N 7020 -7550 7040 -7550 {
lab=#net51}
N 7020 -7570 7040 -7570 {
lab=colon_n[25]}
N 7020 -7590 7040 -7590 {
lab=col_n[25]}
N 6840 -7450 6840 -7440 {
lab=VSS}
N 6840 -7680 6840 -7670 {
lab=VDD}
N 7180 -7450 7190 -7460 {
lab=row_n[23]}
N 7190 -7660 7190 -7460 {
lab=row_n[23]}
N 7180 -7670 7190 -7660 {
lab=row_n[23]}
N 7180 -7450 7180 -7430 {
lab=row_n[23]}
N 7180 -7690 7180 -7670 {
lab=row_n[23]}
N 7060 -7590 7070 -7600 {
lab=col_n[25]}
N 7070 -7600 7270 -7600 {
lab=col_n[25]}
N 7270 -7600 7280 -7590 {
lab=col_n[25]}
N 7060 -7570 7070 -7580 {
lab=colon_n[25]}
N 7070 -7580 7270 -7580 {
lab=colon_n[25]}
N 7270 -7580 7280 -7570 {
lab=colon_n[25]}
N 7060 -7550 7070 -7560 {
lab=#net51}
N 7070 -7560 7270 -7560 {
lab=#net51}
N 7270 -7560 7280 -7550 {
lab=#net51}
N 7060 -7530 7070 -7540 {
lab=#net52}
N 7070 -7540 7270 -7540 {
lab=#net52}
N 7270 -7540 7280 -7530 {
lab=#net52}
N 7120 -7690 7120 -7670 {
lab=vcom}
N 7160 -7690 7160 -7670 {
lab=ctop}
N 7040 -7590 7060 -7590 {
lab=col_n[25]}
N 7040 -7570 7060 -7570 {
lab=colon_n[25]}
N 7040 -7550 7060 -7550 {
lab=#net51}
N 7040 -7530 7060 -7530 {
lab=#net52}
N 7280 -7530 7300 -7530 {
lab=#net52}
N 7280 -7550 7300 -7550 {
lab=#net51}
N 7280 -7570 7300 -7570 {
lab=colon_n[25]}
N 7280 -7590 7300 -7590 {
lab=col_n[25]}
N 7100 -7450 7100 -7440 {
lab=VSS}
N 7100 -7680 7100 -7670 {
lab=VDD}
N 7440 -7450 7450 -7460 {
lab=row_n[24]}
N 7450 -7660 7450 -7460 {
lab=row_n[24]}
N 7440 -7670 7450 -7660 {
lab=row_n[24]}
N 7440 -7450 7440 -7430 {
lab=row_n[24]}
N 7440 -7690 7440 -7670 {
lab=row_n[24]}
N 7320 -7590 7330 -7600 {
lab=col_n[25]}
N 7330 -7600 7530 -7600 {
lab=col_n[25]}
N 7530 -7600 7540 -7590 {
lab=col_n[25]}
N 7320 -7570 7330 -7580 {
lab=colon_n[25]}
N 7330 -7580 7530 -7580 {
lab=colon_n[25]}
N 7530 -7580 7540 -7570 {
lab=colon_n[25]}
N 7320 -7550 7330 -7560 {
lab=#net51}
N 7330 -7560 7530 -7560 {
lab=#net51}
N 7530 -7560 7540 -7550 {
lab=#net51}
N 7320 -7530 7330 -7540 {
lab=#net52}
N 7330 -7540 7530 -7540 {
lab=#net52}
N 7530 -7540 7540 -7530 {
lab=#net52}
N 7380 -7690 7380 -7670 {
lab=vcom}
N 7420 -7690 7420 -7670 {
lab=ctop}
N 7300 -7590 7320 -7590 {
lab=col_n[25]}
N 7300 -7570 7320 -7570 {
lab=colon_n[25]}
N 7300 -7550 7320 -7550 {
lab=#net51}
N 7300 -7530 7320 -7530 {
lab=#net52}
N 7540 -7530 7560 -7530 {
lab=#net52}
N 7540 -7550 7560 -7550 {
lab=#net51}
N 7540 -7570 7560 -7570 {
lab=colon_n[25]}
N 7540 -7590 7560 -7590 {
lab=col_n[25]}
N 7360 -7450 7360 -7440 {
lab=VSS}
N 7360 -7680 7360 -7670 {
lab=VDD}
N 7700 -7450 7710 -7460 {
lab=row_n[25]}
N 7710 -7660 7710 -7460 {
lab=row_n[25]}
N 7700 -7670 7710 -7660 {
lab=row_n[25]}
N 7700 -7450 7700 -7430 {
lab=row_n[25]}
N 7700 -7690 7700 -7670 {
lab=row_n[25]}
N 7580 -7590 7590 -7600 {
lab=col_n[25]}
N 7590 -7600 7790 -7600 {
lab=col_n[25]}
N 7790 -7600 7800 -7590 {
lab=col_n[25]}
N 7580 -7570 7590 -7580 {
lab=colon_n[25]}
N 7590 -7580 7790 -7580 {
lab=colon_n[25]}
N 7790 -7580 7800 -7570 {
lab=colon_n[25]}
N 7580 -7550 7590 -7560 {
lab=#net51}
N 7590 -7560 7790 -7560 {
lab=#net51}
N 7790 -7560 7800 -7550 {
lab=#net51}
N 7580 -7530 7590 -7540 {
lab=#net52}
N 7590 -7540 7790 -7540 {
lab=#net52}
N 7790 -7540 7800 -7530 {
lab=#net52}
N 7640 -7690 7640 -7670 {
lab=vcom}
N 7680 -7690 7680 -7670 {
lab=ctop}
N 7560 -7590 7580 -7590 {
lab=col_n[25]}
N 7560 -7570 7580 -7570 {
lab=colon_n[25]}
N 7560 -7550 7580 -7550 {
lab=#net51}
N 7560 -7530 7580 -7530 {
lab=#net52}
N 7800 -7530 7820 -7530 {
lab=#net52}
N 7800 -7550 7820 -7550 {
lab=#net51}
N 7800 -7570 7820 -7570 {
lab=colon_n[25]}
N 7800 -7590 7820 -7590 {
lab=col_n[25]}
N 7620 -7450 7620 -7440 {
lab=VSS}
N 7620 -7680 7620 -7670 {
lab=VDD}
N 7960 -7450 7970 -7460 {
lab=row_n[26]}
N 7970 -7660 7970 -7460 {
lab=row_n[26]}
N 7960 -7670 7970 -7660 {
lab=row_n[26]}
N 7960 -7450 7960 -7430 {
lab=row_n[26]}
N 7960 -7690 7960 -7670 {
lab=row_n[26]}
N 7840 -7590 7850 -7600 {
lab=col_n[25]}
N 7850 -7600 8050 -7600 {
lab=col_n[25]}
N 8050 -7600 8060 -7590 {
lab=col_n[25]}
N 7840 -7570 7850 -7580 {
lab=colon_n[25]}
N 7850 -7580 8050 -7580 {
lab=colon_n[25]}
N 8050 -7580 8060 -7570 {
lab=colon_n[25]}
N 7840 -7550 7850 -7560 {
lab=#net51}
N 7850 -7560 8050 -7560 {
lab=#net51}
N 8050 -7560 8060 -7550 {
lab=#net51}
N 7840 -7530 7850 -7540 {
lab=#net52}
N 7850 -7540 8050 -7540 {
lab=#net52}
N 8050 -7540 8060 -7530 {
lab=#net52}
N 7900 -7690 7900 -7670 {
lab=vcom}
N 7940 -7690 7940 -7670 {
lab=ctop}
N 7820 -7590 7840 -7590 {
lab=col_n[25]}
N 7820 -7570 7840 -7570 {
lab=colon_n[25]}
N 7820 -7550 7840 -7550 {
lab=#net51}
N 7820 -7530 7840 -7530 {
lab=#net52}
N 8060 -7530 8080 -7530 {
lab=#net52}
N 8060 -7550 8080 -7550 {
lab=#net51}
N 8060 -7570 8080 -7570 {
lab=colon_n[25]}
N 8060 -7590 8080 -7590 {
lab=col_n[25]}
N 7880 -7450 7880 -7440 {
lab=VSS}
N 7880 -7680 7880 -7670 {
lab=VDD}
N 8220 -7450 8230 -7460 {
lab=row_n[27]}
N 8230 -7660 8230 -7460 {
lab=row_n[27]}
N 8220 -7670 8230 -7660 {
lab=row_n[27]}
N 8220 -7450 8220 -7430 {
lab=row_n[27]}
N 8220 -7690 8220 -7670 {
lab=row_n[27]}
N 8100 -7590 8110 -7600 {
lab=col_n[25]}
N 8110 -7600 8310 -7600 {
lab=col_n[25]}
N 8310 -7600 8320 -7590 {
lab=col_n[25]}
N 8100 -7570 8110 -7580 {
lab=colon_n[25]}
N 8110 -7580 8310 -7580 {
lab=colon_n[25]}
N 8310 -7580 8320 -7570 {
lab=colon_n[25]}
N 8100 -7550 8110 -7560 {
lab=#net51}
N 8110 -7560 8310 -7560 {
lab=#net51}
N 8310 -7560 8320 -7550 {
lab=#net51}
N 8100 -7530 8110 -7540 {
lab=#net52}
N 8110 -7540 8310 -7540 {
lab=#net52}
N 8310 -7540 8320 -7530 {
lab=#net52}
N 8160 -7690 8160 -7670 {
lab=vcom}
N 8200 -7690 8200 -7670 {
lab=ctop}
N 8080 -7590 8100 -7590 {
lab=col_n[25]}
N 8080 -7570 8100 -7570 {
lab=colon_n[25]}
N 8080 -7550 8100 -7550 {
lab=#net51}
N 8080 -7530 8100 -7530 {
lab=#net52}
N 8320 -7530 8340 -7530 {
lab=#net52}
N 8320 -7550 8340 -7550 {
lab=#net51}
N 8320 -7570 8340 -7570 {
lab=colon_n[25]}
N 8320 -7590 8340 -7590 {
lab=col_n[25]}
N 8140 -7450 8140 -7440 {
lab=VSS}
N 8140 -7680 8140 -7670 {
lab=VDD}
N 8480 -7450 8490 -7460 {
lab=row_n[28]}
N 8490 -7660 8490 -7460 {
lab=row_n[28]}
N 8480 -7670 8490 -7660 {
lab=row_n[28]}
N 8480 -7450 8480 -7430 {
lab=row_n[28]}
N 8480 -7690 8480 -7670 {
lab=row_n[28]}
N 8360 -7590 8370 -7600 {
lab=col_n[25]}
N 8370 -7600 8570 -7600 {
lab=col_n[25]}
N 8570 -7600 8580 -7590 {
lab=col_n[25]}
N 8360 -7570 8370 -7580 {
lab=colon_n[25]}
N 8370 -7580 8570 -7580 {
lab=colon_n[25]}
N 8570 -7580 8580 -7570 {
lab=colon_n[25]}
N 8360 -7550 8370 -7560 {
lab=#net51}
N 8370 -7560 8570 -7560 {
lab=#net51}
N 8570 -7560 8580 -7550 {
lab=#net51}
N 8360 -7530 8370 -7540 {
lab=#net52}
N 8370 -7540 8570 -7540 {
lab=#net52}
N 8570 -7540 8580 -7530 {
lab=#net52}
N 8420 -7690 8420 -7670 {
lab=vcom}
N 8460 -7690 8460 -7670 {
lab=ctop}
N 8340 -7590 8360 -7590 {
lab=col_n[25]}
N 8340 -7570 8360 -7570 {
lab=colon_n[25]}
N 8340 -7550 8360 -7550 {
lab=#net51}
N 8340 -7530 8360 -7530 {
lab=#net52}
N 8580 -7530 8600 -7530 {
lab=#net52}
N 8580 -7550 8600 -7550 {
lab=#net51}
N 8580 -7570 8600 -7570 {
lab=colon_n[25]}
N 8580 -7590 8600 -7590 {
lab=col_n[25]}
N 8400 -7450 8400 -7440 {
lab=VSS}
N 8400 -7680 8400 -7670 {
lab=VDD}
N 8740 -7450 8750 -7460 {
lab=row_n[29]}
N 8750 -7660 8750 -7460 {
lab=row_n[29]}
N 8740 -7670 8750 -7660 {
lab=row_n[29]}
N 8740 -7450 8740 -7430 {
lab=row_n[29]}
N 8740 -7690 8740 -7670 {
lab=row_n[29]}
N 8620 -7590 8630 -7600 {
lab=col_n[25]}
N 8630 -7600 8830 -7600 {
lab=col_n[25]}
N 8830 -7600 8840 -7590 {
lab=col_n[25]}
N 8620 -7570 8630 -7580 {
lab=colon_n[25]}
N 8630 -7580 8830 -7580 {
lab=colon_n[25]}
N 8830 -7580 8840 -7570 {
lab=colon_n[25]}
N 8620 -7550 8630 -7560 {
lab=#net51}
N 8630 -7560 8830 -7560 {
lab=#net51}
N 8830 -7560 8840 -7550 {
lab=#net51}
N 8620 -7530 8630 -7540 {
lab=#net52}
N 8630 -7540 8830 -7540 {
lab=#net52}
N 8830 -7540 8840 -7530 {
lab=#net52}
N 8680 -7690 8680 -7670 {
lab=vcom}
N 8720 -7690 8720 -7670 {
lab=ctop}
N 8600 -7590 8620 -7590 {
lab=col_n[25]}
N 8600 -7570 8620 -7570 {
lab=colon_n[25]}
N 8600 -7550 8620 -7550 {
lab=#net51}
N 8600 -7530 8620 -7530 {
lab=#net52}
N 8840 -7530 8860 -7530 {
lab=#net52}
N 8840 -7550 8860 -7550 {
lab=#net51}
N 8840 -7570 8860 -7570 {
lab=colon_n[25]}
N 8840 -7590 8860 -7590 {
lab=col_n[25]}
N 8660 -7450 8660 -7440 {
lab=VSS}
N 8660 -7680 8660 -7670 {
lab=VDD}
N 9000 -7450 9010 -7460 {
lab=row_n[30]}
N 9010 -7660 9010 -7460 {
lab=row_n[30]}
N 9000 -7670 9010 -7660 {
lab=row_n[30]}
N 9000 -7450 9000 -7430 {
lab=row_n[30]}
N 9000 -7690 9000 -7670 {
lab=row_n[30]}
N 8880 -7590 8890 -7600 {
lab=col_n[25]}
N 8890 -7600 9090 -7600 {
lab=col_n[25]}
N 9090 -7600 9100 -7590 {
lab=col_n[25]}
N 8880 -7570 8890 -7580 {
lab=colon_n[25]}
N 8890 -7580 9090 -7580 {
lab=colon_n[25]}
N 9090 -7580 9100 -7570 {
lab=colon_n[25]}
N 8880 -7550 8890 -7560 {
lab=#net51}
N 8890 -7560 9090 -7560 {
lab=#net51}
N 9090 -7560 9100 -7550 {
lab=#net51}
N 8880 -7530 8890 -7540 {
lab=#net52}
N 8890 -7540 9090 -7540 {
lab=#net52}
N 9090 -7540 9100 -7530 {
lab=#net52}
N 8940 -7690 8940 -7670 {
lab=vcom}
N 8980 -7690 8980 -7670 {
lab=ctop}
N 8860 -7590 8880 -7590 {
lab=col_n[25]}
N 8860 -7570 8880 -7570 {
lab=colon_n[25]}
N 8860 -7550 8880 -7550 {
lab=#net51}
N 8860 -7530 8880 -7530 {
lab=#net52}
N 9100 -7530 9120 -7530 {
lab=#net52}
N 9100 -7550 9120 -7550 {
lab=#net51}
N 9100 -7570 9120 -7570 {
lab=colon_n[25]}
N 9100 -7590 9120 -7590 {
lab=col_n[25]}
N 8920 -7450 8920 -7440 {
lab=VSS}
N 8920 -7680 8920 -7670 {
lab=VDD}
N 9260 -7450 9270 -7460 {
lab=row_n[31]}
N 9270 -7660 9270 -7460 {
lab=row_n[31]}
N 9260 -7670 9270 -7660 {
lab=row_n[31]}
N 9260 -7450 9260 -7430 {
lab=row_n[31]}
N 9260 -7690 9260 -7670 {
lab=row_n[31]}
N 9140 -7590 9150 -7600 {
lab=col_n[25]}
N 9150 -7600 9350 -7600 {
lab=col_n[25]}
N 9350 -7600 9360 -7590 {
lab=col_n[25]}
N 9140 -7570 9150 -7580 {
lab=colon_n[25]}
N 9150 -7580 9350 -7580 {
lab=colon_n[25]}
N 9350 -7580 9360 -7570 {
lab=colon_n[25]}
N 9140 -7550 9150 -7560 {
lab=#net51}
N 9150 -7560 9350 -7560 {
lab=#net51}
N 9350 -7560 9360 -7550 {
lab=#net51}
N 9140 -7530 9150 -7540 {
lab=#net52}
N 9150 -7540 9350 -7540 {
lab=#net52}
N 9350 -7540 9360 -7530 {
lab=#net52}
N 9200 -7690 9200 -7670 {
lab=vcom}
N 9240 -7690 9240 -7670 {
lab=ctop}
N 9120 -7590 9140 -7590 {
lab=col_n[25]}
N 9120 -7570 9140 -7570 {
lab=colon_n[25]}
N 9120 -7550 9140 -7550 {
lab=#net51}
N 9120 -7530 9140 -7530 {
lab=#net52}
N 9360 -7530 9380 -7530 {
lab=#net52}
N 9360 -7550 9380 -7550 {
lab=#net51}
N 9360 -7570 9380 -7570 {
lab=colon_n[25]}
N 9360 -7590 9380 -7590 {
lab=col_n[25]}
N 9180 -7450 9180 -7440 {
lab=VSS}
N 9180 -7680 9180 -7670 {
lab=VDD}
N 1200 -7710 1210 -7720 {
lab=row_n[0]}
N 1210 -7920 1210 -7720 {
lab=row_n[0]}
N 1200 -7930 1210 -7920 {
lab=row_n[0]}
N 1200 -7710 1200 -7690 {
lab=row_n[0]}
N 1200 -7950 1200 -7930 {
lab=row_n[0]}
N 1080 -7850 1090 -7860 {
lab=col_n[26]}
N 1090 -7860 1290 -7860 {
lab=col_n[26]}
N 1290 -7860 1300 -7850 {
lab=col_n[26]}
N 1080 -7830 1090 -7840 {
lab=colon_n[26]}
N 1090 -7840 1290 -7840 {
lab=colon_n[26]}
N 1290 -7840 1300 -7830 {
lab=colon_n[26]}
N 1080 -7810 1090 -7820 {
lab=#net53}
N 1090 -7820 1290 -7820 {
lab=#net53}
N 1290 -7820 1300 -7810 {
lab=#net53}
N 1080 -7790 1090 -7800 {
lab=#net54}
N 1090 -7800 1290 -7800 {
lab=#net54}
N 1290 -7800 1300 -7790 {
lab=#net54}
N 1140 -7950 1140 -7930 {
lab=vcom}
N 1180 -7950 1180 -7930 {
lab=ctop}
N 1060 -7850 1080 -7850 {
lab=col_n[26]}
N 1060 -7830 1080 -7830 {
lab=colon_n[26]}
N 1060 -7810 1080 -7810 {
lab=#net53}
N 1060 -7790 1080 -7790 {
lab=#net54}
N 1300 -7790 1320 -7790 {
lab=#net54}
N 1300 -7810 1320 -7810 {
lab=#net53}
N 1300 -7830 1320 -7830 {
lab=colon_n[26]}
N 1300 -7850 1320 -7850 {
lab=col_n[26]}
N 1120 -7710 1120 -7700 {
lab=VSS}
N 1120 -7940 1120 -7930 {
lab=VDD}
N 1460 -7710 1470 -7720 {
lab=row_n[1]}
N 1470 -7920 1470 -7720 {
lab=row_n[1]}
N 1460 -7930 1470 -7920 {
lab=row_n[1]}
N 1460 -7710 1460 -7690 {
lab=row_n[1]}
N 1460 -7950 1460 -7930 {
lab=row_n[1]}
N 1340 -7850 1350 -7860 {
lab=col_n[26]}
N 1350 -7860 1550 -7860 {
lab=col_n[26]}
N 1550 -7860 1560 -7850 {
lab=col_n[26]}
N 1340 -7830 1350 -7840 {
lab=colon_n[26]}
N 1350 -7840 1550 -7840 {
lab=colon_n[26]}
N 1550 -7840 1560 -7830 {
lab=colon_n[26]}
N 1340 -7810 1350 -7820 {
lab=#net53}
N 1350 -7820 1550 -7820 {
lab=#net53}
N 1550 -7820 1560 -7810 {
lab=#net53}
N 1340 -7790 1350 -7800 {
lab=#net54}
N 1350 -7800 1550 -7800 {
lab=#net54}
N 1550 -7800 1560 -7790 {
lab=#net54}
N 1400 -7950 1400 -7930 {
lab=vcom}
N 1440 -7950 1440 -7930 {
lab=ctop}
N 1320 -7850 1340 -7850 {
lab=col_n[26]}
N 1320 -7830 1340 -7830 {
lab=colon_n[26]}
N 1320 -7810 1340 -7810 {
lab=#net53}
N 1320 -7790 1340 -7790 {
lab=#net54}
N 1560 -7790 1580 -7790 {
lab=#net54}
N 1560 -7810 1580 -7810 {
lab=#net53}
N 1560 -7830 1580 -7830 {
lab=colon_n[26]}
N 1560 -7850 1580 -7850 {
lab=col_n[26]}
N 1380 -7710 1380 -7700 {
lab=VSS}
N 1380 -7940 1380 -7930 {
lab=VDD}
N 1720 -7710 1730 -7720 {
lab=row_n[2]}
N 1730 -7920 1730 -7720 {
lab=row_n[2]}
N 1720 -7930 1730 -7920 {
lab=row_n[2]}
N 1720 -7710 1720 -7690 {
lab=row_n[2]}
N 1720 -7950 1720 -7930 {
lab=row_n[2]}
N 1600 -7850 1610 -7860 {
lab=col_n[26]}
N 1610 -7860 1810 -7860 {
lab=col_n[26]}
N 1810 -7860 1820 -7850 {
lab=col_n[26]}
N 1600 -7830 1610 -7840 {
lab=colon_n[26]}
N 1610 -7840 1810 -7840 {
lab=colon_n[26]}
N 1810 -7840 1820 -7830 {
lab=colon_n[26]}
N 1600 -7810 1610 -7820 {
lab=#net53}
N 1610 -7820 1810 -7820 {
lab=#net53}
N 1810 -7820 1820 -7810 {
lab=#net53}
N 1600 -7790 1610 -7800 {
lab=#net54}
N 1610 -7800 1810 -7800 {
lab=#net54}
N 1810 -7800 1820 -7790 {
lab=#net54}
N 1660 -7950 1660 -7930 {
lab=vcom}
N 1700 -7950 1700 -7930 {
lab=ctop}
N 1580 -7850 1600 -7850 {
lab=col_n[26]}
N 1580 -7830 1600 -7830 {
lab=colon_n[26]}
N 1580 -7810 1600 -7810 {
lab=#net53}
N 1580 -7790 1600 -7790 {
lab=#net54}
N 1820 -7790 1840 -7790 {
lab=#net54}
N 1820 -7810 1840 -7810 {
lab=#net53}
N 1820 -7830 1840 -7830 {
lab=colon_n[26]}
N 1820 -7850 1840 -7850 {
lab=col_n[26]}
N 1640 -7710 1640 -7700 {
lab=VSS}
N 1640 -7940 1640 -7930 {
lab=VDD}
N 1980 -7710 1990 -7720 {
lab=row_n[3]}
N 1990 -7920 1990 -7720 {
lab=row_n[3]}
N 1980 -7930 1990 -7920 {
lab=row_n[3]}
N 1980 -7710 1980 -7690 {
lab=row_n[3]}
N 1980 -7950 1980 -7930 {
lab=row_n[3]}
N 1860 -7850 1870 -7860 {
lab=col_n[26]}
N 1870 -7860 2070 -7860 {
lab=col_n[26]}
N 2070 -7860 2080 -7850 {
lab=col_n[26]}
N 1860 -7830 1870 -7840 {
lab=colon_n[26]}
N 1870 -7840 2070 -7840 {
lab=colon_n[26]}
N 2070 -7840 2080 -7830 {
lab=colon_n[26]}
N 1860 -7810 1870 -7820 {
lab=#net53}
N 1870 -7820 2070 -7820 {
lab=#net53}
N 2070 -7820 2080 -7810 {
lab=#net53}
N 1860 -7790 1870 -7800 {
lab=#net54}
N 1870 -7800 2070 -7800 {
lab=#net54}
N 2070 -7800 2080 -7790 {
lab=#net54}
N 1920 -7950 1920 -7930 {
lab=vcom}
N 1960 -7950 1960 -7930 {
lab=ctop}
N 1840 -7850 1860 -7850 {
lab=col_n[26]}
N 1840 -7830 1860 -7830 {
lab=colon_n[26]}
N 1840 -7810 1860 -7810 {
lab=#net53}
N 1840 -7790 1860 -7790 {
lab=#net54}
N 2080 -7790 2100 -7790 {
lab=#net54}
N 2080 -7810 2100 -7810 {
lab=#net53}
N 2080 -7830 2100 -7830 {
lab=colon_n[26]}
N 2080 -7850 2100 -7850 {
lab=col_n[26]}
N 1900 -7710 1900 -7700 {
lab=VSS}
N 1900 -7940 1900 -7930 {
lab=VDD}
N 2240 -7710 2250 -7720 {
lab=row_n[4]}
N 2250 -7920 2250 -7720 {
lab=row_n[4]}
N 2240 -7930 2250 -7920 {
lab=row_n[4]}
N 2240 -7710 2240 -7690 {
lab=row_n[4]}
N 2240 -7950 2240 -7930 {
lab=row_n[4]}
N 2120 -7850 2130 -7860 {
lab=col_n[26]}
N 2130 -7860 2330 -7860 {
lab=col_n[26]}
N 2330 -7860 2340 -7850 {
lab=col_n[26]}
N 2120 -7830 2130 -7840 {
lab=colon_n[26]}
N 2130 -7840 2330 -7840 {
lab=colon_n[26]}
N 2330 -7840 2340 -7830 {
lab=colon_n[26]}
N 2120 -7810 2130 -7820 {
lab=#net53}
N 2130 -7820 2330 -7820 {
lab=#net53}
N 2330 -7820 2340 -7810 {
lab=#net53}
N 2120 -7790 2130 -7800 {
lab=#net54}
N 2130 -7800 2330 -7800 {
lab=#net54}
N 2330 -7800 2340 -7790 {
lab=#net54}
N 2180 -7950 2180 -7930 {
lab=vcom}
N 2220 -7950 2220 -7930 {
lab=ctop}
N 2100 -7850 2120 -7850 {
lab=col_n[26]}
N 2100 -7830 2120 -7830 {
lab=colon_n[26]}
N 2100 -7810 2120 -7810 {
lab=#net53}
N 2100 -7790 2120 -7790 {
lab=#net54}
N 2340 -7790 2360 -7790 {
lab=#net54}
N 2340 -7810 2360 -7810 {
lab=#net53}
N 2340 -7830 2360 -7830 {
lab=colon_n[26]}
N 2340 -7850 2360 -7850 {
lab=col_n[26]}
N 2160 -7710 2160 -7700 {
lab=VSS}
N 2160 -7940 2160 -7930 {
lab=VDD}
N 2500 -7710 2510 -7720 {
lab=row_n[5]}
N 2510 -7920 2510 -7720 {
lab=row_n[5]}
N 2500 -7930 2510 -7920 {
lab=row_n[5]}
N 2500 -7710 2500 -7690 {
lab=row_n[5]}
N 2500 -7950 2500 -7930 {
lab=row_n[5]}
N 2380 -7850 2390 -7860 {
lab=col_n[26]}
N 2390 -7860 2590 -7860 {
lab=col_n[26]}
N 2590 -7860 2600 -7850 {
lab=col_n[26]}
N 2380 -7830 2390 -7840 {
lab=colon_n[26]}
N 2390 -7840 2590 -7840 {
lab=colon_n[26]}
N 2590 -7840 2600 -7830 {
lab=colon_n[26]}
N 2380 -7810 2390 -7820 {
lab=#net53}
N 2390 -7820 2590 -7820 {
lab=#net53}
N 2590 -7820 2600 -7810 {
lab=#net53}
N 2380 -7790 2390 -7800 {
lab=#net54}
N 2390 -7800 2590 -7800 {
lab=#net54}
N 2590 -7800 2600 -7790 {
lab=#net54}
N 2440 -7950 2440 -7930 {
lab=vcom}
N 2480 -7950 2480 -7930 {
lab=ctop}
N 2360 -7850 2380 -7850 {
lab=col_n[26]}
N 2360 -7830 2380 -7830 {
lab=colon_n[26]}
N 2360 -7810 2380 -7810 {
lab=#net53}
N 2360 -7790 2380 -7790 {
lab=#net54}
N 2600 -7790 2620 -7790 {
lab=#net54}
N 2600 -7810 2620 -7810 {
lab=#net53}
N 2600 -7830 2620 -7830 {
lab=colon_n[26]}
N 2600 -7850 2620 -7850 {
lab=col_n[26]}
N 2420 -7710 2420 -7700 {
lab=VSS}
N 2420 -7940 2420 -7930 {
lab=VDD}
N 2760 -7710 2770 -7720 {
lab=row_n[6]}
N 2770 -7920 2770 -7720 {
lab=row_n[6]}
N 2760 -7930 2770 -7920 {
lab=row_n[6]}
N 2760 -7710 2760 -7690 {
lab=row_n[6]}
N 2760 -7950 2760 -7930 {
lab=row_n[6]}
N 2640 -7850 2650 -7860 {
lab=col_n[26]}
N 2650 -7860 2850 -7860 {
lab=col_n[26]}
N 2850 -7860 2860 -7850 {
lab=col_n[26]}
N 2640 -7830 2650 -7840 {
lab=colon_n[26]}
N 2650 -7840 2850 -7840 {
lab=colon_n[26]}
N 2850 -7840 2860 -7830 {
lab=colon_n[26]}
N 2640 -7810 2650 -7820 {
lab=#net53}
N 2650 -7820 2850 -7820 {
lab=#net53}
N 2850 -7820 2860 -7810 {
lab=#net53}
N 2640 -7790 2650 -7800 {
lab=#net54}
N 2650 -7800 2850 -7800 {
lab=#net54}
N 2850 -7800 2860 -7790 {
lab=#net54}
N 2700 -7950 2700 -7930 {
lab=vcom}
N 2740 -7950 2740 -7930 {
lab=ctop}
N 2620 -7850 2640 -7850 {
lab=col_n[26]}
N 2620 -7830 2640 -7830 {
lab=colon_n[26]}
N 2620 -7810 2640 -7810 {
lab=#net53}
N 2620 -7790 2640 -7790 {
lab=#net54}
N 2860 -7790 2880 -7790 {
lab=#net54}
N 2860 -7810 2880 -7810 {
lab=#net53}
N 2860 -7830 2880 -7830 {
lab=colon_n[26]}
N 2860 -7850 2880 -7850 {
lab=col_n[26]}
N 2680 -7710 2680 -7700 {
lab=VSS}
N 2680 -7940 2680 -7930 {
lab=VDD}
N 3020 -7710 3030 -7720 {
lab=row_n[7]}
N 3030 -7920 3030 -7720 {
lab=row_n[7]}
N 3020 -7930 3030 -7920 {
lab=row_n[7]}
N 3020 -7710 3020 -7690 {
lab=row_n[7]}
N 3020 -7950 3020 -7930 {
lab=row_n[7]}
N 2900 -7850 2910 -7860 {
lab=col_n[26]}
N 2910 -7860 3110 -7860 {
lab=col_n[26]}
N 3110 -7860 3120 -7850 {
lab=col_n[26]}
N 2900 -7830 2910 -7840 {
lab=colon_n[26]}
N 2910 -7840 3110 -7840 {
lab=colon_n[26]}
N 3110 -7840 3120 -7830 {
lab=colon_n[26]}
N 2900 -7810 2910 -7820 {
lab=#net53}
N 2910 -7820 3110 -7820 {
lab=#net53}
N 3110 -7820 3120 -7810 {
lab=#net53}
N 2900 -7790 2910 -7800 {
lab=#net54}
N 2910 -7800 3110 -7800 {
lab=#net54}
N 3110 -7800 3120 -7790 {
lab=#net54}
N 2960 -7950 2960 -7930 {
lab=vcom}
N 3000 -7950 3000 -7930 {
lab=ctop}
N 2880 -7850 2900 -7850 {
lab=col_n[26]}
N 2880 -7830 2900 -7830 {
lab=colon_n[26]}
N 2880 -7810 2900 -7810 {
lab=#net53}
N 2880 -7790 2900 -7790 {
lab=#net54}
N 3120 -7790 3140 -7790 {
lab=#net54}
N 3120 -7810 3140 -7810 {
lab=#net53}
N 3120 -7830 3140 -7830 {
lab=colon_n[26]}
N 3120 -7850 3140 -7850 {
lab=col_n[26]}
N 2940 -7710 2940 -7700 {
lab=VSS}
N 2940 -7940 2940 -7930 {
lab=VDD}
N 3280 -7710 3290 -7720 {
lab=row_n[8]}
N 3290 -7920 3290 -7720 {
lab=row_n[8]}
N 3280 -7930 3290 -7920 {
lab=row_n[8]}
N 3280 -7710 3280 -7690 {
lab=row_n[8]}
N 3280 -7950 3280 -7930 {
lab=row_n[8]}
N 3160 -7850 3170 -7860 {
lab=col_n[26]}
N 3170 -7860 3370 -7860 {
lab=col_n[26]}
N 3370 -7860 3380 -7850 {
lab=col_n[26]}
N 3160 -7830 3170 -7840 {
lab=colon_n[26]}
N 3170 -7840 3370 -7840 {
lab=colon_n[26]}
N 3370 -7840 3380 -7830 {
lab=colon_n[26]}
N 3160 -7810 3170 -7820 {
lab=#net53}
N 3170 -7820 3370 -7820 {
lab=#net53}
N 3370 -7820 3380 -7810 {
lab=#net53}
N 3160 -7790 3170 -7800 {
lab=#net54}
N 3170 -7800 3370 -7800 {
lab=#net54}
N 3370 -7800 3380 -7790 {
lab=#net54}
N 3220 -7950 3220 -7930 {
lab=vcom}
N 3260 -7950 3260 -7930 {
lab=ctop}
N 3140 -7850 3160 -7850 {
lab=col_n[26]}
N 3140 -7830 3160 -7830 {
lab=colon_n[26]}
N 3140 -7810 3160 -7810 {
lab=#net53}
N 3140 -7790 3160 -7790 {
lab=#net54}
N 3380 -7790 3400 -7790 {
lab=#net54}
N 3380 -7810 3400 -7810 {
lab=#net53}
N 3380 -7830 3400 -7830 {
lab=colon_n[26]}
N 3380 -7850 3400 -7850 {
lab=col_n[26]}
N 3200 -7710 3200 -7700 {
lab=VSS}
N 3200 -7940 3200 -7930 {
lab=VDD}
N 3540 -7710 3550 -7720 {
lab=row_n[9]}
N 3550 -7920 3550 -7720 {
lab=row_n[9]}
N 3540 -7930 3550 -7920 {
lab=row_n[9]}
N 3540 -7710 3540 -7690 {
lab=row_n[9]}
N 3540 -7950 3540 -7930 {
lab=row_n[9]}
N 3420 -7850 3430 -7860 {
lab=col_n[26]}
N 3430 -7860 3630 -7860 {
lab=col_n[26]}
N 3630 -7860 3640 -7850 {
lab=col_n[26]}
N 3420 -7830 3430 -7840 {
lab=colon_n[26]}
N 3430 -7840 3630 -7840 {
lab=colon_n[26]}
N 3630 -7840 3640 -7830 {
lab=colon_n[26]}
N 3420 -7810 3430 -7820 {
lab=#net53}
N 3430 -7820 3630 -7820 {
lab=#net53}
N 3630 -7820 3640 -7810 {
lab=#net53}
N 3420 -7790 3430 -7800 {
lab=#net54}
N 3430 -7800 3630 -7800 {
lab=#net54}
N 3630 -7800 3640 -7790 {
lab=#net54}
N 3480 -7950 3480 -7930 {
lab=vcom}
N 3520 -7950 3520 -7930 {
lab=ctop}
N 3400 -7850 3420 -7850 {
lab=col_n[26]}
N 3400 -7830 3420 -7830 {
lab=colon_n[26]}
N 3400 -7810 3420 -7810 {
lab=#net53}
N 3400 -7790 3420 -7790 {
lab=#net54}
N 3640 -7790 3660 -7790 {
lab=#net54}
N 3640 -7810 3660 -7810 {
lab=#net53}
N 3640 -7830 3660 -7830 {
lab=colon_n[26]}
N 3640 -7850 3660 -7850 {
lab=col_n[26]}
N 3460 -7710 3460 -7700 {
lab=VSS}
N 3460 -7940 3460 -7930 {
lab=VDD}
N 3800 -7710 3810 -7720 {
lab=row_n[10]}
N 3810 -7920 3810 -7720 {
lab=row_n[10]}
N 3800 -7930 3810 -7920 {
lab=row_n[10]}
N 3800 -7710 3800 -7690 {
lab=row_n[10]}
N 3800 -7950 3800 -7930 {
lab=row_n[10]}
N 3680 -7850 3690 -7860 {
lab=col_n[26]}
N 3690 -7860 3890 -7860 {
lab=col_n[26]}
N 3890 -7860 3900 -7850 {
lab=col_n[26]}
N 3680 -7830 3690 -7840 {
lab=colon_n[26]}
N 3690 -7840 3890 -7840 {
lab=colon_n[26]}
N 3890 -7840 3900 -7830 {
lab=colon_n[26]}
N 3680 -7810 3690 -7820 {
lab=#net53}
N 3690 -7820 3890 -7820 {
lab=#net53}
N 3890 -7820 3900 -7810 {
lab=#net53}
N 3680 -7790 3690 -7800 {
lab=#net54}
N 3690 -7800 3890 -7800 {
lab=#net54}
N 3890 -7800 3900 -7790 {
lab=#net54}
N 3740 -7950 3740 -7930 {
lab=vcom}
N 3780 -7950 3780 -7930 {
lab=ctop}
N 3660 -7850 3680 -7850 {
lab=col_n[26]}
N 3660 -7830 3680 -7830 {
lab=colon_n[26]}
N 3660 -7810 3680 -7810 {
lab=#net53}
N 3660 -7790 3680 -7790 {
lab=#net54}
N 3900 -7790 3920 -7790 {
lab=#net54}
N 3900 -7810 3920 -7810 {
lab=#net53}
N 3900 -7830 3920 -7830 {
lab=colon_n[26]}
N 3900 -7850 3920 -7850 {
lab=col_n[26]}
N 3720 -7710 3720 -7700 {
lab=VSS}
N 3720 -7940 3720 -7930 {
lab=VDD}
N 4060 -7710 4070 -7720 {
lab=row_n[11]}
N 4070 -7920 4070 -7720 {
lab=row_n[11]}
N 4060 -7930 4070 -7920 {
lab=row_n[11]}
N 4060 -7710 4060 -7690 {
lab=row_n[11]}
N 4060 -7950 4060 -7930 {
lab=row_n[11]}
N 3940 -7850 3950 -7860 {
lab=col_n[26]}
N 3950 -7860 4150 -7860 {
lab=col_n[26]}
N 4150 -7860 4160 -7850 {
lab=col_n[26]}
N 3940 -7830 3950 -7840 {
lab=colon_n[26]}
N 3950 -7840 4150 -7840 {
lab=colon_n[26]}
N 4150 -7840 4160 -7830 {
lab=colon_n[26]}
N 3940 -7810 3950 -7820 {
lab=#net53}
N 3950 -7820 4150 -7820 {
lab=#net53}
N 4150 -7820 4160 -7810 {
lab=#net53}
N 3940 -7790 3950 -7800 {
lab=#net54}
N 3950 -7800 4150 -7800 {
lab=#net54}
N 4150 -7800 4160 -7790 {
lab=#net54}
N 4000 -7950 4000 -7930 {
lab=vcom}
N 4040 -7950 4040 -7930 {
lab=ctop}
N 3920 -7850 3940 -7850 {
lab=col_n[26]}
N 3920 -7830 3940 -7830 {
lab=colon_n[26]}
N 3920 -7810 3940 -7810 {
lab=#net53}
N 3920 -7790 3940 -7790 {
lab=#net54}
N 4160 -7790 4180 -7790 {
lab=#net54}
N 4160 -7810 4180 -7810 {
lab=#net53}
N 4160 -7830 4180 -7830 {
lab=colon_n[26]}
N 4160 -7850 4180 -7850 {
lab=col_n[26]}
N 3980 -7710 3980 -7700 {
lab=VSS}
N 3980 -7940 3980 -7930 {
lab=VDD}
N 4320 -7710 4330 -7720 {
lab=row_n[12]}
N 4330 -7920 4330 -7720 {
lab=row_n[12]}
N 4320 -7930 4330 -7920 {
lab=row_n[12]}
N 4320 -7710 4320 -7690 {
lab=row_n[12]}
N 4320 -7950 4320 -7930 {
lab=row_n[12]}
N 4200 -7850 4210 -7860 {
lab=col_n[26]}
N 4210 -7860 4410 -7860 {
lab=col_n[26]}
N 4410 -7860 4420 -7850 {
lab=col_n[26]}
N 4200 -7830 4210 -7840 {
lab=colon_n[26]}
N 4210 -7840 4410 -7840 {
lab=colon_n[26]}
N 4410 -7840 4420 -7830 {
lab=colon_n[26]}
N 4200 -7810 4210 -7820 {
lab=#net53}
N 4210 -7820 4410 -7820 {
lab=#net53}
N 4410 -7820 4420 -7810 {
lab=#net53}
N 4200 -7790 4210 -7800 {
lab=#net54}
N 4210 -7800 4410 -7800 {
lab=#net54}
N 4410 -7800 4420 -7790 {
lab=#net54}
N 4260 -7950 4260 -7930 {
lab=vcom}
N 4300 -7950 4300 -7930 {
lab=ctop}
N 4180 -7850 4200 -7850 {
lab=col_n[26]}
N 4180 -7830 4200 -7830 {
lab=colon_n[26]}
N 4180 -7810 4200 -7810 {
lab=#net53}
N 4180 -7790 4200 -7790 {
lab=#net54}
N 4420 -7790 4440 -7790 {
lab=#net54}
N 4420 -7810 4440 -7810 {
lab=#net53}
N 4420 -7830 4440 -7830 {
lab=colon_n[26]}
N 4420 -7850 4440 -7850 {
lab=col_n[26]}
N 4240 -7710 4240 -7700 {
lab=VSS}
N 4240 -7940 4240 -7930 {
lab=VDD}
N 4580 -7710 4590 -7720 {
lab=row_n[13]}
N 4590 -7920 4590 -7720 {
lab=row_n[13]}
N 4580 -7930 4590 -7920 {
lab=row_n[13]}
N 4580 -7710 4580 -7690 {
lab=row_n[13]}
N 4580 -7950 4580 -7930 {
lab=row_n[13]}
N 4460 -7850 4470 -7860 {
lab=col_n[26]}
N 4470 -7860 4670 -7860 {
lab=col_n[26]}
N 4670 -7860 4680 -7850 {
lab=col_n[26]}
N 4460 -7830 4470 -7840 {
lab=colon_n[26]}
N 4470 -7840 4670 -7840 {
lab=colon_n[26]}
N 4670 -7840 4680 -7830 {
lab=colon_n[26]}
N 4460 -7810 4470 -7820 {
lab=#net53}
N 4470 -7820 4670 -7820 {
lab=#net53}
N 4670 -7820 4680 -7810 {
lab=#net53}
N 4460 -7790 4470 -7800 {
lab=#net54}
N 4470 -7800 4670 -7800 {
lab=#net54}
N 4670 -7800 4680 -7790 {
lab=#net54}
N 4520 -7950 4520 -7930 {
lab=vcom}
N 4560 -7950 4560 -7930 {
lab=ctop}
N 4440 -7850 4460 -7850 {
lab=col_n[26]}
N 4440 -7830 4460 -7830 {
lab=colon_n[26]}
N 4440 -7810 4460 -7810 {
lab=#net53}
N 4440 -7790 4460 -7790 {
lab=#net54}
N 4680 -7790 4700 -7790 {
lab=#net54}
N 4680 -7810 4700 -7810 {
lab=#net53}
N 4680 -7830 4700 -7830 {
lab=colon_n[26]}
N 4680 -7850 4700 -7850 {
lab=col_n[26]}
N 4500 -7710 4500 -7700 {
lab=VSS}
N 4500 -7940 4500 -7930 {
lab=VDD}
N 4840 -7710 4850 -7720 {
lab=row_n[14]}
N 4850 -7920 4850 -7720 {
lab=row_n[14]}
N 4840 -7930 4850 -7920 {
lab=row_n[14]}
N 4840 -7710 4840 -7690 {
lab=row_n[14]}
N 4840 -7950 4840 -7930 {
lab=row_n[14]}
N 4720 -7850 4730 -7860 {
lab=col_n[26]}
N 4730 -7860 4930 -7860 {
lab=col_n[26]}
N 4930 -7860 4940 -7850 {
lab=col_n[26]}
N 4720 -7830 4730 -7840 {
lab=colon_n[26]}
N 4730 -7840 4930 -7840 {
lab=colon_n[26]}
N 4930 -7840 4940 -7830 {
lab=colon_n[26]}
N 4720 -7810 4730 -7820 {
lab=#net53}
N 4730 -7820 4930 -7820 {
lab=#net53}
N 4930 -7820 4940 -7810 {
lab=#net53}
N 4720 -7790 4730 -7800 {
lab=#net54}
N 4730 -7800 4930 -7800 {
lab=#net54}
N 4930 -7800 4940 -7790 {
lab=#net54}
N 4780 -7950 4780 -7930 {
lab=vcom}
N 4820 -7950 4820 -7930 {
lab=ctop}
N 4700 -7850 4720 -7850 {
lab=col_n[26]}
N 4700 -7830 4720 -7830 {
lab=colon_n[26]}
N 4700 -7810 4720 -7810 {
lab=#net53}
N 4700 -7790 4720 -7790 {
lab=#net54}
N 4940 -7790 4960 -7790 {
lab=#net54}
N 4940 -7810 4960 -7810 {
lab=#net53}
N 4940 -7830 4960 -7830 {
lab=colon_n[26]}
N 4940 -7850 4960 -7850 {
lab=col_n[26]}
N 4760 -7710 4760 -7700 {
lab=VSS}
N 4760 -7940 4760 -7930 {
lab=VDD}
N 5100 -7710 5110 -7720 {
lab=row_n[15]}
N 5110 -7920 5110 -7720 {
lab=row_n[15]}
N 5100 -7930 5110 -7920 {
lab=row_n[15]}
N 5100 -7710 5100 -7690 {
lab=row_n[15]}
N 5100 -7950 5100 -7930 {
lab=row_n[15]}
N 4980 -7850 4990 -7860 {
lab=col_n[26]}
N 4990 -7860 5190 -7860 {
lab=col_n[26]}
N 5190 -7860 5200 -7850 {
lab=col_n[26]}
N 4980 -7830 4990 -7840 {
lab=colon_n[26]}
N 4990 -7840 5190 -7840 {
lab=colon_n[26]}
N 5190 -7840 5200 -7830 {
lab=colon_n[26]}
N 4980 -7810 4990 -7820 {
lab=#net53}
N 4990 -7820 5190 -7820 {
lab=#net53}
N 5190 -7820 5200 -7810 {
lab=#net53}
N 4980 -7790 4990 -7800 {
lab=#net54}
N 4990 -7800 5190 -7800 {
lab=#net54}
N 5190 -7800 5200 -7790 {
lab=#net54}
N 5040 -7950 5040 -7930 {
lab=vcom}
N 5080 -7950 5080 -7930 {
lab=ctop}
N 4960 -7850 4980 -7850 {
lab=col_n[26]}
N 4960 -7830 4980 -7830 {
lab=colon_n[26]}
N 4960 -7810 4980 -7810 {
lab=#net53}
N 4960 -7790 4980 -7790 {
lab=#net54}
N 5200 -7790 5220 -7790 {
lab=#net54}
N 5200 -7810 5220 -7810 {
lab=#net53}
N 5200 -7830 5220 -7830 {
lab=colon_n[26]}
N 5200 -7850 5220 -7850 {
lab=col_n[26]}
N 5020 -7710 5020 -7700 {
lab=VSS}
N 5020 -7940 5020 -7930 {
lab=VDD}
N 5360 -7710 5370 -7720 {
lab=row_n[16]}
N 5370 -7920 5370 -7720 {
lab=row_n[16]}
N 5360 -7930 5370 -7920 {
lab=row_n[16]}
N 5360 -7710 5360 -7690 {
lab=row_n[16]}
N 5360 -7950 5360 -7930 {
lab=row_n[16]}
N 5240 -7850 5250 -7860 {
lab=col_n[26]}
N 5250 -7860 5450 -7860 {
lab=col_n[26]}
N 5450 -7860 5460 -7850 {
lab=col_n[26]}
N 5240 -7830 5250 -7840 {
lab=colon_n[26]}
N 5250 -7840 5450 -7840 {
lab=colon_n[26]}
N 5450 -7840 5460 -7830 {
lab=colon_n[26]}
N 5240 -7810 5250 -7820 {
lab=#net53}
N 5250 -7820 5450 -7820 {
lab=#net53}
N 5450 -7820 5460 -7810 {
lab=#net53}
N 5240 -7790 5250 -7800 {
lab=#net54}
N 5250 -7800 5450 -7800 {
lab=#net54}
N 5450 -7800 5460 -7790 {
lab=#net54}
N 5300 -7950 5300 -7930 {
lab=vcom}
N 5340 -7950 5340 -7930 {
lab=ctop}
N 5220 -7850 5240 -7850 {
lab=col_n[26]}
N 5220 -7830 5240 -7830 {
lab=colon_n[26]}
N 5220 -7810 5240 -7810 {
lab=#net53}
N 5220 -7790 5240 -7790 {
lab=#net54}
N 5460 -7790 5480 -7790 {
lab=#net54}
N 5460 -7810 5480 -7810 {
lab=#net53}
N 5460 -7830 5480 -7830 {
lab=colon_n[26]}
N 5460 -7850 5480 -7850 {
lab=col_n[26]}
N 5280 -7710 5280 -7700 {
lab=VSS}
N 5280 -7940 5280 -7930 {
lab=VDD}
N 5620 -7710 5630 -7720 {
lab=row_n[17]}
N 5630 -7920 5630 -7720 {
lab=row_n[17]}
N 5620 -7930 5630 -7920 {
lab=row_n[17]}
N 5620 -7710 5620 -7690 {
lab=row_n[17]}
N 5620 -7950 5620 -7930 {
lab=row_n[17]}
N 5500 -7850 5510 -7860 {
lab=col_n[26]}
N 5510 -7860 5710 -7860 {
lab=col_n[26]}
N 5710 -7860 5720 -7850 {
lab=col_n[26]}
N 5500 -7830 5510 -7840 {
lab=colon_n[26]}
N 5510 -7840 5710 -7840 {
lab=colon_n[26]}
N 5710 -7840 5720 -7830 {
lab=colon_n[26]}
N 5500 -7810 5510 -7820 {
lab=#net53}
N 5510 -7820 5710 -7820 {
lab=#net53}
N 5710 -7820 5720 -7810 {
lab=#net53}
N 5500 -7790 5510 -7800 {
lab=#net54}
N 5510 -7800 5710 -7800 {
lab=#net54}
N 5710 -7800 5720 -7790 {
lab=#net54}
N 5560 -7950 5560 -7930 {
lab=vcom}
N 5600 -7950 5600 -7930 {
lab=ctop}
N 5480 -7850 5500 -7850 {
lab=col_n[26]}
N 5480 -7830 5500 -7830 {
lab=colon_n[26]}
N 5480 -7810 5500 -7810 {
lab=#net53}
N 5480 -7790 5500 -7790 {
lab=#net54}
N 5720 -7790 5740 -7790 {
lab=#net54}
N 5720 -7810 5740 -7810 {
lab=#net53}
N 5720 -7830 5740 -7830 {
lab=colon_n[26]}
N 5720 -7850 5740 -7850 {
lab=col_n[26]}
N 5540 -7710 5540 -7700 {
lab=VSS}
N 5540 -7940 5540 -7930 {
lab=VDD}
N 5880 -7710 5890 -7720 {
lab=row_n[18]}
N 5890 -7920 5890 -7720 {
lab=row_n[18]}
N 5880 -7930 5890 -7920 {
lab=row_n[18]}
N 5880 -7710 5880 -7690 {
lab=row_n[18]}
N 5880 -7950 5880 -7930 {
lab=row_n[18]}
N 5760 -7850 5770 -7860 {
lab=col_n[26]}
N 5770 -7860 5970 -7860 {
lab=col_n[26]}
N 5970 -7860 5980 -7850 {
lab=col_n[26]}
N 5760 -7830 5770 -7840 {
lab=colon_n[26]}
N 5770 -7840 5970 -7840 {
lab=colon_n[26]}
N 5970 -7840 5980 -7830 {
lab=colon_n[26]}
N 5760 -7810 5770 -7820 {
lab=#net53}
N 5770 -7820 5970 -7820 {
lab=#net53}
N 5970 -7820 5980 -7810 {
lab=#net53}
N 5760 -7790 5770 -7800 {
lab=#net54}
N 5770 -7800 5970 -7800 {
lab=#net54}
N 5970 -7800 5980 -7790 {
lab=#net54}
N 5820 -7950 5820 -7930 {
lab=vcom}
N 5860 -7950 5860 -7930 {
lab=ctop}
N 5740 -7850 5760 -7850 {
lab=col_n[26]}
N 5740 -7830 5760 -7830 {
lab=colon_n[26]}
N 5740 -7810 5760 -7810 {
lab=#net53}
N 5740 -7790 5760 -7790 {
lab=#net54}
N 5980 -7790 6000 -7790 {
lab=#net54}
N 5980 -7810 6000 -7810 {
lab=#net53}
N 5980 -7830 6000 -7830 {
lab=colon_n[26]}
N 5980 -7850 6000 -7850 {
lab=col_n[26]}
N 5800 -7710 5800 -7700 {
lab=VSS}
N 5800 -7940 5800 -7930 {
lab=VDD}
N 6140 -7710 6150 -7720 {
lab=row_n[19]}
N 6150 -7920 6150 -7720 {
lab=row_n[19]}
N 6140 -7930 6150 -7920 {
lab=row_n[19]}
N 6140 -7710 6140 -7690 {
lab=row_n[19]}
N 6140 -7950 6140 -7930 {
lab=row_n[19]}
N 6020 -7850 6030 -7860 {
lab=col_n[26]}
N 6030 -7860 6230 -7860 {
lab=col_n[26]}
N 6230 -7860 6240 -7850 {
lab=col_n[26]}
N 6020 -7830 6030 -7840 {
lab=colon_n[26]}
N 6030 -7840 6230 -7840 {
lab=colon_n[26]}
N 6230 -7840 6240 -7830 {
lab=colon_n[26]}
N 6020 -7810 6030 -7820 {
lab=#net53}
N 6030 -7820 6230 -7820 {
lab=#net53}
N 6230 -7820 6240 -7810 {
lab=#net53}
N 6020 -7790 6030 -7800 {
lab=#net54}
N 6030 -7800 6230 -7800 {
lab=#net54}
N 6230 -7800 6240 -7790 {
lab=#net54}
N 6080 -7950 6080 -7930 {
lab=vcom}
N 6120 -7950 6120 -7930 {
lab=ctop}
N 6000 -7850 6020 -7850 {
lab=col_n[26]}
N 6000 -7830 6020 -7830 {
lab=colon_n[26]}
N 6000 -7810 6020 -7810 {
lab=#net53}
N 6000 -7790 6020 -7790 {
lab=#net54}
N 6240 -7790 6260 -7790 {
lab=#net54}
N 6240 -7810 6260 -7810 {
lab=#net53}
N 6240 -7830 6260 -7830 {
lab=colon_n[26]}
N 6240 -7850 6260 -7850 {
lab=col_n[26]}
N 6060 -7710 6060 -7700 {
lab=VSS}
N 6060 -7940 6060 -7930 {
lab=VDD}
N 6400 -7710 6410 -7720 {
lab=row_n[20]}
N 6410 -7920 6410 -7720 {
lab=row_n[20]}
N 6400 -7930 6410 -7920 {
lab=row_n[20]}
N 6400 -7710 6400 -7690 {
lab=row_n[20]}
N 6400 -7950 6400 -7930 {
lab=row_n[20]}
N 6280 -7850 6290 -7860 {
lab=col_n[26]}
N 6290 -7860 6490 -7860 {
lab=col_n[26]}
N 6490 -7860 6500 -7850 {
lab=col_n[26]}
N 6280 -7830 6290 -7840 {
lab=colon_n[26]}
N 6290 -7840 6490 -7840 {
lab=colon_n[26]}
N 6490 -7840 6500 -7830 {
lab=colon_n[26]}
N 6280 -7810 6290 -7820 {
lab=#net53}
N 6290 -7820 6490 -7820 {
lab=#net53}
N 6490 -7820 6500 -7810 {
lab=#net53}
N 6280 -7790 6290 -7800 {
lab=#net54}
N 6290 -7800 6490 -7800 {
lab=#net54}
N 6490 -7800 6500 -7790 {
lab=#net54}
N 6340 -7950 6340 -7930 {
lab=vcom}
N 6380 -7950 6380 -7930 {
lab=ctop}
N 6260 -7850 6280 -7850 {
lab=col_n[26]}
N 6260 -7830 6280 -7830 {
lab=colon_n[26]}
N 6260 -7810 6280 -7810 {
lab=#net53}
N 6260 -7790 6280 -7790 {
lab=#net54}
N 6500 -7790 6520 -7790 {
lab=#net54}
N 6500 -7810 6520 -7810 {
lab=#net53}
N 6500 -7830 6520 -7830 {
lab=colon_n[26]}
N 6500 -7850 6520 -7850 {
lab=col_n[26]}
N 6320 -7710 6320 -7700 {
lab=VSS}
N 6320 -7940 6320 -7930 {
lab=VDD}
N 6660 -7710 6670 -7720 {
lab=row_n[21]}
N 6670 -7920 6670 -7720 {
lab=row_n[21]}
N 6660 -7930 6670 -7920 {
lab=row_n[21]}
N 6660 -7710 6660 -7690 {
lab=row_n[21]}
N 6660 -7950 6660 -7930 {
lab=row_n[21]}
N 6540 -7850 6550 -7860 {
lab=col_n[26]}
N 6550 -7860 6750 -7860 {
lab=col_n[26]}
N 6750 -7860 6760 -7850 {
lab=col_n[26]}
N 6540 -7830 6550 -7840 {
lab=colon_n[26]}
N 6550 -7840 6750 -7840 {
lab=colon_n[26]}
N 6750 -7840 6760 -7830 {
lab=colon_n[26]}
N 6540 -7810 6550 -7820 {
lab=#net53}
N 6550 -7820 6750 -7820 {
lab=#net53}
N 6750 -7820 6760 -7810 {
lab=#net53}
N 6540 -7790 6550 -7800 {
lab=#net54}
N 6550 -7800 6750 -7800 {
lab=#net54}
N 6750 -7800 6760 -7790 {
lab=#net54}
N 6600 -7950 6600 -7930 {
lab=vcom}
N 6640 -7950 6640 -7930 {
lab=ctop}
N 6520 -7850 6540 -7850 {
lab=col_n[26]}
N 6520 -7830 6540 -7830 {
lab=colon_n[26]}
N 6520 -7810 6540 -7810 {
lab=#net53}
N 6520 -7790 6540 -7790 {
lab=#net54}
N 6760 -7790 6780 -7790 {
lab=#net54}
N 6760 -7810 6780 -7810 {
lab=#net53}
N 6760 -7830 6780 -7830 {
lab=colon_n[26]}
N 6760 -7850 6780 -7850 {
lab=col_n[26]}
N 6580 -7710 6580 -7700 {
lab=VSS}
N 6580 -7940 6580 -7930 {
lab=VDD}
N 6920 -7710 6930 -7720 {
lab=row_n[22]}
N 6930 -7920 6930 -7720 {
lab=row_n[22]}
N 6920 -7930 6930 -7920 {
lab=row_n[22]}
N 6920 -7710 6920 -7690 {
lab=row_n[22]}
N 6920 -7950 6920 -7930 {
lab=row_n[22]}
N 6800 -7850 6810 -7860 {
lab=col_n[26]}
N 6810 -7860 7010 -7860 {
lab=col_n[26]}
N 7010 -7860 7020 -7850 {
lab=col_n[26]}
N 6800 -7830 6810 -7840 {
lab=colon_n[26]}
N 6810 -7840 7010 -7840 {
lab=colon_n[26]}
N 7010 -7840 7020 -7830 {
lab=colon_n[26]}
N 6800 -7810 6810 -7820 {
lab=#net53}
N 6810 -7820 7010 -7820 {
lab=#net53}
N 7010 -7820 7020 -7810 {
lab=#net53}
N 6800 -7790 6810 -7800 {
lab=#net54}
N 6810 -7800 7010 -7800 {
lab=#net54}
N 7010 -7800 7020 -7790 {
lab=#net54}
N 6860 -7950 6860 -7930 {
lab=vcom}
N 6900 -7950 6900 -7930 {
lab=ctop}
N 6780 -7850 6800 -7850 {
lab=col_n[26]}
N 6780 -7830 6800 -7830 {
lab=colon_n[26]}
N 6780 -7810 6800 -7810 {
lab=#net53}
N 6780 -7790 6800 -7790 {
lab=#net54}
N 7020 -7790 7040 -7790 {
lab=#net54}
N 7020 -7810 7040 -7810 {
lab=#net53}
N 7020 -7830 7040 -7830 {
lab=colon_n[26]}
N 7020 -7850 7040 -7850 {
lab=col_n[26]}
N 6840 -7710 6840 -7700 {
lab=VSS}
N 6840 -7940 6840 -7930 {
lab=VDD}
N 7180 -7710 7190 -7720 {
lab=row_n[23]}
N 7190 -7920 7190 -7720 {
lab=row_n[23]}
N 7180 -7930 7190 -7920 {
lab=row_n[23]}
N 7180 -7710 7180 -7690 {
lab=row_n[23]}
N 7180 -7950 7180 -7930 {
lab=row_n[23]}
N 7060 -7850 7070 -7860 {
lab=col_n[26]}
N 7070 -7860 7270 -7860 {
lab=col_n[26]}
N 7270 -7860 7280 -7850 {
lab=col_n[26]}
N 7060 -7830 7070 -7840 {
lab=colon_n[26]}
N 7070 -7840 7270 -7840 {
lab=colon_n[26]}
N 7270 -7840 7280 -7830 {
lab=colon_n[26]}
N 7060 -7810 7070 -7820 {
lab=#net53}
N 7070 -7820 7270 -7820 {
lab=#net53}
N 7270 -7820 7280 -7810 {
lab=#net53}
N 7060 -7790 7070 -7800 {
lab=#net54}
N 7070 -7800 7270 -7800 {
lab=#net54}
N 7270 -7800 7280 -7790 {
lab=#net54}
N 7120 -7950 7120 -7930 {
lab=vcom}
N 7160 -7950 7160 -7930 {
lab=ctop}
N 7040 -7850 7060 -7850 {
lab=col_n[26]}
N 7040 -7830 7060 -7830 {
lab=colon_n[26]}
N 7040 -7810 7060 -7810 {
lab=#net53}
N 7040 -7790 7060 -7790 {
lab=#net54}
N 7280 -7790 7300 -7790 {
lab=#net54}
N 7280 -7810 7300 -7810 {
lab=#net53}
N 7280 -7830 7300 -7830 {
lab=colon_n[26]}
N 7280 -7850 7300 -7850 {
lab=col_n[26]}
N 7100 -7710 7100 -7700 {
lab=VSS}
N 7100 -7940 7100 -7930 {
lab=VDD}
N 7440 -7710 7450 -7720 {
lab=row_n[24]}
N 7450 -7920 7450 -7720 {
lab=row_n[24]}
N 7440 -7930 7450 -7920 {
lab=row_n[24]}
N 7440 -7710 7440 -7690 {
lab=row_n[24]}
N 7440 -7950 7440 -7930 {
lab=row_n[24]}
N 7320 -7850 7330 -7860 {
lab=col_n[26]}
N 7330 -7860 7530 -7860 {
lab=col_n[26]}
N 7530 -7860 7540 -7850 {
lab=col_n[26]}
N 7320 -7830 7330 -7840 {
lab=colon_n[26]}
N 7330 -7840 7530 -7840 {
lab=colon_n[26]}
N 7530 -7840 7540 -7830 {
lab=colon_n[26]}
N 7320 -7810 7330 -7820 {
lab=#net53}
N 7330 -7820 7530 -7820 {
lab=#net53}
N 7530 -7820 7540 -7810 {
lab=#net53}
N 7320 -7790 7330 -7800 {
lab=#net54}
N 7330 -7800 7530 -7800 {
lab=#net54}
N 7530 -7800 7540 -7790 {
lab=#net54}
N 7380 -7950 7380 -7930 {
lab=vcom}
N 7420 -7950 7420 -7930 {
lab=ctop}
N 7300 -7850 7320 -7850 {
lab=col_n[26]}
N 7300 -7830 7320 -7830 {
lab=colon_n[26]}
N 7300 -7810 7320 -7810 {
lab=#net53}
N 7300 -7790 7320 -7790 {
lab=#net54}
N 7540 -7790 7560 -7790 {
lab=#net54}
N 7540 -7810 7560 -7810 {
lab=#net53}
N 7540 -7830 7560 -7830 {
lab=colon_n[26]}
N 7540 -7850 7560 -7850 {
lab=col_n[26]}
N 7360 -7710 7360 -7700 {
lab=VSS}
N 7360 -7940 7360 -7930 {
lab=VDD}
N 7700 -7710 7710 -7720 {
lab=row_n[25]}
N 7710 -7920 7710 -7720 {
lab=row_n[25]}
N 7700 -7930 7710 -7920 {
lab=row_n[25]}
N 7700 -7710 7700 -7690 {
lab=row_n[25]}
N 7700 -7950 7700 -7930 {
lab=row_n[25]}
N 7580 -7850 7590 -7860 {
lab=col_n[26]}
N 7590 -7860 7790 -7860 {
lab=col_n[26]}
N 7790 -7860 7800 -7850 {
lab=col_n[26]}
N 7580 -7830 7590 -7840 {
lab=colon_n[26]}
N 7590 -7840 7790 -7840 {
lab=colon_n[26]}
N 7790 -7840 7800 -7830 {
lab=colon_n[26]}
N 7580 -7810 7590 -7820 {
lab=#net53}
N 7590 -7820 7790 -7820 {
lab=#net53}
N 7790 -7820 7800 -7810 {
lab=#net53}
N 7580 -7790 7590 -7800 {
lab=#net54}
N 7590 -7800 7790 -7800 {
lab=#net54}
N 7790 -7800 7800 -7790 {
lab=#net54}
N 7640 -7950 7640 -7930 {
lab=vcom}
N 7680 -7950 7680 -7930 {
lab=ctop}
N 7560 -7850 7580 -7850 {
lab=col_n[26]}
N 7560 -7830 7580 -7830 {
lab=colon_n[26]}
N 7560 -7810 7580 -7810 {
lab=#net53}
N 7560 -7790 7580 -7790 {
lab=#net54}
N 7800 -7790 7820 -7790 {
lab=#net54}
N 7800 -7810 7820 -7810 {
lab=#net53}
N 7800 -7830 7820 -7830 {
lab=colon_n[26]}
N 7800 -7850 7820 -7850 {
lab=col_n[26]}
N 7620 -7710 7620 -7700 {
lab=VSS}
N 7620 -7940 7620 -7930 {
lab=VDD}
N 7960 -7710 7970 -7720 {
lab=row_n[26]}
N 7970 -7920 7970 -7720 {
lab=row_n[26]}
N 7960 -7930 7970 -7920 {
lab=row_n[26]}
N 7960 -7710 7960 -7690 {
lab=row_n[26]}
N 7960 -7950 7960 -7930 {
lab=row_n[26]}
N 7840 -7850 7850 -7860 {
lab=col_n[26]}
N 7850 -7860 8050 -7860 {
lab=col_n[26]}
N 8050 -7860 8060 -7850 {
lab=col_n[26]}
N 7840 -7830 7850 -7840 {
lab=colon_n[26]}
N 7850 -7840 8050 -7840 {
lab=colon_n[26]}
N 8050 -7840 8060 -7830 {
lab=colon_n[26]}
N 7840 -7810 7850 -7820 {
lab=#net53}
N 7850 -7820 8050 -7820 {
lab=#net53}
N 8050 -7820 8060 -7810 {
lab=#net53}
N 7840 -7790 7850 -7800 {
lab=#net54}
N 7850 -7800 8050 -7800 {
lab=#net54}
N 8050 -7800 8060 -7790 {
lab=#net54}
N 7900 -7950 7900 -7930 {
lab=vcom}
N 7940 -7950 7940 -7930 {
lab=ctop}
N 7820 -7850 7840 -7850 {
lab=col_n[26]}
N 7820 -7830 7840 -7830 {
lab=colon_n[26]}
N 7820 -7810 7840 -7810 {
lab=#net53}
N 7820 -7790 7840 -7790 {
lab=#net54}
N 8060 -7790 8080 -7790 {
lab=#net54}
N 8060 -7810 8080 -7810 {
lab=#net53}
N 8060 -7830 8080 -7830 {
lab=colon_n[26]}
N 8060 -7850 8080 -7850 {
lab=col_n[26]}
N 7880 -7710 7880 -7700 {
lab=VSS}
N 7880 -7940 7880 -7930 {
lab=VDD}
N 8220 -7710 8230 -7720 {
lab=row_n[27]}
N 8230 -7920 8230 -7720 {
lab=row_n[27]}
N 8220 -7930 8230 -7920 {
lab=row_n[27]}
N 8220 -7710 8220 -7690 {
lab=row_n[27]}
N 8220 -7950 8220 -7930 {
lab=row_n[27]}
N 8100 -7850 8110 -7860 {
lab=col_n[26]}
N 8110 -7860 8310 -7860 {
lab=col_n[26]}
N 8310 -7860 8320 -7850 {
lab=col_n[26]}
N 8100 -7830 8110 -7840 {
lab=colon_n[26]}
N 8110 -7840 8310 -7840 {
lab=colon_n[26]}
N 8310 -7840 8320 -7830 {
lab=colon_n[26]}
N 8100 -7810 8110 -7820 {
lab=#net53}
N 8110 -7820 8310 -7820 {
lab=#net53}
N 8310 -7820 8320 -7810 {
lab=#net53}
N 8100 -7790 8110 -7800 {
lab=#net54}
N 8110 -7800 8310 -7800 {
lab=#net54}
N 8310 -7800 8320 -7790 {
lab=#net54}
N 8160 -7950 8160 -7930 {
lab=vcom}
N 8200 -7950 8200 -7930 {
lab=ctop}
N 8080 -7850 8100 -7850 {
lab=col_n[26]}
N 8080 -7830 8100 -7830 {
lab=colon_n[26]}
N 8080 -7810 8100 -7810 {
lab=#net53}
N 8080 -7790 8100 -7790 {
lab=#net54}
N 8320 -7790 8340 -7790 {
lab=#net54}
N 8320 -7810 8340 -7810 {
lab=#net53}
N 8320 -7830 8340 -7830 {
lab=colon_n[26]}
N 8320 -7850 8340 -7850 {
lab=col_n[26]}
N 8140 -7710 8140 -7700 {
lab=VSS}
N 8140 -7940 8140 -7930 {
lab=VDD}
N 8480 -7710 8490 -7720 {
lab=row_n[28]}
N 8490 -7920 8490 -7720 {
lab=row_n[28]}
N 8480 -7930 8490 -7920 {
lab=row_n[28]}
N 8480 -7710 8480 -7690 {
lab=row_n[28]}
N 8480 -7950 8480 -7930 {
lab=row_n[28]}
N 8360 -7850 8370 -7860 {
lab=col_n[26]}
N 8370 -7860 8570 -7860 {
lab=col_n[26]}
N 8570 -7860 8580 -7850 {
lab=col_n[26]}
N 8360 -7830 8370 -7840 {
lab=colon_n[26]}
N 8370 -7840 8570 -7840 {
lab=colon_n[26]}
N 8570 -7840 8580 -7830 {
lab=colon_n[26]}
N 8360 -7810 8370 -7820 {
lab=#net53}
N 8370 -7820 8570 -7820 {
lab=#net53}
N 8570 -7820 8580 -7810 {
lab=#net53}
N 8360 -7790 8370 -7800 {
lab=#net54}
N 8370 -7800 8570 -7800 {
lab=#net54}
N 8570 -7800 8580 -7790 {
lab=#net54}
N 8420 -7950 8420 -7930 {
lab=vcom}
N 8460 -7950 8460 -7930 {
lab=ctop}
N 8340 -7850 8360 -7850 {
lab=col_n[26]}
N 8340 -7830 8360 -7830 {
lab=colon_n[26]}
N 8340 -7810 8360 -7810 {
lab=#net53}
N 8340 -7790 8360 -7790 {
lab=#net54}
N 8580 -7790 8600 -7790 {
lab=#net54}
N 8580 -7810 8600 -7810 {
lab=#net53}
N 8580 -7830 8600 -7830 {
lab=colon_n[26]}
N 8580 -7850 8600 -7850 {
lab=col_n[26]}
N 8400 -7710 8400 -7700 {
lab=VSS}
N 8400 -7940 8400 -7930 {
lab=VDD}
N 8740 -7710 8750 -7720 {
lab=row_n[29]}
N 8750 -7920 8750 -7720 {
lab=row_n[29]}
N 8740 -7930 8750 -7920 {
lab=row_n[29]}
N 8740 -7710 8740 -7690 {
lab=row_n[29]}
N 8740 -7950 8740 -7930 {
lab=row_n[29]}
N 8620 -7850 8630 -7860 {
lab=col_n[26]}
N 8630 -7860 8830 -7860 {
lab=col_n[26]}
N 8830 -7860 8840 -7850 {
lab=col_n[26]}
N 8620 -7830 8630 -7840 {
lab=colon_n[26]}
N 8630 -7840 8830 -7840 {
lab=colon_n[26]}
N 8830 -7840 8840 -7830 {
lab=colon_n[26]}
N 8620 -7810 8630 -7820 {
lab=#net53}
N 8630 -7820 8830 -7820 {
lab=#net53}
N 8830 -7820 8840 -7810 {
lab=#net53}
N 8620 -7790 8630 -7800 {
lab=#net54}
N 8630 -7800 8830 -7800 {
lab=#net54}
N 8830 -7800 8840 -7790 {
lab=#net54}
N 8680 -7950 8680 -7930 {
lab=vcom}
N 8720 -7950 8720 -7930 {
lab=ctop}
N 8600 -7850 8620 -7850 {
lab=col_n[26]}
N 8600 -7830 8620 -7830 {
lab=colon_n[26]}
N 8600 -7810 8620 -7810 {
lab=#net53}
N 8600 -7790 8620 -7790 {
lab=#net54}
N 8840 -7790 8860 -7790 {
lab=#net54}
N 8840 -7810 8860 -7810 {
lab=#net53}
N 8840 -7830 8860 -7830 {
lab=colon_n[26]}
N 8840 -7850 8860 -7850 {
lab=col_n[26]}
N 8660 -7710 8660 -7700 {
lab=VSS}
N 8660 -7940 8660 -7930 {
lab=VDD}
N 9000 -7710 9010 -7720 {
lab=row_n[30]}
N 9010 -7920 9010 -7720 {
lab=row_n[30]}
N 9000 -7930 9010 -7920 {
lab=row_n[30]}
N 9000 -7710 9000 -7690 {
lab=row_n[30]}
N 9000 -7950 9000 -7930 {
lab=row_n[30]}
N 8880 -7850 8890 -7860 {
lab=col_n[26]}
N 8890 -7860 9090 -7860 {
lab=col_n[26]}
N 9090 -7860 9100 -7850 {
lab=col_n[26]}
N 8880 -7830 8890 -7840 {
lab=colon_n[26]}
N 8890 -7840 9090 -7840 {
lab=colon_n[26]}
N 9090 -7840 9100 -7830 {
lab=colon_n[26]}
N 8880 -7810 8890 -7820 {
lab=#net53}
N 8890 -7820 9090 -7820 {
lab=#net53}
N 9090 -7820 9100 -7810 {
lab=#net53}
N 8880 -7790 8890 -7800 {
lab=#net54}
N 8890 -7800 9090 -7800 {
lab=#net54}
N 9090 -7800 9100 -7790 {
lab=#net54}
N 8940 -7950 8940 -7930 {
lab=vcom}
N 8980 -7950 8980 -7930 {
lab=ctop}
N 8860 -7850 8880 -7850 {
lab=col_n[26]}
N 8860 -7830 8880 -7830 {
lab=colon_n[26]}
N 8860 -7810 8880 -7810 {
lab=#net53}
N 8860 -7790 8880 -7790 {
lab=#net54}
N 9100 -7790 9120 -7790 {
lab=#net54}
N 9100 -7810 9120 -7810 {
lab=#net53}
N 9100 -7830 9120 -7830 {
lab=colon_n[26]}
N 9100 -7850 9120 -7850 {
lab=col_n[26]}
N 8920 -7710 8920 -7700 {
lab=VSS}
N 8920 -7940 8920 -7930 {
lab=VDD}
N 9260 -7710 9270 -7720 {
lab=row_n[31]}
N 9270 -7920 9270 -7720 {
lab=row_n[31]}
N 9260 -7930 9270 -7920 {
lab=row_n[31]}
N 9260 -7710 9260 -7690 {
lab=row_n[31]}
N 9260 -7950 9260 -7930 {
lab=row_n[31]}
N 9140 -7850 9150 -7860 {
lab=col_n[26]}
N 9150 -7860 9350 -7860 {
lab=col_n[26]}
N 9350 -7860 9360 -7850 {
lab=col_n[26]}
N 9140 -7830 9150 -7840 {
lab=colon_n[26]}
N 9150 -7840 9350 -7840 {
lab=colon_n[26]}
N 9350 -7840 9360 -7830 {
lab=colon_n[26]}
N 9140 -7810 9150 -7820 {
lab=#net53}
N 9150 -7820 9350 -7820 {
lab=#net53}
N 9350 -7820 9360 -7810 {
lab=#net53}
N 9140 -7790 9150 -7800 {
lab=#net54}
N 9150 -7800 9350 -7800 {
lab=#net54}
N 9350 -7800 9360 -7790 {
lab=#net54}
N 9200 -7950 9200 -7930 {
lab=vcom}
N 9240 -7950 9240 -7930 {
lab=ctop}
N 9120 -7850 9140 -7850 {
lab=col_n[26]}
N 9120 -7830 9140 -7830 {
lab=colon_n[26]}
N 9120 -7810 9140 -7810 {
lab=#net53}
N 9120 -7790 9140 -7790 {
lab=#net54}
N 9360 -7790 9380 -7790 {
lab=#net54}
N 9360 -7810 9380 -7810 {
lab=#net53}
N 9360 -7830 9380 -7830 {
lab=colon_n[26]}
N 9360 -7850 9380 -7850 {
lab=col_n[26]}
N 9180 -7710 9180 -7700 {
lab=VSS}
N 9180 -7940 9180 -7930 {
lab=VDD}
N 1200 -7970 1210 -7980 {
lab=row_n[0]}
N 1210 -8180 1210 -7980 {
lab=row_n[0]}
N 1200 -8190 1210 -8180 {
lab=row_n[0]}
N 1200 -7970 1200 -7950 {
lab=row_n[0]}
N 1200 -8210 1200 -8190 {
lab=row_n[0]}
N 1080 -8110 1090 -8120 {
lab=col_n[27]}
N 1090 -8120 1290 -8120 {
lab=col_n[27]}
N 1290 -8120 1300 -8110 {
lab=col_n[27]}
N 1080 -8090 1090 -8100 {
lab=colon_n[27]}
N 1090 -8100 1290 -8100 {
lab=colon_n[27]}
N 1290 -8100 1300 -8090 {
lab=colon_n[27]}
N 1080 -8070 1090 -8080 {
lab=#net55}
N 1090 -8080 1290 -8080 {
lab=#net55}
N 1290 -8080 1300 -8070 {
lab=#net55}
N 1080 -8050 1090 -8060 {
lab=#net56}
N 1090 -8060 1290 -8060 {
lab=#net56}
N 1290 -8060 1300 -8050 {
lab=#net56}
N 1140 -8210 1140 -8190 {
lab=vcom}
N 1180 -8210 1180 -8190 {
lab=ctop}
N 1060 -8110 1080 -8110 {
lab=col_n[27]}
N 1060 -8090 1080 -8090 {
lab=colon_n[27]}
N 1060 -8070 1080 -8070 {
lab=#net55}
N 1060 -8050 1080 -8050 {
lab=#net56}
N 1300 -8050 1320 -8050 {
lab=#net56}
N 1300 -8070 1320 -8070 {
lab=#net55}
N 1300 -8090 1320 -8090 {
lab=colon_n[27]}
N 1300 -8110 1320 -8110 {
lab=col_n[27]}
N 1120 -7970 1120 -7960 {
lab=VSS}
N 1120 -8200 1120 -8190 {
lab=VDD}
N 1460 -7970 1470 -7980 {
lab=row_n[1]}
N 1470 -8180 1470 -7980 {
lab=row_n[1]}
N 1460 -8190 1470 -8180 {
lab=row_n[1]}
N 1460 -7970 1460 -7950 {
lab=row_n[1]}
N 1460 -8210 1460 -8190 {
lab=row_n[1]}
N 1340 -8110 1350 -8120 {
lab=col_n[27]}
N 1350 -8120 1550 -8120 {
lab=col_n[27]}
N 1550 -8120 1560 -8110 {
lab=col_n[27]}
N 1340 -8090 1350 -8100 {
lab=colon_n[27]}
N 1350 -8100 1550 -8100 {
lab=colon_n[27]}
N 1550 -8100 1560 -8090 {
lab=colon_n[27]}
N 1340 -8070 1350 -8080 {
lab=#net55}
N 1350 -8080 1550 -8080 {
lab=#net55}
N 1550 -8080 1560 -8070 {
lab=#net55}
N 1340 -8050 1350 -8060 {
lab=#net56}
N 1350 -8060 1550 -8060 {
lab=#net56}
N 1550 -8060 1560 -8050 {
lab=#net56}
N 1400 -8210 1400 -8190 {
lab=vcom}
N 1440 -8210 1440 -8190 {
lab=ctop}
N 1320 -8110 1340 -8110 {
lab=col_n[27]}
N 1320 -8090 1340 -8090 {
lab=colon_n[27]}
N 1320 -8070 1340 -8070 {
lab=#net55}
N 1320 -8050 1340 -8050 {
lab=#net56}
N 1560 -8050 1580 -8050 {
lab=#net56}
N 1560 -8070 1580 -8070 {
lab=#net55}
N 1560 -8090 1580 -8090 {
lab=colon_n[27]}
N 1560 -8110 1580 -8110 {
lab=col_n[27]}
N 1380 -7970 1380 -7960 {
lab=VSS}
N 1380 -8200 1380 -8190 {
lab=VDD}
N 1720 -7970 1730 -7980 {
lab=row_n[2]}
N 1730 -8180 1730 -7980 {
lab=row_n[2]}
N 1720 -8190 1730 -8180 {
lab=row_n[2]}
N 1720 -7970 1720 -7950 {
lab=row_n[2]}
N 1720 -8210 1720 -8190 {
lab=row_n[2]}
N 1600 -8110 1610 -8120 {
lab=col_n[27]}
N 1610 -8120 1810 -8120 {
lab=col_n[27]}
N 1810 -8120 1820 -8110 {
lab=col_n[27]}
N 1600 -8090 1610 -8100 {
lab=colon_n[27]}
N 1610 -8100 1810 -8100 {
lab=colon_n[27]}
N 1810 -8100 1820 -8090 {
lab=colon_n[27]}
N 1600 -8070 1610 -8080 {
lab=#net55}
N 1610 -8080 1810 -8080 {
lab=#net55}
N 1810 -8080 1820 -8070 {
lab=#net55}
N 1600 -8050 1610 -8060 {
lab=#net56}
N 1610 -8060 1810 -8060 {
lab=#net56}
N 1810 -8060 1820 -8050 {
lab=#net56}
N 1660 -8210 1660 -8190 {
lab=vcom}
N 1700 -8210 1700 -8190 {
lab=ctop}
N 1580 -8110 1600 -8110 {
lab=col_n[27]}
N 1580 -8090 1600 -8090 {
lab=colon_n[27]}
N 1580 -8070 1600 -8070 {
lab=#net55}
N 1580 -8050 1600 -8050 {
lab=#net56}
N 1820 -8050 1840 -8050 {
lab=#net56}
N 1820 -8070 1840 -8070 {
lab=#net55}
N 1820 -8090 1840 -8090 {
lab=colon_n[27]}
N 1820 -8110 1840 -8110 {
lab=col_n[27]}
N 1640 -7970 1640 -7960 {
lab=VSS}
N 1640 -8200 1640 -8190 {
lab=VDD}
N 1980 -7970 1990 -7980 {
lab=row_n[3]}
N 1990 -8180 1990 -7980 {
lab=row_n[3]}
N 1980 -8190 1990 -8180 {
lab=row_n[3]}
N 1980 -7970 1980 -7950 {
lab=row_n[3]}
N 1980 -8210 1980 -8190 {
lab=row_n[3]}
N 1860 -8110 1870 -8120 {
lab=col_n[27]}
N 1870 -8120 2070 -8120 {
lab=col_n[27]}
N 2070 -8120 2080 -8110 {
lab=col_n[27]}
N 1860 -8090 1870 -8100 {
lab=colon_n[27]}
N 1870 -8100 2070 -8100 {
lab=colon_n[27]}
N 2070 -8100 2080 -8090 {
lab=colon_n[27]}
N 1860 -8070 1870 -8080 {
lab=#net55}
N 1870 -8080 2070 -8080 {
lab=#net55}
N 2070 -8080 2080 -8070 {
lab=#net55}
N 1860 -8050 1870 -8060 {
lab=#net56}
N 1870 -8060 2070 -8060 {
lab=#net56}
N 2070 -8060 2080 -8050 {
lab=#net56}
N 1920 -8210 1920 -8190 {
lab=vcom}
N 1960 -8210 1960 -8190 {
lab=ctop}
N 1840 -8110 1860 -8110 {
lab=col_n[27]}
N 1840 -8090 1860 -8090 {
lab=colon_n[27]}
N 1840 -8070 1860 -8070 {
lab=#net55}
N 1840 -8050 1860 -8050 {
lab=#net56}
N 2080 -8050 2100 -8050 {
lab=#net56}
N 2080 -8070 2100 -8070 {
lab=#net55}
N 2080 -8090 2100 -8090 {
lab=colon_n[27]}
N 2080 -8110 2100 -8110 {
lab=col_n[27]}
N 1900 -7970 1900 -7960 {
lab=VSS}
N 1900 -8200 1900 -8190 {
lab=VDD}
N 2240 -7970 2250 -7980 {
lab=row_n[4]}
N 2250 -8180 2250 -7980 {
lab=row_n[4]}
N 2240 -8190 2250 -8180 {
lab=row_n[4]}
N 2240 -7970 2240 -7950 {
lab=row_n[4]}
N 2240 -8210 2240 -8190 {
lab=row_n[4]}
N 2120 -8110 2130 -8120 {
lab=col_n[27]}
N 2130 -8120 2330 -8120 {
lab=col_n[27]}
N 2330 -8120 2340 -8110 {
lab=col_n[27]}
N 2120 -8090 2130 -8100 {
lab=colon_n[27]}
N 2130 -8100 2330 -8100 {
lab=colon_n[27]}
N 2330 -8100 2340 -8090 {
lab=colon_n[27]}
N 2120 -8070 2130 -8080 {
lab=#net55}
N 2130 -8080 2330 -8080 {
lab=#net55}
N 2330 -8080 2340 -8070 {
lab=#net55}
N 2120 -8050 2130 -8060 {
lab=#net56}
N 2130 -8060 2330 -8060 {
lab=#net56}
N 2330 -8060 2340 -8050 {
lab=#net56}
N 2180 -8210 2180 -8190 {
lab=vcom}
N 2220 -8210 2220 -8190 {
lab=ctop}
N 2100 -8110 2120 -8110 {
lab=col_n[27]}
N 2100 -8090 2120 -8090 {
lab=colon_n[27]}
N 2100 -8070 2120 -8070 {
lab=#net55}
N 2100 -8050 2120 -8050 {
lab=#net56}
N 2340 -8050 2360 -8050 {
lab=#net56}
N 2340 -8070 2360 -8070 {
lab=#net55}
N 2340 -8090 2360 -8090 {
lab=colon_n[27]}
N 2340 -8110 2360 -8110 {
lab=col_n[27]}
N 2160 -7970 2160 -7960 {
lab=VSS}
N 2160 -8200 2160 -8190 {
lab=VDD}
N 2500 -7970 2510 -7980 {
lab=row_n[5]}
N 2510 -8180 2510 -7980 {
lab=row_n[5]}
N 2500 -8190 2510 -8180 {
lab=row_n[5]}
N 2500 -7970 2500 -7950 {
lab=row_n[5]}
N 2500 -8210 2500 -8190 {
lab=row_n[5]}
N 2380 -8110 2390 -8120 {
lab=col_n[27]}
N 2390 -8120 2590 -8120 {
lab=col_n[27]}
N 2590 -8120 2600 -8110 {
lab=col_n[27]}
N 2380 -8090 2390 -8100 {
lab=colon_n[27]}
N 2390 -8100 2590 -8100 {
lab=colon_n[27]}
N 2590 -8100 2600 -8090 {
lab=colon_n[27]}
N 2380 -8070 2390 -8080 {
lab=#net55}
N 2390 -8080 2590 -8080 {
lab=#net55}
N 2590 -8080 2600 -8070 {
lab=#net55}
N 2380 -8050 2390 -8060 {
lab=#net56}
N 2390 -8060 2590 -8060 {
lab=#net56}
N 2590 -8060 2600 -8050 {
lab=#net56}
N 2440 -8210 2440 -8190 {
lab=vcom}
N 2480 -8210 2480 -8190 {
lab=ctop}
N 2360 -8110 2380 -8110 {
lab=col_n[27]}
N 2360 -8090 2380 -8090 {
lab=colon_n[27]}
N 2360 -8070 2380 -8070 {
lab=#net55}
N 2360 -8050 2380 -8050 {
lab=#net56}
N 2600 -8050 2620 -8050 {
lab=#net56}
N 2600 -8070 2620 -8070 {
lab=#net55}
N 2600 -8090 2620 -8090 {
lab=colon_n[27]}
N 2600 -8110 2620 -8110 {
lab=col_n[27]}
N 2420 -7970 2420 -7960 {
lab=VSS}
N 2420 -8200 2420 -8190 {
lab=VDD}
N 2760 -7970 2770 -7980 {
lab=row_n[6]}
N 2770 -8180 2770 -7980 {
lab=row_n[6]}
N 2760 -8190 2770 -8180 {
lab=row_n[6]}
N 2760 -7970 2760 -7950 {
lab=row_n[6]}
N 2760 -8210 2760 -8190 {
lab=row_n[6]}
N 2640 -8110 2650 -8120 {
lab=col_n[27]}
N 2650 -8120 2850 -8120 {
lab=col_n[27]}
N 2850 -8120 2860 -8110 {
lab=col_n[27]}
N 2640 -8090 2650 -8100 {
lab=colon_n[27]}
N 2650 -8100 2850 -8100 {
lab=colon_n[27]}
N 2850 -8100 2860 -8090 {
lab=colon_n[27]}
N 2640 -8070 2650 -8080 {
lab=#net55}
N 2650 -8080 2850 -8080 {
lab=#net55}
N 2850 -8080 2860 -8070 {
lab=#net55}
N 2640 -8050 2650 -8060 {
lab=#net56}
N 2650 -8060 2850 -8060 {
lab=#net56}
N 2850 -8060 2860 -8050 {
lab=#net56}
N 2700 -8210 2700 -8190 {
lab=vcom}
N 2740 -8210 2740 -8190 {
lab=ctop}
N 2620 -8110 2640 -8110 {
lab=col_n[27]}
N 2620 -8090 2640 -8090 {
lab=colon_n[27]}
N 2620 -8070 2640 -8070 {
lab=#net55}
N 2620 -8050 2640 -8050 {
lab=#net56}
N 2860 -8050 2880 -8050 {
lab=#net56}
N 2860 -8070 2880 -8070 {
lab=#net55}
N 2860 -8090 2880 -8090 {
lab=colon_n[27]}
N 2860 -8110 2880 -8110 {
lab=col_n[27]}
N 2680 -7970 2680 -7960 {
lab=VSS}
N 2680 -8200 2680 -8190 {
lab=VDD}
N 3020 -7970 3030 -7980 {
lab=row_n[7]}
N 3030 -8180 3030 -7980 {
lab=row_n[7]}
N 3020 -8190 3030 -8180 {
lab=row_n[7]}
N 3020 -7970 3020 -7950 {
lab=row_n[7]}
N 3020 -8210 3020 -8190 {
lab=row_n[7]}
N 2900 -8110 2910 -8120 {
lab=col_n[27]}
N 2910 -8120 3110 -8120 {
lab=col_n[27]}
N 3110 -8120 3120 -8110 {
lab=col_n[27]}
N 2900 -8090 2910 -8100 {
lab=colon_n[27]}
N 2910 -8100 3110 -8100 {
lab=colon_n[27]}
N 3110 -8100 3120 -8090 {
lab=colon_n[27]}
N 2900 -8070 2910 -8080 {
lab=#net55}
N 2910 -8080 3110 -8080 {
lab=#net55}
N 3110 -8080 3120 -8070 {
lab=#net55}
N 2900 -8050 2910 -8060 {
lab=#net56}
N 2910 -8060 3110 -8060 {
lab=#net56}
N 3110 -8060 3120 -8050 {
lab=#net56}
N 2960 -8210 2960 -8190 {
lab=vcom}
N 3000 -8210 3000 -8190 {
lab=ctop}
N 2880 -8110 2900 -8110 {
lab=col_n[27]}
N 2880 -8090 2900 -8090 {
lab=colon_n[27]}
N 2880 -8070 2900 -8070 {
lab=#net55}
N 2880 -8050 2900 -8050 {
lab=#net56}
N 3120 -8050 3140 -8050 {
lab=#net56}
N 3120 -8070 3140 -8070 {
lab=#net55}
N 3120 -8090 3140 -8090 {
lab=colon_n[27]}
N 3120 -8110 3140 -8110 {
lab=col_n[27]}
N 2940 -7970 2940 -7960 {
lab=VSS}
N 2940 -8200 2940 -8190 {
lab=VDD}
N 3280 -7970 3290 -7980 {
lab=row_n[8]}
N 3290 -8180 3290 -7980 {
lab=row_n[8]}
N 3280 -8190 3290 -8180 {
lab=row_n[8]}
N 3280 -7970 3280 -7950 {
lab=row_n[8]}
N 3280 -8210 3280 -8190 {
lab=row_n[8]}
N 3160 -8110 3170 -8120 {
lab=col_n[27]}
N 3170 -8120 3370 -8120 {
lab=col_n[27]}
N 3370 -8120 3380 -8110 {
lab=col_n[27]}
N 3160 -8090 3170 -8100 {
lab=colon_n[27]}
N 3170 -8100 3370 -8100 {
lab=colon_n[27]}
N 3370 -8100 3380 -8090 {
lab=colon_n[27]}
N 3160 -8070 3170 -8080 {
lab=#net55}
N 3170 -8080 3370 -8080 {
lab=#net55}
N 3370 -8080 3380 -8070 {
lab=#net55}
N 3160 -8050 3170 -8060 {
lab=#net56}
N 3170 -8060 3370 -8060 {
lab=#net56}
N 3370 -8060 3380 -8050 {
lab=#net56}
N 3220 -8210 3220 -8190 {
lab=vcom}
N 3260 -8210 3260 -8190 {
lab=ctop}
N 3140 -8110 3160 -8110 {
lab=col_n[27]}
N 3140 -8090 3160 -8090 {
lab=colon_n[27]}
N 3140 -8070 3160 -8070 {
lab=#net55}
N 3140 -8050 3160 -8050 {
lab=#net56}
N 3380 -8050 3400 -8050 {
lab=#net56}
N 3380 -8070 3400 -8070 {
lab=#net55}
N 3380 -8090 3400 -8090 {
lab=colon_n[27]}
N 3380 -8110 3400 -8110 {
lab=col_n[27]}
N 3200 -7970 3200 -7960 {
lab=VSS}
N 3200 -8200 3200 -8190 {
lab=VDD}
N 3540 -7970 3550 -7980 {
lab=row_n[9]}
N 3550 -8180 3550 -7980 {
lab=row_n[9]}
N 3540 -8190 3550 -8180 {
lab=row_n[9]}
N 3540 -7970 3540 -7950 {
lab=row_n[9]}
N 3540 -8210 3540 -8190 {
lab=row_n[9]}
N 3420 -8110 3430 -8120 {
lab=col_n[27]}
N 3430 -8120 3630 -8120 {
lab=col_n[27]}
N 3630 -8120 3640 -8110 {
lab=col_n[27]}
N 3420 -8090 3430 -8100 {
lab=colon_n[27]}
N 3430 -8100 3630 -8100 {
lab=colon_n[27]}
N 3630 -8100 3640 -8090 {
lab=colon_n[27]}
N 3420 -8070 3430 -8080 {
lab=#net55}
N 3430 -8080 3630 -8080 {
lab=#net55}
N 3630 -8080 3640 -8070 {
lab=#net55}
N 3420 -8050 3430 -8060 {
lab=#net56}
N 3430 -8060 3630 -8060 {
lab=#net56}
N 3630 -8060 3640 -8050 {
lab=#net56}
N 3480 -8210 3480 -8190 {
lab=vcom}
N 3520 -8210 3520 -8190 {
lab=ctop}
N 3400 -8110 3420 -8110 {
lab=col_n[27]}
N 3400 -8090 3420 -8090 {
lab=colon_n[27]}
N 3400 -8070 3420 -8070 {
lab=#net55}
N 3400 -8050 3420 -8050 {
lab=#net56}
N 3640 -8050 3660 -8050 {
lab=#net56}
N 3640 -8070 3660 -8070 {
lab=#net55}
N 3640 -8090 3660 -8090 {
lab=colon_n[27]}
N 3640 -8110 3660 -8110 {
lab=col_n[27]}
N 3460 -7970 3460 -7960 {
lab=VSS}
N 3460 -8200 3460 -8190 {
lab=VDD}
N 3800 -7970 3810 -7980 {
lab=row_n[10]}
N 3810 -8180 3810 -7980 {
lab=row_n[10]}
N 3800 -8190 3810 -8180 {
lab=row_n[10]}
N 3800 -7970 3800 -7950 {
lab=row_n[10]}
N 3800 -8210 3800 -8190 {
lab=row_n[10]}
N 3680 -8110 3690 -8120 {
lab=col_n[27]}
N 3690 -8120 3890 -8120 {
lab=col_n[27]}
N 3890 -8120 3900 -8110 {
lab=col_n[27]}
N 3680 -8090 3690 -8100 {
lab=colon_n[27]}
N 3690 -8100 3890 -8100 {
lab=colon_n[27]}
N 3890 -8100 3900 -8090 {
lab=colon_n[27]}
N 3680 -8070 3690 -8080 {
lab=#net55}
N 3690 -8080 3890 -8080 {
lab=#net55}
N 3890 -8080 3900 -8070 {
lab=#net55}
N 3680 -8050 3690 -8060 {
lab=#net56}
N 3690 -8060 3890 -8060 {
lab=#net56}
N 3890 -8060 3900 -8050 {
lab=#net56}
N 3740 -8210 3740 -8190 {
lab=vcom}
N 3780 -8210 3780 -8190 {
lab=ctop}
N 3660 -8110 3680 -8110 {
lab=col_n[27]}
N 3660 -8090 3680 -8090 {
lab=colon_n[27]}
N 3660 -8070 3680 -8070 {
lab=#net55}
N 3660 -8050 3680 -8050 {
lab=#net56}
N 3900 -8050 3920 -8050 {
lab=#net56}
N 3900 -8070 3920 -8070 {
lab=#net55}
N 3900 -8090 3920 -8090 {
lab=colon_n[27]}
N 3900 -8110 3920 -8110 {
lab=col_n[27]}
N 3720 -7970 3720 -7960 {
lab=VSS}
N 3720 -8200 3720 -8190 {
lab=VDD}
N 4060 -7970 4070 -7980 {
lab=row_n[11]}
N 4070 -8180 4070 -7980 {
lab=row_n[11]}
N 4060 -8190 4070 -8180 {
lab=row_n[11]}
N 4060 -7970 4060 -7950 {
lab=row_n[11]}
N 4060 -8210 4060 -8190 {
lab=row_n[11]}
N 3940 -8110 3950 -8120 {
lab=col_n[27]}
N 3950 -8120 4150 -8120 {
lab=col_n[27]}
N 4150 -8120 4160 -8110 {
lab=col_n[27]}
N 3940 -8090 3950 -8100 {
lab=colon_n[27]}
N 3950 -8100 4150 -8100 {
lab=colon_n[27]}
N 4150 -8100 4160 -8090 {
lab=colon_n[27]}
N 3940 -8070 3950 -8080 {
lab=#net55}
N 3950 -8080 4150 -8080 {
lab=#net55}
N 4150 -8080 4160 -8070 {
lab=#net55}
N 3940 -8050 3950 -8060 {
lab=#net56}
N 3950 -8060 4150 -8060 {
lab=#net56}
N 4150 -8060 4160 -8050 {
lab=#net56}
N 4000 -8210 4000 -8190 {
lab=vcom}
N 4040 -8210 4040 -8190 {
lab=ctop}
N 3920 -8110 3940 -8110 {
lab=col_n[27]}
N 3920 -8090 3940 -8090 {
lab=colon_n[27]}
N 3920 -8070 3940 -8070 {
lab=#net55}
N 3920 -8050 3940 -8050 {
lab=#net56}
N 4160 -8050 4180 -8050 {
lab=#net56}
N 4160 -8070 4180 -8070 {
lab=#net55}
N 4160 -8090 4180 -8090 {
lab=colon_n[27]}
N 4160 -8110 4180 -8110 {
lab=col_n[27]}
N 3980 -7970 3980 -7960 {
lab=VSS}
N 3980 -8200 3980 -8190 {
lab=VDD}
N 4320 -7970 4330 -7980 {
lab=row_n[12]}
N 4330 -8180 4330 -7980 {
lab=row_n[12]}
N 4320 -8190 4330 -8180 {
lab=row_n[12]}
N 4320 -7970 4320 -7950 {
lab=row_n[12]}
N 4320 -8210 4320 -8190 {
lab=row_n[12]}
N 4200 -8110 4210 -8120 {
lab=col_n[27]}
N 4210 -8120 4410 -8120 {
lab=col_n[27]}
N 4410 -8120 4420 -8110 {
lab=col_n[27]}
N 4200 -8090 4210 -8100 {
lab=colon_n[27]}
N 4210 -8100 4410 -8100 {
lab=colon_n[27]}
N 4410 -8100 4420 -8090 {
lab=colon_n[27]}
N 4200 -8070 4210 -8080 {
lab=#net55}
N 4210 -8080 4410 -8080 {
lab=#net55}
N 4410 -8080 4420 -8070 {
lab=#net55}
N 4200 -8050 4210 -8060 {
lab=#net56}
N 4210 -8060 4410 -8060 {
lab=#net56}
N 4410 -8060 4420 -8050 {
lab=#net56}
N 4260 -8210 4260 -8190 {
lab=vcom}
N 4300 -8210 4300 -8190 {
lab=ctop}
N 4180 -8110 4200 -8110 {
lab=col_n[27]}
N 4180 -8090 4200 -8090 {
lab=colon_n[27]}
N 4180 -8070 4200 -8070 {
lab=#net55}
N 4180 -8050 4200 -8050 {
lab=#net56}
N 4420 -8050 4440 -8050 {
lab=#net56}
N 4420 -8070 4440 -8070 {
lab=#net55}
N 4420 -8090 4440 -8090 {
lab=colon_n[27]}
N 4420 -8110 4440 -8110 {
lab=col_n[27]}
N 4240 -7970 4240 -7960 {
lab=VSS}
N 4240 -8200 4240 -8190 {
lab=VDD}
N 4580 -7970 4590 -7980 {
lab=row_n[13]}
N 4590 -8180 4590 -7980 {
lab=row_n[13]}
N 4580 -8190 4590 -8180 {
lab=row_n[13]}
N 4580 -7970 4580 -7950 {
lab=row_n[13]}
N 4580 -8210 4580 -8190 {
lab=row_n[13]}
N 4460 -8110 4470 -8120 {
lab=col_n[27]}
N 4470 -8120 4670 -8120 {
lab=col_n[27]}
N 4670 -8120 4680 -8110 {
lab=col_n[27]}
N 4460 -8090 4470 -8100 {
lab=colon_n[27]}
N 4470 -8100 4670 -8100 {
lab=colon_n[27]}
N 4670 -8100 4680 -8090 {
lab=colon_n[27]}
N 4460 -8070 4470 -8080 {
lab=#net55}
N 4470 -8080 4670 -8080 {
lab=#net55}
N 4670 -8080 4680 -8070 {
lab=#net55}
N 4460 -8050 4470 -8060 {
lab=#net56}
N 4470 -8060 4670 -8060 {
lab=#net56}
N 4670 -8060 4680 -8050 {
lab=#net56}
N 4520 -8210 4520 -8190 {
lab=vcom}
N 4560 -8210 4560 -8190 {
lab=ctop}
N 4440 -8110 4460 -8110 {
lab=col_n[27]}
N 4440 -8090 4460 -8090 {
lab=colon_n[27]}
N 4440 -8070 4460 -8070 {
lab=#net55}
N 4440 -8050 4460 -8050 {
lab=#net56}
N 4680 -8050 4700 -8050 {
lab=#net56}
N 4680 -8070 4700 -8070 {
lab=#net55}
N 4680 -8090 4700 -8090 {
lab=colon_n[27]}
N 4680 -8110 4700 -8110 {
lab=col_n[27]}
N 4500 -7970 4500 -7960 {
lab=VSS}
N 4500 -8200 4500 -8190 {
lab=VDD}
N 4840 -7970 4850 -7980 {
lab=row_n[14]}
N 4850 -8180 4850 -7980 {
lab=row_n[14]}
N 4840 -8190 4850 -8180 {
lab=row_n[14]}
N 4840 -7970 4840 -7950 {
lab=row_n[14]}
N 4840 -8210 4840 -8190 {
lab=row_n[14]}
N 4720 -8110 4730 -8120 {
lab=col_n[27]}
N 4730 -8120 4930 -8120 {
lab=col_n[27]}
N 4930 -8120 4940 -8110 {
lab=col_n[27]}
N 4720 -8090 4730 -8100 {
lab=colon_n[27]}
N 4730 -8100 4930 -8100 {
lab=colon_n[27]}
N 4930 -8100 4940 -8090 {
lab=colon_n[27]}
N 4720 -8070 4730 -8080 {
lab=#net55}
N 4730 -8080 4930 -8080 {
lab=#net55}
N 4930 -8080 4940 -8070 {
lab=#net55}
N 4720 -8050 4730 -8060 {
lab=#net56}
N 4730 -8060 4930 -8060 {
lab=#net56}
N 4930 -8060 4940 -8050 {
lab=#net56}
N 4780 -8210 4780 -8190 {
lab=vcom}
N 4820 -8210 4820 -8190 {
lab=ctop}
N 4700 -8110 4720 -8110 {
lab=col_n[27]}
N 4700 -8090 4720 -8090 {
lab=colon_n[27]}
N 4700 -8070 4720 -8070 {
lab=#net55}
N 4700 -8050 4720 -8050 {
lab=#net56}
N 4940 -8050 4960 -8050 {
lab=#net56}
N 4940 -8070 4960 -8070 {
lab=#net55}
N 4940 -8090 4960 -8090 {
lab=colon_n[27]}
N 4940 -8110 4960 -8110 {
lab=col_n[27]}
N 4760 -7970 4760 -7960 {
lab=VSS}
N 4760 -8200 4760 -8190 {
lab=VDD}
N 5100 -7970 5110 -7980 {
lab=row_n[15]}
N 5110 -8180 5110 -7980 {
lab=row_n[15]}
N 5100 -8190 5110 -8180 {
lab=row_n[15]}
N 5100 -7970 5100 -7950 {
lab=row_n[15]}
N 5100 -8210 5100 -8190 {
lab=row_n[15]}
N 4980 -8110 4990 -8120 {
lab=col_n[27]}
N 4990 -8120 5190 -8120 {
lab=col_n[27]}
N 5190 -8120 5200 -8110 {
lab=col_n[27]}
N 4980 -8090 4990 -8100 {
lab=colon_n[27]}
N 4990 -8100 5190 -8100 {
lab=colon_n[27]}
N 5190 -8100 5200 -8090 {
lab=colon_n[27]}
N 4980 -8070 4990 -8080 {
lab=#net55}
N 4990 -8080 5190 -8080 {
lab=#net55}
N 5190 -8080 5200 -8070 {
lab=#net55}
N 4980 -8050 4990 -8060 {
lab=#net56}
N 4990 -8060 5190 -8060 {
lab=#net56}
N 5190 -8060 5200 -8050 {
lab=#net56}
N 5040 -8210 5040 -8190 {
lab=vcom}
N 5080 -8210 5080 -8190 {
lab=ctop}
N 4960 -8110 4980 -8110 {
lab=col_n[27]}
N 4960 -8090 4980 -8090 {
lab=colon_n[27]}
N 4960 -8070 4980 -8070 {
lab=#net55}
N 4960 -8050 4980 -8050 {
lab=#net56}
N 5200 -8050 5220 -8050 {
lab=#net56}
N 5200 -8070 5220 -8070 {
lab=#net55}
N 5200 -8090 5220 -8090 {
lab=colon_n[27]}
N 5200 -8110 5220 -8110 {
lab=col_n[27]}
N 5020 -7970 5020 -7960 {
lab=VSS}
N 5020 -8200 5020 -8190 {
lab=VDD}
N 5360 -7970 5370 -7980 {
lab=row_n[16]}
N 5370 -8180 5370 -7980 {
lab=row_n[16]}
N 5360 -8190 5370 -8180 {
lab=row_n[16]}
N 5360 -7970 5360 -7950 {
lab=row_n[16]}
N 5360 -8210 5360 -8190 {
lab=row_n[16]}
N 5240 -8110 5250 -8120 {
lab=col_n[27]}
N 5250 -8120 5450 -8120 {
lab=col_n[27]}
N 5450 -8120 5460 -8110 {
lab=col_n[27]}
N 5240 -8090 5250 -8100 {
lab=colon_n[27]}
N 5250 -8100 5450 -8100 {
lab=colon_n[27]}
N 5450 -8100 5460 -8090 {
lab=colon_n[27]}
N 5240 -8070 5250 -8080 {
lab=#net55}
N 5250 -8080 5450 -8080 {
lab=#net55}
N 5450 -8080 5460 -8070 {
lab=#net55}
N 5240 -8050 5250 -8060 {
lab=#net56}
N 5250 -8060 5450 -8060 {
lab=#net56}
N 5450 -8060 5460 -8050 {
lab=#net56}
N 5300 -8210 5300 -8190 {
lab=vcom}
N 5340 -8210 5340 -8190 {
lab=ctop}
N 5220 -8110 5240 -8110 {
lab=col_n[27]}
N 5220 -8090 5240 -8090 {
lab=colon_n[27]}
N 5220 -8070 5240 -8070 {
lab=#net55}
N 5220 -8050 5240 -8050 {
lab=#net56}
N 5460 -8050 5480 -8050 {
lab=#net56}
N 5460 -8070 5480 -8070 {
lab=#net55}
N 5460 -8090 5480 -8090 {
lab=colon_n[27]}
N 5460 -8110 5480 -8110 {
lab=col_n[27]}
N 5280 -7970 5280 -7960 {
lab=VSS}
N 5280 -8200 5280 -8190 {
lab=VDD}
N 5620 -7970 5630 -7980 {
lab=row_n[17]}
N 5630 -8180 5630 -7980 {
lab=row_n[17]}
N 5620 -8190 5630 -8180 {
lab=row_n[17]}
N 5620 -7970 5620 -7950 {
lab=row_n[17]}
N 5620 -8210 5620 -8190 {
lab=row_n[17]}
N 5500 -8110 5510 -8120 {
lab=col_n[27]}
N 5510 -8120 5710 -8120 {
lab=col_n[27]}
N 5710 -8120 5720 -8110 {
lab=col_n[27]}
N 5500 -8090 5510 -8100 {
lab=colon_n[27]}
N 5510 -8100 5710 -8100 {
lab=colon_n[27]}
N 5710 -8100 5720 -8090 {
lab=colon_n[27]}
N 5500 -8070 5510 -8080 {
lab=#net55}
N 5510 -8080 5710 -8080 {
lab=#net55}
N 5710 -8080 5720 -8070 {
lab=#net55}
N 5500 -8050 5510 -8060 {
lab=#net56}
N 5510 -8060 5710 -8060 {
lab=#net56}
N 5710 -8060 5720 -8050 {
lab=#net56}
N 5560 -8210 5560 -8190 {
lab=vcom}
N 5600 -8210 5600 -8190 {
lab=ctop}
N 5480 -8110 5500 -8110 {
lab=col_n[27]}
N 5480 -8090 5500 -8090 {
lab=colon_n[27]}
N 5480 -8070 5500 -8070 {
lab=#net55}
N 5480 -8050 5500 -8050 {
lab=#net56}
N 5720 -8050 5740 -8050 {
lab=#net56}
N 5720 -8070 5740 -8070 {
lab=#net55}
N 5720 -8090 5740 -8090 {
lab=colon_n[27]}
N 5720 -8110 5740 -8110 {
lab=col_n[27]}
N 5540 -7970 5540 -7960 {
lab=VSS}
N 5540 -8200 5540 -8190 {
lab=VDD}
N 5880 -7970 5890 -7980 {
lab=row_n[18]}
N 5890 -8180 5890 -7980 {
lab=row_n[18]}
N 5880 -8190 5890 -8180 {
lab=row_n[18]}
N 5880 -7970 5880 -7950 {
lab=row_n[18]}
N 5880 -8210 5880 -8190 {
lab=row_n[18]}
N 5760 -8110 5770 -8120 {
lab=col_n[27]}
N 5770 -8120 5970 -8120 {
lab=col_n[27]}
N 5970 -8120 5980 -8110 {
lab=col_n[27]}
N 5760 -8090 5770 -8100 {
lab=colon_n[27]}
N 5770 -8100 5970 -8100 {
lab=colon_n[27]}
N 5970 -8100 5980 -8090 {
lab=colon_n[27]}
N 5760 -8070 5770 -8080 {
lab=#net55}
N 5770 -8080 5970 -8080 {
lab=#net55}
N 5970 -8080 5980 -8070 {
lab=#net55}
N 5760 -8050 5770 -8060 {
lab=#net56}
N 5770 -8060 5970 -8060 {
lab=#net56}
N 5970 -8060 5980 -8050 {
lab=#net56}
N 5820 -8210 5820 -8190 {
lab=vcom}
N 5860 -8210 5860 -8190 {
lab=ctop}
N 5740 -8110 5760 -8110 {
lab=col_n[27]}
N 5740 -8090 5760 -8090 {
lab=colon_n[27]}
N 5740 -8070 5760 -8070 {
lab=#net55}
N 5740 -8050 5760 -8050 {
lab=#net56}
N 5980 -8050 6000 -8050 {
lab=#net56}
N 5980 -8070 6000 -8070 {
lab=#net55}
N 5980 -8090 6000 -8090 {
lab=colon_n[27]}
N 5980 -8110 6000 -8110 {
lab=col_n[27]}
N 5800 -7970 5800 -7960 {
lab=VSS}
N 5800 -8200 5800 -8190 {
lab=VDD}
N 6140 -7970 6150 -7980 {
lab=row_n[19]}
N 6150 -8180 6150 -7980 {
lab=row_n[19]}
N 6140 -8190 6150 -8180 {
lab=row_n[19]}
N 6140 -7970 6140 -7950 {
lab=row_n[19]}
N 6140 -8210 6140 -8190 {
lab=row_n[19]}
N 6020 -8110 6030 -8120 {
lab=col_n[27]}
N 6030 -8120 6230 -8120 {
lab=col_n[27]}
N 6230 -8120 6240 -8110 {
lab=col_n[27]}
N 6020 -8090 6030 -8100 {
lab=colon_n[27]}
N 6030 -8100 6230 -8100 {
lab=colon_n[27]}
N 6230 -8100 6240 -8090 {
lab=colon_n[27]}
N 6020 -8070 6030 -8080 {
lab=#net55}
N 6030 -8080 6230 -8080 {
lab=#net55}
N 6230 -8080 6240 -8070 {
lab=#net55}
N 6020 -8050 6030 -8060 {
lab=#net56}
N 6030 -8060 6230 -8060 {
lab=#net56}
N 6230 -8060 6240 -8050 {
lab=#net56}
N 6080 -8210 6080 -8190 {
lab=vcom}
N 6120 -8210 6120 -8190 {
lab=ctop}
N 6000 -8110 6020 -8110 {
lab=col_n[27]}
N 6000 -8090 6020 -8090 {
lab=colon_n[27]}
N 6000 -8070 6020 -8070 {
lab=#net55}
N 6000 -8050 6020 -8050 {
lab=#net56}
N 6240 -8050 6260 -8050 {
lab=#net56}
N 6240 -8070 6260 -8070 {
lab=#net55}
N 6240 -8090 6260 -8090 {
lab=colon_n[27]}
N 6240 -8110 6260 -8110 {
lab=col_n[27]}
N 6060 -7970 6060 -7960 {
lab=VSS}
N 6060 -8200 6060 -8190 {
lab=VDD}
N 6400 -7970 6410 -7980 {
lab=row_n[20]}
N 6410 -8180 6410 -7980 {
lab=row_n[20]}
N 6400 -8190 6410 -8180 {
lab=row_n[20]}
N 6400 -7970 6400 -7950 {
lab=row_n[20]}
N 6400 -8210 6400 -8190 {
lab=row_n[20]}
N 6280 -8110 6290 -8120 {
lab=col_n[27]}
N 6290 -8120 6490 -8120 {
lab=col_n[27]}
N 6490 -8120 6500 -8110 {
lab=col_n[27]}
N 6280 -8090 6290 -8100 {
lab=colon_n[27]}
N 6290 -8100 6490 -8100 {
lab=colon_n[27]}
N 6490 -8100 6500 -8090 {
lab=colon_n[27]}
N 6280 -8070 6290 -8080 {
lab=#net55}
N 6290 -8080 6490 -8080 {
lab=#net55}
N 6490 -8080 6500 -8070 {
lab=#net55}
N 6280 -8050 6290 -8060 {
lab=#net56}
N 6290 -8060 6490 -8060 {
lab=#net56}
N 6490 -8060 6500 -8050 {
lab=#net56}
N 6340 -8210 6340 -8190 {
lab=vcom}
N 6380 -8210 6380 -8190 {
lab=ctop}
N 6260 -8110 6280 -8110 {
lab=col_n[27]}
N 6260 -8090 6280 -8090 {
lab=colon_n[27]}
N 6260 -8070 6280 -8070 {
lab=#net55}
N 6260 -8050 6280 -8050 {
lab=#net56}
N 6500 -8050 6520 -8050 {
lab=#net56}
N 6500 -8070 6520 -8070 {
lab=#net55}
N 6500 -8090 6520 -8090 {
lab=colon_n[27]}
N 6500 -8110 6520 -8110 {
lab=col_n[27]}
N 6320 -7970 6320 -7960 {
lab=VSS}
N 6320 -8200 6320 -8190 {
lab=VDD}
N 6660 -7970 6670 -7980 {
lab=row_n[21]}
N 6670 -8180 6670 -7980 {
lab=row_n[21]}
N 6660 -8190 6670 -8180 {
lab=row_n[21]}
N 6660 -7970 6660 -7950 {
lab=row_n[21]}
N 6660 -8210 6660 -8190 {
lab=row_n[21]}
N 6540 -8110 6550 -8120 {
lab=col_n[27]}
N 6550 -8120 6750 -8120 {
lab=col_n[27]}
N 6750 -8120 6760 -8110 {
lab=col_n[27]}
N 6540 -8090 6550 -8100 {
lab=colon_n[27]}
N 6550 -8100 6750 -8100 {
lab=colon_n[27]}
N 6750 -8100 6760 -8090 {
lab=colon_n[27]}
N 6540 -8070 6550 -8080 {
lab=#net55}
N 6550 -8080 6750 -8080 {
lab=#net55}
N 6750 -8080 6760 -8070 {
lab=#net55}
N 6540 -8050 6550 -8060 {
lab=#net56}
N 6550 -8060 6750 -8060 {
lab=#net56}
N 6750 -8060 6760 -8050 {
lab=#net56}
N 6600 -8210 6600 -8190 {
lab=vcom}
N 6640 -8210 6640 -8190 {
lab=ctop}
N 6520 -8110 6540 -8110 {
lab=col_n[27]}
N 6520 -8090 6540 -8090 {
lab=colon_n[27]}
N 6520 -8070 6540 -8070 {
lab=#net55}
N 6520 -8050 6540 -8050 {
lab=#net56}
N 6760 -8050 6780 -8050 {
lab=#net56}
N 6760 -8070 6780 -8070 {
lab=#net55}
N 6760 -8090 6780 -8090 {
lab=colon_n[27]}
N 6760 -8110 6780 -8110 {
lab=col_n[27]}
N 6580 -7970 6580 -7960 {
lab=VSS}
N 6580 -8200 6580 -8190 {
lab=VDD}
N 6920 -7970 6930 -7980 {
lab=row_n[22]}
N 6930 -8180 6930 -7980 {
lab=row_n[22]}
N 6920 -8190 6930 -8180 {
lab=row_n[22]}
N 6920 -7970 6920 -7950 {
lab=row_n[22]}
N 6920 -8210 6920 -8190 {
lab=row_n[22]}
N 6800 -8110 6810 -8120 {
lab=col_n[27]}
N 6810 -8120 7010 -8120 {
lab=col_n[27]}
N 7010 -8120 7020 -8110 {
lab=col_n[27]}
N 6800 -8090 6810 -8100 {
lab=colon_n[27]}
N 6810 -8100 7010 -8100 {
lab=colon_n[27]}
N 7010 -8100 7020 -8090 {
lab=colon_n[27]}
N 6800 -8070 6810 -8080 {
lab=#net55}
N 6810 -8080 7010 -8080 {
lab=#net55}
N 7010 -8080 7020 -8070 {
lab=#net55}
N 6800 -8050 6810 -8060 {
lab=#net56}
N 6810 -8060 7010 -8060 {
lab=#net56}
N 7010 -8060 7020 -8050 {
lab=#net56}
N 6860 -8210 6860 -8190 {
lab=vcom}
N 6900 -8210 6900 -8190 {
lab=ctop}
N 6780 -8110 6800 -8110 {
lab=col_n[27]}
N 6780 -8090 6800 -8090 {
lab=colon_n[27]}
N 6780 -8070 6800 -8070 {
lab=#net55}
N 6780 -8050 6800 -8050 {
lab=#net56}
N 7020 -8050 7040 -8050 {
lab=#net56}
N 7020 -8070 7040 -8070 {
lab=#net55}
N 7020 -8090 7040 -8090 {
lab=colon_n[27]}
N 7020 -8110 7040 -8110 {
lab=col_n[27]}
N 6840 -7970 6840 -7960 {
lab=VSS}
N 6840 -8200 6840 -8190 {
lab=VDD}
N 7180 -7970 7190 -7980 {
lab=row_n[23]}
N 7190 -8180 7190 -7980 {
lab=row_n[23]}
N 7180 -8190 7190 -8180 {
lab=row_n[23]}
N 7180 -7970 7180 -7950 {
lab=row_n[23]}
N 7180 -8210 7180 -8190 {
lab=row_n[23]}
N 7060 -8110 7070 -8120 {
lab=col_n[27]}
N 7070 -8120 7270 -8120 {
lab=col_n[27]}
N 7270 -8120 7280 -8110 {
lab=col_n[27]}
N 7060 -8090 7070 -8100 {
lab=colon_n[27]}
N 7070 -8100 7270 -8100 {
lab=colon_n[27]}
N 7270 -8100 7280 -8090 {
lab=colon_n[27]}
N 7060 -8070 7070 -8080 {
lab=#net55}
N 7070 -8080 7270 -8080 {
lab=#net55}
N 7270 -8080 7280 -8070 {
lab=#net55}
N 7060 -8050 7070 -8060 {
lab=#net56}
N 7070 -8060 7270 -8060 {
lab=#net56}
N 7270 -8060 7280 -8050 {
lab=#net56}
N 7120 -8210 7120 -8190 {
lab=vcom}
N 7160 -8210 7160 -8190 {
lab=ctop}
N 7040 -8110 7060 -8110 {
lab=col_n[27]}
N 7040 -8090 7060 -8090 {
lab=colon_n[27]}
N 7040 -8070 7060 -8070 {
lab=#net55}
N 7040 -8050 7060 -8050 {
lab=#net56}
N 7280 -8050 7300 -8050 {
lab=#net56}
N 7280 -8070 7300 -8070 {
lab=#net55}
N 7280 -8090 7300 -8090 {
lab=colon_n[27]}
N 7280 -8110 7300 -8110 {
lab=col_n[27]}
N 7100 -7970 7100 -7960 {
lab=VSS}
N 7100 -8200 7100 -8190 {
lab=VDD}
N 7440 -7970 7450 -7980 {
lab=row_n[24]}
N 7450 -8180 7450 -7980 {
lab=row_n[24]}
N 7440 -8190 7450 -8180 {
lab=row_n[24]}
N 7440 -7970 7440 -7950 {
lab=row_n[24]}
N 7440 -8210 7440 -8190 {
lab=row_n[24]}
N 7320 -8110 7330 -8120 {
lab=col_n[27]}
N 7330 -8120 7530 -8120 {
lab=col_n[27]}
N 7530 -8120 7540 -8110 {
lab=col_n[27]}
N 7320 -8090 7330 -8100 {
lab=colon_n[27]}
N 7330 -8100 7530 -8100 {
lab=colon_n[27]}
N 7530 -8100 7540 -8090 {
lab=colon_n[27]}
N 7320 -8070 7330 -8080 {
lab=#net55}
N 7330 -8080 7530 -8080 {
lab=#net55}
N 7530 -8080 7540 -8070 {
lab=#net55}
N 7320 -8050 7330 -8060 {
lab=#net56}
N 7330 -8060 7530 -8060 {
lab=#net56}
N 7530 -8060 7540 -8050 {
lab=#net56}
N 7380 -8210 7380 -8190 {
lab=vcom}
N 7420 -8210 7420 -8190 {
lab=ctop}
N 7300 -8110 7320 -8110 {
lab=col_n[27]}
N 7300 -8090 7320 -8090 {
lab=colon_n[27]}
N 7300 -8070 7320 -8070 {
lab=#net55}
N 7300 -8050 7320 -8050 {
lab=#net56}
N 7540 -8050 7560 -8050 {
lab=#net56}
N 7540 -8070 7560 -8070 {
lab=#net55}
N 7540 -8090 7560 -8090 {
lab=colon_n[27]}
N 7540 -8110 7560 -8110 {
lab=col_n[27]}
N 7360 -7970 7360 -7960 {
lab=VSS}
N 7360 -8200 7360 -8190 {
lab=VDD}
N 7700 -7970 7710 -7980 {
lab=row_n[25]}
N 7710 -8180 7710 -7980 {
lab=row_n[25]}
N 7700 -8190 7710 -8180 {
lab=row_n[25]}
N 7700 -7970 7700 -7950 {
lab=row_n[25]}
N 7700 -8210 7700 -8190 {
lab=row_n[25]}
N 7580 -8110 7590 -8120 {
lab=col_n[27]}
N 7590 -8120 7790 -8120 {
lab=col_n[27]}
N 7790 -8120 7800 -8110 {
lab=col_n[27]}
N 7580 -8090 7590 -8100 {
lab=colon_n[27]}
N 7590 -8100 7790 -8100 {
lab=colon_n[27]}
N 7790 -8100 7800 -8090 {
lab=colon_n[27]}
N 7580 -8070 7590 -8080 {
lab=#net55}
N 7590 -8080 7790 -8080 {
lab=#net55}
N 7790 -8080 7800 -8070 {
lab=#net55}
N 7580 -8050 7590 -8060 {
lab=#net56}
N 7590 -8060 7790 -8060 {
lab=#net56}
N 7790 -8060 7800 -8050 {
lab=#net56}
N 7640 -8210 7640 -8190 {
lab=vcom}
N 7680 -8210 7680 -8190 {
lab=ctop}
N 7560 -8110 7580 -8110 {
lab=col_n[27]}
N 7560 -8090 7580 -8090 {
lab=colon_n[27]}
N 7560 -8070 7580 -8070 {
lab=#net55}
N 7560 -8050 7580 -8050 {
lab=#net56}
N 7800 -8050 7820 -8050 {
lab=#net56}
N 7800 -8070 7820 -8070 {
lab=#net55}
N 7800 -8090 7820 -8090 {
lab=colon_n[27]}
N 7800 -8110 7820 -8110 {
lab=col_n[27]}
N 7620 -7970 7620 -7960 {
lab=VSS}
N 7620 -8200 7620 -8190 {
lab=VDD}
N 7960 -7970 7970 -7980 {
lab=row_n[26]}
N 7970 -8180 7970 -7980 {
lab=row_n[26]}
N 7960 -8190 7970 -8180 {
lab=row_n[26]}
N 7960 -7970 7960 -7950 {
lab=row_n[26]}
N 7960 -8210 7960 -8190 {
lab=row_n[26]}
N 7840 -8110 7850 -8120 {
lab=col_n[27]}
N 7850 -8120 8050 -8120 {
lab=col_n[27]}
N 8050 -8120 8060 -8110 {
lab=col_n[27]}
N 7840 -8090 7850 -8100 {
lab=colon_n[27]}
N 7850 -8100 8050 -8100 {
lab=colon_n[27]}
N 8050 -8100 8060 -8090 {
lab=colon_n[27]}
N 7840 -8070 7850 -8080 {
lab=#net55}
N 7850 -8080 8050 -8080 {
lab=#net55}
N 8050 -8080 8060 -8070 {
lab=#net55}
N 7840 -8050 7850 -8060 {
lab=#net56}
N 7850 -8060 8050 -8060 {
lab=#net56}
N 8050 -8060 8060 -8050 {
lab=#net56}
N 7900 -8210 7900 -8190 {
lab=vcom}
N 7940 -8210 7940 -8190 {
lab=ctop}
N 7820 -8110 7840 -8110 {
lab=col_n[27]}
N 7820 -8090 7840 -8090 {
lab=colon_n[27]}
N 7820 -8070 7840 -8070 {
lab=#net55}
N 7820 -8050 7840 -8050 {
lab=#net56}
N 8060 -8050 8080 -8050 {
lab=#net56}
N 8060 -8070 8080 -8070 {
lab=#net55}
N 8060 -8090 8080 -8090 {
lab=colon_n[27]}
N 8060 -8110 8080 -8110 {
lab=col_n[27]}
N 7880 -7970 7880 -7960 {
lab=VSS}
N 7880 -8200 7880 -8190 {
lab=VDD}
N 8220 -7970 8230 -7980 {
lab=row_n[27]}
N 8230 -8180 8230 -7980 {
lab=row_n[27]}
N 8220 -8190 8230 -8180 {
lab=row_n[27]}
N 8220 -7970 8220 -7950 {
lab=row_n[27]}
N 8220 -8210 8220 -8190 {
lab=row_n[27]}
N 8100 -8110 8110 -8120 {
lab=col_n[27]}
N 8110 -8120 8310 -8120 {
lab=col_n[27]}
N 8310 -8120 8320 -8110 {
lab=col_n[27]}
N 8100 -8090 8110 -8100 {
lab=colon_n[27]}
N 8110 -8100 8310 -8100 {
lab=colon_n[27]}
N 8310 -8100 8320 -8090 {
lab=colon_n[27]}
N 8100 -8070 8110 -8080 {
lab=#net55}
N 8110 -8080 8310 -8080 {
lab=#net55}
N 8310 -8080 8320 -8070 {
lab=#net55}
N 8100 -8050 8110 -8060 {
lab=#net56}
N 8110 -8060 8310 -8060 {
lab=#net56}
N 8310 -8060 8320 -8050 {
lab=#net56}
N 8160 -8210 8160 -8190 {
lab=vcom}
N 8200 -8210 8200 -8190 {
lab=ctop}
N 8080 -8110 8100 -8110 {
lab=col_n[27]}
N 8080 -8090 8100 -8090 {
lab=colon_n[27]}
N 8080 -8070 8100 -8070 {
lab=#net55}
N 8080 -8050 8100 -8050 {
lab=#net56}
N 8320 -8050 8340 -8050 {
lab=#net56}
N 8320 -8070 8340 -8070 {
lab=#net55}
N 8320 -8090 8340 -8090 {
lab=colon_n[27]}
N 8320 -8110 8340 -8110 {
lab=col_n[27]}
N 8140 -7970 8140 -7960 {
lab=VSS}
N 8140 -8200 8140 -8190 {
lab=VDD}
N 8480 -7970 8490 -7980 {
lab=row_n[28]}
N 8490 -8180 8490 -7980 {
lab=row_n[28]}
N 8480 -8190 8490 -8180 {
lab=row_n[28]}
N 8480 -7970 8480 -7950 {
lab=row_n[28]}
N 8480 -8210 8480 -8190 {
lab=row_n[28]}
N 8360 -8110 8370 -8120 {
lab=col_n[27]}
N 8370 -8120 8570 -8120 {
lab=col_n[27]}
N 8570 -8120 8580 -8110 {
lab=col_n[27]}
N 8360 -8090 8370 -8100 {
lab=colon_n[27]}
N 8370 -8100 8570 -8100 {
lab=colon_n[27]}
N 8570 -8100 8580 -8090 {
lab=colon_n[27]}
N 8360 -8070 8370 -8080 {
lab=#net55}
N 8370 -8080 8570 -8080 {
lab=#net55}
N 8570 -8080 8580 -8070 {
lab=#net55}
N 8360 -8050 8370 -8060 {
lab=#net56}
N 8370 -8060 8570 -8060 {
lab=#net56}
N 8570 -8060 8580 -8050 {
lab=#net56}
N 8420 -8210 8420 -8190 {
lab=vcom}
N 8460 -8210 8460 -8190 {
lab=ctop}
N 8340 -8110 8360 -8110 {
lab=col_n[27]}
N 8340 -8090 8360 -8090 {
lab=colon_n[27]}
N 8340 -8070 8360 -8070 {
lab=#net55}
N 8340 -8050 8360 -8050 {
lab=#net56}
N 8580 -8050 8600 -8050 {
lab=#net56}
N 8580 -8070 8600 -8070 {
lab=#net55}
N 8580 -8090 8600 -8090 {
lab=colon_n[27]}
N 8580 -8110 8600 -8110 {
lab=col_n[27]}
N 8400 -7970 8400 -7960 {
lab=VSS}
N 8400 -8200 8400 -8190 {
lab=VDD}
N 8740 -7970 8750 -7980 {
lab=row_n[29]}
N 8750 -8180 8750 -7980 {
lab=row_n[29]}
N 8740 -8190 8750 -8180 {
lab=row_n[29]}
N 8740 -7970 8740 -7950 {
lab=row_n[29]}
N 8740 -8210 8740 -8190 {
lab=row_n[29]}
N 8620 -8110 8630 -8120 {
lab=col_n[27]}
N 8630 -8120 8830 -8120 {
lab=col_n[27]}
N 8830 -8120 8840 -8110 {
lab=col_n[27]}
N 8620 -8090 8630 -8100 {
lab=colon_n[27]}
N 8630 -8100 8830 -8100 {
lab=colon_n[27]}
N 8830 -8100 8840 -8090 {
lab=colon_n[27]}
N 8620 -8070 8630 -8080 {
lab=#net55}
N 8630 -8080 8830 -8080 {
lab=#net55}
N 8830 -8080 8840 -8070 {
lab=#net55}
N 8620 -8050 8630 -8060 {
lab=#net56}
N 8630 -8060 8830 -8060 {
lab=#net56}
N 8830 -8060 8840 -8050 {
lab=#net56}
N 8680 -8210 8680 -8190 {
lab=vcom}
N 8720 -8210 8720 -8190 {
lab=ctop}
N 8600 -8110 8620 -8110 {
lab=col_n[27]}
N 8600 -8090 8620 -8090 {
lab=colon_n[27]}
N 8600 -8070 8620 -8070 {
lab=#net55}
N 8600 -8050 8620 -8050 {
lab=#net56}
N 8840 -8050 8860 -8050 {
lab=#net56}
N 8840 -8070 8860 -8070 {
lab=#net55}
N 8840 -8090 8860 -8090 {
lab=colon_n[27]}
N 8840 -8110 8860 -8110 {
lab=col_n[27]}
N 8660 -7970 8660 -7960 {
lab=VSS}
N 8660 -8200 8660 -8190 {
lab=VDD}
N 9000 -7970 9010 -7980 {
lab=row_n[30]}
N 9010 -8180 9010 -7980 {
lab=row_n[30]}
N 9000 -8190 9010 -8180 {
lab=row_n[30]}
N 9000 -7970 9000 -7950 {
lab=row_n[30]}
N 9000 -8210 9000 -8190 {
lab=row_n[30]}
N 8880 -8110 8890 -8120 {
lab=col_n[27]}
N 8890 -8120 9090 -8120 {
lab=col_n[27]}
N 9090 -8120 9100 -8110 {
lab=col_n[27]}
N 8880 -8090 8890 -8100 {
lab=colon_n[27]}
N 8890 -8100 9090 -8100 {
lab=colon_n[27]}
N 9090 -8100 9100 -8090 {
lab=colon_n[27]}
N 8880 -8070 8890 -8080 {
lab=#net55}
N 8890 -8080 9090 -8080 {
lab=#net55}
N 9090 -8080 9100 -8070 {
lab=#net55}
N 8880 -8050 8890 -8060 {
lab=#net56}
N 8890 -8060 9090 -8060 {
lab=#net56}
N 9090 -8060 9100 -8050 {
lab=#net56}
N 8940 -8210 8940 -8190 {
lab=vcom}
N 8980 -8210 8980 -8190 {
lab=ctop}
N 8860 -8110 8880 -8110 {
lab=col_n[27]}
N 8860 -8090 8880 -8090 {
lab=colon_n[27]}
N 8860 -8070 8880 -8070 {
lab=#net55}
N 8860 -8050 8880 -8050 {
lab=#net56}
N 9100 -8050 9120 -8050 {
lab=#net56}
N 9100 -8070 9120 -8070 {
lab=#net55}
N 9100 -8090 9120 -8090 {
lab=colon_n[27]}
N 9100 -8110 9120 -8110 {
lab=col_n[27]}
N 8920 -7970 8920 -7960 {
lab=VSS}
N 8920 -8200 8920 -8190 {
lab=VDD}
N 9260 -7970 9270 -7980 {
lab=row_n[31]}
N 9270 -8180 9270 -7980 {
lab=row_n[31]}
N 9260 -8190 9270 -8180 {
lab=row_n[31]}
N 9260 -7970 9260 -7950 {
lab=row_n[31]}
N 9260 -8210 9260 -8190 {
lab=row_n[31]}
N 9140 -8110 9150 -8120 {
lab=col_n[27]}
N 9150 -8120 9350 -8120 {
lab=col_n[27]}
N 9350 -8120 9360 -8110 {
lab=col_n[27]}
N 9140 -8090 9150 -8100 {
lab=colon_n[27]}
N 9150 -8100 9350 -8100 {
lab=colon_n[27]}
N 9350 -8100 9360 -8090 {
lab=colon_n[27]}
N 9140 -8070 9150 -8080 {
lab=#net55}
N 9150 -8080 9350 -8080 {
lab=#net55}
N 9350 -8080 9360 -8070 {
lab=#net55}
N 9140 -8050 9150 -8060 {
lab=#net56}
N 9150 -8060 9350 -8060 {
lab=#net56}
N 9350 -8060 9360 -8050 {
lab=#net56}
N 9200 -8210 9200 -8190 {
lab=vcom}
N 9240 -8210 9240 -8190 {
lab=ctop}
N 9120 -8110 9140 -8110 {
lab=col_n[27]}
N 9120 -8090 9140 -8090 {
lab=colon_n[27]}
N 9120 -8070 9140 -8070 {
lab=#net55}
N 9120 -8050 9140 -8050 {
lab=#net56}
N 9360 -8050 9380 -8050 {
lab=#net56}
N 9360 -8070 9380 -8070 {
lab=#net55}
N 9360 -8090 9380 -8090 {
lab=colon_n[27]}
N 9360 -8110 9380 -8110 {
lab=col_n[27]}
N 9180 -7970 9180 -7960 {
lab=VSS}
N 9180 -8200 9180 -8190 {
lab=VDD}
N 1200 -8230 1210 -8240 {
lab=row_n[0]}
N 1210 -8440 1210 -8240 {
lab=row_n[0]}
N 1200 -8450 1210 -8440 {
lab=row_n[0]}
N 1200 -8230 1200 -8210 {
lab=row_n[0]}
N 1200 -8470 1200 -8450 {
lab=row_n[0]}
N 1080 -8370 1090 -8380 {
lab=col_n[28]}
N 1090 -8380 1290 -8380 {
lab=col_n[28]}
N 1290 -8380 1300 -8370 {
lab=col_n[28]}
N 1080 -8350 1090 -8360 {
lab=colon_n[28]}
N 1090 -8360 1290 -8360 {
lab=colon_n[28]}
N 1290 -8360 1300 -8350 {
lab=colon_n[28]}
N 1080 -8330 1090 -8340 {
lab=#net57}
N 1090 -8340 1290 -8340 {
lab=#net57}
N 1290 -8340 1300 -8330 {
lab=#net57}
N 1080 -8310 1090 -8320 {
lab=#net58}
N 1090 -8320 1290 -8320 {
lab=#net58}
N 1290 -8320 1300 -8310 {
lab=#net58}
N 1140 -8470 1140 -8450 {
lab=vcom}
N 1180 -8470 1180 -8450 {
lab=ctop}
N 1060 -8370 1080 -8370 {
lab=col_n[28]}
N 1060 -8350 1080 -8350 {
lab=colon_n[28]}
N 1060 -8330 1080 -8330 {
lab=#net57}
N 1060 -8310 1080 -8310 {
lab=#net58}
N 1300 -8310 1320 -8310 {
lab=#net58}
N 1300 -8330 1320 -8330 {
lab=#net57}
N 1300 -8350 1320 -8350 {
lab=colon_n[28]}
N 1300 -8370 1320 -8370 {
lab=col_n[28]}
N 1120 -8230 1120 -8220 {
lab=VSS}
N 1120 -8460 1120 -8450 {
lab=VDD}
N 1460 -8230 1470 -8240 {
lab=row_n[1]}
N 1470 -8440 1470 -8240 {
lab=row_n[1]}
N 1460 -8450 1470 -8440 {
lab=row_n[1]}
N 1460 -8230 1460 -8210 {
lab=row_n[1]}
N 1460 -8470 1460 -8450 {
lab=row_n[1]}
N 1340 -8370 1350 -8380 {
lab=col_n[28]}
N 1350 -8380 1550 -8380 {
lab=col_n[28]}
N 1550 -8380 1560 -8370 {
lab=col_n[28]}
N 1340 -8350 1350 -8360 {
lab=colon_n[28]}
N 1350 -8360 1550 -8360 {
lab=colon_n[28]}
N 1550 -8360 1560 -8350 {
lab=colon_n[28]}
N 1340 -8330 1350 -8340 {
lab=#net57}
N 1350 -8340 1550 -8340 {
lab=#net57}
N 1550 -8340 1560 -8330 {
lab=#net57}
N 1340 -8310 1350 -8320 {
lab=#net58}
N 1350 -8320 1550 -8320 {
lab=#net58}
N 1550 -8320 1560 -8310 {
lab=#net58}
N 1400 -8470 1400 -8450 {
lab=vcom}
N 1440 -8470 1440 -8450 {
lab=ctop}
N 1320 -8370 1340 -8370 {
lab=col_n[28]}
N 1320 -8350 1340 -8350 {
lab=colon_n[28]}
N 1320 -8330 1340 -8330 {
lab=#net57}
N 1320 -8310 1340 -8310 {
lab=#net58}
N 1560 -8310 1580 -8310 {
lab=#net58}
N 1560 -8330 1580 -8330 {
lab=#net57}
N 1560 -8350 1580 -8350 {
lab=colon_n[28]}
N 1560 -8370 1580 -8370 {
lab=col_n[28]}
N 1380 -8230 1380 -8220 {
lab=VSS}
N 1380 -8460 1380 -8450 {
lab=VDD}
N 1720 -8230 1730 -8240 {
lab=row_n[2]}
N 1730 -8440 1730 -8240 {
lab=row_n[2]}
N 1720 -8450 1730 -8440 {
lab=row_n[2]}
N 1720 -8230 1720 -8210 {
lab=row_n[2]}
N 1720 -8470 1720 -8450 {
lab=row_n[2]}
N 1600 -8370 1610 -8380 {
lab=col_n[28]}
N 1610 -8380 1810 -8380 {
lab=col_n[28]}
N 1810 -8380 1820 -8370 {
lab=col_n[28]}
N 1600 -8350 1610 -8360 {
lab=colon_n[28]}
N 1610 -8360 1810 -8360 {
lab=colon_n[28]}
N 1810 -8360 1820 -8350 {
lab=colon_n[28]}
N 1600 -8330 1610 -8340 {
lab=#net57}
N 1610 -8340 1810 -8340 {
lab=#net57}
N 1810 -8340 1820 -8330 {
lab=#net57}
N 1600 -8310 1610 -8320 {
lab=#net58}
N 1610 -8320 1810 -8320 {
lab=#net58}
N 1810 -8320 1820 -8310 {
lab=#net58}
N 1660 -8470 1660 -8450 {
lab=vcom}
N 1700 -8470 1700 -8450 {
lab=ctop}
N 1580 -8370 1600 -8370 {
lab=col_n[28]}
N 1580 -8350 1600 -8350 {
lab=colon_n[28]}
N 1580 -8330 1600 -8330 {
lab=#net57}
N 1580 -8310 1600 -8310 {
lab=#net58}
N 1820 -8310 1840 -8310 {
lab=#net58}
N 1820 -8330 1840 -8330 {
lab=#net57}
N 1820 -8350 1840 -8350 {
lab=colon_n[28]}
N 1820 -8370 1840 -8370 {
lab=col_n[28]}
N 1640 -8230 1640 -8220 {
lab=VSS}
N 1640 -8460 1640 -8450 {
lab=VDD}
N 1980 -8230 1990 -8240 {
lab=row_n[3]}
N 1990 -8440 1990 -8240 {
lab=row_n[3]}
N 1980 -8450 1990 -8440 {
lab=row_n[3]}
N 1980 -8230 1980 -8210 {
lab=row_n[3]}
N 1980 -8470 1980 -8450 {
lab=row_n[3]}
N 1860 -8370 1870 -8380 {
lab=col_n[28]}
N 1870 -8380 2070 -8380 {
lab=col_n[28]}
N 2070 -8380 2080 -8370 {
lab=col_n[28]}
N 1860 -8350 1870 -8360 {
lab=colon_n[28]}
N 1870 -8360 2070 -8360 {
lab=colon_n[28]}
N 2070 -8360 2080 -8350 {
lab=colon_n[28]}
N 1860 -8330 1870 -8340 {
lab=#net57}
N 1870 -8340 2070 -8340 {
lab=#net57}
N 2070 -8340 2080 -8330 {
lab=#net57}
N 1860 -8310 1870 -8320 {
lab=#net58}
N 1870 -8320 2070 -8320 {
lab=#net58}
N 2070 -8320 2080 -8310 {
lab=#net58}
N 1920 -8470 1920 -8450 {
lab=vcom}
N 1960 -8470 1960 -8450 {
lab=ctop}
N 1840 -8370 1860 -8370 {
lab=col_n[28]}
N 1840 -8350 1860 -8350 {
lab=colon_n[28]}
N 1840 -8330 1860 -8330 {
lab=#net57}
N 1840 -8310 1860 -8310 {
lab=#net58}
N 2080 -8310 2100 -8310 {
lab=#net58}
N 2080 -8330 2100 -8330 {
lab=#net57}
N 2080 -8350 2100 -8350 {
lab=colon_n[28]}
N 2080 -8370 2100 -8370 {
lab=col_n[28]}
N 1900 -8230 1900 -8220 {
lab=VSS}
N 1900 -8460 1900 -8450 {
lab=VDD}
N 2240 -8230 2250 -8240 {
lab=row_n[4]}
N 2250 -8440 2250 -8240 {
lab=row_n[4]}
N 2240 -8450 2250 -8440 {
lab=row_n[4]}
N 2240 -8230 2240 -8210 {
lab=row_n[4]}
N 2240 -8470 2240 -8450 {
lab=row_n[4]}
N 2120 -8370 2130 -8380 {
lab=col_n[28]}
N 2130 -8380 2330 -8380 {
lab=col_n[28]}
N 2330 -8380 2340 -8370 {
lab=col_n[28]}
N 2120 -8350 2130 -8360 {
lab=colon_n[28]}
N 2130 -8360 2330 -8360 {
lab=colon_n[28]}
N 2330 -8360 2340 -8350 {
lab=colon_n[28]}
N 2120 -8330 2130 -8340 {
lab=#net57}
N 2130 -8340 2330 -8340 {
lab=#net57}
N 2330 -8340 2340 -8330 {
lab=#net57}
N 2120 -8310 2130 -8320 {
lab=#net58}
N 2130 -8320 2330 -8320 {
lab=#net58}
N 2330 -8320 2340 -8310 {
lab=#net58}
N 2180 -8470 2180 -8450 {
lab=vcom}
N 2220 -8470 2220 -8450 {
lab=ctop}
N 2100 -8370 2120 -8370 {
lab=col_n[28]}
N 2100 -8350 2120 -8350 {
lab=colon_n[28]}
N 2100 -8330 2120 -8330 {
lab=#net57}
N 2100 -8310 2120 -8310 {
lab=#net58}
N 2340 -8310 2360 -8310 {
lab=#net58}
N 2340 -8330 2360 -8330 {
lab=#net57}
N 2340 -8350 2360 -8350 {
lab=colon_n[28]}
N 2340 -8370 2360 -8370 {
lab=col_n[28]}
N 2160 -8230 2160 -8220 {
lab=VSS}
N 2160 -8460 2160 -8450 {
lab=VDD}
N 2500 -8230 2510 -8240 {
lab=row_n[5]}
N 2510 -8440 2510 -8240 {
lab=row_n[5]}
N 2500 -8450 2510 -8440 {
lab=row_n[5]}
N 2500 -8230 2500 -8210 {
lab=row_n[5]}
N 2500 -8470 2500 -8450 {
lab=row_n[5]}
N 2380 -8370 2390 -8380 {
lab=col_n[28]}
N 2390 -8380 2590 -8380 {
lab=col_n[28]}
N 2590 -8380 2600 -8370 {
lab=col_n[28]}
N 2380 -8350 2390 -8360 {
lab=colon_n[28]}
N 2390 -8360 2590 -8360 {
lab=colon_n[28]}
N 2590 -8360 2600 -8350 {
lab=colon_n[28]}
N 2380 -8330 2390 -8340 {
lab=#net57}
N 2390 -8340 2590 -8340 {
lab=#net57}
N 2590 -8340 2600 -8330 {
lab=#net57}
N 2380 -8310 2390 -8320 {
lab=#net58}
N 2390 -8320 2590 -8320 {
lab=#net58}
N 2590 -8320 2600 -8310 {
lab=#net58}
N 2440 -8470 2440 -8450 {
lab=vcom}
N 2480 -8470 2480 -8450 {
lab=ctop}
N 2360 -8370 2380 -8370 {
lab=col_n[28]}
N 2360 -8350 2380 -8350 {
lab=colon_n[28]}
N 2360 -8330 2380 -8330 {
lab=#net57}
N 2360 -8310 2380 -8310 {
lab=#net58}
N 2600 -8310 2620 -8310 {
lab=#net58}
N 2600 -8330 2620 -8330 {
lab=#net57}
N 2600 -8350 2620 -8350 {
lab=colon_n[28]}
N 2600 -8370 2620 -8370 {
lab=col_n[28]}
N 2420 -8230 2420 -8220 {
lab=VSS}
N 2420 -8460 2420 -8450 {
lab=VDD}
N 2760 -8230 2770 -8240 {
lab=row_n[6]}
N 2770 -8440 2770 -8240 {
lab=row_n[6]}
N 2760 -8450 2770 -8440 {
lab=row_n[6]}
N 2760 -8230 2760 -8210 {
lab=row_n[6]}
N 2760 -8470 2760 -8450 {
lab=row_n[6]}
N 2640 -8370 2650 -8380 {
lab=col_n[28]}
N 2650 -8380 2850 -8380 {
lab=col_n[28]}
N 2850 -8380 2860 -8370 {
lab=col_n[28]}
N 2640 -8350 2650 -8360 {
lab=colon_n[28]}
N 2650 -8360 2850 -8360 {
lab=colon_n[28]}
N 2850 -8360 2860 -8350 {
lab=colon_n[28]}
N 2640 -8330 2650 -8340 {
lab=#net57}
N 2650 -8340 2850 -8340 {
lab=#net57}
N 2850 -8340 2860 -8330 {
lab=#net57}
N 2640 -8310 2650 -8320 {
lab=#net58}
N 2650 -8320 2850 -8320 {
lab=#net58}
N 2850 -8320 2860 -8310 {
lab=#net58}
N 2700 -8470 2700 -8450 {
lab=vcom}
N 2740 -8470 2740 -8450 {
lab=ctop}
N 2620 -8370 2640 -8370 {
lab=col_n[28]}
N 2620 -8350 2640 -8350 {
lab=colon_n[28]}
N 2620 -8330 2640 -8330 {
lab=#net57}
N 2620 -8310 2640 -8310 {
lab=#net58}
N 2860 -8310 2880 -8310 {
lab=#net58}
N 2860 -8330 2880 -8330 {
lab=#net57}
N 2860 -8350 2880 -8350 {
lab=colon_n[28]}
N 2860 -8370 2880 -8370 {
lab=col_n[28]}
N 2680 -8230 2680 -8220 {
lab=VSS}
N 2680 -8460 2680 -8450 {
lab=VDD}
N 3020 -8230 3030 -8240 {
lab=row_n[7]}
N 3030 -8440 3030 -8240 {
lab=row_n[7]}
N 3020 -8450 3030 -8440 {
lab=row_n[7]}
N 3020 -8230 3020 -8210 {
lab=row_n[7]}
N 3020 -8470 3020 -8450 {
lab=row_n[7]}
N 2900 -8370 2910 -8380 {
lab=col_n[28]}
N 2910 -8380 3110 -8380 {
lab=col_n[28]}
N 3110 -8380 3120 -8370 {
lab=col_n[28]}
N 2900 -8350 2910 -8360 {
lab=colon_n[28]}
N 2910 -8360 3110 -8360 {
lab=colon_n[28]}
N 3110 -8360 3120 -8350 {
lab=colon_n[28]}
N 2900 -8330 2910 -8340 {
lab=#net57}
N 2910 -8340 3110 -8340 {
lab=#net57}
N 3110 -8340 3120 -8330 {
lab=#net57}
N 2900 -8310 2910 -8320 {
lab=#net58}
N 2910 -8320 3110 -8320 {
lab=#net58}
N 3110 -8320 3120 -8310 {
lab=#net58}
N 2960 -8470 2960 -8450 {
lab=vcom}
N 3000 -8470 3000 -8450 {
lab=ctop}
N 2880 -8370 2900 -8370 {
lab=col_n[28]}
N 2880 -8350 2900 -8350 {
lab=colon_n[28]}
N 2880 -8330 2900 -8330 {
lab=#net57}
N 2880 -8310 2900 -8310 {
lab=#net58}
N 3120 -8310 3140 -8310 {
lab=#net58}
N 3120 -8330 3140 -8330 {
lab=#net57}
N 3120 -8350 3140 -8350 {
lab=colon_n[28]}
N 3120 -8370 3140 -8370 {
lab=col_n[28]}
N 2940 -8230 2940 -8220 {
lab=VSS}
N 2940 -8460 2940 -8450 {
lab=VDD}
N 3280 -8230 3290 -8240 {
lab=row_n[8]}
N 3290 -8440 3290 -8240 {
lab=row_n[8]}
N 3280 -8450 3290 -8440 {
lab=row_n[8]}
N 3280 -8230 3280 -8210 {
lab=row_n[8]}
N 3280 -8470 3280 -8450 {
lab=row_n[8]}
N 3160 -8370 3170 -8380 {
lab=col_n[28]}
N 3170 -8380 3370 -8380 {
lab=col_n[28]}
N 3370 -8380 3380 -8370 {
lab=col_n[28]}
N 3160 -8350 3170 -8360 {
lab=colon_n[28]}
N 3170 -8360 3370 -8360 {
lab=colon_n[28]}
N 3370 -8360 3380 -8350 {
lab=colon_n[28]}
N 3160 -8330 3170 -8340 {
lab=#net57}
N 3170 -8340 3370 -8340 {
lab=#net57}
N 3370 -8340 3380 -8330 {
lab=#net57}
N 3160 -8310 3170 -8320 {
lab=#net58}
N 3170 -8320 3370 -8320 {
lab=#net58}
N 3370 -8320 3380 -8310 {
lab=#net58}
N 3220 -8470 3220 -8450 {
lab=vcom}
N 3260 -8470 3260 -8450 {
lab=ctop}
N 3140 -8370 3160 -8370 {
lab=col_n[28]}
N 3140 -8350 3160 -8350 {
lab=colon_n[28]}
N 3140 -8330 3160 -8330 {
lab=#net57}
N 3140 -8310 3160 -8310 {
lab=#net58}
N 3380 -8310 3400 -8310 {
lab=#net58}
N 3380 -8330 3400 -8330 {
lab=#net57}
N 3380 -8350 3400 -8350 {
lab=colon_n[28]}
N 3380 -8370 3400 -8370 {
lab=col_n[28]}
N 3200 -8230 3200 -8220 {
lab=VSS}
N 3200 -8460 3200 -8450 {
lab=VDD}
N 3540 -8230 3550 -8240 {
lab=row_n[9]}
N 3550 -8440 3550 -8240 {
lab=row_n[9]}
N 3540 -8450 3550 -8440 {
lab=row_n[9]}
N 3540 -8230 3540 -8210 {
lab=row_n[9]}
N 3540 -8470 3540 -8450 {
lab=row_n[9]}
N 3420 -8370 3430 -8380 {
lab=col_n[28]}
N 3430 -8380 3630 -8380 {
lab=col_n[28]}
N 3630 -8380 3640 -8370 {
lab=col_n[28]}
N 3420 -8350 3430 -8360 {
lab=colon_n[28]}
N 3430 -8360 3630 -8360 {
lab=colon_n[28]}
N 3630 -8360 3640 -8350 {
lab=colon_n[28]}
N 3420 -8330 3430 -8340 {
lab=#net57}
N 3430 -8340 3630 -8340 {
lab=#net57}
N 3630 -8340 3640 -8330 {
lab=#net57}
N 3420 -8310 3430 -8320 {
lab=#net58}
N 3430 -8320 3630 -8320 {
lab=#net58}
N 3630 -8320 3640 -8310 {
lab=#net58}
N 3480 -8470 3480 -8450 {
lab=vcom}
N 3520 -8470 3520 -8450 {
lab=ctop}
N 3400 -8370 3420 -8370 {
lab=col_n[28]}
N 3400 -8350 3420 -8350 {
lab=colon_n[28]}
N 3400 -8330 3420 -8330 {
lab=#net57}
N 3400 -8310 3420 -8310 {
lab=#net58}
N 3640 -8310 3660 -8310 {
lab=#net58}
N 3640 -8330 3660 -8330 {
lab=#net57}
N 3640 -8350 3660 -8350 {
lab=colon_n[28]}
N 3640 -8370 3660 -8370 {
lab=col_n[28]}
N 3460 -8230 3460 -8220 {
lab=VSS}
N 3460 -8460 3460 -8450 {
lab=VDD}
N 3800 -8230 3810 -8240 {
lab=row_n[10]}
N 3810 -8440 3810 -8240 {
lab=row_n[10]}
N 3800 -8450 3810 -8440 {
lab=row_n[10]}
N 3800 -8230 3800 -8210 {
lab=row_n[10]}
N 3800 -8470 3800 -8450 {
lab=row_n[10]}
N 3680 -8370 3690 -8380 {
lab=col_n[28]}
N 3690 -8380 3890 -8380 {
lab=col_n[28]}
N 3890 -8380 3900 -8370 {
lab=col_n[28]}
N 3680 -8350 3690 -8360 {
lab=colon_n[28]}
N 3690 -8360 3890 -8360 {
lab=colon_n[28]}
N 3890 -8360 3900 -8350 {
lab=colon_n[28]}
N 3680 -8330 3690 -8340 {
lab=#net57}
N 3690 -8340 3890 -8340 {
lab=#net57}
N 3890 -8340 3900 -8330 {
lab=#net57}
N 3680 -8310 3690 -8320 {
lab=#net58}
N 3690 -8320 3890 -8320 {
lab=#net58}
N 3890 -8320 3900 -8310 {
lab=#net58}
N 3740 -8470 3740 -8450 {
lab=vcom}
N 3780 -8470 3780 -8450 {
lab=ctop}
N 3660 -8370 3680 -8370 {
lab=col_n[28]}
N 3660 -8350 3680 -8350 {
lab=colon_n[28]}
N 3660 -8330 3680 -8330 {
lab=#net57}
N 3660 -8310 3680 -8310 {
lab=#net58}
N 3900 -8310 3920 -8310 {
lab=#net58}
N 3900 -8330 3920 -8330 {
lab=#net57}
N 3900 -8350 3920 -8350 {
lab=colon_n[28]}
N 3900 -8370 3920 -8370 {
lab=col_n[28]}
N 3720 -8230 3720 -8220 {
lab=VSS}
N 3720 -8460 3720 -8450 {
lab=VDD}
N 4060 -8230 4070 -8240 {
lab=row_n[11]}
N 4070 -8440 4070 -8240 {
lab=row_n[11]}
N 4060 -8450 4070 -8440 {
lab=row_n[11]}
N 4060 -8230 4060 -8210 {
lab=row_n[11]}
N 4060 -8470 4060 -8450 {
lab=row_n[11]}
N 3940 -8370 3950 -8380 {
lab=col_n[28]}
N 3950 -8380 4150 -8380 {
lab=col_n[28]}
N 4150 -8380 4160 -8370 {
lab=col_n[28]}
N 3940 -8350 3950 -8360 {
lab=colon_n[28]}
N 3950 -8360 4150 -8360 {
lab=colon_n[28]}
N 4150 -8360 4160 -8350 {
lab=colon_n[28]}
N 3940 -8330 3950 -8340 {
lab=#net57}
N 3950 -8340 4150 -8340 {
lab=#net57}
N 4150 -8340 4160 -8330 {
lab=#net57}
N 3940 -8310 3950 -8320 {
lab=#net58}
N 3950 -8320 4150 -8320 {
lab=#net58}
N 4150 -8320 4160 -8310 {
lab=#net58}
N 4000 -8470 4000 -8450 {
lab=vcom}
N 4040 -8470 4040 -8450 {
lab=ctop}
N 3920 -8370 3940 -8370 {
lab=col_n[28]}
N 3920 -8350 3940 -8350 {
lab=colon_n[28]}
N 3920 -8330 3940 -8330 {
lab=#net57}
N 3920 -8310 3940 -8310 {
lab=#net58}
N 4160 -8310 4180 -8310 {
lab=#net58}
N 4160 -8330 4180 -8330 {
lab=#net57}
N 4160 -8350 4180 -8350 {
lab=colon_n[28]}
N 4160 -8370 4180 -8370 {
lab=col_n[28]}
N 3980 -8230 3980 -8220 {
lab=VSS}
N 3980 -8460 3980 -8450 {
lab=VDD}
N 4320 -8230 4330 -8240 {
lab=row_n[12]}
N 4330 -8440 4330 -8240 {
lab=row_n[12]}
N 4320 -8450 4330 -8440 {
lab=row_n[12]}
N 4320 -8230 4320 -8210 {
lab=row_n[12]}
N 4320 -8470 4320 -8450 {
lab=row_n[12]}
N 4200 -8370 4210 -8380 {
lab=col_n[28]}
N 4210 -8380 4410 -8380 {
lab=col_n[28]}
N 4410 -8380 4420 -8370 {
lab=col_n[28]}
N 4200 -8350 4210 -8360 {
lab=colon_n[28]}
N 4210 -8360 4410 -8360 {
lab=colon_n[28]}
N 4410 -8360 4420 -8350 {
lab=colon_n[28]}
N 4200 -8330 4210 -8340 {
lab=#net57}
N 4210 -8340 4410 -8340 {
lab=#net57}
N 4410 -8340 4420 -8330 {
lab=#net57}
N 4200 -8310 4210 -8320 {
lab=#net58}
N 4210 -8320 4410 -8320 {
lab=#net58}
N 4410 -8320 4420 -8310 {
lab=#net58}
N 4260 -8470 4260 -8450 {
lab=vcom}
N 4300 -8470 4300 -8450 {
lab=ctop}
N 4180 -8370 4200 -8370 {
lab=col_n[28]}
N 4180 -8350 4200 -8350 {
lab=colon_n[28]}
N 4180 -8330 4200 -8330 {
lab=#net57}
N 4180 -8310 4200 -8310 {
lab=#net58}
N 4420 -8310 4440 -8310 {
lab=#net58}
N 4420 -8330 4440 -8330 {
lab=#net57}
N 4420 -8350 4440 -8350 {
lab=colon_n[28]}
N 4420 -8370 4440 -8370 {
lab=col_n[28]}
N 4240 -8230 4240 -8220 {
lab=VSS}
N 4240 -8460 4240 -8450 {
lab=VDD}
N 4580 -8230 4590 -8240 {
lab=row_n[13]}
N 4590 -8440 4590 -8240 {
lab=row_n[13]}
N 4580 -8450 4590 -8440 {
lab=row_n[13]}
N 4580 -8230 4580 -8210 {
lab=row_n[13]}
N 4580 -8470 4580 -8450 {
lab=row_n[13]}
N 4460 -8370 4470 -8380 {
lab=col_n[28]}
N 4470 -8380 4670 -8380 {
lab=col_n[28]}
N 4670 -8380 4680 -8370 {
lab=col_n[28]}
N 4460 -8350 4470 -8360 {
lab=colon_n[28]}
N 4470 -8360 4670 -8360 {
lab=colon_n[28]}
N 4670 -8360 4680 -8350 {
lab=colon_n[28]}
N 4460 -8330 4470 -8340 {
lab=#net57}
N 4470 -8340 4670 -8340 {
lab=#net57}
N 4670 -8340 4680 -8330 {
lab=#net57}
N 4460 -8310 4470 -8320 {
lab=#net58}
N 4470 -8320 4670 -8320 {
lab=#net58}
N 4670 -8320 4680 -8310 {
lab=#net58}
N 4520 -8470 4520 -8450 {
lab=vcom}
N 4560 -8470 4560 -8450 {
lab=ctop}
N 4440 -8370 4460 -8370 {
lab=col_n[28]}
N 4440 -8350 4460 -8350 {
lab=colon_n[28]}
N 4440 -8330 4460 -8330 {
lab=#net57}
N 4440 -8310 4460 -8310 {
lab=#net58}
N 4680 -8310 4700 -8310 {
lab=#net58}
N 4680 -8330 4700 -8330 {
lab=#net57}
N 4680 -8350 4700 -8350 {
lab=colon_n[28]}
N 4680 -8370 4700 -8370 {
lab=col_n[28]}
N 4500 -8230 4500 -8220 {
lab=VSS}
N 4500 -8460 4500 -8450 {
lab=VDD}
N 4840 -8230 4850 -8240 {
lab=row_n[14]}
N 4850 -8440 4850 -8240 {
lab=row_n[14]}
N 4840 -8450 4850 -8440 {
lab=row_n[14]}
N 4840 -8230 4840 -8210 {
lab=row_n[14]}
N 4840 -8470 4840 -8450 {
lab=row_n[14]}
N 4720 -8370 4730 -8380 {
lab=col_n[28]}
N 4730 -8380 4930 -8380 {
lab=col_n[28]}
N 4930 -8380 4940 -8370 {
lab=col_n[28]}
N 4720 -8350 4730 -8360 {
lab=colon_n[28]}
N 4730 -8360 4930 -8360 {
lab=colon_n[28]}
N 4930 -8360 4940 -8350 {
lab=colon_n[28]}
N 4720 -8330 4730 -8340 {
lab=#net57}
N 4730 -8340 4930 -8340 {
lab=#net57}
N 4930 -8340 4940 -8330 {
lab=#net57}
N 4720 -8310 4730 -8320 {
lab=#net58}
N 4730 -8320 4930 -8320 {
lab=#net58}
N 4930 -8320 4940 -8310 {
lab=#net58}
N 4780 -8470 4780 -8450 {
lab=vcom}
N 4820 -8470 4820 -8450 {
lab=ctop}
N 4700 -8370 4720 -8370 {
lab=col_n[28]}
N 4700 -8350 4720 -8350 {
lab=colon_n[28]}
N 4700 -8330 4720 -8330 {
lab=#net57}
N 4700 -8310 4720 -8310 {
lab=#net58}
N 4940 -8310 4960 -8310 {
lab=#net58}
N 4940 -8330 4960 -8330 {
lab=#net57}
N 4940 -8350 4960 -8350 {
lab=colon_n[28]}
N 4940 -8370 4960 -8370 {
lab=col_n[28]}
N 4760 -8230 4760 -8220 {
lab=VSS}
N 4760 -8460 4760 -8450 {
lab=VDD}
N 5100 -8230 5110 -8240 {
lab=row_n[15]}
N 5110 -8440 5110 -8240 {
lab=row_n[15]}
N 5100 -8450 5110 -8440 {
lab=row_n[15]}
N 5100 -8230 5100 -8210 {
lab=row_n[15]}
N 5100 -8470 5100 -8450 {
lab=row_n[15]}
N 4980 -8370 4990 -8380 {
lab=col_n[28]}
N 4990 -8380 5190 -8380 {
lab=col_n[28]}
N 5190 -8380 5200 -8370 {
lab=col_n[28]}
N 4980 -8350 4990 -8360 {
lab=colon_n[28]}
N 4990 -8360 5190 -8360 {
lab=colon_n[28]}
N 5190 -8360 5200 -8350 {
lab=colon_n[28]}
N 4980 -8330 4990 -8340 {
lab=#net57}
N 4990 -8340 5190 -8340 {
lab=#net57}
N 5190 -8340 5200 -8330 {
lab=#net57}
N 4980 -8310 4990 -8320 {
lab=#net58}
N 4990 -8320 5190 -8320 {
lab=#net58}
N 5190 -8320 5200 -8310 {
lab=#net58}
N 5040 -8470 5040 -8450 {
lab=vcom}
N 5080 -8470 5080 -8450 {
lab=ctop}
N 4960 -8370 4980 -8370 {
lab=col_n[28]}
N 4960 -8350 4980 -8350 {
lab=colon_n[28]}
N 4960 -8330 4980 -8330 {
lab=#net57}
N 4960 -8310 4980 -8310 {
lab=#net58}
N 5200 -8310 5220 -8310 {
lab=#net58}
N 5200 -8330 5220 -8330 {
lab=#net57}
N 5200 -8350 5220 -8350 {
lab=colon_n[28]}
N 5200 -8370 5220 -8370 {
lab=col_n[28]}
N 5020 -8230 5020 -8220 {
lab=VSS}
N 5020 -8460 5020 -8450 {
lab=VDD}
N 5360 -8230 5370 -8240 {
lab=row_n[16]}
N 5370 -8440 5370 -8240 {
lab=row_n[16]}
N 5360 -8450 5370 -8440 {
lab=row_n[16]}
N 5360 -8230 5360 -8210 {
lab=row_n[16]}
N 5360 -8470 5360 -8450 {
lab=row_n[16]}
N 5240 -8370 5250 -8380 {
lab=col_n[28]}
N 5250 -8380 5450 -8380 {
lab=col_n[28]}
N 5450 -8380 5460 -8370 {
lab=col_n[28]}
N 5240 -8350 5250 -8360 {
lab=colon_n[28]}
N 5250 -8360 5450 -8360 {
lab=colon_n[28]}
N 5450 -8360 5460 -8350 {
lab=colon_n[28]}
N 5240 -8330 5250 -8340 {
lab=#net57}
N 5250 -8340 5450 -8340 {
lab=#net57}
N 5450 -8340 5460 -8330 {
lab=#net57}
N 5240 -8310 5250 -8320 {
lab=#net58}
N 5250 -8320 5450 -8320 {
lab=#net58}
N 5450 -8320 5460 -8310 {
lab=#net58}
N 5300 -8470 5300 -8450 {
lab=vcom}
N 5340 -8470 5340 -8450 {
lab=ctop}
N 5220 -8370 5240 -8370 {
lab=col_n[28]}
N 5220 -8350 5240 -8350 {
lab=colon_n[28]}
N 5220 -8330 5240 -8330 {
lab=#net57}
N 5220 -8310 5240 -8310 {
lab=#net58}
N 5460 -8310 5480 -8310 {
lab=#net58}
N 5460 -8330 5480 -8330 {
lab=#net57}
N 5460 -8350 5480 -8350 {
lab=colon_n[28]}
N 5460 -8370 5480 -8370 {
lab=col_n[28]}
N 5280 -8230 5280 -8220 {
lab=VSS}
N 5280 -8460 5280 -8450 {
lab=VDD}
N 5620 -8230 5630 -8240 {
lab=row_n[17]}
N 5630 -8440 5630 -8240 {
lab=row_n[17]}
N 5620 -8450 5630 -8440 {
lab=row_n[17]}
N 5620 -8230 5620 -8210 {
lab=row_n[17]}
N 5620 -8470 5620 -8450 {
lab=row_n[17]}
N 5500 -8370 5510 -8380 {
lab=col_n[28]}
N 5510 -8380 5710 -8380 {
lab=col_n[28]}
N 5710 -8380 5720 -8370 {
lab=col_n[28]}
N 5500 -8350 5510 -8360 {
lab=colon_n[28]}
N 5510 -8360 5710 -8360 {
lab=colon_n[28]}
N 5710 -8360 5720 -8350 {
lab=colon_n[28]}
N 5500 -8330 5510 -8340 {
lab=#net57}
N 5510 -8340 5710 -8340 {
lab=#net57}
N 5710 -8340 5720 -8330 {
lab=#net57}
N 5500 -8310 5510 -8320 {
lab=#net58}
N 5510 -8320 5710 -8320 {
lab=#net58}
N 5710 -8320 5720 -8310 {
lab=#net58}
N 5560 -8470 5560 -8450 {
lab=vcom}
N 5600 -8470 5600 -8450 {
lab=ctop}
N 5480 -8370 5500 -8370 {
lab=col_n[28]}
N 5480 -8350 5500 -8350 {
lab=colon_n[28]}
N 5480 -8330 5500 -8330 {
lab=#net57}
N 5480 -8310 5500 -8310 {
lab=#net58}
N 5720 -8310 5740 -8310 {
lab=#net58}
N 5720 -8330 5740 -8330 {
lab=#net57}
N 5720 -8350 5740 -8350 {
lab=colon_n[28]}
N 5720 -8370 5740 -8370 {
lab=col_n[28]}
N 5540 -8230 5540 -8220 {
lab=VSS}
N 5540 -8460 5540 -8450 {
lab=VDD}
N 5880 -8230 5890 -8240 {
lab=row_n[18]}
N 5890 -8440 5890 -8240 {
lab=row_n[18]}
N 5880 -8450 5890 -8440 {
lab=row_n[18]}
N 5880 -8230 5880 -8210 {
lab=row_n[18]}
N 5880 -8470 5880 -8450 {
lab=row_n[18]}
N 5760 -8370 5770 -8380 {
lab=col_n[28]}
N 5770 -8380 5970 -8380 {
lab=col_n[28]}
N 5970 -8380 5980 -8370 {
lab=col_n[28]}
N 5760 -8350 5770 -8360 {
lab=colon_n[28]}
N 5770 -8360 5970 -8360 {
lab=colon_n[28]}
N 5970 -8360 5980 -8350 {
lab=colon_n[28]}
N 5760 -8330 5770 -8340 {
lab=#net57}
N 5770 -8340 5970 -8340 {
lab=#net57}
N 5970 -8340 5980 -8330 {
lab=#net57}
N 5760 -8310 5770 -8320 {
lab=#net58}
N 5770 -8320 5970 -8320 {
lab=#net58}
N 5970 -8320 5980 -8310 {
lab=#net58}
N 5820 -8470 5820 -8450 {
lab=vcom}
N 5860 -8470 5860 -8450 {
lab=ctop}
N 5740 -8370 5760 -8370 {
lab=col_n[28]}
N 5740 -8350 5760 -8350 {
lab=colon_n[28]}
N 5740 -8330 5760 -8330 {
lab=#net57}
N 5740 -8310 5760 -8310 {
lab=#net58}
N 5980 -8310 6000 -8310 {
lab=#net58}
N 5980 -8330 6000 -8330 {
lab=#net57}
N 5980 -8350 6000 -8350 {
lab=colon_n[28]}
N 5980 -8370 6000 -8370 {
lab=col_n[28]}
N 5800 -8230 5800 -8220 {
lab=VSS}
N 5800 -8460 5800 -8450 {
lab=VDD}
N 6140 -8230 6150 -8240 {
lab=row_n[19]}
N 6150 -8440 6150 -8240 {
lab=row_n[19]}
N 6140 -8450 6150 -8440 {
lab=row_n[19]}
N 6140 -8230 6140 -8210 {
lab=row_n[19]}
N 6140 -8470 6140 -8450 {
lab=row_n[19]}
N 6020 -8370 6030 -8380 {
lab=col_n[28]}
N 6030 -8380 6230 -8380 {
lab=col_n[28]}
N 6230 -8380 6240 -8370 {
lab=col_n[28]}
N 6020 -8350 6030 -8360 {
lab=colon_n[28]}
N 6030 -8360 6230 -8360 {
lab=colon_n[28]}
N 6230 -8360 6240 -8350 {
lab=colon_n[28]}
N 6020 -8330 6030 -8340 {
lab=#net57}
N 6030 -8340 6230 -8340 {
lab=#net57}
N 6230 -8340 6240 -8330 {
lab=#net57}
N 6020 -8310 6030 -8320 {
lab=#net58}
N 6030 -8320 6230 -8320 {
lab=#net58}
N 6230 -8320 6240 -8310 {
lab=#net58}
N 6080 -8470 6080 -8450 {
lab=vcom}
N 6120 -8470 6120 -8450 {
lab=ctop}
N 6000 -8370 6020 -8370 {
lab=col_n[28]}
N 6000 -8350 6020 -8350 {
lab=colon_n[28]}
N 6000 -8330 6020 -8330 {
lab=#net57}
N 6000 -8310 6020 -8310 {
lab=#net58}
N 6240 -8310 6260 -8310 {
lab=#net58}
N 6240 -8330 6260 -8330 {
lab=#net57}
N 6240 -8350 6260 -8350 {
lab=colon_n[28]}
N 6240 -8370 6260 -8370 {
lab=col_n[28]}
N 6060 -8230 6060 -8220 {
lab=VSS}
N 6060 -8460 6060 -8450 {
lab=VDD}
N 6400 -8230 6410 -8240 {
lab=row_n[20]}
N 6410 -8440 6410 -8240 {
lab=row_n[20]}
N 6400 -8450 6410 -8440 {
lab=row_n[20]}
N 6400 -8230 6400 -8210 {
lab=row_n[20]}
N 6400 -8470 6400 -8450 {
lab=row_n[20]}
N 6280 -8370 6290 -8380 {
lab=col_n[28]}
N 6290 -8380 6490 -8380 {
lab=col_n[28]}
N 6490 -8380 6500 -8370 {
lab=col_n[28]}
N 6280 -8350 6290 -8360 {
lab=colon_n[28]}
N 6290 -8360 6490 -8360 {
lab=colon_n[28]}
N 6490 -8360 6500 -8350 {
lab=colon_n[28]}
N 6280 -8330 6290 -8340 {
lab=#net57}
N 6290 -8340 6490 -8340 {
lab=#net57}
N 6490 -8340 6500 -8330 {
lab=#net57}
N 6280 -8310 6290 -8320 {
lab=#net58}
N 6290 -8320 6490 -8320 {
lab=#net58}
N 6490 -8320 6500 -8310 {
lab=#net58}
N 6340 -8470 6340 -8450 {
lab=vcom}
N 6380 -8470 6380 -8450 {
lab=ctop}
N 6260 -8370 6280 -8370 {
lab=col_n[28]}
N 6260 -8350 6280 -8350 {
lab=colon_n[28]}
N 6260 -8330 6280 -8330 {
lab=#net57}
N 6260 -8310 6280 -8310 {
lab=#net58}
N 6500 -8310 6520 -8310 {
lab=#net58}
N 6500 -8330 6520 -8330 {
lab=#net57}
N 6500 -8350 6520 -8350 {
lab=colon_n[28]}
N 6500 -8370 6520 -8370 {
lab=col_n[28]}
N 6320 -8230 6320 -8220 {
lab=VSS}
N 6320 -8460 6320 -8450 {
lab=VDD}
N 6660 -8230 6670 -8240 {
lab=row_n[21]}
N 6670 -8440 6670 -8240 {
lab=row_n[21]}
N 6660 -8450 6670 -8440 {
lab=row_n[21]}
N 6660 -8230 6660 -8210 {
lab=row_n[21]}
N 6660 -8470 6660 -8450 {
lab=row_n[21]}
N 6540 -8370 6550 -8380 {
lab=col_n[28]}
N 6550 -8380 6750 -8380 {
lab=col_n[28]}
N 6750 -8380 6760 -8370 {
lab=col_n[28]}
N 6540 -8350 6550 -8360 {
lab=colon_n[28]}
N 6550 -8360 6750 -8360 {
lab=colon_n[28]}
N 6750 -8360 6760 -8350 {
lab=colon_n[28]}
N 6540 -8330 6550 -8340 {
lab=#net57}
N 6550 -8340 6750 -8340 {
lab=#net57}
N 6750 -8340 6760 -8330 {
lab=#net57}
N 6540 -8310 6550 -8320 {
lab=#net58}
N 6550 -8320 6750 -8320 {
lab=#net58}
N 6750 -8320 6760 -8310 {
lab=#net58}
N 6600 -8470 6600 -8450 {
lab=vcom}
N 6640 -8470 6640 -8450 {
lab=ctop}
N 6520 -8370 6540 -8370 {
lab=col_n[28]}
N 6520 -8350 6540 -8350 {
lab=colon_n[28]}
N 6520 -8330 6540 -8330 {
lab=#net57}
N 6520 -8310 6540 -8310 {
lab=#net58}
N 6760 -8310 6780 -8310 {
lab=#net58}
N 6760 -8330 6780 -8330 {
lab=#net57}
N 6760 -8350 6780 -8350 {
lab=colon_n[28]}
N 6760 -8370 6780 -8370 {
lab=col_n[28]}
N 6580 -8230 6580 -8220 {
lab=VSS}
N 6580 -8460 6580 -8450 {
lab=VDD}
N 6920 -8230 6930 -8240 {
lab=row_n[22]}
N 6930 -8440 6930 -8240 {
lab=row_n[22]}
N 6920 -8450 6930 -8440 {
lab=row_n[22]}
N 6920 -8230 6920 -8210 {
lab=row_n[22]}
N 6920 -8470 6920 -8450 {
lab=row_n[22]}
N 6800 -8370 6810 -8380 {
lab=col_n[28]}
N 6810 -8380 7010 -8380 {
lab=col_n[28]}
N 7010 -8380 7020 -8370 {
lab=col_n[28]}
N 6800 -8350 6810 -8360 {
lab=colon_n[28]}
N 6810 -8360 7010 -8360 {
lab=colon_n[28]}
N 7010 -8360 7020 -8350 {
lab=colon_n[28]}
N 6800 -8330 6810 -8340 {
lab=#net57}
N 6810 -8340 7010 -8340 {
lab=#net57}
N 7010 -8340 7020 -8330 {
lab=#net57}
N 6800 -8310 6810 -8320 {
lab=#net58}
N 6810 -8320 7010 -8320 {
lab=#net58}
N 7010 -8320 7020 -8310 {
lab=#net58}
N 6860 -8470 6860 -8450 {
lab=vcom}
N 6900 -8470 6900 -8450 {
lab=ctop}
N 6780 -8370 6800 -8370 {
lab=col_n[28]}
N 6780 -8350 6800 -8350 {
lab=colon_n[28]}
N 6780 -8330 6800 -8330 {
lab=#net57}
N 6780 -8310 6800 -8310 {
lab=#net58}
N 7020 -8310 7040 -8310 {
lab=#net58}
N 7020 -8330 7040 -8330 {
lab=#net57}
N 7020 -8350 7040 -8350 {
lab=colon_n[28]}
N 7020 -8370 7040 -8370 {
lab=col_n[28]}
N 6840 -8230 6840 -8220 {
lab=VSS}
N 6840 -8460 6840 -8450 {
lab=VDD}
N 7180 -8230 7190 -8240 {
lab=row_n[23]}
N 7190 -8440 7190 -8240 {
lab=row_n[23]}
N 7180 -8450 7190 -8440 {
lab=row_n[23]}
N 7180 -8230 7180 -8210 {
lab=row_n[23]}
N 7180 -8470 7180 -8450 {
lab=row_n[23]}
N 7060 -8370 7070 -8380 {
lab=col_n[28]}
N 7070 -8380 7270 -8380 {
lab=col_n[28]}
N 7270 -8380 7280 -8370 {
lab=col_n[28]}
N 7060 -8350 7070 -8360 {
lab=colon_n[28]}
N 7070 -8360 7270 -8360 {
lab=colon_n[28]}
N 7270 -8360 7280 -8350 {
lab=colon_n[28]}
N 7060 -8330 7070 -8340 {
lab=#net57}
N 7070 -8340 7270 -8340 {
lab=#net57}
N 7270 -8340 7280 -8330 {
lab=#net57}
N 7060 -8310 7070 -8320 {
lab=#net58}
N 7070 -8320 7270 -8320 {
lab=#net58}
N 7270 -8320 7280 -8310 {
lab=#net58}
N 7120 -8470 7120 -8450 {
lab=vcom}
N 7160 -8470 7160 -8450 {
lab=ctop}
N 7040 -8370 7060 -8370 {
lab=col_n[28]}
N 7040 -8350 7060 -8350 {
lab=colon_n[28]}
N 7040 -8330 7060 -8330 {
lab=#net57}
N 7040 -8310 7060 -8310 {
lab=#net58}
N 7280 -8310 7300 -8310 {
lab=#net58}
N 7280 -8330 7300 -8330 {
lab=#net57}
N 7280 -8350 7300 -8350 {
lab=colon_n[28]}
N 7280 -8370 7300 -8370 {
lab=col_n[28]}
N 7100 -8230 7100 -8220 {
lab=VSS}
N 7100 -8460 7100 -8450 {
lab=VDD}
N 7440 -8230 7450 -8240 {
lab=row_n[24]}
N 7450 -8440 7450 -8240 {
lab=row_n[24]}
N 7440 -8450 7450 -8440 {
lab=row_n[24]}
N 7440 -8230 7440 -8210 {
lab=row_n[24]}
N 7440 -8470 7440 -8450 {
lab=row_n[24]}
N 7320 -8370 7330 -8380 {
lab=col_n[28]}
N 7330 -8380 7530 -8380 {
lab=col_n[28]}
N 7530 -8380 7540 -8370 {
lab=col_n[28]}
N 7320 -8350 7330 -8360 {
lab=colon_n[28]}
N 7330 -8360 7530 -8360 {
lab=colon_n[28]}
N 7530 -8360 7540 -8350 {
lab=colon_n[28]}
N 7320 -8330 7330 -8340 {
lab=#net57}
N 7330 -8340 7530 -8340 {
lab=#net57}
N 7530 -8340 7540 -8330 {
lab=#net57}
N 7320 -8310 7330 -8320 {
lab=#net58}
N 7330 -8320 7530 -8320 {
lab=#net58}
N 7530 -8320 7540 -8310 {
lab=#net58}
N 7380 -8470 7380 -8450 {
lab=vcom}
N 7420 -8470 7420 -8450 {
lab=ctop}
N 7300 -8370 7320 -8370 {
lab=col_n[28]}
N 7300 -8350 7320 -8350 {
lab=colon_n[28]}
N 7300 -8330 7320 -8330 {
lab=#net57}
N 7300 -8310 7320 -8310 {
lab=#net58}
N 7540 -8310 7560 -8310 {
lab=#net58}
N 7540 -8330 7560 -8330 {
lab=#net57}
N 7540 -8350 7560 -8350 {
lab=colon_n[28]}
N 7540 -8370 7560 -8370 {
lab=col_n[28]}
N 7360 -8230 7360 -8220 {
lab=VSS}
N 7360 -8460 7360 -8450 {
lab=VDD}
N 7700 -8230 7710 -8240 {
lab=row_n[25]}
N 7710 -8440 7710 -8240 {
lab=row_n[25]}
N 7700 -8450 7710 -8440 {
lab=row_n[25]}
N 7700 -8230 7700 -8210 {
lab=row_n[25]}
N 7700 -8470 7700 -8450 {
lab=row_n[25]}
N 7580 -8370 7590 -8380 {
lab=col_n[28]}
N 7590 -8380 7790 -8380 {
lab=col_n[28]}
N 7790 -8380 7800 -8370 {
lab=col_n[28]}
N 7580 -8350 7590 -8360 {
lab=colon_n[28]}
N 7590 -8360 7790 -8360 {
lab=colon_n[28]}
N 7790 -8360 7800 -8350 {
lab=colon_n[28]}
N 7580 -8330 7590 -8340 {
lab=#net57}
N 7590 -8340 7790 -8340 {
lab=#net57}
N 7790 -8340 7800 -8330 {
lab=#net57}
N 7580 -8310 7590 -8320 {
lab=#net58}
N 7590 -8320 7790 -8320 {
lab=#net58}
N 7790 -8320 7800 -8310 {
lab=#net58}
N 7640 -8470 7640 -8450 {
lab=vcom}
N 7680 -8470 7680 -8450 {
lab=ctop}
N 7560 -8370 7580 -8370 {
lab=col_n[28]}
N 7560 -8350 7580 -8350 {
lab=colon_n[28]}
N 7560 -8330 7580 -8330 {
lab=#net57}
N 7560 -8310 7580 -8310 {
lab=#net58}
N 7800 -8310 7820 -8310 {
lab=#net58}
N 7800 -8330 7820 -8330 {
lab=#net57}
N 7800 -8350 7820 -8350 {
lab=colon_n[28]}
N 7800 -8370 7820 -8370 {
lab=col_n[28]}
N 7620 -8230 7620 -8220 {
lab=VSS}
N 7620 -8460 7620 -8450 {
lab=VDD}
N 7960 -8230 7970 -8240 {
lab=row_n[26]}
N 7970 -8440 7970 -8240 {
lab=row_n[26]}
N 7960 -8450 7970 -8440 {
lab=row_n[26]}
N 7960 -8230 7960 -8210 {
lab=row_n[26]}
N 7960 -8470 7960 -8450 {
lab=row_n[26]}
N 7840 -8370 7850 -8380 {
lab=col_n[28]}
N 7850 -8380 8050 -8380 {
lab=col_n[28]}
N 8050 -8380 8060 -8370 {
lab=col_n[28]}
N 7840 -8350 7850 -8360 {
lab=colon_n[28]}
N 7850 -8360 8050 -8360 {
lab=colon_n[28]}
N 8050 -8360 8060 -8350 {
lab=colon_n[28]}
N 7840 -8330 7850 -8340 {
lab=#net57}
N 7850 -8340 8050 -8340 {
lab=#net57}
N 8050 -8340 8060 -8330 {
lab=#net57}
N 7840 -8310 7850 -8320 {
lab=#net58}
N 7850 -8320 8050 -8320 {
lab=#net58}
N 8050 -8320 8060 -8310 {
lab=#net58}
N 7900 -8470 7900 -8450 {
lab=vcom}
N 7940 -8470 7940 -8450 {
lab=ctop}
N 7820 -8370 7840 -8370 {
lab=col_n[28]}
N 7820 -8350 7840 -8350 {
lab=colon_n[28]}
N 7820 -8330 7840 -8330 {
lab=#net57}
N 7820 -8310 7840 -8310 {
lab=#net58}
N 8060 -8310 8080 -8310 {
lab=#net58}
N 8060 -8330 8080 -8330 {
lab=#net57}
N 8060 -8350 8080 -8350 {
lab=colon_n[28]}
N 8060 -8370 8080 -8370 {
lab=col_n[28]}
N 7880 -8230 7880 -8220 {
lab=VSS}
N 7880 -8460 7880 -8450 {
lab=VDD}
N 8220 -8230 8230 -8240 {
lab=row_n[27]}
N 8230 -8440 8230 -8240 {
lab=row_n[27]}
N 8220 -8450 8230 -8440 {
lab=row_n[27]}
N 8220 -8230 8220 -8210 {
lab=row_n[27]}
N 8220 -8470 8220 -8450 {
lab=row_n[27]}
N 8100 -8370 8110 -8380 {
lab=col_n[28]}
N 8110 -8380 8310 -8380 {
lab=col_n[28]}
N 8310 -8380 8320 -8370 {
lab=col_n[28]}
N 8100 -8350 8110 -8360 {
lab=colon_n[28]}
N 8110 -8360 8310 -8360 {
lab=colon_n[28]}
N 8310 -8360 8320 -8350 {
lab=colon_n[28]}
N 8100 -8330 8110 -8340 {
lab=#net57}
N 8110 -8340 8310 -8340 {
lab=#net57}
N 8310 -8340 8320 -8330 {
lab=#net57}
N 8100 -8310 8110 -8320 {
lab=#net58}
N 8110 -8320 8310 -8320 {
lab=#net58}
N 8310 -8320 8320 -8310 {
lab=#net58}
N 8160 -8470 8160 -8450 {
lab=vcom}
N 8200 -8470 8200 -8450 {
lab=ctop}
N 8080 -8370 8100 -8370 {
lab=col_n[28]}
N 8080 -8350 8100 -8350 {
lab=colon_n[28]}
N 8080 -8330 8100 -8330 {
lab=#net57}
N 8080 -8310 8100 -8310 {
lab=#net58}
N 8320 -8310 8340 -8310 {
lab=#net58}
N 8320 -8330 8340 -8330 {
lab=#net57}
N 8320 -8350 8340 -8350 {
lab=colon_n[28]}
N 8320 -8370 8340 -8370 {
lab=col_n[28]}
N 8140 -8230 8140 -8220 {
lab=VSS}
N 8140 -8460 8140 -8450 {
lab=VDD}
N 8480 -8230 8490 -8240 {
lab=row_n[28]}
N 8490 -8440 8490 -8240 {
lab=row_n[28]}
N 8480 -8450 8490 -8440 {
lab=row_n[28]}
N 8480 -8230 8480 -8210 {
lab=row_n[28]}
N 8480 -8470 8480 -8450 {
lab=row_n[28]}
N 8360 -8370 8370 -8380 {
lab=col_n[28]}
N 8370 -8380 8570 -8380 {
lab=col_n[28]}
N 8570 -8380 8580 -8370 {
lab=col_n[28]}
N 8360 -8350 8370 -8360 {
lab=colon_n[28]}
N 8370 -8360 8570 -8360 {
lab=colon_n[28]}
N 8570 -8360 8580 -8350 {
lab=colon_n[28]}
N 8360 -8330 8370 -8340 {
lab=#net57}
N 8370 -8340 8570 -8340 {
lab=#net57}
N 8570 -8340 8580 -8330 {
lab=#net57}
N 8360 -8310 8370 -8320 {
lab=#net58}
N 8370 -8320 8570 -8320 {
lab=#net58}
N 8570 -8320 8580 -8310 {
lab=#net58}
N 8420 -8470 8420 -8450 {
lab=vcom}
N 8460 -8470 8460 -8450 {
lab=ctop}
N 8340 -8370 8360 -8370 {
lab=col_n[28]}
N 8340 -8350 8360 -8350 {
lab=colon_n[28]}
N 8340 -8330 8360 -8330 {
lab=#net57}
N 8340 -8310 8360 -8310 {
lab=#net58}
N 8580 -8310 8600 -8310 {
lab=#net58}
N 8580 -8330 8600 -8330 {
lab=#net57}
N 8580 -8350 8600 -8350 {
lab=colon_n[28]}
N 8580 -8370 8600 -8370 {
lab=col_n[28]}
N 8400 -8230 8400 -8220 {
lab=VSS}
N 8400 -8460 8400 -8450 {
lab=VDD}
N 8740 -8230 8750 -8240 {
lab=row_n[29]}
N 8750 -8440 8750 -8240 {
lab=row_n[29]}
N 8740 -8450 8750 -8440 {
lab=row_n[29]}
N 8740 -8230 8740 -8210 {
lab=row_n[29]}
N 8740 -8470 8740 -8450 {
lab=row_n[29]}
N 8620 -8370 8630 -8380 {
lab=col_n[28]}
N 8630 -8380 8830 -8380 {
lab=col_n[28]}
N 8830 -8380 8840 -8370 {
lab=col_n[28]}
N 8620 -8350 8630 -8360 {
lab=colon_n[28]}
N 8630 -8360 8830 -8360 {
lab=colon_n[28]}
N 8830 -8360 8840 -8350 {
lab=colon_n[28]}
N 8620 -8330 8630 -8340 {
lab=#net57}
N 8630 -8340 8830 -8340 {
lab=#net57}
N 8830 -8340 8840 -8330 {
lab=#net57}
N 8620 -8310 8630 -8320 {
lab=#net58}
N 8630 -8320 8830 -8320 {
lab=#net58}
N 8830 -8320 8840 -8310 {
lab=#net58}
N 8680 -8470 8680 -8450 {
lab=vcom}
N 8720 -8470 8720 -8450 {
lab=ctop}
N 8600 -8370 8620 -8370 {
lab=col_n[28]}
N 8600 -8350 8620 -8350 {
lab=colon_n[28]}
N 8600 -8330 8620 -8330 {
lab=#net57}
N 8600 -8310 8620 -8310 {
lab=#net58}
N 8840 -8310 8860 -8310 {
lab=#net58}
N 8840 -8330 8860 -8330 {
lab=#net57}
N 8840 -8350 8860 -8350 {
lab=colon_n[28]}
N 8840 -8370 8860 -8370 {
lab=col_n[28]}
N 8660 -8230 8660 -8220 {
lab=VSS}
N 8660 -8460 8660 -8450 {
lab=VDD}
N 9000 -8230 9010 -8240 {
lab=row_n[30]}
N 9010 -8440 9010 -8240 {
lab=row_n[30]}
N 9000 -8450 9010 -8440 {
lab=row_n[30]}
N 9000 -8230 9000 -8210 {
lab=row_n[30]}
N 9000 -8470 9000 -8450 {
lab=row_n[30]}
N 8880 -8370 8890 -8380 {
lab=col_n[28]}
N 8890 -8380 9090 -8380 {
lab=col_n[28]}
N 9090 -8380 9100 -8370 {
lab=col_n[28]}
N 8880 -8350 8890 -8360 {
lab=colon_n[28]}
N 8890 -8360 9090 -8360 {
lab=colon_n[28]}
N 9090 -8360 9100 -8350 {
lab=colon_n[28]}
N 8880 -8330 8890 -8340 {
lab=#net57}
N 8890 -8340 9090 -8340 {
lab=#net57}
N 9090 -8340 9100 -8330 {
lab=#net57}
N 8880 -8310 8890 -8320 {
lab=#net58}
N 8890 -8320 9090 -8320 {
lab=#net58}
N 9090 -8320 9100 -8310 {
lab=#net58}
N 8940 -8470 8940 -8450 {
lab=vcom}
N 8980 -8470 8980 -8450 {
lab=ctop}
N 8860 -8370 8880 -8370 {
lab=col_n[28]}
N 8860 -8350 8880 -8350 {
lab=colon_n[28]}
N 8860 -8330 8880 -8330 {
lab=#net57}
N 8860 -8310 8880 -8310 {
lab=#net58}
N 9100 -8310 9120 -8310 {
lab=#net58}
N 9100 -8330 9120 -8330 {
lab=#net57}
N 9100 -8350 9120 -8350 {
lab=colon_n[28]}
N 9100 -8370 9120 -8370 {
lab=col_n[28]}
N 8920 -8230 8920 -8220 {
lab=VSS}
N 8920 -8460 8920 -8450 {
lab=VDD}
N 9260 -8230 9270 -8240 {
lab=row_n[31]}
N 9270 -8440 9270 -8240 {
lab=row_n[31]}
N 9260 -8450 9270 -8440 {
lab=row_n[31]}
N 9260 -8230 9260 -8210 {
lab=row_n[31]}
N 9260 -8470 9260 -8450 {
lab=row_n[31]}
N 9140 -8370 9150 -8380 {
lab=col_n[28]}
N 9150 -8380 9350 -8380 {
lab=col_n[28]}
N 9350 -8380 9360 -8370 {
lab=col_n[28]}
N 9140 -8350 9150 -8360 {
lab=colon_n[28]}
N 9150 -8360 9350 -8360 {
lab=colon_n[28]}
N 9350 -8360 9360 -8350 {
lab=colon_n[28]}
N 9140 -8330 9150 -8340 {
lab=#net57}
N 9150 -8340 9350 -8340 {
lab=#net57}
N 9350 -8340 9360 -8330 {
lab=#net57}
N 9140 -8310 9150 -8320 {
lab=#net58}
N 9150 -8320 9350 -8320 {
lab=#net58}
N 9350 -8320 9360 -8310 {
lab=#net58}
N 9200 -8470 9200 -8450 {
lab=vcom}
N 9240 -8470 9240 -8450 {
lab=ctop}
N 9120 -8370 9140 -8370 {
lab=col_n[28]}
N 9120 -8350 9140 -8350 {
lab=colon_n[28]}
N 9120 -8330 9140 -8330 {
lab=#net57}
N 9120 -8310 9140 -8310 {
lab=#net58}
N 9360 -8310 9380 -8310 {
lab=#net58}
N 9360 -8330 9380 -8330 {
lab=#net57}
N 9360 -8350 9380 -8350 {
lab=colon_n[28]}
N 9360 -8370 9380 -8370 {
lab=col_n[28]}
N 9180 -8230 9180 -8220 {
lab=VSS}
N 9180 -8460 9180 -8450 {
lab=VDD}
N 1200 -8490 1210 -8500 {
lab=row_n[0]}
N 1210 -8700 1210 -8500 {
lab=row_n[0]}
N 1200 -8710 1210 -8700 {
lab=row_n[0]}
N 1200 -8490 1200 -8470 {
lab=row_n[0]}
N 1200 -8730 1200 -8710 {
lab=row_n[0]}
N 1080 -8630 1090 -8640 {
lab=col_n[29]}
N 1090 -8640 1290 -8640 {
lab=col_n[29]}
N 1290 -8640 1300 -8630 {
lab=col_n[29]}
N 1080 -8610 1090 -8620 {
lab=colon_n[29]}
N 1090 -8620 1290 -8620 {
lab=colon_n[29]}
N 1290 -8620 1300 -8610 {
lab=colon_n[29]}
N 1080 -8590 1090 -8600 {
lab=#net59}
N 1090 -8600 1290 -8600 {
lab=#net59}
N 1290 -8600 1300 -8590 {
lab=#net59}
N 1080 -8570 1090 -8580 {
lab=#net60}
N 1090 -8580 1290 -8580 {
lab=#net60}
N 1290 -8580 1300 -8570 {
lab=#net60}
N 1140 -8730 1140 -8710 {
lab=vcom}
N 1180 -8730 1180 -8710 {
lab=ctop}
N 1060 -8630 1080 -8630 {
lab=col_n[29]}
N 1060 -8610 1080 -8610 {
lab=colon_n[29]}
N 1060 -8590 1080 -8590 {
lab=#net59}
N 1060 -8570 1080 -8570 {
lab=#net60}
N 1300 -8570 1320 -8570 {
lab=#net60}
N 1300 -8590 1320 -8590 {
lab=#net59}
N 1300 -8610 1320 -8610 {
lab=colon_n[29]}
N 1300 -8630 1320 -8630 {
lab=col_n[29]}
N 1120 -8490 1120 -8480 {
lab=VSS}
N 1120 -8720 1120 -8710 {
lab=VDD}
N 1460 -8490 1470 -8500 {
lab=row_n[1]}
N 1470 -8700 1470 -8500 {
lab=row_n[1]}
N 1460 -8710 1470 -8700 {
lab=row_n[1]}
N 1460 -8490 1460 -8470 {
lab=row_n[1]}
N 1460 -8730 1460 -8710 {
lab=row_n[1]}
N 1340 -8630 1350 -8640 {
lab=col_n[29]}
N 1350 -8640 1550 -8640 {
lab=col_n[29]}
N 1550 -8640 1560 -8630 {
lab=col_n[29]}
N 1340 -8610 1350 -8620 {
lab=colon_n[29]}
N 1350 -8620 1550 -8620 {
lab=colon_n[29]}
N 1550 -8620 1560 -8610 {
lab=colon_n[29]}
N 1340 -8590 1350 -8600 {
lab=#net59}
N 1350 -8600 1550 -8600 {
lab=#net59}
N 1550 -8600 1560 -8590 {
lab=#net59}
N 1340 -8570 1350 -8580 {
lab=#net60}
N 1350 -8580 1550 -8580 {
lab=#net60}
N 1550 -8580 1560 -8570 {
lab=#net60}
N 1400 -8730 1400 -8710 {
lab=vcom}
N 1440 -8730 1440 -8710 {
lab=ctop}
N 1320 -8630 1340 -8630 {
lab=col_n[29]}
N 1320 -8610 1340 -8610 {
lab=colon_n[29]}
N 1320 -8590 1340 -8590 {
lab=#net59}
N 1320 -8570 1340 -8570 {
lab=#net60}
N 1560 -8570 1580 -8570 {
lab=#net60}
N 1560 -8590 1580 -8590 {
lab=#net59}
N 1560 -8610 1580 -8610 {
lab=colon_n[29]}
N 1560 -8630 1580 -8630 {
lab=col_n[29]}
N 1380 -8490 1380 -8480 {
lab=VSS}
N 1380 -8720 1380 -8710 {
lab=VDD}
N 1720 -8490 1730 -8500 {
lab=row_n[2]}
N 1730 -8700 1730 -8500 {
lab=row_n[2]}
N 1720 -8710 1730 -8700 {
lab=row_n[2]}
N 1720 -8490 1720 -8470 {
lab=row_n[2]}
N 1720 -8730 1720 -8710 {
lab=row_n[2]}
N 1600 -8630 1610 -8640 {
lab=col_n[29]}
N 1610 -8640 1810 -8640 {
lab=col_n[29]}
N 1810 -8640 1820 -8630 {
lab=col_n[29]}
N 1600 -8610 1610 -8620 {
lab=colon_n[29]}
N 1610 -8620 1810 -8620 {
lab=colon_n[29]}
N 1810 -8620 1820 -8610 {
lab=colon_n[29]}
N 1600 -8590 1610 -8600 {
lab=#net59}
N 1610 -8600 1810 -8600 {
lab=#net59}
N 1810 -8600 1820 -8590 {
lab=#net59}
N 1600 -8570 1610 -8580 {
lab=#net60}
N 1610 -8580 1810 -8580 {
lab=#net60}
N 1810 -8580 1820 -8570 {
lab=#net60}
N 1660 -8730 1660 -8710 {
lab=vcom}
N 1700 -8730 1700 -8710 {
lab=ctop}
N 1580 -8630 1600 -8630 {
lab=col_n[29]}
N 1580 -8610 1600 -8610 {
lab=colon_n[29]}
N 1580 -8590 1600 -8590 {
lab=#net59}
N 1580 -8570 1600 -8570 {
lab=#net60}
N 1820 -8570 1840 -8570 {
lab=#net60}
N 1820 -8590 1840 -8590 {
lab=#net59}
N 1820 -8610 1840 -8610 {
lab=colon_n[29]}
N 1820 -8630 1840 -8630 {
lab=col_n[29]}
N 1640 -8490 1640 -8480 {
lab=VSS}
N 1640 -8720 1640 -8710 {
lab=VDD}
N 1980 -8490 1990 -8500 {
lab=row_n[3]}
N 1990 -8700 1990 -8500 {
lab=row_n[3]}
N 1980 -8710 1990 -8700 {
lab=row_n[3]}
N 1980 -8490 1980 -8470 {
lab=row_n[3]}
N 1980 -8730 1980 -8710 {
lab=row_n[3]}
N 1860 -8630 1870 -8640 {
lab=col_n[29]}
N 1870 -8640 2070 -8640 {
lab=col_n[29]}
N 2070 -8640 2080 -8630 {
lab=col_n[29]}
N 1860 -8610 1870 -8620 {
lab=colon_n[29]}
N 1870 -8620 2070 -8620 {
lab=colon_n[29]}
N 2070 -8620 2080 -8610 {
lab=colon_n[29]}
N 1860 -8590 1870 -8600 {
lab=#net59}
N 1870 -8600 2070 -8600 {
lab=#net59}
N 2070 -8600 2080 -8590 {
lab=#net59}
N 1860 -8570 1870 -8580 {
lab=#net60}
N 1870 -8580 2070 -8580 {
lab=#net60}
N 2070 -8580 2080 -8570 {
lab=#net60}
N 1920 -8730 1920 -8710 {
lab=vcom}
N 1960 -8730 1960 -8710 {
lab=ctop}
N 1840 -8630 1860 -8630 {
lab=col_n[29]}
N 1840 -8610 1860 -8610 {
lab=colon_n[29]}
N 1840 -8590 1860 -8590 {
lab=#net59}
N 1840 -8570 1860 -8570 {
lab=#net60}
N 2080 -8570 2100 -8570 {
lab=#net60}
N 2080 -8590 2100 -8590 {
lab=#net59}
N 2080 -8610 2100 -8610 {
lab=colon_n[29]}
N 2080 -8630 2100 -8630 {
lab=col_n[29]}
N 1900 -8490 1900 -8480 {
lab=VSS}
N 1900 -8720 1900 -8710 {
lab=VDD}
N 2240 -8490 2250 -8500 {
lab=row_n[4]}
N 2250 -8700 2250 -8500 {
lab=row_n[4]}
N 2240 -8710 2250 -8700 {
lab=row_n[4]}
N 2240 -8490 2240 -8470 {
lab=row_n[4]}
N 2240 -8730 2240 -8710 {
lab=row_n[4]}
N 2120 -8630 2130 -8640 {
lab=col_n[29]}
N 2130 -8640 2330 -8640 {
lab=col_n[29]}
N 2330 -8640 2340 -8630 {
lab=col_n[29]}
N 2120 -8610 2130 -8620 {
lab=colon_n[29]}
N 2130 -8620 2330 -8620 {
lab=colon_n[29]}
N 2330 -8620 2340 -8610 {
lab=colon_n[29]}
N 2120 -8590 2130 -8600 {
lab=#net59}
N 2130 -8600 2330 -8600 {
lab=#net59}
N 2330 -8600 2340 -8590 {
lab=#net59}
N 2120 -8570 2130 -8580 {
lab=#net60}
N 2130 -8580 2330 -8580 {
lab=#net60}
N 2330 -8580 2340 -8570 {
lab=#net60}
N 2180 -8730 2180 -8710 {
lab=vcom}
N 2220 -8730 2220 -8710 {
lab=ctop}
N 2100 -8630 2120 -8630 {
lab=col_n[29]}
N 2100 -8610 2120 -8610 {
lab=colon_n[29]}
N 2100 -8590 2120 -8590 {
lab=#net59}
N 2100 -8570 2120 -8570 {
lab=#net60}
N 2340 -8570 2360 -8570 {
lab=#net60}
N 2340 -8590 2360 -8590 {
lab=#net59}
N 2340 -8610 2360 -8610 {
lab=colon_n[29]}
N 2340 -8630 2360 -8630 {
lab=col_n[29]}
N 2160 -8490 2160 -8480 {
lab=VSS}
N 2160 -8720 2160 -8710 {
lab=VDD}
N 2500 -8490 2510 -8500 {
lab=row_n[5]}
N 2510 -8700 2510 -8500 {
lab=row_n[5]}
N 2500 -8710 2510 -8700 {
lab=row_n[5]}
N 2500 -8490 2500 -8470 {
lab=row_n[5]}
N 2500 -8730 2500 -8710 {
lab=row_n[5]}
N 2380 -8630 2390 -8640 {
lab=col_n[29]}
N 2390 -8640 2590 -8640 {
lab=col_n[29]}
N 2590 -8640 2600 -8630 {
lab=col_n[29]}
N 2380 -8610 2390 -8620 {
lab=colon_n[29]}
N 2390 -8620 2590 -8620 {
lab=colon_n[29]}
N 2590 -8620 2600 -8610 {
lab=colon_n[29]}
N 2380 -8590 2390 -8600 {
lab=#net59}
N 2390 -8600 2590 -8600 {
lab=#net59}
N 2590 -8600 2600 -8590 {
lab=#net59}
N 2380 -8570 2390 -8580 {
lab=#net60}
N 2390 -8580 2590 -8580 {
lab=#net60}
N 2590 -8580 2600 -8570 {
lab=#net60}
N 2440 -8730 2440 -8710 {
lab=vcom}
N 2480 -8730 2480 -8710 {
lab=ctop}
N 2360 -8630 2380 -8630 {
lab=col_n[29]}
N 2360 -8610 2380 -8610 {
lab=colon_n[29]}
N 2360 -8590 2380 -8590 {
lab=#net59}
N 2360 -8570 2380 -8570 {
lab=#net60}
N 2600 -8570 2620 -8570 {
lab=#net60}
N 2600 -8590 2620 -8590 {
lab=#net59}
N 2600 -8610 2620 -8610 {
lab=colon_n[29]}
N 2600 -8630 2620 -8630 {
lab=col_n[29]}
N 2420 -8490 2420 -8480 {
lab=VSS}
N 2420 -8720 2420 -8710 {
lab=VDD}
N 2760 -8490 2770 -8500 {
lab=row_n[6]}
N 2770 -8700 2770 -8500 {
lab=row_n[6]}
N 2760 -8710 2770 -8700 {
lab=row_n[6]}
N 2760 -8490 2760 -8470 {
lab=row_n[6]}
N 2760 -8730 2760 -8710 {
lab=row_n[6]}
N 2640 -8630 2650 -8640 {
lab=col_n[29]}
N 2650 -8640 2850 -8640 {
lab=col_n[29]}
N 2850 -8640 2860 -8630 {
lab=col_n[29]}
N 2640 -8610 2650 -8620 {
lab=colon_n[29]}
N 2650 -8620 2850 -8620 {
lab=colon_n[29]}
N 2850 -8620 2860 -8610 {
lab=colon_n[29]}
N 2640 -8590 2650 -8600 {
lab=#net59}
N 2650 -8600 2850 -8600 {
lab=#net59}
N 2850 -8600 2860 -8590 {
lab=#net59}
N 2640 -8570 2650 -8580 {
lab=#net60}
N 2650 -8580 2850 -8580 {
lab=#net60}
N 2850 -8580 2860 -8570 {
lab=#net60}
N 2700 -8730 2700 -8710 {
lab=vcom}
N 2740 -8730 2740 -8710 {
lab=ctop}
N 2620 -8630 2640 -8630 {
lab=col_n[29]}
N 2620 -8610 2640 -8610 {
lab=colon_n[29]}
N 2620 -8590 2640 -8590 {
lab=#net59}
N 2620 -8570 2640 -8570 {
lab=#net60}
N 2860 -8570 2880 -8570 {
lab=#net60}
N 2860 -8590 2880 -8590 {
lab=#net59}
N 2860 -8610 2880 -8610 {
lab=colon_n[29]}
N 2860 -8630 2880 -8630 {
lab=col_n[29]}
N 2680 -8490 2680 -8480 {
lab=VSS}
N 2680 -8720 2680 -8710 {
lab=VDD}
N 3020 -8490 3030 -8500 {
lab=row_n[7]}
N 3030 -8700 3030 -8500 {
lab=row_n[7]}
N 3020 -8710 3030 -8700 {
lab=row_n[7]}
N 3020 -8490 3020 -8470 {
lab=row_n[7]}
N 3020 -8730 3020 -8710 {
lab=row_n[7]}
N 2900 -8630 2910 -8640 {
lab=col_n[29]}
N 2910 -8640 3110 -8640 {
lab=col_n[29]}
N 3110 -8640 3120 -8630 {
lab=col_n[29]}
N 2900 -8610 2910 -8620 {
lab=colon_n[29]}
N 2910 -8620 3110 -8620 {
lab=colon_n[29]}
N 3110 -8620 3120 -8610 {
lab=colon_n[29]}
N 2900 -8590 2910 -8600 {
lab=#net59}
N 2910 -8600 3110 -8600 {
lab=#net59}
N 3110 -8600 3120 -8590 {
lab=#net59}
N 2900 -8570 2910 -8580 {
lab=#net60}
N 2910 -8580 3110 -8580 {
lab=#net60}
N 3110 -8580 3120 -8570 {
lab=#net60}
N 2960 -8730 2960 -8710 {
lab=vcom}
N 3000 -8730 3000 -8710 {
lab=ctop}
N 2880 -8630 2900 -8630 {
lab=col_n[29]}
N 2880 -8610 2900 -8610 {
lab=colon_n[29]}
N 2880 -8590 2900 -8590 {
lab=#net59}
N 2880 -8570 2900 -8570 {
lab=#net60}
N 3120 -8570 3140 -8570 {
lab=#net60}
N 3120 -8590 3140 -8590 {
lab=#net59}
N 3120 -8610 3140 -8610 {
lab=colon_n[29]}
N 3120 -8630 3140 -8630 {
lab=col_n[29]}
N 2940 -8490 2940 -8480 {
lab=VSS}
N 2940 -8720 2940 -8710 {
lab=VDD}
N 3280 -8490 3290 -8500 {
lab=row_n[8]}
N 3290 -8700 3290 -8500 {
lab=row_n[8]}
N 3280 -8710 3290 -8700 {
lab=row_n[8]}
N 3280 -8490 3280 -8470 {
lab=row_n[8]}
N 3280 -8730 3280 -8710 {
lab=row_n[8]}
N 3160 -8630 3170 -8640 {
lab=col_n[29]}
N 3170 -8640 3370 -8640 {
lab=col_n[29]}
N 3370 -8640 3380 -8630 {
lab=col_n[29]}
N 3160 -8610 3170 -8620 {
lab=colon_n[29]}
N 3170 -8620 3370 -8620 {
lab=colon_n[29]}
N 3370 -8620 3380 -8610 {
lab=colon_n[29]}
N 3160 -8590 3170 -8600 {
lab=#net59}
N 3170 -8600 3370 -8600 {
lab=#net59}
N 3370 -8600 3380 -8590 {
lab=#net59}
N 3160 -8570 3170 -8580 {
lab=#net60}
N 3170 -8580 3370 -8580 {
lab=#net60}
N 3370 -8580 3380 -8570 {
lab=#net60}
N 3220 -8730 3220 -8710 {
lab=vcom}
N 3260 -8730 3260 -8710 {
lab=ctop}
N 3140 -8630 3160 -8630 {
lab=col_n[29]}
N 3140 -8610 3160 -8610 {
lab=colon_n[29]}
N 3140 -8590 3160 -8590 {
lab=#net59}
N 3140 -8570 3160 -8570 {
lab=#net60}
N 3380 -8570 3400 -8570 {
lab=#net60}
N 3380 -8590 3400 -8590 {
lab=#net59}
N 3380 -8610 3400 -8610 {
lab=colon_n[29]}
N 3380 -8630 3400 -8630 {
lab=col_n[29]}
N 3200 -8490 3200 -8480 {
lab=VSS}
N 3200 -8720 3200 -8710 {
lab=VDD}
N 3540 -8490 3550 -8500 {
lab=row_n[9]}
N 3550 -8700 3550 -8500 {
lab=row_n[9]}
N 3540 -8710 3550 -8700 {
lab=row_n[9]}
N 3540 -8490 3540 -8470 {
lab=row_n[9]}
N 3540 -8730 3540 -8710 {
lab=row_n[9]}
N 3420 -8630 3430 -8640 {
lab=col_n[29]}
N 3430 -8640 3630 -8640 {
lab=col_n[29]}
N 3630 -8640 3640 -8630 {
lab=col_n[29]}
N 3420 -8610 3430 -8620 {
lab=colon_n[29]}
N 3430 -8620 3630 -8620 {
lab=colon_n[29]}
N 3630 -8620 3640 -8610 {
lab=colon_n[29]}
N 3420 -8590 3430 -8600 {
lab=#net59}
N 3430 -8600 3630 -8600 {
lab=#net59}
N 3630 -8600 3640 -8590 {
lab=#net59}
N 3420 -8570 3430 -8580 {
lab=#net60}
N 3430 -8580 3630 -8580 {
lab=#net60}
N 3630 -8580 3640 -8570 {
lab=#net60}
N 3480 -8730 3480 -8710 {
lab=vcom}
N 3520 -8730 3520 -8710 {
lab=ctop}
N 3400 -8630 3420 -8630 {
lab=col_n[29]}
N 3400 -8610 3420 -8610 {
lab=colon_n[29]}
N 3400 -8590 3420 -8590 {
lab=#net59}
N 3400 -8570 3420 -8570 {
lab=#net60}
N 3640 -8570 3660 -8570 {
lab=#net60}
N 3640 -8590 3660 -8590 {
lab=#net59}
N 3640 -8610 3660 -8610 {
lab=colon_n[29]}
N 3640 -8630 3660 -8630 {
lab=col_n[29]}
N 3460 -8490 3460 -8480 {
lab=VSS}
N 3460 -8720 3460 -8710 {
lab=VDD}
N 3800 -8490 3810 -8500 {
lab=row_n[10]}
N 3810 -8700 3810 -8500 {
lab=row_n[10]}
N 3800 -8710 3810 -8700 {
lab=row_n[10]}
N 3800 -8490 3800 -8470 {
lab=row_n[10]}
N 3800 -8730 3800 -8710 {
lab=row_n[10]}
N 3680 -8630 3690 -8640 {
lab=col_n[29]}
N 3690 -8640 3890 -8640 {
lab=col_n[29]}
N 3890 -8640 3900 -8630 {
lab=col_n[29]}
N 3680 -8610 3690 -8620 {
lab=colon_n[29]}
N 3690 -8620 3890 -8620 {
lab=colon_n[29]}
N 3890 -8620 3900 -8610 {
lab=colon_n[29]}
N 3680 -8590 3690 -8600 {
lab=#net59}
N 3690 -8600 3890 -8600 {
lab=#net59}
N 3890 -8600 3900 -8590 {
lab=#net59}
N 3680 -8570 3690 -8580 {
lab=#net60}
N 3690 -8580 3890 -8580 {
lab=#net60}
N 3890 -8580 3900 -8570 {
lab=#net60}
N 3740 -8730 3740 -8710 {
lab=vcom}
N 3780 -8730 3780 -8710 {
lab=ctop}
N 3660 -8630 3680 -8630 {
lab=col_n[29]}
N 3660 -8610 3680 -8610 {
lab=colon_n[29]}
N 3660 -8590 3680 -8590 {
lab=#net59}
N 3660 -8570 3680 -8570 {
lab=#net60}
N 3900 -8570 3920 -8570 {
lab=#net60}
N 3900 -8590 3920 -8590 {
lab=#net59}
N 3900 -8610 3920 -8610 {
lab=colon_n[29]}
N 3900 -8630 3920 -8630 {
lab=col_n[29]}
N 3720 -8490 3720 -8480 {
lab=VSS}
N 3720 -8720 3720 -8710 {
lab=VDD}
N 4060 -8490 4070 -8500 {
lab=row_n[11]}
N 4070 -8700 4070 -8500 {
lab=row_n[11]}
N 4060 -8710 4070 -8700 {
lab=row_n[11]}
N 4060 -8490 4060 -8470 {
lab=row_n[11]}
N 4060 -8730 4060 -8710 {
lab=row_n[11]}
N 3940 -8630 3950 -8640 {
lab=col_n[29]}
N 3950 -8640 4150 -8640 {
lab=col_n[29]}
N 4150 -8640 4160 -8630 {
lab=col_n[29]}
N 3940 -8610 3950 -8620 {
lab=colon_n[29]}
N 3950 -8620 4150 -8620 {
lab=colon_n[29]}
N 4150 -8620 4160 -8610 {
lab=colon_n[29]}
N 3940 -8590 3950 -8600 {
lab=#net59}
N 3950 -8600 4150 -8600 {
lab=#net59}
N 4150 -8600 4160 -8590 {
lab=#net59}
N 3940 -8570 3950 -8580 {
lab=#net60}
N 3950 -8580 4150 -8580 {
lab=#net60}
N 4150 -8580 4160 -8570 {
lab=#net60}
N 4000 -8730 4000 -8710 {
lab=vcom}
N 4040 -8730 4040 -8710 {
lab=ctop}
N 3920 -8630 3940 -8630 {
lab=col_n[29]}
N 3920 -8610 3940 -8610 {
lab=colon_n[29]}
N 3920 -8590 3940 -8590 {
lab=#net59}
N 3920 -8570 3940 -8570 {
lab=#net60}
N 4160 -8570 4180 -8570 {
lab=#net60}
N 4160 -8590 4180 -8590 {
lab=#net59}
N 4160 -8610 4180 -8610 {
lab=colon_n[29]}
N 4160 -8630 4180 -8630 {
lab=col_n[29]}
N 3980 -8490 3980 -8480 {
lab=VSS}
N 3980 -8720 3980 -8710 {
lab=VDD}
N 4320 -8490 4330 -8500 {
lab=row_n[12]}
N 4330 -8700 4330 -8500 {
lab=row_n[12]}
N 4320 -8710 4330 -8700 {
lab=row_n[12]}
N 4320 -8490 4320 -8470 {
lab=row_n[12]}
N 4320 -8730 4320 -8710 {
lab=row_n[12]}
N 4200 -8630 4210 -8640 {
lab=col_n[29]}
N 4210 -8640 4410 -8640 {
lab=col_n[29]}
N 4410 -8640 4420 -8630 {
lab=col_n[29]}
N 4200 -8610 4210 -8620 {
lab=colon_n[29]}
N 4210 -8620 4410 -8620 {
lab=colon_n[29]}
N 4410 -8620 4420 -8610 {
lab=colon_n[29]}
N 4200 -8590 4210 -8600 {
lab=#net59}
N 4210 -8600 4410 -8600 {
lab=#net59}
N 4410 -8600 4420 -8590 {
lab=#net59}
N 4200 -8570 4210 -8580 {
lab=#net60}
N 4210 -8580 4410 -8580 {
lab=#net60}
N 4410 -8580 4420 -8570 {
lab=#net60}
N 4260 -8730 4260 -8710 {
lab=vcom}
N 4300 -8730 4300 -8710 {
lab=ctop}
N 4180 -8630 4200 -8630 {
lab=col_n[29]}
N 4180 -8610 4200 -8610 {
lab=colon_n[29]}
N 4180 -8590 4200 -8590 {
lab=#net59}
N 4180 -8570 4200 -8570 {
lab=#net60}
N 4420 -8570 4440 -8570 {
lab=#net60}
N 4420 -8590 4440 -8590 {
lab=#net59}
N 4420 -8610 4440 -8610 {
lab=colon_n[29]}
N 4420 -8630 4440 -8630 {
lab=col_n[29]}
N 4240 -8490 4240 -8480 {
lab=VSS}
N 4240 -8720 4240 -8710 {
lab=VDD}
N 4580 -8490 4590 -8500 {
lab=row_n[13]}
N 4590 -8700 4590 -8500 {
lab=row_n[13]}
N 4580 -8710 4590 -8700 {
lab=row_n[13]}
N 4580 -8490 4580 -8470 {
lab=row_n[13]}
N 4580 -8730 4580 -8710 {
lab=row_n[13]}
N 4460 -8630 4470 -8640 {
lab=col_n[29]}
N 4470 -8640 4670 -8640 {
lab=col_n[29]}
N 4670 -8640 4680 -8630 {
lab=col_n[29]}
N 4460 -8610 4470 -8620 {
lab=colon_n[29]}
N 4470 -8620 4670 -8620 {
lab=colon_n[29]}
N 4670 -8620 4680 -8610 {
lab=colon_n[29]}
N 4460 -8590 4470 -8600 {
lab=#net59}
N 4470 -8600 4670 -8600 {
lab=#net59}
N 4670 -8600 4680 -8590 {
lab=#net59}
N 4460 -8570 4470 -8580 {
lab=#net60}
N 4470 -8580 4670 -8580 {
lab=#net60}
N 4670 -8580 4680 -8570 {
lab=#net60}
N 4520 -8730 4520 -8710 {
lab=vcom}
N 4560 -8730 4560 -8710 {
lab=ctop}
N 4440 -8630 4460 -8630 {
lab=col_n[29]}
N 4440 -8610 4460 -8610 {
lab=colon_n[29]}
N 4440 -8590 4460 -8590 {
lab=#net59}
N 4440 -8570 4460 -8570 {
lab=#net60}
N 4680 -8570 4700 -8570 {
lab=#net60}
N 4680 -8590 4700 -8590 {
lab=#net59}
N 4680 -8610 4700 -8610 {
lab=colon_n[29]}
N 4680 -8630 4700 -8630 {
lab=col_n[29]}
N 4500 -8490 4500 -8480 {
lab=VSS}
N 4500 -8720 4500 -8710 {
lab=VDD}
N 4840 -8490 4850 -8500 {
lab=row_n[14]}
N 4850 -8700 4850 -8500 {
lab=row_n[14]}
N 4840 -8710 4850 -8700 {
lab=row_n[14]}
N 4840 -8490 4840 -8470 {
lab=row_n[14]}
N 4840 -8730 4840 -8710 {
lab=row_n[14]}
N 4720 -8630 4730 -8640 {
lab=col_n[29]}
N 4730 -8640 4930 -8640 {
lab=col_n[29]}
N 4930 -8640 4940 -8630 {
lab=col_n[29]}
N 4720 -8610 4730 -8620 {
lab=colon_n[29]}
N 4730 -8620 4930 -8620 {
lab=colon_n[29]}
N 4930 -8620 4940 -8610 {
lab=colon_n[29]}
N 4720 -8590 4730 -8600 {
lab=#net59}
N 4730 -8600 4930 -8600 {
lab=#net59}
N 4930 -8600 4940 -8590 {
lab=#net59}
N 4720 -8570 4730 -8580 {
lab=#net60}
N 4730 -8580 4930 -8580 {
lab=#net60}
N 4930 -8580 4940 -8570 {
lab=#net60}
N 4780 -8730 4780 -8710 {
lab=vcom}
N 4820 -8730 4820 -8710 {
lab=ctop}
N 4700 -8630 4720 -8630 {
lab=col_n[29]}
N 4700 -8610 4720 -8610 {
lab=colon_n[29]}
N 4700 -8590 4720 -8590 {
lab=#net59}
N 4700 -8570 4720 -8570 {
lab=#net60}
N 4940 -8570 4960 -8570 {
lab=#net60}
N 4940 -8590 4960 -8590 {
lab=#net59}
N 4940 -8610 4960 -8610 {
lab=colon_n[29]}
N 4940 -8630 4960 -8630 {
lab=col_n[29]}
N 4760 -8490 4760 -8480 {
lab=VSS}
N 4760 -8720 4760 -8710 {
lab=VDD}
N 5100 -8490 5110 -8500 {
lab=row_n[15]}
N 5110 -8700 5110 -8500 {
lab=row_n[15]}
N 5100 -8710 5110 -8700 {
lab=row_n[15]}
N 5100 -8490 5100 -8470 {
lab=row_n[15]}
N 5100 -8730 5100 -8710 {
lab=row_n[15]}
N 4980 -8630 4990 -8640 {
lab=col_n[29]}
N 4990 -8640 5190 -8640 {
lab=col_n[29]}
N 5190 -8640 5200 -8630 {
lab=col_n[29]}
N 4980 -8610 4990 -8620 {
lab=colon_n[29]}
N 4990 -8620 5190 -8620 {
lab=colon_n[29]}
N 5190 -8620 5200 -8610 {
lab=colon_n[29]}
N 4980 -8590 4990 -8600 {
lab=#net59}
N 4990 -8600 5190 -8600 {
lab=#net59}
N 5190 -8600 5200 -8590 {
lab=#net59}
N 4980 -8570 4990 -8580 {
lab=#net60}
N 4990 -8580 5190 -8580 {
lab=#net60}
N 5190 -8580 5200 -8570 {
lab=#net60}
N 5040 -8730 5040 -8710 {
lab=vcom}
N 5080 -8730 5080 -8710 {
lab=ctop}
N 4960 -8630 4980 -8630 {
lab=col_n[29]}
N 4960 -8610 4980 -8610 {
lab=colon_n[29]}
N 4960 -8590 4980 -8590 {
lab=#net59}
N 4960 -8570 4980 -8570 {
lab=#net60}
N 5200 -8570 5220 -8570 {
lab=#net60}
N 5200 -8590 5220 -8590 {
lab=#net59}
N 5200 -8610 5220 -8610 {
lab=colon_n[29]}
N 5200 -8630 5220 -8630 {
lab=col_n[29]}
N 5020 -8490 5020 -8480 {
lab=VSS}
N 5020 -8720 5020 -8710 {
lab=VDD}
N 5360 -8490 5370 -8500 {
lab=row_n[16]}
N 5370 -8700 5370 -8500 {
lab=row_n[16]}
N 5360 -8710 5370 -8700 {
lab=row_n[16]}
N 5360 -8490 5360 -8470 {
lab=row_n[16]}
N 5360 -8730 5360 -8710 {
lab=row_n[16]}
N 5240 -8630 5250 -8640 {
lab=col_n[29]}
N 5250 -8640 5450 -8640 {
lab=col_n[29]}
N 5450 -8640 5460 -8630 {
lab=col_n[29]}
N 5240 -8610 5250 -8620 {
lab=colon_n[29]}
N 5250 -8620 5450 -8620 {
lab=colon_n[29]}
N 5450 -8620 5460 -8610 {
lab=colon_n[29]}
N 5240 -8590 5250 -8600 {
lab=#net59}
N 5250 -8600 5450 -8600 {
lab=#net59}
N 5450 -8600 5460 -8590 {
lab=#net59}
N 5240 -8570 5250 -8580 {
lab=#net60}
N 5250 -8580 5450 -8580 {
lab=#net60}
N 5450 -8580 5460 -8570 {
lab=#net60}
N 5300 -8730 5300 -8710 {
lab=vcom}
N 5340 -8730 5340 -8710 {
lab=ctop}
N 5220 -8630 5240 -8630 {
lab=col_n[29]}
N 5220 -8610 5240 -8610 {
lab=colon_n[29]}
N 5220 -8590 5240 -8590 {
lab=#net59}
N 5220 -8570 5240 -8570 {
lab=#net60}
N 5460 -8570 5480 -8570 {
lab=#net60}
N 5460 -8590 5480 -8590 {
lab=#net59}
N 5460 -8610 5480 -8610 {
lab=colon_n[29]}
N 5460 -8630 5480 -8630 {
lab=col_n[29]}
N 5280 -8490 5280 -8480 {
lab=VSS}
N 5280 -8720 5280 -8710 {
lab=VDD}
N 5620 -8490 5630 -8500 {
lab=row_n[17]}
N 5630 -8700 5630 -8500 {
lab=row_n[17]}
N 5620 -8710 5630 -8700 {
lab=row_n[17]}
N 5620 -8490 5620 -8470 {
lab=row_n[17]}
N 5620 -8730 5620 -8710 {
lab=row_n[17]}
N 5500 -8630 5510 -8640 {
lab=col_n[29]}
N 5510 -8640 5710 -8640 {
lab=col_n[29]}
N 5710 -8640 5720 -8630 {
lab=col_n[29]}
N 5500 -8610 5510 -8620 {
lab=colon_n[29]}
N 5510 -8620 5710 -8620 {
lab=colon_n[29]}
N 5710 -8620 5720 -8610 {
lab=colon_n[29]}
N 5500 -8590 5510 -8600 {
lab=#net59}
N 5510 -8600 5710 -8600 {
lab=#net59}
N 5710 -8600 5720 -8590 {
lab=#net59}
N 5500 -8570 5510 -8580 {
lab=#net60}
N 5510 -8580 5710 -8580 {
lab=#net60}
N 5710 -8580 5720 -8570 {
lab=#net60}
N 5560 -8730 5560 -8710 {
lab=vcom}
N 5600 -8730 5600 -8710 {
lab=ctop}
N 5480 -8630 5500 -8630 {
lab=col_n[29]}
N 5480 -8610 5500 -8610 {
lab=colon_n[29]}
N 5480 -8590 5500 -8590 {
lab=#net59}
N 5480 -8570 5500 -8570 {
lab=#net60}
N 5720 -8570 5740 -8570 {
lab=#net60}
N 5720 -8590 5740 -8590 {
lab=#net59}
N 5720 -8610 5740 -8610 {
lab=colon_n[29]}
N 5720 -8630 5740 -8630 {
lab=col_n[29]}
N 5540 -8490 5540 -8480 {
lab=VSS}
N 5540 -8720 5540 -8710 {
lab=VDD}
N 5880 -8490 5890 -8500 {
lab=row_n[18]}
N 5890 -8700 5890 -8500 {
lab=row_n[18]}
N 5880 -8710 5890 -8700 {
lab=row_n[18]}
N 5880 -8490 5880 -8470 {
lab=row_n[18]}
N 5880 -8730 5880 -8710 {
lab=row_n[18]}
N 5760 -8630 5770 -8640 {
lab=col_n[29]}
N 5770 -8640 5970 -8640 {
lab=col_n[29]}
N 5970 -8640 5980 -8630 {
lab=col_n[29]}
N 5760 -8610 5770 -8620 {
lab=colon_n[29]}
N 5770 -8620 5970 -8620 {
lab=colon_n[29]}
N 5970 -8620 5980 -8610 {
lab=colon_n[29]}
N 5760 -8590 5770 -8600 {
lab=#net59}
N 5770 -8600 5970 -8600 {
lab=#net59}
N 5970 -8600 5980 -8590 {
lab=#net59}
N 5760 -8570 5770 -8580 {
lab=#net60}
N 5770 -8580 5970 -8580 {
lab=#net60}
N 5970 -8580 5980 -8570 {
lab=#net60}
N 5820 -8730 5820 -8710 {
lab=vcom}
N 5860 -8730 5860 -8710 {
lab=ctop}
N 5740 -8630 5760 -8630 {
lab=col_n[29]}
N 5740 -8610 5760 -8610 {
lab=colon_n[29]}
N 5740 -8590 5760 -8590 {
lab=#net59}
N 5740 -8570 5760 -8570 {
lab=#net60}
N 5980 -8570 6000 -8570 {
lab=#net60}
N 5980 -8590 6000 -8590 {
lab=#net59}
N 5980 -8610 6000 -8610 {
lab=colon_n[29]}
N 5980 -8630 6000 -8630 {
lab=col_n[29]}
N 5800 -8490 5800 -8480 {
lab=VSS}
N 5800 -8720 5800 -8710 {
lab=VDD}
N 6140 -8490 6150 -8500 {
lab=row_n[19]}
N 6150 -8700 6150 -8500 {
lab=row_n[19]}
N 6140 -8710 6150 -8700 {
lab=row_n[19]}
N 6140 -8490 6140 -8470 {
lab=row_n[19]}
N 6140 -8730 6140 -8710 {
lab=row_n[19]}
N 6020 -8630 6030 -8640 {
lab=col_n[29]}
N 6030 -8640 6230 -8640 {
lab=col_n[29]}
N 6230 -8640 6240 -8630 {
lab=col_n[29]}
N 6020 -8610 6030 -8620 {
lab=colon_n[29]}
N 6030 -8620 6230 -8620 {
lab=colon_n[29]}
N 6230 -8620 6240 -8610 {
lab=colon_n[29]}
N 6020 -8590 6030 -8600 {
lab=#net59}
N 6030 -8600 6230 -8600 {
lab=#net59}
N 6230 -8600 6240 -8590 {
lab=#net59}
N 6020 -8570 6030 -8580 {
lab=#net60}
N 6030 -8580 6230 -8580 {
lab=#net60}
N 6230 -8580 6240 -8570 {
lab=#net60}
N 6080 -8730 6080 -8710 {
lab=vcom}
N 6120 -8730 6120 -8710 {
lab=ctop}
N 6000 -8630 6020 -8630 {
lab=col_n[29]}
N 6000 -8610 6020 -8610 {
lab=colon_n[29]}
N 6000 -8590 6020 -8590 {
lab=#net59}
N 6000 -8570 6020 -8570 {
lab=#net60}
N 6240 -8570 6260 -8570 {
lab=#net60}
N 6240 -8590 6260 -8590 {
lab=#net59}
N 6240 -8610 6260 -8610 {
lab=colon_n[29]}
N 6240 -8630 6260 -8630 {
lab=col_n[29]}
N 6060 -8490 6060 -8480 {
lab=VSS}
N 6060 -8720 6060 -8710 {
lab=VDD}
N 6400 -8490 6410 -8500 {
lab=row_n[20]}
N 6410 -8700 6410 -8500 {
lab=row_n[20]}
N 6400 -8710 6410 -8700 {
lab=row_n[20]}
N 6400 -8490 6400 -8470 {
lab=row_n[20]}
N 6400 -8730 6400 -8710 {
lab=row_n[20]}
N 6280 -8630 6290 -8640 {
lab=col_n[29]}
N 6290 -8640 6490 -8640 {
lab=col_n[29]}
N 6490 -8640 6500 -8630 {
lab=col_n[29]}
N 6280 -8610 6290 -8620 {
lab=colon_n[29]}
N 6290 -8620 6490 -8620 {
lab=colon_n[29]}
N 6490 -8620 6500 -8610 {
lab=colon_n[29]}
N 6280 -8590 6290 -8600 {
lab=#net59}
N 6290 -8600 6490 -8600 {
lab=#net59}
N 6490 -8600 6500 -8590 {
lab=#net59}
N 6280 -8570 6290 -8580 {
lab=#net60}
N 6290 -8580 6490 -8580 {
lab=#net60}
N 6490 -8580 6500 -8570 {
lab=#net60}
N 6340 -8730 6340 -8710 {
lab=vcom}
N 6380 -8730 6380 -8710 {
lab=ctop}
N 6260 -8630 6280 -8630 {
lab=col_n[29]}
N 6260 -8610 6280 -8610 {
lab=colon_n[29]}
N 6260 -8590 6280 -8590 {
lab=#net59}
N 6260 -8570 6280 -8570 {
lab=#net60}
N 6500 -8570 6520 -8570 {
lab=#net60}
N 6500 -8590 6520 -8590 {
lab=#net59}
N 6500 -8610 6520 -8610 {
lab=colon_n[29]}
N 6500 -8630 6520 -8630 {
lab=col_n[29]}
N 6320 -8490 6320 -8480 {
lab=VSS}
N 6320 -8720 6320 -8710 {
lab=VDD}
N 6660 -8490 6670 -8500 {
lab=row_n[21]}
N 6670 -8700 6670 -8500 {
lab=row_n[21]}
N 6660 -8710 6670 -8700 {
lab=row_n[21]}
N 6660 -8490 6660 -8470 {
lab=row_n[21]}
N 6660 -8730 6660 -8710 {
lab=row_n[21]}
N 6540 -8630 6550 -8640 {
lab=col_n[29]}
N 6550 -8640 6750 -8640 {
lab=col_n[29]}
N 6750 -8640 6760 -8630 {
lab=col_n[29]}
N 6540 -8610 6550 -8620 {
lab=colon_n[29]}
N 6550 -8620 6750 -8620 {
lab=colon_n[29]}
N 6750 -8620 6760 -8610 {
lab=colon_n[29]}
N 6540 -8590 6550 -8600 {
lab=#net59}
N 6550 -8600 6750 -8600 {
lab=#net59}
N 6750 -8600 6760 -8590 {
lab=#net59}
N 6540 -8570 6550 -8580 {
lab=#net60}
N 6550 -8580 6750 -8580 {
lab=#net60}
N 6750 -8580 6760 -8570 {
lab=#net60}
N 6600 -8730 6600 -8710 {
lab=vcom}
N 6640 -8730 6640 -8710 {
lab=ctop}
N 6520 -8630 6540 -8630 {
lab=col_n[29]}
N 6520 -8610 6540 -8610 {
lab=colon_n[29]}
N 6520 -8590 6540 -8590 {
lab=#net59}
N 6520 -8570 6540 -8570 {
lab=#net60}
N 6760 -8570 6780 -8570 {
lab=#net60}
N 6760 -8590 6780 -8590 {
lab=#net59}
N 6760 -8610 6780 -8610 {
lab=colon_n[29]}
N 6760 -8630 6780 -8630 {
lab=col_n[29]}
N 6580 -8490 6580 -8480 {
lab=VSS}
N 6580 -8720 6580 -8710 {
lab=VDD}
N 6920 -8490 6930 -8500 {
lab=row_n[22]}
N 6930 -8700 6930 -8500 {
lab=row_n[22]}
N 6920 -8710 6930 -8700 {
lab=row_n[22]}
N 6920 -8490 6920 -8470 {
lab=row_n[22]}
N 6920 -8730 6920 -8710 {
lab=row_n[22]}
N 6800 -8630 6810 -8640 {
lab=col_n[29]}
N 6810 -8640 7010 -8640 {
lab=col_n[29]}
N 7010 -8640 7020 -8630 {
lab=col_n[29]}
N 6800 -8610 6810 -8620 {
lab=colon_n[29]}
N 6810 -8620 7010 -8620 {
lab=colon_n[29]}
N 7010 -8620 7020 -8610 {
lab=colon_n[29]}
N 6800 -8590 6810 -8600 {
lab=#net59}
N 6810 -8600 7010 -8600 {
lab=#net59}
N 7010 -8600 7020 -8590 {
lab=#net59}
N 6800 -8570 6810 -8580 {
lab=#net60}
N 6810 -8580 7010 -8580 {
lab=#net60}
N 7010 -8580 7020 -8570 {
lab=#net60}
N 6860 -8730 6860 -8710 {
lab=vcom}
N 6900 -8730 6900 -8710 {
lab=ctop}
N 6780 -8630 6800 -8630 {
lab=col_n[29]}
N 6780 -8610 6800 -8610 {
lab=colon_n[29]}
N 6780 -8590 6800 -8590 {
lab=#net59}
N 6780 -8570 6800 -8570 {
lab=#net60}
N 7020 -8570 7040 -8570 {
lab=#net60}
N 7020 -8590 7040 -8590 {
lab=#net59}
N 7020 -8610 7040 -8610 {
lab=colon_n[29]}
N 7020 -8630 7040 -8630 {
lab=col_n[29]}
N 6840 -8490 6840 -8480 {
lab=VSS}
N 6840 -8720 6840 -8710 {
lab=VDD}
N 7180 -8490 7190 -8500 {
lab=row_n[23]}
N 7190 -8700 7190 -8500 {
lab=row_n[23]}
N 7180 -8710 7190 -8700 {
lab=row_n[23]}
N 7180 -8490 7180 -8470 {
lab=row_n[23]}
N 7180 -8730 7180 -8710 {
lab=row_n[23]}
N 7060 -8630 7070 -8640 {
lab=col_n[29]}
N 7070 -8640 7270 -8640 {
lab=col_n[29]}
N 7270 -8640 7280 -8630 {
lab=col_n[29]}
N 7060 -8610 7070 -8620 {
lab=colon_n[29]}
N 7070 -8620 7270 -8620 {
lab=colon_n[29]}
N 7270 -8620 7280 -8610 {
lab=colon_n[29]}
N 7060 -8590 7070 -8600 {
lab=#net59}
N 7070 -8600 7270 -8600 {
lab=#net59}
N 7270 -8600 7280 -8590 {
lab=#net59}
N 7060 -8570 7070 -8580 {
lab=#net60}
N 7070 -8580 7270 -8580 {
lab=#net60}
N 7270 -8580 7280 -8570 {
lab=#net60}
N 7120 -8730 7120 -8710 {
lab=vcom}
N 7160 -8730 7160 -8710 {
lab=ctop}
N 7040 -8630 7060 -8630 {
lab=col_n[29]}
N 7040 -8610 7060 -8610 {
lab=colon_n[29]}
N 7040 -8590 7060 -8590 {
lab=#net59}
N 7040 -8570 7060 -8570 {
lab=#net60}
N 7280 -8570 7300 -8570 {
lab=#net60}
N 7280 -8590 7300 -8590 {
lab=#net59}
N 7280 -8610 7300 -8610 {
lab=colon_n[29]}
N 7280 -8630 7300 -8630 {
lab=col_n[29]}
N 7100 -8490 7100 -8480 {
lab=VSS}
N 7100 -8720 7100 -8710 {
lab=VDD}
N 7440 -8490 7450 -8500 {
lab=row_n[24]}
N 7450 -8700 7450 -8500 {
lab=row_n[24]}
N 7440 -8710 7450 -8700 {
lab=row_n[24]}
N 7440 -8490 7440 -8470 {
lab=row_n[24]}
N 7440 -8730 7440 -8710 {
lab=row_n[24]}
N 7320 -8630 7330 -8640 {
lab=col_n[29]}
N 7330 -8640 7530 -8640 {
lab=col_n[29]}
N 7530 -8640 7540 -8630 {
lab=col_n[29]}
N 7320 -8610 7330 -8620 {
lab=colon_n[29]}
N 7330 -8620 7530 -8620 {
lab=colon_n[29]}
N 7530 -8620 7540 -8610 {
lab=colon_n[29]}
N 7320 -8590 7330 -8600 {
lab=#net59}
N 7330 -8600 7530 -8600 {
lab=#net59}
N 7530 -8600 7540 -8590 {
lab=#net59}
N 7320 -8570 7330 -8580 {
lab=#net60}
N 7330 -8580 7530 -8580 {
lab=#net60}
N 7530 -8580 7540 -8570 {
lab=#net60}
N 7380 -8730 7380 -8710 {
lab=vcom}
N 7420 -8730 7420 -8710 {
lab=ctop}
N 7300 -8630 7320 -8630 {
lab=col_n[29]}
N 7300 -8610 7320 -8610 {
lab=colon_n[29]}
N 7300 -8590 7320 -8590 {
lab=#net59}
N 7300 -8570 7320 -8570 {
lab=#net60}
N 7540 -8570 7560 -8570 {
lab=#net60}
N 7540 -8590 7560 -8590 {
lab=#net59}
N 7540 -8610 7560 -8610 {
lab=colon_n[29]}
N 7540 -8630 7560 -8630 {
lab=col_n[29]}
N 7360 -8490 7360 -8480 {
lab=VSS}
N 7360 -8720 7360 -8710 {
lab=VDD}
N 7700 -8490 7710 -8500 {
lab=row_n[25]}
N 7710 -8700 7710 -8500 {
lab=row_n[25]}
N 7700 -8710 7710 -8700 {
lab=row_n[25]}
N 7700 -8490 7700 -8470 {
lab=row_n[25]}
N 7700 -8730 7700 -8710 {
lab=row_n[25]}
N 7580 -8630 7590 -8640 {
lab=col_n[29]}
N 7590 -8640 7790 -8640 {
lab=col_n[29]}
N 7790 -8640 7800 -8630 {
lab=col_n[29]}
N 7580 -8610 7590 -8620 {
lab=colon_n[29]}
N 7590 -8620 7790 -8620 {
lab=colon_n[29]}
N 7790 -8620 7800 -8610 {
lab=colon_n[29]}
N 7580 -8590 7590 -8600 {
lab=#net59}
N 7590 -8600 7790 -8600 {
lab=#net59}
N 7790 -8600 7800 -8590 {
lab=#net59}
N 7580 -8570 7590 -8580 {
lab=#net60}
N 7590 -8580 7790 -8580 {
lab=#net60}
N 7790 -8580 7800 -8570 {
lab=#net60}
N 7640 -8730 7640 -8710 {
lab=vcom}
N 7680 -8730 7680 -8710 {
lab=ctop}
N 7560 -8630 7580 -8630 {
lab=col_n[29]}
N 7560 -8610 7580 -8610 {
lab=colon_n[29]}
N 7560 -8590 7580 -8590 {
lab=#net59}
N 7560 -8570 7580 -8570 {
lab=#net60}
N 7800 -8570 7820 -8570 {
lab=#net60}
N 7800 -8590 7820 -8590 {
lab=#net59}
N 7800 -8610 7820 -8610 {
lab=colon_n[29]}
N 7800 -8630 7820 -8630 {
lab=col_n[29]}
N 7620 -8490 7620 -8480 {
lab=VSS}
N 7620 -8720 7620 -8710 {
lab=VDD}
N 7960 -8490 7970 -8500 {
lab=row_n[26]}
N 7970 -8700 7970 -8500 {
lab=row_n[26]}
N 7960 -8710 7970 -8700 {
lab=row_n[26]}
N 7960 -8490 7960 -8470 {
lab=row_n[26]}
N 7960 -8730 7960 -8710 {
lab=row_n[26]}
N 7840 -8630 7850 -8640 {
lab=col_n[29]}
N 7850 -8640 8050 -8640 {
lab=col_n[29]}
N 8050 -8640 8060 -8630 {
lab=col_n[29]}
N 7840 -8610 7850 -8620 {
lab=colon_n[29]}
N 7850 -8620 8050 -8620 {
lab=colon_n[29]}
N 8050 -8620 8060 -8610 {
lab=colon_n[29]}
N 7840 -8590 7850 -8600 {
lab=#net59}
N 7850 -8600 8050 -8600 {
lab=#net59}
N 8050 -8600 8060 -8590 {
lab=#net59}
N 7840 -8570 7850 -8580 {
lab=#net60}
N 7850 -8580 8050 -8580 {
lab=#net60}
N 8050 -8580 8060 -8570 {
lab=#net60}
N 7900 -8730 7900 -8710 {
lab=vcom}
N 7940 -8730 7940 -8710 {
lab=ctop}
N 7820 -8630 7840 -8630 {
lab=col_n[29]}
N 7820 -8610 7840 -8610 {
lab=colon_n[29]}
N 7820 -8590 7840 -8590 {
lab=#net59}
N 7820 -8570 7840 -8570 {
lab=#net60}
N 8060 -8570 8080 -8570 {
lab=#net60}
N 8060 -8590 8080 -8590 {
lab=#net59}
N 8060 -8610 8080 -8610 {
lab=colon_n[29]}
N 8060 -8630 8080 -8630 {
lab=col_n[29]}
N 7880 -8490 7880 -8480 {
lab=VSS}
N 7880 -8720 7880 -8710 {
lab=VDD}
N 8220 -8490 8230 -8500 {
lab=row_n[27]}
N 8230 -8700 8230 -8500 {
lab=row_n[27]}
N 8220 -8710 8230 -8700 {
lab=row_n[27]}
N 8220 -8490 8220 -8470 {
lab=row_n[27]}
N 8220 -8730 8220 -8710 {
lab=row_n[27]}
N 8100 -8630 8110 -8640 {
lab=col_n[29]}
N 8110 -8640 8310 -8640 {
lab=col_n[29]}
N 8310 -8640 8320 -8630 {
lab=col_n[29]}
N 8100 -8610 8110 -8620 {
lab=colon_n[29]}
N 8110 -8620 8310 -8620 {
lab=colon_n[29]}
N 8310 -8620 8320 -8610 {
lab=colon_n[29]}
N 8100 -8590 8110 -8600 {
lab=#net59}
N 8110 -8600 8310 -8600 {
lab=#net59}
N 8310 -8600 8320 -8590 {
lab=#net59}
N 8100 -8570 8110 -8580 {
lab=#net60}
N 8110 -8580 8310 -8580 {
lab=#net60}
N 8310 -8580 8320 -8570 {
lab=#net60}
N 8160 -8730 8160 -8710 {
lab=vcom}
N 8200 -8730 8200 -8710 {
lab=ctop}
N 8080 -8630 8100 -8630 {
lab=col_n[29]}
N 8080 -8610 8100 -8610 {
lab=colon_n[29]}
N 8080 -8590 8100 -8590 {
lab=#net59}
N 8080 -8570 8100 -8570 {
lab=#net60}
N 8320 -8570 8340 -8570 {
lab=#net60}
N 8320 -8590 8340 -8590 {
lab=#net59}
N 8320 -8610 8340 -8610 {
lab=colon_n[29]}
N 8320 -8630 8340 -8630 {
lab=col_n[29]}
N 8140 -8490 8140 -8480 {
lab=VSS}
N 8140 -8720 8140 -8710 {
lab=VDD}
N 8480 -8490 8490 -8500 {
lab=row_n[28]}
N 8490 -8700 8490 -8500 {
lab=row_n[28]}
N 8480 -8710 8490 -8700 {
lab=row_n[28]}
N 8480 -8490 8480 -8470 {
lab=row_n[28]}
N 8480 -8730 8480 -8710 {
lab=row_n[28]}
N 8360 -8630 8370 -8640 {
lab=col_n[29]}
N 8370 -8640 8570 -8640 {
lab=col_n[29]}
N 8570 -8640 8580 -8630 {
lab=col_n[29]}
N 8360 -8610 8370 -8620 {
lab=colon_n[29]}
N 8370 -8620 8570 -8620 {
lab=colon_n[29]}
N 8570 -8620 8580 -8610 {
lab=colon_n[29]}
N 8360 -8590 8370 -8600 {
lab=#net59}
N 8370 -8600 8570 -8600 {
lab=#net59}
N 8570 -8600 8580 -8590 {
lab=#net59}
N 8360 -8570 8370 -8580 {
lab=#net60}
N 8370 -8580 8570 -8580 {
lab=#net60}
N 8570 -8580 8580 -8570 {
lab=#net60}
N 8420 -8730 8420 -8710 {
lab=vcom}
N 8460 -8730 8460 -8710 {
lab=ctop}
N 8340 -8630 8360 -8630 {
lab=col_n[29]}
N 8340 -8610 8360 -8610 {
lab=colon_n[29]}
N 8340 -8590 8360 -8590 {
lab=#net59}
N 8340 -8570 8360 -8570 {
lab=#net60}
N 8580 -8570 8600 -8570 {
lab=#net60}
N 8580 -8590 8600 -8590 {
lab=#net59}
N 8580 -8610 8600 -8610 {
lab=colon_n[29]}
N 8580 -8630 8600 -8630 {
lab=col_n[29]}
N 8400 -8490 8400 -8480 {
lab=VSS}
N 8400 -8720 8400 -8710 {
lab=VDD}
N 8740 -8490 8750 -8500 {
lab=row_n[29]}
N 8750 -8700 8750 -8500 {
lab=row_n[29]}
N 8740 -8710 8750 -8700 {
lab=row_n[29]}
N 8740 -8490 8740 -8470 {
lab=row_n[29]}
N 8740 -8730 8740 -8710 {
lab=row_n[29]}
N 8620 -8630 8630 -8640 {
lab=col_n[29]}
N 8630 -8640 8830 -8640 {
lab=col_n[29]}
N 8830 -8640 8840 -8630 {
lab=col_n[29]}
N 8620 -8610 8630 -8620 {
lab=colon_n[29]}
N 8630 -8620 8830 -8620 {
lab=colon_n[29]}
N 8830 -8620 8840 -8610 {
lab=colon_n[29]}
N 8620 -8590 8630 -8600 {
lab=#net59}
N 8630 -8600 8830 -8600 {
lab=#net59}
N 8830 -8600 8840 -8590 {
lab=#net59}
N 8620 -8570 8630 -8580 {
lab=#net60}
N 8630 -8580 8830 -8580 {
lab=#net60}
N 8830 -8580 8840 -8570 {
lab=#net60}
N 8680 -8730 8680 -8710 {
lab=vcom}
N 8720 -8730 8720 -8710 {
lab=ctop}
N 8600 -8630 8620 -8630 {
lab=col_n[29]}
N 8600 -8610 8620 -8610 {
lab=colon_n[29]}
N 8600 -8590 8620 -8590 {
lab=#net59}
N 8600 -8570 8620 -8570 {
lab=#net60}
N 8840 -8570 8860 -8570 {
lab=#net60}
N 8840 -8590 8860 -8590 {
lab=#net59}
N 8840 -8610 8860 -8610 {
lab=colon_n[29]}
N 8840 -8630 8860 -8630 {
lab=col_n[29]}
N 8660 -8490 8660 -8480 {
lab=VSS}
N 8660 -8720 8660 -8710 {
lab=VDD}
N 9000 -8490 9010 -8500 {
lab=row_n[30]}
N 9010 -8700 9010 -8500 {
lab=row_n[30]}
N 9000 -8710 9010 -8700 {
lab=row_n[30]}
N 9000 -8490 9000 -8470 {
lab=row_n[30]}
N 9000 -8730 9000 -8710 {
lab=row_n[30]}
N 8880 -8630 8890 -8640 {
lab=col_n[29]}
N 8890 -8640 9090 -8640 {
lab=col_n[29]}
N 9090 -8640 9100 -8630 {
lab=col_n[29]}
N 8880 -8610 8890 -8620 {
lab=colon_n[29]}
N 8890 -8620 9090 -8620 {
lab=colon_n[29]}
N 9090 -8620 9100 -8610 {
lab=colon_n[29]}
N 8880 -8590 8890 -8600 {
lab=#net59}
N 8890 -8600 9090 -8600 {
lab=#net59}
N 9090 -8600 9100 -8590 {
lab=#net59}
N 8880 -8570 8890 -8580 {
lab=#net60}
N 8890 -8580 9090 -8580 {
lab=#net60}
N 9090 -8580 9100 -8570 {
lab=#net60}
N 8940 -8730 8940 -8710 {
lab=vcom}
N 8980 -8730 8980 -8710 {
lab=ctop}
N 8860 -8630 8880 -8630 {
lab=col_n[29]}
N 8860 -8610 8880 -8610 {
lab=colon_n[29]}
N 8860 -8590 8880 -8590 {
lab=#net59}
N 8860 -8570 8880 -8570 {
lab=#net60}
N 9100 -8570 9120 -8570 {
lab=#net60}
N 9100 -8590 9120 -8590 {
lab=#net59}
N 9100 -8610 9120 -8610 {
lab=colon_n[29]}
N 9100 -8630 9120 -8630 {
lab=col_n[29]}
N 8920 -8490 8920 -8480 {
lab=VSS}
N 8920 -8720 8920 -8710 {
lab=VDD}
N 9260 -8490 9270 -8500 {
lab=row_n[31]}
N 9270 -8700 9270 -8500 {
lab=row_n[31]}
N 9260 -8710 9270 -8700 {
lab=row_n[31]}
N 9260 -8490 9260 -8470 {
lab=row_n[31]}
N 9260 -8730 9260 -8710 {
lab=row_n[31]}
N 9140 -8630 9150 -8640 {
lab=col_n[29]}
N 9150 -8640 9350 -8640 {
lab=col_n[29]}
N 9350 -8640 9360 -8630 {
lab=col_n[29]}
N 9140 -8610 9150 -8620 {
lab=colon_n[29]}
N 9150 -8620 9350 -8620 {
lab=colon_n[29]}
N 9350 -8620 9360 -8610 {
lab=colon_n[29]}
N 9140 -8590 9150 -8600 {
lab=#net59}
N 9150 -8600 9350 -8600 {
lab=#net59}
N 9350 -8600 9360 -8590 {
lab=#net59}
N 9140 -8570 9150 -8580 {
lab=#net60}
N 9150 -8580 9350 -8580 {
lab=#net60}
N 9350 -8580 9360 -8570 {
lab=#net60}
N 9200 -8730 9200 -8710 {
lab=vcom}
N 9240 -8730 9240 -8710 {
lab=ctop}
N 9120 -8630 9140 -8630 {
lab=col_n[29]}
N 9120 -8610 9140 -8610 {
lab=colon_n[29]}
N 9120 -8590 9140 -8590 {
lab=#net59}
N 9120 -8570 9140 -8570 {
lab=#net60}
N 9360 -8570 9380 -8570 {
lab=#net60}
N 9360 -8590 9380 -8590 {
lab=#net59}
N 9360 -8610 9380 -8610 {
lab=colon_n[29]}
N 9360 -8630 9380 -8630 {
lab=col_n[29]}
N 9180 -8490 9180 -8480 {
lab=VSS}
N 9180 -8720 9180 -8710 {
lab=VDD}
N 1200 -8750 1210 -8760 {
lab=row_n[0]}
N 1210 -8960 1210 -8760 {
lab=row_n[0]}
N 1200 -8970 1210 -8960 {
lab=row_n[0]}
N 1200 -8750 1200 -8730 {
lab=row_n[0]}
N 1200 -8990 1200 -8970 {
lab=row_n[0]}
N 1080 -8890 1090 -8900 {
lab=col_n[30]}
N 1090 -8900 1290 -8900 {
lab=col_n[30]}
N 1290 -8900 1300 -8890 {
lab=col_n[30]}
N 1080 -8870 1090 -8880 {
lab=colon_n[30]}
N 1090 -8880 1290 -8880 {
lab=colon_n[30]}
N 1290 -8880 1300 -8870 {
lab=colon_n[30]}
N 1080 -8850 1090 -8860 {
lab=#net61}
N 1090 -8860 1290 -8860 {
lab=#net61}
N 1290 -8860 1300 -8850 {
lab=#net61}
N 1080 -8830 1090 -8840 {
lab=#net62}
N 1090 -8840 1290 -8840 {
lab=#net62}
N 1290 -8840 1300 -8830 {
lab=#net62}
N 1140 -8990 1140 -8970 {
lab=vcom}
N 1180 -8990 1180 -8970 {
lab=ctop}
N 1060 -8890 1080 -8890 {
lab=col_n[30]}
N 1060 -8870 1080 -8870 {
lab=colon_n[30]}
N 1060 -8850 1080 -8850 {
lab=#net61}
N 1060 -8830 1080 -8830 {
lab=#net62}
N 1300 -8830 1320 -8830 {
lab=#net62}
N 1300 -8850 1320 -8850 {
lab=#net61}
N 1300 -8870 1320 -8870 {
lab=colon_n[30]}
N 1300 -8890 1320 -8890 {
lab=col_n[30]}
N 1120 -8750 1120 -8740 {
lab=VSS}
N 1120 -8980 1120 -8970 {
lab=VDD}
N 1460 -8750 1470 -8760 {
lab=row_n[1]}
N 1470 -8960 1470 -8760 {
lab=row_n[1]}
N 1460 -8970 1470 -8960 {
lab=row_n[1]}
N 1460 -8750 1460 -8730 {
lab=row_n[1]}
N 1460 -8990 1460 -8970 {
lab=row_n[1]}
N 1340 -8890 1350 -8900 {
lab=col_n[30]}
N 1350 -8900 1550 -8900 {
lab=col_n[30]}
N 1550 -8900 1560 -8890 {
lab=col_n[30]}
N 1340 -8870 1350 -8880 {
lab=colon_n[30]}
N 1350 -8880 1550 -8880 {
lab=colon_n[30]}
N 1550 -8880 1560 -8870 {
lab=colon_n[30]}
N 1340 -8850 1350 -8860 {
lab=#net61}
N 1350 -8860 1550 -8860 {
lab=#net61}
N 1550 -8860 1560 -8850 {
lab=#net61}
N 1340 -8830 1350 -8840 {
lab=#net62}
N 1350 -8840 1550 -8840 {
lab=#net62}
N 1550 -8840 1560 -8830 {
lab=#net62}
N 1400 -8990 1400 -8970 {
lab=vcom}
N 1440 -8990 1440 -8970 {
lab=ctop}
N 1320 -8890 1340 -8890 {
lab=col_n[30]}
N 1320 -8870 1340 -8870 {
lab=colon_n[30]}
N 1320 -8850 1340 -8850 {
lab=#net61}
N 1320 -8830 1340 -8830 {
lab=#net62}
N 1560 -8830 1580 -8830 {
lab=#net62}
N 1560 -8850 1580 -8850 {
lab=#net61}
N 1560 -8870 1580 -8870 {
lab=colon_n[30]}
N 1560 -8890 1580 -8890 {
lab=col_n[30]}
N 1380 -8750 1380 -8740 {
lab=VSS}
N 1380 -8980 1380 -8970 {
lab=VDD}
N 1720 -8750 1730 -8760 {
lab=row_n[2]}
N 1730 -8960 1730 -8760 {
lab=row_n[2]}
N 1720 -8970 1730 -8960 {
lab=row_n[2]}
N 1720 -8750 1720 -8730 {
lab=row_n[2]}
N 1720 -8990 1720 -8970 {
lab=row_n[2]}
N 1600 -8890 1610 -8900 {
lab=col_n[30]}
N 1610 -8900 1810 -8900 {
lab=col_n[30]}
N 1810 -8900 1820 -8890 {
lab=col_n[30]}
N 1600 -8870 1610 -8880 {
lab=colon_n[30]}
N 1610 -8880 1810 -8880 {
lab=colon_n[30]}
N 1810 -8880 1820 -8870 {
lab=colon_n[30]}
N 1600 -8850 1610 -8860 {
lab=#net61}
N 1610 -8860 1810 -8860 {
lab=#net61}
N 1810 -8860 1820 -8850 {
lab=#net61}
N 1600 -8830 1610 -8840 {
lab=#net62}
N 1610 -8840 1810 -8840 {
lab=#net62}
N 1810 -8840 1820 -8830 {
lab=#net62}
N 1660 -8990 1660 -8970 {
lab=vcom}
N 1700 -8990 1700 -8970 {
lab=ctop}
N 1580 -8890 1600 -8890 {
lab=col_n[30]}
N 1580 -8870 1600 -8870 {
lab=colon_n[30]}
N 1580 -8850 1600 -8850 {
lab=#net61}
N 1580 -8830 1600 -8830 {
lab=#net62}
N 1820 -8830 1840 -8830 {
lab=#net62}
N 1820 -8850 1840 -8850 {
lab=#net61}
N 1820 -8870 1840 -8870 {
lab=colon_n[30]}
N 1820 -8890 1840 -8890 {
lab=col_n[30]}
N 1640 -8750 1640 -8740 {
lab=VSS}
N 1640 -8980 1640 -8970 {
lab=VDD}
N 1980 -8750 1990 -8760 {
lab=row_n[3]}
N 1990 -8960 1990 -8760 {
lab=row_n[3]}
N 1980 -8970 1990 -8960 {
lab=row_n[3]}
N 1980 -8750 1980 -8730 {
lab=row_n[3]}
N 1980 -8990 1980 -8970 {
lab=row_n[3]}
N 1860 -8890 1870 -8900 {
lab=col_n[30]}
N 1870 -8900 2070 -8900 {
lab=col_n[30]}
N 2070 -8900 2080 -8890 {
lab=col_n[30]}
N 1860 -8870 1870 -8880 {
lab=colon_n[30]}
N 1870 -8880 2070 -8880 {
lab=colon_n[30]}
N 2070 -8880 2080 -8870 {
lab=colon_n[30]}
N 1860 -8850 1870 -8860 {
lab=#net61}
N 1870 -8860 2070 -8860 {
lab=#net61}
N 2070 -8860 2080 -8850 {
lab=#net61}
N 1860 -8830 1870 -8840 {
lab=#net62}
N 1870 -8840 2070 -8840 {
lab=#net62}
N 2070 -8840 2080 -8830 {
lab=#net62}
N 1920 -8990 1920 -8970 {
lab=vcom}
N 1960 -8990 1960 -8970 {
lab=ctop}
N 1840 -8890 1860 -8890 {
lab=col_n[30]}
N 1840 -8870 1860 -8870 {
lab=colon_n[30]}
N 1840 -8850 1860 -8850 {
lab=#net61}
N 1840 -8830 1860 -8830 {
lab=#net62}
N 2080 -8830 2100 -8830 {
lab=#net62}
N 2080 -8850 2100 -8850 {
lab=#net61}
N 2080 -8870 2100 -8870 {
lab=colon_n[30]}
N 2080 -8890 2100 -8890 {
lab=col_n[30]}
N 1900 -8750 1900 -8740 {
lab=VSS}
N 1900 -8980 1900 -8970 {
lab=VDD}
N 2240 -8750 2250 -8760 {
lab=row_n[4]}
N 2250 -8960 2250 -8760 {
lab=row_n[4]}
N 2240 -8970 2250 -8960 {
lab=row_n[4]}
N 2240 -8750 2240 -8730 {
lab=row_n[4]}
N 2240 -8990 2240 -8970 {
lab=row_n[4]}
N 2120 -8890 2130 -8900 {
lab=col_n[30]}
N 2130 -8900 2330 -8900 {
lab=col_n[30]}
N 2330 -8900 2340 -8890 {
lab=col_n[30]}
N 2120 -8870 2130 -8880 {
lab=colon_n[30]}
N 2130 -8880 2330 -8880 {
lab=colon_n[30]}
N 2330 -8880 2340 -8870 {
lab=colon_n[30]}
N 2120 -8850 2130 -8860 {
lab=#net61}
N 2130 -8860 2330 -8860 {
lab=#net61}
N 2330 -8860 2340 -8850 {
lab=#net61}
N 2120 -8830 2130 -8840 {
lab=#net62}
N 2130 -8840 2330 -8840 {
lab=#net62}
N 2330 -8840 2340 -8830 {
lab=#net62}
N 2180 -8990 2180 -8970 {
lab=vcom}
N 2220 -8990 2220 -8970 {
lab=ctop}
N 2100 -8890 2120 -8890 {
lab=col_n[30]}
N 2100 -8870 2120 -8870 {
lab=colon_n[30]}
N 2100 -8850 2120 -8850 {
lab=#net61}
N 2100 -8830 2120 -8830 {
lab=#net62}
N 2340 -8830 2360 -8830 {
lab=#net62}
N 2340 -8850 2360 -8850 {
lab=#net61}
N 2340 -8870 2360 -8870 {
lab=colon_n[30]}
N 2340 -8890 2360 -8890 {
lab=col_n[30]}
N 2160 -8750 2160 -8740 {
lab=VSS}
N 2160 -8980 2160 -8970 {
lab=VDD}
N 2500 -8750 2510 -8760 {
lab=row_n[5]}
N 2510 -8960 2510 -8760 {
lab=row_n[5]}
N 2500 -8970 2510 -8960 {
lab=row_n[5]}
N 2500 -8750 2500 -8730 {
lab=row_n[5]}
N 2500 -8990 2500 -8970 {
lab=row_n[5]}
N 2380 -8890 2390 -8900 {
lab=col_n[30]}
N 2390 -8900 2590 -8900 {
lab=col_n[30]}
N 2590 -8900 2600 -8890 {
lab=col_n[30]}
N 2380 -8870 2390 -8880 {
lab=colon_n[30]}
N 2390 -8880 2590 -8880 {
lab=colon_n[30]}
N 2590 -8880 2600 -8870 {
lab=colon_n[30]}
N 2380 -8850 2390 -8860 {
lab=#net61}
N 2390 -8860 2590 -8860 {
lab=#net61}
N 2590 -8860 2600 -8850 {
lab=#net61}
N 2380 -8830 2390 -8840 {
lab=#net62}
N 2390 -8840 2590 -8840 {
lab=#net62}
N 2590 -8840 2600 -8830 {
lab=#net62}
N 2440 -8990 2440 -8970 {
lab=vcom}
N 2480 -8990 2480 -8970 {
lab=ctop}
N 2360 -8890 2380 -8890 {
lab=col_n[30]}
N 2360 -8870 2380 -8870 {
lab=colon_n[30]}
N 2360 -8850 2380 -8850 {
lab=#net61}
N 2360 -8830 2380 -8830 {
lab=#net62}
N 2600 -8830 2620 -8830 {
lab=#net62}
N 2600 -8850 2620 -8850 {
lab=#net61}
N 2600 -8870 2620 -8870 {
lab=colon_n[30]}
N 2600 -8890 2620 -8890 {
lab=col_n[30]}
N 2420 -8750 2420 -8740 {
lab=VSS}
N 2420 -8980 2420 -8970 {
lab=VDD}
N 2760 -8750 2770 -8760 {
lab=row_n[6]}
N 2770 -8960 2770 -8760 {
lab=row_n[6]}
N 2760 -8970 2770 -8960 {
lab=row_n[6]}
N 2760 -8750 2760 -8730 {
lab=row_n[6]}
N 2760 -8990 2760 -8970 {
lab=row_n[6]}
N 2640 -8890 2650 -8900 {
lab=col_n[30]}
N 2650 -8900 2850 -8900 {
lab=col_n[30]}
N 2850 -8900 2860 -8890 {
lab=col_n[30]}
N 2640 -8870 2650 -8880 {
lab=colon_n[30]}
N 2650 -8880 2850 -8880 {
lab=colon_n[30]}
N 2850 -8880 2860 -8870 {
lab=colon_n[30]}
N 2640 -8850 2650 -8860 {
lab=#net61}
N 2650 -8860 2850 -8860 {
lab=#net61}
N 2850 -8860 2860 -8850 {
lab=#net61}
N 2640 -8830 2650 -8840 {
lab=#net62}
N 2650 -8840 2850 -8840 {
lab=#net62}
N 2850 -8840 2860 -8830 {
lab=#net62}
N 2700 -8990 2700 -8970 {
lab=vcom}
N 2740 -8990 2740 -8970 {
lab=ctop}
N 2620 -8890 2640 -8890 {
lab=col_n[30]}
N 2620 -8870 2640 -8870 {
lab=colon_n[30]}
N 2620 -8850 2640 -8850 {
lab=#net61}
N 2620 -8830 2640 -8830 {
lab=#net62}
N 2860 -8830 2880 -8830 {
lab=#net62}
N 2860 -8850 2880 -8850 {
lab=#net61}
N 2860 -8870 2880 -8870 {
lab=colon_n[30]}
N 2860 -8890 2880 -8890 {
lab=col_n[30]}
N 2680 -8750 2680 -8740 {
lab=VSS}
N 2680 -8980 2680 -8970 {
lab=VDD}
N 3020 -8750 3030 -8760 {
lab=row_n[7]}
N 3030 -8960 3030 -8760 {
lab=row_n[7]}
N 3020 -8970 3030 -8960 {
lab=row_n[7]}
N 3020 -8750 3020 -8730 {
lab=row_n[7]}
N 3020 -8990 3020 -8970 {
lab=row_n[7]}
N 2900 -8890 2910 -8900 {
lab=col_n[30]}
N 2910 -8900 3110 -8900 {
lab=col_n[30]}
N 3110 -8900 3120 -8890 {
lab=col_n[30]}
N 2900 -8870 2910 -8880 {
lab=colon_n[30]}
N 2910 -8880 3110 -8880 {
lab=colon_n[30]}
N 3110 -8880 3120 -8870 {
lab=colon_n[30]}
N 2900 -8850 2910 -8860 {
lab=#net61}
N 2910 -8860 3110 -8860 {
lab=#net61}
N 3110 -8860 3120 -8850 {
lab=#net61}
N 2900 -8830 2910 -8840 {
lab=#net62}
N 2910 -8840 3110 -8840 {
lab=#net62}
N 3110 -8840 3120 -8830 {
lab=#net62}
N 2960 -8990 2960 -8970 {
lab=vcom}
N 3000 -8990 3000 -8970 {
lab=ctop}
N 2880 -8890 2900 -8890 {
lab=col_n[30]}
N 2880 -8870 2900 -8870 {
lab=colon_n[30]}
N 2880 -8850 2900 -8850 {
lab=#net61}
N 2880 -8830 2900 -8830 {
lab=#net62}
N 3120 -8830 3140 -8830 {
lab=#net62}
N 3120 -8850 3140 -8850 {
lab=#net61}
N 3120 -8870 3140 -8870 {
lab=colon_n[30]}
N 3120 -8890 3140 -8890 {
lab=col_n[30]}
N 2940 -8750 2940 -8740 {
lab=VSS}
N 2940 -8980 2940 -8970 {
lab=VDD}
N 3280 -8750 3290 -8760 {
lab=row_n[8]}
N 3290 -8960 3290 -8760 {
lab=row_n[8]}
N 3280 -8970 3290 -8960 {
lab=row_n[8]}
N 3280 -8750 3280 -8730 {
lab=row_n[8]}
N 3280 -8990 3280 -8970 {
lab=row_n[8]}
N 3160 -8890 3170 -8900 {
lab=col_n[30]}
N 3170 -8900 3370 -8900 {
lab=col_n[30]}
N 3370 -8900 3380 -8890 {
lab=col_n[30]}
N 3160 -8870 3170 -8880 {
lab=colon_n[30]}
N 3170 -8880 3370 -8880 {
lab=colon_n[30]}
N 3370 -8880 3380 -8870 {
lab=colon_n[30]}
N 3160 -8850 3170 -8860 {
lab=#net61}
N 3170 -8860 3370 -8860 {
lab=#net61}
N 3370 -8860 3380 -8850 {
lab=#net61}
N 3160 -8830 3170 -8840 {
lab=#net62}
N 3170 -8840 3370 -8840 {
lab=#net62}
N 3370 -8840 3380 -8830 {
lab=#net62}
N 3220 -8990 3220 -8970 {
lab=vcom}
N 3260 -8990 3260 -8970 {
lab=ctop}
N 3140 -8890 3160 -8890 {
lab=col_n[30]}
N 3140 -8870 3160 -8870 {
lab=colon_n[30]}
N 3140 -8850 3160 -8850 {
lab=#net61}
N 3140 -8830 3160 -8830 {
lab=#net62}
N 3380 -8830 3400 -8830 {
lab=#net62}
N 3380 -8850 3400 -8850 {
lab=#net61}
N 3380 -8870 3400 -8870 {
lab=colon_n[30]}
N 3380 -8890 3400 -8890 {
lab=col_n[30]}
N 3200 -8750 3200 -8740 {
lab=VSS}
N 3200 -8980 3200 -8970 {
lab=VDD}
N 3540 -8750 3550 -8760 {
lab=row_n[9]}
N 3550 -8960 3550 -8760 {
lab=row_n[9]}
N 3540 -8970 3550 -8960 {
lab=row_n[9]}
N 3540 -8750 3540 -8730 {
lab=row_n[9]}
N 3540 -8990 3540 -8970 {
lab=row_n[9]}
N 3420 -8890 3430 -8900 {
lab=col_n[30]}
N 3430 -8900 3630 -8900 {
lab=col_n[30]}
N 3630 -8900 3640 -8890 {
lab=col_n[30]}
N 3420 -8870 3430 -8880 {
lab=colon_n[30]}
N 3430 -8880 3630 -8880 {
lab=colon_n[30]}
N 3630 -8880 3640 -8870 {
lab=colon_n[30]}
N 3420 -8850 3430 -8860 {
lab=#net61}
N 3430 -8860 3630 -8860 {
lab=#net61}
N 3630 -8860 3640 -8850 {
lab=#net61}
N 3420 -8830 3430 -8840 {
lab=#net62}
N 3430 -8840 3630 -8840 {
lab=#net62}
N 3630 -8840 3640 -8830 {
lab=#net62}
N 3480 -8990 3480 -8970 {
lab=vcom}
N 3520 -8990 3520 -8970 {
lab=ctop}
N 3400 -8890 3420 -8890 {
lab=col_n[30]}
N 3400 -8870 3420 -8870 {
lab=colon_n[30]}
N 3400 -8850 3420 -8850 {
lab=#net61}
N 3400 -8830 3420 -8830 {
lab=#net62}
N 3640 -8830 3660 -8830 {
lab=#net62}
N 3640 -8850 3660 -8850 {
lab=#net61}
N 3640 -8870 3660 -8870 {
lab=colon_n[30]}
N 3640 -8890 3660 -8890 {
lab=col_n[30]}
N 3460 -8750 3460 -8740 {
lab=VSS}
N 3460 -8980 3460 -8970 {
lab=VDD}
N 3800 -8750 3810 -8760 {
lab=row_n[10]}
N 3810 -8960 3810 -8760 {
lab=row_n[10]}
N 3800 -8970 3810 -8960 {
lab=row_n[10]}
N 3800 -8750 3800 -8730 {
lab=row_n[10]}
N 3800 -8990 3800 -8970 {
lab=row_n[10]}
N 3680 -8890 3690 -8900 {
lab=col_n[30]}
N 3690 -8900 3890 -8900 {
lab=col_n[30]}
N 3890 -8900 3900 -8890 {
lab=col_n[30]}
N 3680 -8870 3690 -8880 {
lab=colon_n[30]}
N 3690 -8880 3890 -8880 {
lab=colon_n[30]}
N 3890 -8880 3900 -8870 {
lab=colon_n[30]}
N 3680 -8850 3690 -8860 {
lab=#net61}
N 3690 -8860 3890 -8860 {
lab=#net61}
N 3890 -8860 3900 -8850 {
lab=#net61}
N 3680 -8830 3690 -8840 {
lab=#net62}
N 3690 -8840 3890 -8840 {
lab=#net62}
N 3890 -8840 3900 -8830 {
lab=#net62}
N 3740 -8990 3740 -8970 {
lab=vcom}
N 3780 -8990 3780 -8970 {
lab=ctop}
N 3660 -8890 3680 -8890 {
lab=col_n[30]}
N 3660 -8870 3680 -8870 {
lab=colon_n[30]}
N 3660 -8850 3680 -8850 {
lab=#net61}
N 3660 -8830 3680 -8830 {
lab=#net62}
N 3900 -8830 3920 -8830 {
lab=#net62}
N 3900 -8850 3920 -8850 {
lab=#net61}
N 3900 -8870 3920 -8870 {
lab=colon_n[30]}
N 3900 -8890 3920 -8890 {
lab=col_n[30]}
N 3720 -8750 3720 -8740 {
lab=VSS}
N 3720 -8980 3720 -8970 {
lab=VDD}
N 4060 -8750 4070 -8760 {
lab=row_n[11]}
N 4070 -8960 4070 -8760 {
lab=row_n[11]}
N 4060 -8970 4070 -8960 {
lab=row_n[11]}
N 4060 -8750 4060 -8730 {
lab=row_n[11]}
N 4060 -8990 4060 -8970 {
lab=row_n[11]}
N 3940 -8890 3950 -8900 {
lab=col_n[30]}
N 3950 -8900 4150 -8900 {
lab=col_n[30]}
N 4150 -8900 4160 -8890 {
lab=col_n[30]}
N 3940 -8870 3950 -8880 {
lab=colon_n[30]}
N 3950 -8880 4150 -8880 {
lab=colon_n[30]}
N 4150 -8880 4160 -8870 {
lab=colon_n[30]}
N 3940 -8850 3950 -8860 {
lab=#net61}
N 3950 -8860 4150 -8860 {
lab=#net61}
N 4150 -8860 4160 -8850 {
lab=#net61}
N 3940 -8830 3950 -8840 {
lab=#net62}
N 3950 -8840 4150 -8840 {
lab=#net62}
N 4150 -8840 4160 -8830 {
lab=#net62}
N 4000 -8990 4000 -8970 {
lab=vcom}
N 4040 -8990 4040 -8970 {
lab=ctop}
N 3920 -8890 3940 -8890 {
lab=col_n[30]}
N 3920 -8870 3940 -8870 {
lab=colon_n[30]}
N 3920 -8850 3940 -8850 {
lab=#net61}
N 3920 -8830 3940 -8830 {
lab=#net62}
N 4160 -8830 4180 -8830 {
lab=#net62}
N 4160 -8850 4180 -8850 {
lab=#net61}
N 4160 -8870 4180 -8870 {
lab=colon_n[30]}
N 4160 -8890 4180 -8890 {
lab=col_n[30]}
N 3980 -8750 3980 -8740 {
lab=VSS}
N 3980 -8980 3980 -8970 {
lab=VDD}
N 4320 -8750 4330 -8760 {
lab=row_n[12]}
N 4330 -8960 4330 -8760 {
lab=row_n[12]}
N 4320 -8970 4330 -8960 {
lab=row_n[12]}
N 4320 -8750 4320 -8730 {
lab=row_n[12]}
N 4320 -8990 4320 -8970 {
lab=row_n[12]}
N 4200 -8890 4210 -8900 {
lab=col_n[30]}
N 4210 -8900 4410 -8900 {
lab=col_n[30]}
N 4410 -8900 4420 -8890 {
lab=col_n[30]}
N 4200 -8870 4210 -8880 {
lab=colon_n[30]}
N 4210 -8880 4410 -8880 {
lab=colon_n[30]}
N 4410 -8880 4420 -8870 {
lab=colon_n[30]}
N 4200 -8850 4210 -8860 {
lab=#net61}
N 4210 -8860 4410 -8860 {
lab=#net61}
N 4410 -8860 4420 -8850 {
lab=#net61}
N 4200 -8830 4210 -8840 {
lab=#net62}
N 4210 -8840 4410 -8840 {
lab=#net62}
N 4410 -8840 4420 -8830 {
lab=#net62}
N 4260 -8990 4260 -8970 {
lab=vcom}
N 4300 -8990 4300 -8970 {
lab=ctop}
N 4180 -8890 4200 -8890 {
lab=col_n[30]}
N 4180 -8870 4200 -8870 {
lab=colon_n[30]}
N 4180 -8850 4200 -8850 {
lab=#net61}
N 4180 -8830 4200 -8830 {
lab=#net62}
N 4420 -8830 4440 -8830 {
lab=#net62}
N 4420 -8850 4440 -8850 {
lab=#net61}
N 4420 -8870 4440 -8870 {
lab=colon_n[30]}
N 4420 -8890 4440 -8890 {
lab=col_n[30]}
N 4240 -8750 4240 -8740 {
lab=VSS}
N 4240 -8980 4240 -8970 {
lab=VDD}
N 4580 -8750 4590 -8760 {
lab=row_n[13]}
N 4590 -8960 4590 -8760 {
lab=row_n[13]}
N 4580 -8970 4590 -8960 {
lab=row_n[13]}
N 4580 -8750 4580 -8730 {
lab=row_n[13]}
N 4580 -8990 4580 -8970 {
lab=row_n[13]}
N 4460 -8890 4470 -8900 {
lab=col_n[30]}
N 4470 -8900 4670 -8900 {
lab=col_n[30]}
N 4670 -8900 4680 -8890 {
lab=col_n[30]}
N 4460 -8870 4470 -8880 {
lab=colon_n[30]}
N 4470 -8880 4670 -8880 {
lab=colon_n[30]}
N 4670 -8880 4680 -8870 {
lab=colon_n[30]}
N 4460 -8850 4470 -8860 {
lab=#net61}
N 4470 -8860 4670 -8860 {
lab=#net61}
N 4670 -8860 4680 -8850 {
lab=#net61}
N 4460 -8830 4470 -8840 {
lab=#net62}
N 4470 -8840 4670 -8840 {
lab=#net62}
N 4670 -8840 4680 -8830 {
lab=#net62}
N 4520 -8990 4520 -8970 {
lab=vcom}
N 4560 -8990 4560 -8970 {
lab=ctop}
N 4440 -8890 4460 -8890 {
lab=col_n[30]}
N 4440 -8870 4460 -8870 {
lab=colon_n[30]}
N 4440 -8850 4460 -8850 {
lab=#net61}
N 4440 -8830 4460 -8830 {
lab=#net62}
N 4680 -8830 4700 -8830 {
lab=#net62}
N 4680 -8850 4700 -8850 {
lab=#net61}
N 4680 -8870 4700 -8870 {
lab=colon_n[30]}
N 4680 -8890 4700 -8890 {
lab=col_n[30]}
N 4500 -8750 4500 -8740 {
lab=VSS}
N 4500 -8980 4500 -8970 {
lab=VDD}
N 4840 -8750 4850 -8760 {
lab=row_n[14]}
N 4850 -8960 4850 -8760 {
lab=row_n[14]}
N 4840 -8970 4850 -8960 {
lab=row_n[14]}
N 4840 -8750 4840 -8730 {
lab=row_n[14]}
N 4840 -8990 4840 -8970 {
lab=row_n[14]}
N 4720 -8890 4730 -8900 {
lab=col_n[30]}
N 4730 -8900 4930 -8900 {
lab=col_n[30]}
N 4930 -8900 4940 -8890 {
lab=col_n[30]}
N 4720 -8870 4730 -8880 {
lab=colon_n[30]}
N 4730 -8880 4930 -8880 {
lab=colon_n[30]}
N 4930 -8880 4940 -8870 {
lab=colon_n[30]}
N 4720 -8850 4730 -8860 {
lab=#net61}
N 4730 -8860 4930 -8860 {
lab=#net61}
N 4930 -8860 4940 -8850 {
lab=#net61}
N 4720 -8830 4730 -8840 {
lab=#net62}
N 4730 -8840 4930 -8840 {
lab=#net62}
N 4930 -8840 4940 -8830 {
lab=#net62}
N 4780 -8990 4780 -8970 {
lab=vcom}
N 4820 -8990 4820 -8970 {
lab=ctop}
N 4700 -8890 4720 -8890 {
lab=col_n[30]}
N 4700 -8870 4720 -8870 {
lab=colon_n[30]}
N 4700 -8850 4720 -8850 {
lab=#net61}
N 4700 -8830 4720 -8830 {
lab=#net62}
N 4940 -8830 4960 -8830 {
lab=#net62}
N 4940 -8850 4960 -8850 {
lab=#net61}
N 4940 -8870 4960 -8870 {
lab=colon_n[30]}
N 4940 -8890 4960 -8890 {
lab=col_n[30]}
N 4760 -8750 4760 -8740 {
lab=VSS}
N 4760 -8980 4760 -8970 {
lab=VDD}
N 5100 -8750 5110 -8760 {
lab=row_n[15]}
N 5110 -8960 5110 -8760 {
lab=row_n[15]}
N 5100 -8970 5110 -8960 {
lab=row_n[15]}
N 5100 -8750 5100 -8730 {
lab=row_n[15]}
N 5100 -8990 5100 -8970 {
lab=row_n[15]}
N 4980 -8890 4990 -8900 {
lab=col_n[30]}
N 4990 -8900 5190 -8900 {
lab=col_n[30]}
N 5190 -8900 5200 -8890 {
lab=col_n[30]}
N 4980 -8870 4990 -8880 {
lab=colon_n[30]}
N 4990 -8880 5190 -8880 {
lab=colon_n[30]}
N 5190 -8880 5200 -8870 {
lab=colon_n[30]}
N 4980 -8850 4990 -8860 {
lab=#net61}
N 4990 -8860 5190 -8860 {
lab=#net61}
N 5190 -8860 5200 -8850 {
lab=#net61}
N 4980 -8830 4990 -8840 {
lab=#net62}
N 4990 -8840 5190 -8840 {
lab=#net62}
N 5190 -8840 5200 -8830 {
lab=#net62}
N 5040 -8990 5040 -8970 {
lab=vcom}
N 5080 -8990 5080 -8970 {
lab=ctop}
N 4960 -8890 4980 -8890 {
lab=col_n[30]}
N 4960 -8870 4980 -8870 {
lab=colon_n[30]}
N 4960 -8850 4980 -8850 {
lab=#net61}
N 4960 -8830 4980 -8830 {
lab=#net62}
N 5200 -8830 5220 -8830 {
lab=#net62}
N 5200 -8850 5220 -8850 {
lab=#net61}
N 5200 -8870 5220 -8870 {
lab=colon_n[30]}
N 5200 -8890 5220 -8890 {
lab=col_n[30]}
N 5020 -8750 5020 -8740 {
lab=VSS}
N 5020 -8980 5020 -8970 {
lab=VDD}
N 5360 -8750 5370 -8760 {
lab=row_n[16]}
N 5370 -8960 5370 -8760 {
lab=row_n[16]}
N 5360 -8970 5370 -8960 {
lab=row_n[16]}
N 5360 -8750 5360 -8730 {
lab=row_n[16]}
N 5360 -8990 5360 -8970 {
lab=row_n[16]}
N 5240 -8890 5250 -8900 {
lab=col_n[30]}
N 5250 -8900 5450 -8900 {
lab=col_n[30]}
N 5450 -8900 5460 -8890 {
lab=col_n[30]}
N 5240 -8870 5250 -8880 {
lab=colon_n[30]}
N 5250 -8880 5450 -8880 {
lab=colon_n[30]}
N 5450 -8880 5460 -8870 {
lab=colon_n[30]}
N 5240 -8850 5250 -8860 {
lab=#net61}
N 5250 -8860 5450 -8860 {
lab=#net61}
N 5450 -8860 5460 -8850 {
lab=#net61}
N 5240 -8830 5250 -8840 {
lab=#net62}
N 5250 -8840 5450 -8840 {
lab=#net62}
N 5450 -8840 5460 -8830 {
lab=#net62}
N 5300 -8990 5300 -8970 {
lab=vcom}
N 5340 -8990 5340 -8970 {
lab=ctop}
N 5220 -8890 5240 -8890 {
lab=col_n[30]}
N 5220 -8870 5240 -8870 {
lab=colon_n[30]}
N 5220 -8850 5240 -8850 {
lab=#net61}
N 5220 -8830 5240 -8830 {
lab=#net62}
N 5460 -8830 5480 -8830 {
lab=#net62}
N 5460 -8850 5480 -8850 {
lab=#net61}
N 5460 -8870 5480 -8870 {
lab=colon_n[30]}
N 5460 -8890 5480 -8890 {
lab=col_n[30]}
N 5280 -8750 5280 -8740 {
lab=VSS}
N 5280 -8980 5280 -8970 {
lab=VDD}
N 5620 -8750 5630 -8760 {
lab=row_n[17]}
N 5630 -8960 5630 -8760 {
lab=row_n[17]}
N 5620 -8970 5630 -8960 {
lab=row_n[17]}
N 5620 -8750 5620 -8730 {
lab=row_n[17]}
N 5620 -8990 5620 -8970 {
lab=row_n[17]}
N 5500 -8890 5510 -8900 {
lab=col_n[30]}
N 5510 -8900 5710 -8900 {
lab=col_n[30]}
N 5710 -8900 5720 -8890 {
lab=col_n[30]}
N 5500 -8870 5510 -8880 {
lab=colon_n[30]}
N 5510 -8880 5710 -8880 {
lab=colon_n[30]}
N 5710 -8880 5720 -8870 {
lab=colon_n[30]}
N 5500 -8850 5510 -8860 {
lab=#net61}
N 5510 -8860 5710 -8860 {
lab=#net61}
N 5710 -8860 5720 -8850 {
lab=#net61}
N 5500 -8830 5510 -8840 {
lab=#net62}
N 5510 -8840 5710 -8840 {
lab=#net62}
N 5710 -8840 5720 -8830 {
lab=#net62}
N 5560 -8990 5560 -8970 {
lab=vcom}
N 5600 -8990 5600 -8970 {
lab=ctop}
N 5480 -8890 5500 -8890 {
lab=col_n[30]}
N 5480 -8870 5500 -8870 {
lab=colon_n[30]}
N 5480 -8850 5500 -8850 {
lab=#net61}
N 5480 -8830 5500 -8830 {
lab=#net62}
N 5720 -8830 5740 -8830 {
lab=#net62}
N 5720 -8850 5740 -8850 {
lab=#net61}
N 5720 -8870 5740 -8870 {
lab=colon_n[30]}
N 5720 -8890 5740 -8890 {
lab=col_n[30]}
N 5540 -8750 5540 -8740 {
lab=VSS}
N 5540 -8980 5540 -8970 {
lab=VDD}
N 5880 -8750 5890 -8760 {
lab=row_n[18]}
N 5890 -8960 5890 -8760 {
lab=row_n[18]}
N 5880 -8970 5890 -8960 {
lab=row_n[18]}
N 5880 -8750 5880 -8730 {
lab=row_n[18]}
N 5880 -8990 5880 -8970 {
lab=row_n[18]}
N 5760 -8890 5770 -8900 {
lab=col_n[30]}
N 5770 -8900 5970 -8900 {
lab=col_n[30]}
N 5970 -8900 5980 -8890 {
lab=col_n[30]}
N 5760 -8870 5770 -8880 {
lab=colon_n[30]}
N 5770 -8880 5970 -8880 {
lab=colon_n[30]}
N 5970 -8880 5980 -8870 {
lab=colon_n[30]}
N 5760 -8850 5770 -8860 {
lab=#net61}
N 5770 -8860 5970 -8860 {
lab=#net61}
N 5970 -8860 5980 -8850 {
lab=#net61}
N 5760 -8830 5770 -8840 {
lab=#net62}
N 5770 -8840 5970 -8840 {
lab=#net62}
N 5970 -8840 5980 -8830 {
lab=#net62}
N 5820 -8990 5820 -8970 {
lab=vcom}
N 5860 -8990 5860 -8970 {
lab=ctop}
N 5740 -8890 5760 -8890 {
lab=col_n[30]}
N 5740 -8870 5760 -8870 {
lab=colon_n[30]}
N 5740 -8850 5760 -8850 {
lab=#net61}
N 5740 -8830 5760 -8830 {
lab=#net62}
N 5980 -8830 6000 -8830 {
lab=#net62}
N 5980 -8850 6000 -8850 {
lab=#net61}
N 5980 -8870 6000 -8870 {
lab=colon_n[30]}
N 5980 -8890 6000 -8890 {
lab=col_n[30]}
N 5800 -8750 5800 -8740 {
lab=VSS}
N 5800 -8980 5800 -8970 {
lab=VDD}
N 6140 -8750 6150 -8760 {
lab=row_n[19]}
N 6150 -8960 6150 -8760 {
lab=row_n[19]}
N 6140 -8970 6150 -8960 {
lab=row_n[19]}
N 6140 -8750 6140 -8730 {
lab=row_n[19]}
N 6140 -8990 6140 -8970 {
lab=row_n[19]}
N 6020 -8890 6030 -8900 {
lab=col_n[30]}
N 6030 -8900 6230 -8900 {
lab=col_n[30]}
N 6230 -8900 6240 -8890 {
lab=col_n[30]}
N 6020 -8870 6030 -8880 {
lab=colon_n[30]}
N 6030 -8880 6230 -8880 {
lab=colon_n[30]}
N 6230 -8880 6240 -8870 {
lab=colon_n[30]}
N 6020 -8850 6030 -8860 {
lab=#net61}
N 6030 -8860 6230 -8860 {
lab=#net61}
N 6230 -8860 6240 -8850 {
lab=#net61}
N 6020 -8830 6030 -8840 {
lab=#net62}
N 6030 -8840 6230 -8840 {
lab=#net62}
N 6230 -8840 6240 -8830 {
lab=#net62}
N 6080 -8990 6080 -8970 {
lab=vcom}
N 6120 -8990 6120 -8970 {
lab=ctop}
N 6000 -8890 6020 -8890 {
lab=col_n[30]}
N 6000 -8870 6020 -8870 {
lab=colon_n[30]}
N 6000 -8850 6020 -8850 {
lab=#net61}
N 6000 -8830 6020 -8830 {
lab=#net62}
N 6240 -8830 6260 -8830 {
lab=#net62}
N 6240 -8850 6260 -8850 {
lab=#net61}
N 6240 -8870 6260 -8870 {
lab=colon_n[30]}
N 6240 -8890 6260 -8890 {
lab=col_n[30]}
N 6060 -8750 6060 -8740 {
lab=VSS}
N 6060 -8980 6060 -8970 {
lab=VDD}
N 6400 -8750 6410 -8760 {
lab=row_n[20]}
N 6410 -8960 6410 -8760 {
lab=row_n[20]}
N 6400 -8970 6410 -8960 {
lab=row_n[20]}
N 6400 -8750 6400 -8730 {
lab=row_n[20]}
N 6400 -8990 6400 -8970 {
lab=row_n[20]}
N 6280 -8890 6290 -8900 {
lab=col_n[30]}
N 6290 -8900 6490 -8900 {
lab=col_n[30]}
N 6490 -8900 6500 -8890 {
lab=col_n[30]}
N 6280 -8870 6290 -8880 {
lab=colon_n[30]}
N 6290 -8880 6490 -8880 {
lab=colon_n[30]}
N 6490 -8880 6500 -8870 {
lab=colon_n[30]}
N 6280 -8850 6290 -8860 {
lab=#net61}
N 6290 -8860 6490 -8860 {
lab=#net61}
N 6490 -8860 6500 -8850 {
lab=#net61}
N 6280 -8830 6290 -8840 {
lab=#net62}
N 6290 -8840 6490 -8840 {
lab=#net62}
N 6490 -8840 6500 -8830 {
lab=#net62}
N 6340 -8990 6340 -8970 {
lab=vcom}
N 6380 -8990 6380 -8970 {
lab=ctop}
N 6260 -8890 6280 -8890 {
lab=col_n[30]}
N 6260 -8870 6280 -8870 {
lab=colon_n[30]}
N 6260 -8850 6280 -8850 {
lab=#net61}
N 6260 -8830 6280 -8830 {
lab=#net62}
N 6500 -8830 6520 -8830 {
lab=#net62}
N 6500 -8850 6520 -8850 {
lab=#net61}
N 6500 -8870 6520 -8870 {
lab=colon_n[30]}
N 6500 -8890 6520 -8890 {
lab=col_n[30]}
N 6320 -8750 6320 -8740 {
lab=VSS}
N 6320 -8980 6320 -8970 {
lab=VDD}
N 6660 -8750 6670 -8760 {
lab=row_n[21]}
N 6670 -8960 6670 -8760 {
lab=row_n[21]}
N 6660 -8970 6670 -8960 {
lab=row_n[21]}
N 6660 -8750 6660 -8730 {
lab=row_n[21]}
N 6660 -8990 6660 -8970 {
lab=row_n[21]}
N 6540 -8890 6550 -8900 {
lab=col_n[30]}
N 6550 -8900 6750 -8900 {
lab=col_n[30]}
N 6750 -8900 6760 -8890 {
lab=col_n[30]}
N 6540 -8870 6550 -8880 {
lab=colon_n[30]}
N 6550 -8880 6750 -8880 {
lab=colon_n[30]}
N 6750 -8880 6760 -8870 {
lab=colon_n[30]}
N 6540 -8850 6550 -8860 {
lab=#net61}
N 6550 -8860 6750 -8860 {
lab=#net61}
N 6750 -8860 6760 -8850 {
lab=#net61}
N 6540 -8830 6550 -8840 {
lab=#net62}
N 6550 -8840 6750 -8840 {
lab=#net62}
N 6750 -8840 6760 -8830 {
lab=#net62}
N 6600 -8990 6600 -8970 {
lab=vcom}
N 6640 -8990 6640 -8970 {
lab=ctop}
N 6520 -8890 6540 -8890 {
lab=col_n[30]}
N 6520 -8870 6540 -8870 {
lab=colon_n[30]}
N 6520 -8850 6540 -8850 {
lab=#net61}
N 6520 -8830 6540 -8830 {
lab=#net62}
N 6760 -8830 6780 -8830 {
lab=#net62}
N 6760 -8850 6780 -8850 {
lab=#net61}
N 6760 -8870 6780 -8870 {
lab=colon_n[30]}
N 6760 -8890 6780 -8890 {
lab=col_n[30]}
N 6580 -8750 6580 -8740 {
lab=VSS}
N 6580 -8980 6580 -8970 {
lab=VDD}
N 6920 -8750 6930 -8760 {
lab=row_n[22]}
N 6930 -8960 6930 -8760 {
lab=row_n[22]}
N 6920 -8970 6930 -8960 {
lab=row_n[22]}
N 6920 -8750 6920 -8730 {
lab=row_n[22]}
N 6920 -8990 6920 -8970 {
lab=row_n[22]}
N 6800 -8890 6810 -8900 {
lab=col_n[30]}
N 6810 -8900 7010 -8900 {
lab=col_n[30]}
N 7010 -8900 7020 -8890 {
lab=col_n[30]}
N 6800 -8870 6810 -8880 {
lab=colon_n[30]}
N 6810 -8880 7010 -8880 {
lab=colon_n[30]}
N 7010 -8880 7020 -8870 {
lab=colon_n[30]}
N 6800 -8850 6810 -8860 {
lab=#net61}
N 6810 -8860 7010 -8860 {
lab=#net61}
N 7010 -8860 7020 -8850 {
lab=#net61}
N 6800 -8830 6810 -8840 {
lab=#net62}
N 6810 -8840 7010 -8840 {
lab=#net62}
N 7010 -8840 7020 -8830 {
lab=#net62}
N 6860 -8990 6860 -8970 {
lab=vcom}
N 6900 -8990 6900 -8970 {
lab=ctop}
N 6780 -8890 6800 -8890 {
lab=col_n[30]}
N 6780 -8870 6800 -8870 {
lab=colon_n[30]}
N 6780 -8850 6800 -8850 {
lab=#net61}
N 6780 -8830 6800 -8830 {
lab=#net62}
N 7020 -8830 7040 -8830 {
lab=#net62}
N 7020 -8850 7040 -8850 {
lab=#net61}
N 7020 -8870 7040 -8870 {
lab=colon_n[30]}
N 7020 -8890 7040 -8890 {
lab=col_n[30]}
N 6840 -8750 6840 -8740 {
lab=VSS}
N 6840 -8980 6840 -8970 {
lab=VDD}
N 7180 -8750 7190 -8760 {
lab=row_n[23]}
N 7190 -8960 7190 -8760 {
lab=row_n[23]}
N 7180 -8970 7190 -8960 {
lab=row_n[23]}
N 7180 -8750 7180 -8730 {
lab=row_n[23]}
N 7180 -8990 7180 -8970 {
lab=row_n[23]}
N 7060 -8890 7070 -8900 {
lab=col_n[30]}
N 7070 -8900 7270 -8900 {
lab=col_n[30]}
N 7270 -8900 7280 -8890 {
lab=col_n[30]}
N 7060 -8870 7070 -8880 {
lab=colon_n[30]}
N 7070 -8880 7270 -8880 {
lab=colon_n[30]}
N 7270 -8880 7280 -8870 {
lab=colon_n[30]}
N 7060 -8850 7070 -8860 {
lab=#net61}
N 7070 -8860 7270 -8860 {
lab=#net61}
N 7270 -8860 7280 -8850 {
lab=#net61}
N 7060 -8830 7070 -8840 {
lab=#net62}
N 7070 -8840 7270 -8840 {
lab=#net62}
N 7270 -8840 7280 -8830 {
lab=#net62}
N 7120 -8990 7120 -8970 {
lab=vcom}
N 7160 -8990 7160 -8970 {
lab=ctop}
N 7040 -8890 7060 -8890 {
lab=col_n[30]}
N 7040 -8870 7060 -8870 {
lab=colon_n[30]}
N 7040 -8850 7060 -8850 {
lab=#net61}
N 7040 -8830 7060 -8830 {
lab=#net62}
N 7280 -8830 7300 -8830 {
lab=#net62}
N 7280 -8850 7300 -8850 {
lab=#net61}
N 7280 -8870 7300 -8870 {
lab=colon_n[30]}
N 7280 -8890 7300 -8890 {
lab=col_n[30]}
N 7100 -8750 7100 -8740 {
lab=VSS}
N 7100 -8980 7100 -8970 {
lab=VDD}
N 7440 -8750 7450 -8760 {
lab=row_n[24]}
N 7450 -8960 7450 -8760 {
lab=row_n[24]}
N 7440 -8970 7450 -8960 {
lab=row_n[24]}
N 7440 -8750 7440 -8730 {
lab=row_n[24]}
N 7440 -8990 7440 -8970 {
lab=row_n[24]}
N 7320 -8890 7330 -8900 {
lab=col_n[30]}
N 7330 -8900 7530 -8900 {
lab=col_n[30]}
N 7530 -8900 7540 -8890 {
lab=col_n[30]}
N 7320 -8870 7330 -8880 {
lab=colon_n[30]}
N 7330 -8880 7530 -8880 {
lab=colon_n[30]}
N 7530 -8880 7540 -8870 {
lab=colon_n[30]}
N 7320 -8850 7330 -8860 {
lab=#net61}
N 7330 -8860 7530 -8860 {
lab=#net61}
N 7530 -8860 7540 -8850 {
lab=#net61}
N 7320 -8830 7330 -8840 {
lab=#net62}
N 7330 -8840 7530 -8840 {
lab=#net62}
N 7530 -8840 7540 -8830 {
lab=#net62}
N 7380 -8990 7380 -8970 {
lab=vcom}
N 7420 -8990 7420 -8970 {
lab=ctop}
N 7300 -8890 7320 -8890 {
lab=col_n[30]}
N 7300 -8870 7320 -8870 {
lab=colon_n[30]}
N 7300 -8850 7320 -8850 {
lab=#net61}
N 7300 -8830 7320 -8830 {
lab=#net62}
N 7540 -8830 7560 -8830 {
lab=#net62}
N 7540 -8850 7560 -8850 {
lab=#net61}
N 7540 -8870 7560 -8870 {
lab=colon_n[30]}
N 7540 -8890 7560 -8890 {
lab=col_n[30]}
N 7360 -8750 7360 -8740 {
lab=VSS}
N 7360 -8980 7360 -8970 {
lab=VDD}
N 7700 -8750 7710 -8760 {
lab=row_n[25]}
N 7710 -8960 7710 -8760 {
lab=row_n[25]}
N 7700 -8970 7710 -8960 {
lab=row_n[25]}
N 7700 -8750 7700 -8730 {
lab=row_n[25]}
N 7700 -8990 7700 -8970 {
lab=row_n[25]}
N 7580 -8890 7590 -8900 {
lab=col_n[30]}
N 7590 -8900 7790 -8900 {
lab=col_n[30]}
N 7790 -8900 7800 -8890 {
lab=col_n[30]}
N 7580 -8870 7590 -8880 {
lab=colon_n[30]}
N 7590 -8880 7790 -8880 {
lab=colon_n[30]}
N 7790 -8880 7800 -8870 {
lab=colon_n[30]}
N 7580 -8850 7590 -8860 {
lab=#net61}
N 7590 -8860 7790 -8860 {
lab=#net61}
N 7790 -8860 7800 -8850 {
lab=#net61}
N 7580 -8830 7590 -8840 {
lab=#net62}
N 7590 -8840 7790 -8840 {
lab=#net62}
N 7790 -8840 7800 -8830 {
lab=#net62}
N 7640 -8990 7640 -8970 {
lab=vcom}
N 7680 -8990 7680 -8970 {
lab=ctop}
N 7560 -8890 7580 -8890 {
lab=col_n[30]}
N 7560 -8870 7580 -8870 {
lab=colon_n[30]}
N 7560 -8850 7580 -8850 {
lab=#net61}
N 7560 -8830 7580 -8830 {
lab=#net62}
N 7800 -8830 7820 -8830 {
lab=#net62}
N 7800 -8850 7820 -8850 {
lab=#net61}
N 7800 -8870 7820 -8870 {
lab=colon_n[30]}
N 7800 -8890 7820 -8890 {
lab=col_n[30]}
N 7620 -8750 7620 -8740 {
lab=VSS}
N 7620 -8980 7620 -8970 {
lab=VDD}
N 7960 -8750 7970 -8760 {
lab=row_n[26]}
N 7970 -8960 7970 -8760 {
lab=row_n[26]}
N 7960 -8970 7970 -8960 {
lab=row_n[26]}
N 7960 -8750 7960 -8730 {
lab=row_n[26]}
N 7960 -8990 7960 -8970 {
lab=row_n[26]}
N 7840 -8890 7850 -8900 {
lab=col_n[30]}
N 7850 -8900 8050 -8900 {
lab=col_n[30]}
N 8050 -8900 8060 -8890 {
lab=col_n[30]}
N 7840 -8870 7850 -8880 {
lab=colon_n[30]}
N 7850 -8880 8050 -8880 {
lab=colon_n[30]}
N 8050 -8880 8060 -8870 {
lab=colon_n[30]}
N 7840 -8850 7850 -8860 {
lab=#net61}
N 7850 -8860 8050 -8860 {
lab=#net61}
N 8050 -8860 8060 -8850 {
lab=#net61}
N 7840 -8830 7850 -8840 {
lab=#net62}
N 7850 -8840 8050 -8840 {
lab=#net62}
N 8050 -8840 8060 -8830 {
lab=#net62}
N 7900 -8990 7900 -8970 {
lab=vcom}
N 7940 -8990 7940 -8970 {
lab=ctop}
N 7820 -8890 7840 -8890 {
lab=col_n[30]}
N 7820 -8870 7840 -8870 {
lab=colon_n[30]}
N 7820 -8850 7840 -8850 {
lab=#net61}
N 7820 -8830 7840 -8830 {
lab=#net62}
N 8060 -8830 8080 -8830 {
lab=#net62}
N 8060 -8850 8080 -8850 {
lab=#net61}
N 8060 -8870 8080 -8870 {
lab=colon_n[30]}
N 8060 -8890 8080 -8890 {
lab=col_n[30]}
N 7880 -8750 7880 -8740 {
lab=VSS}
N 7880 -8980 7880 -8970 {
lab=VDD}
N 8220 -8750 8230 -8760 {
lab=row_n[27]}
N 8230 -8960 8230 -8760 {
lab=row_n[27]}
N 8220 -8970 8230 -8960 {
lab=row_n[27]}
N 8220 -8750 8220 -8730 {
lab=row_n[27]}
N 8220 -8990 8220 -8970 {
lab=row_n[27]}
N 8100 -8890 8110 -8900 {
lab=col_n[30]}
N 8110 -8900 8310 -8900 {
lab=col_n[30]}
N 8310 -8900 8320 -8890 {
lab=col_n[30]}
N 8100 -8870 8110 -8880 {
lab=colon_n[30]}
N 8110 -8880 8310 -8880 {
lab=colon_n[30]}
N 8310 -8880 8320 -8870 {
lab=colon_n[30]}
N 8100 -8850 8110 -8860 {
lab=#net61}
N 8110 -8860 8310 -8860 {
lab=#net61}
N 8310 -8860 8320 -8850 {
lab=#net61}
N 8100 -8830 8110 -8840 {
lab=#net62}
N 8110 -8840 8310 -8840 {
lab=#net62}
N 8310 -8840 8320 -8830 {
lab=#net62}
N 8160 -8990 8160 -8970 {
lab=vcom}
N 8200 -8990 8200 -8970 {
lab=ctop}
N 8080 -8890 8100 -8890 {
lab=col_n[30]}
N 8080 -8870 8100 -8870 {
lab=colon_n[30]}
N 8080 -8850 8100 -8850 {
lab=#net61}
N 8080 -8830 8100 -8830 {
lab=#net62}
N 8320 -8830 8340 -8830 {
lab=#net62}
N 8320 -8850 8340 -8850 {
lab=#net61}
N 8320 -8870 8340 -8870 {
lab=colon_n[30]}
N 8320 -8890 8340 -8890 {
lab=col_n[30]}
N 8140 -8750 8140 -8740 {
lab=VSS}
N 8140 -8980 8140 -8970 {
lab=VDD}
N 8480 -8750 8490 -8760 {
lab=row_n[28]}
N 8490 -8960 8490 -8760 {
lab=row_n[28]}
N 8480 -8970 8490 -8960 {
lab=row_n[28]}
N 8480 -8750 8480 -8730 {
lab=row_n[28]}
N 8480 -8990 8480 -8970 {
lab=row_n[28]}
N 8360 -8890 8370 -8900 {
lab=col_n[30]}
N 8370 -8900 8570 -8900 {
lab=col_n[30]}
N 8570 -8900 8580 -8890 {
lab=col_n[30]}
N 8360 -8870 8370 -8880 {
lab=colon_n[30]}
N 8370 -8880 8570 -8880 {
lab=colon_n[30]}
N 8570 -8880 8580 -8870 {
lab=colon_n[30]}
N 8360 -8850 8370 -8860 {
lab=#net61}
N 8370 -8860 8570 -8860 {
lab=#net61}
N 8570 -8860 8580 -8850 {
lab=#net61}
N 8360 -8830 8370 -8840 {
lab=#net62}
N 8370 -8840 8570 -8840 {
lab=#net62}
N 8570 -8840 8580 -8830 {
lab=#net62}
N 8420 -8990 8420 -8970 {
lab=vcom}
N 8460 -8990 8460 -8970 {
lab=ctop}
N 8340 -8890 8360 -8890 {
lab=col_n[30]}
N 8340 -8870 8360 -8870 {
lab=colon_n[30]}
N 8340 -8850 8360 -8850 {
lab=#net61}
N 8340 -8830 8360 -8830 {
lab=#net62}
N 8580 -8830 8600 -8830 {
lab=#net62}
N 8580 -8850 8600 -8850 {
lab=#net61}
N 8580 -8870 8600 -8870 {
lab=colon_n[30]}
N 8580 -8890 8600 -8890 {
lab=col_n[30]}
N 8400 -8750 8400 -8740 {
lab=VSS}
N 8400 -8980 8400 -8970 {
lab=VDD}
N 8740 -8750 8750 -8760 {
lab=row_n[29]}
N 8750 -8960 8750 -8760 {
lab=row_n[29]}
N 8740 -8970 8750 -8960 {
lab=row_n[29]}
N 8740 -8750 8740 -8730 {
lab=row_n[29]}
N 8740 -8990 8740 -8970 {
lab=row_n[29]}
N 8620 -8890 8630 -8900 {
lab=col_n[30]}
N 8630 -8900 8830 -8900 {
lab=col_n[30]}
N 8830 -8900 8840 -8890 {
lab=col_n[30]}
N 8620 -8870 8630 -8880 {
lab=colon_n[30]}
N 8630 -8880 8830 -8880 {
lab=colon_n[30]}
N 8830 -8880 8840 -8870 {
lab=colon_n[30]}
N 8620 -8850 8630 -8860 {
lab=#net61}
N 8630 -8860 8830 -8860 {
lab=#net61}
N 8830 -8860 8840 -8850 {
lab=#net61}
N 8620 -8830 8630 -8840 {
lab=#net62}
N 8630 -8840 8830 -8840 {
lab=#net62}
N 8830 -8840 8840 -8830 {
lab=#net62}
N 8680 -8990 8680 -8970 {
lab=vcom}
N 8720 -8990 8720 -8970 {
lab=ctop}
N 8600 -8890 8620 -8890 {
lab=col_n[30]}
N 8600 -8870 8620 -8870 {
lab=colon_n[30]}
N 8600 -8850 8620 -8850 {
lab=#net61}
N 8600 -8830 8620 -8830 {
lab=#net62}
N 8840 -8830 8860 -8830 {
lab=#net62}
N 8840 -8850 8860 -8850 {
lab=#net61}
N 8840 -8870 8860 -8870 {
lab=colon_n[30]}
N 8840 -8890 8860 -8890 {
lab=col_n[30]}
N 8660 -8750 8660 -8740 {
lab=VSS}
N 8660 -8980 8660 -8970 {
lab=VDD}
N 9000 -8750 9010 -8760 {
lab=row_n[30]}
N 9010 -8960 9010 -8760 {
lab=row_n[30]}
N 9000 -8970 9010 -8960 {
lab=row_n[30]}
N 9000 -8750 9000 -8730 {
lab=row_n[30]}
N 9000 -8990 9000 -8970 {
lab=row_n[30]}
N 8880 -8890 8890 -8900 {
lab=col_n[30]}
N 8890 -8900 9090 -8900 {
lab=col_n[30]}
N 9090 -8900 9100 -8890 {
lab=col_n[30]}
N 8880 -8870 8890 -8880 {
lab=colon_n[30]}
N 8890 -8880 9090 -8880 {
lab=colon_n[30]}
N 9090 -8880 9100 -8870 {
lab=colon_n[30]}
N 8880 -8850 8890 -8860 {
lab=#net61}
N 8890 -8860 9090 -8860 {
lab=#net61}
N 9090 -8860 9100 -8850 {
lab=#net61}
N 8880 -8830 8890 -8840 {
lab=#net62}
N 8890 -8840 9090 -8840 {
lab=#net62}
N 9090 -8840 9100 -8830 {
lab=#net62}
N 8940 -8990 8940 -8970 {
lab=vcom}
N 8980 -8990 8980 -8970 {
lab=ctop}
N 8860 -8890 8880 -8890 {
lab=col_n[30]}
N 8860 -8870 8880 -8870 {
lab=colon_n[30]}
N 8860 -8850 8880 -8850 {
lab=#net61}
N 8860 -8830 8880 -8830 {
lab=#net62}
N 9100 -8830 9120 -8830 {
lab=#net62}
N 9100 -8850 9120 -8850 {
lab=#net61}
N 9100 -8870 9120 -8870 {
lab=colon_n[30]}
N 9100 -8890 9120 -8890 {
lab=col_n[30]}
N 8920 -8750 8920 -8740 {
lab=VSS}
N 8920 -8980 8920 -8970 {
lab=VDD}
N 9260 -8750 9270 -8760 {
lab=row_n[31]}
N 9270 -8960 9270 -8760 {
lab=row_n[31]}
N 9260 -8970 9270 -8960 {
lab=row_n[31]}
N 9260 -8750 9260 -8730 {
lab=row_n[31]}
N 9260 -8990 9260 -8970 {
lab=row_n[31]}
N 9140 -8890 9150 -8900 {
lab=col_n[30]}
N 9150 -8900 9350 -8900 {
lab=col_n[30]}
N 9350 -8900 9360 -8890 {
lab=col_n[30]}
N 9140 -8870 9150 -8880 {
lab=colon_n[30]}
N 9150 -8880 9350 -8880 {
lab=colon_n[30]}
N 9350 -8880 9360 -8870 {
lab=colon_n[30]}
N 9140 -8850 9150 -8860 {
lab=#net61}
N 9150 -8860 9350 -8860 {
lab=#net61}
N 9350 -8860 9360 -8850 {
lab=#net61}
N 9140 -8830 9150 -8840 {
lab=#net62}
N 9150 -8840 9350 -8840 {
lab=#net62}
N 9350 -8840 9360 -8830 {
lab=#net62}
N 9200 -8990 9200 -8970 {
lab=vcom}
N 9240 -8990 9240 -8970 {
lab=ctop}
N 9120 -8890 9140 -8890 {
lab=col_n[30]}
N 9120 -8870 9140 -8870 {
lab=colon_n[30]}
N 9120 -8850 9140 -8850 {
lab=#net61}
N 9120 -8830 9140 -8830 {
lab=#net62}
N 9360 -8830 9380 -8830 {
lab=#net62}
N 9360 -8850 9380 -8850 {
lab=#net61}
N 9360 -8870 9380 -8870 {
lab=colon_n[30]}
N 9360 -8890 9380 -8890 {
lab=col_n[30]}
N 9180 -8750 9180 -8740 {
lab=VSS}
N 9180 -8980 9180 -8970 {
lab=VDD}
N 1200 -9010 1210 -9020 {
lab=row_n[0]}
N 1210 -9220 1210 -9020 {
lab=row_n[0]}
N 1200 -9230 1210 -9220 {
lab=row_n[0]}
N 1200 -9010 1200 -8990 {
lab=row_n[0]}
N 1200 -9250 1200 -9230 {
lab=row_n[0]}
N 1080 -9150 1090 -9160 {
lab=col_n[31]}
N 1090 -9160 1290 -9160 {
lab=col_n[31]}
N 1290 -9160 1300 -9150 {
lab=col_n[31]}
N 1080 -9130 1090 -9140 {
lab=colon_n[31]}
N 1090 -9140 1290 -9140 {
lab=colon_n[31]}
N 1290 -9140 1300 -9130 {
lab=colon_n[31]}
N 1080 -9110 1090 -9120 {
lab=#net63}
N 1090 -9120 1290 -9120 {
lab=#net63}
N 1290 -9120 1300 -9110 {
lab=#net63}
N 1080 -9090 1090 -9100 {
lab=#net64}
N 1090 -9100 1290 -9100 {
lab=#net64}
N 1290 -9100 1300 -9090 {
lab=#net64}
N 1140 -9250 1140 -9230 {
lab=vcom}
N 1180 -9250 1180 -9230 {
lab=ctop}
N 1060 -9150 1080 -9150 {
lab=col_n[31]}
N 1060 -9130 1080 -9130 {
lab=colon_n[31]}
N 1060 -9110 1080 -9110 {
lab=#net63}
N 1060 -9090 1080 -9090 {
lab=#net64}
N 1300 -9090 1320 -9090 {
lab=#net64}
N 1300 -9110 1320 -9110 {
lab=#net63}
N 1300 -9130 1320 -9130 {
lab=colon_n[31]}
N 1300 -9150 1320 -9150 {
lab=col_n[31]}
N 1120 -9010 1120 -9000 {
lab=VSS}
N 1120 -9240 1120 -9230 {
lab=VDD}
N 1460 -9010 1470 -9020 {
lab=row_n[1]}
N 1470 -9220 1470 -9020 {
lab=row_n[1]}
N 1460 -9230 1470 -9220 {
lab=row_n[1]}
N 1460 -9010 1460 -8990 {
lab=row_n[1]}
N 1460 -9250 1460 -9230 {
lab=row_n[1]}
N 1340 -9150 1350 -9160 {
lab=col_n[31]}
N 1350 -9160 1550 -9160 {
lab=col_n[31]}
N 1550 -9160 1560 -9150 {
lab=col_n[31]}
N 1340 -9130 1350 -9140 {
lab=colon_n[31]}
N 1350 -9140 1550 -9140 {
lab=colon_n[31]}
N 1550 -9140 1560 -9130 {
lab=colon_n[31]}
N 1340 -9110 1350 -9120 {
lab=#net63}
N 1350 -9120 1550 -9120 {
lab=#net63}
N 1550 -9120 1560 -9110 {
lab=#net63}
N 1340 -9090 1350 -9100 {
lab=#net64}
N 1350 -9100 1550 -9100 {
lab=#net64}
N 1550 -9100 1560 -9090 {
lab=#net64}
N 1400 -9250 1400 -9230 {
lab=vcom}
N 1440 -9250 1440 -9230 {
lab=ctop}
N 1320 -9150 1340 -9150 {
lab=col_n[31]}
N 1320 -9130 1340 -9130 {
lab=colon_n[31]}
N 1320 -9110 1340 -9110 {
lab=#net63}
N 1320 -9090 1340 -9090 {
lab=#net64}
N 1560 -9090 1580 -9090 {
lab=#net64}
N 1560 -9110 1580 -9110 {
lab=#net63}
N 1560 -9130 1580 -9130 {
lab=colon_n[31]}
N 1560 -9150 1580 -9150 {
lab=col_n[31]}
N 1380 -9010 1380 -9000 {
lab=VSS}
N 1380 -9240 1380 -9230 {
lab=VDD}
N 1720 -9010 1730 -9020 {
lab=row_n[2]}
N 1730 -9220 1730 -9020 {
lab=row_n[2]}
N 1720 -9230 1730 -9220 {
lab=row_n[2]}
N 1720 -9010 1720 -8990 {
lab=row_n[2]}
N 1720 -9250 1720 -9230 {
lab=row_n[2]}
N 1600 -9150 1610 -9160 {
lab=col_n[31]}
N 1610 -9160 1810 -9160 {
lab=col_n[31]}
N 1810 -9160 1820 -9150 {
lab=col_n[31]}
N 1600 -9130 1610 -9140 {
lab=colon_n[31]}
N 1610 -9140 1810 -9140 {
lab=colon_n[31]}
N 1810 -9140 1820 -9130 {
lab=colon_n[31]}
N 1600 -9110 1610 -9120 {
lab=#net63}
N 1610 -9120 1810 -9120 {
lab=#net63}
N 1810 -9120 1820 -9110 {
lab=#net63}
N 1600 -9090 1610 -9100 {
lab=#net64}
N 1610 -9100 1810 -9100 {
lab=#net64}
N 1810 -9100 1820 -9090 {
lab=#net64}
N 1660 -9250 1660 -9230 {
lab=vcom}
N 1700 -9250 1700 -9230 {
lab=ctop}
N 1580 -9150 1600 -9150 {
lab=col_n[31]}
N 1580 -9130 1600 -9130 {
lab=colon_n[31]}
N 1580 -9110 1600 -9110 {
lab=#net63}
N 1580 -9090 1600 -9090 {
lab=#net64}
N 1820 -9090 1840 -9090 {
lab=#net64}
N 1820 -9110 1840 -9110 {
lab=#net63}
N 1820 -9130 1840 -9130 {
lab=colon_n[31]}
N 1820 -9150 1840 -9150 {
lab=col_n[31]}
N 1640 -9010 1640 -9000 {
lab=VSS}
N 1640 -9240 1640 -9230 {
lab=VDD}
N 1980 -9010 1990 -9020 {
lab=row_n[3]}
N 1990 -9220 1990 -9020 {
lab=row_n[3]}
N 1980 -9230 1990 -9220 {
lab=row_n[3]}
N 1980 -9010 1980 -8990 {
lab=row_n[3]}
N 1980 -9250 1980 -9230 {
lab=row_n[3]}
N 1860 -9150 1870 -9160 {
lab=col_n[31]}
N 1870 -9160 2070 -9160 {
lab=col_n[31]}
N 2070 -9160 2080 -9150 {
lab=col_n[31]}
N 1860 -9130 1870 -9140 {
lab=colon_n[31]}
N 1870 -9140 2070 -9140 {
lab=colon_n[31]}
N 2070 -9140 2080 -9130 {
lab=colon_n[31]}
N 1860 -9110 1870 -9120 {
lab=#net63}
N 1870 -9120 2070 -9120 {
lab=#net63}
N 2070 -9120 2080 -9110 {
lab=#net63}
N 1860 -9090 1870 -9100 {
lab=#net64}
N 1870 -9100 2070 -9100 {
lab=#net64}
N 2070 -9100 2080 -9090 {
lab=#net64}
N 1920 -9250 1920 -9230 {
lab=vcom}
N 1960 -9250 1960 -9230 {
lab=ctop}
N 1840 -9150 1860 -9150 {
lab=col_n[31]}
N 1840 -9130 1860 -9130 {
lab=colon_n[31]}
N 1840 -9110 1860 -9110 {
lab=#net63}
N 1840 -9090 1860 -9090 {
lab=#net64}
N 2080 -9090 2100 -9090 {
lab=#net64}
N 2080 -9110 2100 -9110 {
lab=#net63}
N 2080 -9130 2100 -9130 {
lab=colon_n[31]}
N 2080 -9150 2100 -9150 {
lab=col_n[31]}
N 1900 -9010 1900 -9000 {
lab=VSS}
N 1900 -9240 1900 -9230 {
lab=VDD}
N 2240 -9010 2250 -9020 {
lab=row_n[4]}
N 2250 -9220 2250 -9020 {
lab=row_n[4]}
N 2240 -9230 2250 -9220 {
lab=row_n[4]}
N 2240 -9010 2240 -8990 {
lab=row_n[4]}
N 2240 -9250 2240 -9230 {
lab=row_n[4]}
N 2120 -9150 2130 -9160 {
lab=col_n[31]}
N 2130 -9160 2330 -9160 {
lab=col_n[31]}
N 2330 -9160 2340 -9150 {
lab=col_n[31]}
N 2120 -9130 2130 -9140 {
lab=colon_n[31]}
N 2130 -9140 2330 -9140 {
lab=colon_n[31]}
N 2330 -9140 2340 -9130 {
lab=colon_n[31]}
N 2120 -9110 2130 -9120 {
lab=#net63}
N 2130 -9120 2330 -9120 {
lab=#net63}
N 2330 -9120 2340 -9110 {
lab=#net63}
N 2120 -9090 2130 -9100 {
lab=#net64}
N 2130 -9100 2330 -9100 {
lab=#net64}
N 2330 -9100 2340 -9090 {
lab=#net64}
N 2180 -9250 2180 -9230 {
lab=vcom}
N 2220 -9250 2220 -9230 {
lab=ctop}
N 2100 -9150 2120 -9150 {
lab=col_n[31]}
N 2100 -9130 2120 -9130 {
lab=colon_n[31]}
N 2100 -9110 2120 -9110 {
lab=#net63}
N 2100 -9090 2120 -9090 {
lab=#net64}
N 2340 -9090 2360 -9090 {
lab=#net64}
N 2340 -9110 2360 -9110 {
lab=#net63}
N 2340 -9130 2360 -9130 {
lab=colon_n[31]}
N 2340 -9150 2360 -9150 {
lab=col_n[31]}
N 2160 -9010 2160 -9000 {
lab=VSS}
N 2160 -9240 2160 -9230 {
lab=VDD}
N 2500 -9010 2510 -9020 {
lab=row_n[5]}
N 2510 -9220 2510 -9020 {
lab=row_n[5]}
N 2500 -9230 2510 -9220 {
lab=row_n[5]}
N 2500 -9010 2500 -8990 {
lab=row_n[5]}
N 2500 -9250 2500 -9230 {
lab=row_n[5]}
N 2380 -9150 2390 -9160 {
lab=col_n[31]}
N 2390 -9160 2590 -9160 {
lab=col_n[31]}
N 2590 -9160 2600 -9150 {
lab=col_n[31]}
N 2380 -9130 2390 -9140 {
lab=colon_n[31]}
N 2390 -9140 2590 -9140 {
lab=colon_n[31]}
N 2590 -9140 2600 -9130 {
lab=colon_n[31]}
N 2380 -9110 2390 -9120 {
lab=#net63}
N 2390 -9120 2590 -9120 {
lab=#net63}
N 2590 -9120 2600 -9110 {
lab=#net63}
N 2380 -9090 2390 -9100 {
lab=#net64}
N 2390 -9100 2590 -9100 {
lab=#net64}
N 2590 -9100 2600 -9090 {
lab=#net64}
N 2440 -9250 2440 -9230 {
lab=vcom}
N 2480 -9250 2480 -9230 {
lab=ctop}
N 2360 -9150 2380 -9150 {
lab=col_n[31]}
N 2360 -9130 2380 -9130 {
lab=colon_n[31]}
N 2360 -9110 2380 -9110 {
lab=#net63}
N 2360 -9090 2380 -9090 {
lab=#net64}
N 2600 -9090 2620 -9090 {
lab=#net64}
N 2600 -9110 2620 -9110 {
lab=#net63}
N 2600 -9130 2620 -9130 {
lab=colon_n[31]}
N 2600 -9150 2620 -9150 {
lab=col_n[31]}
N 2420 -9010 2420 -9000 {
lab=VSS}
N 2420 -9240 2420 -9230 {
lab=VDD}
N 2760 -9010 2770 -9020 {
lab=row_n[6]}
N 2770 -9220 2770 -9020 {
lab=row_n[6]}
N 2760 -9230 2770 -9220 {
lab=row_n[6]}
N 2760 -9010 2760 -8990 {
lab=row_n[6]}
N 2760 -9250 2760 -9230 {
lab=row_n[6]}
N 2640 -9150 2650 -9160 {
lab=col_n[31]}
N 2650 -9160 2850 -9160 {
lab=col_n[31]}
N 2850 -9160 2860 -9150 {
lab=col_n[31]}
N 2640 -9130 2650 -9140 {
lab=colon_n[31]}
N 2650 -9140 2850 -9140 {
lab=colon_n[31]}
N 2850 -9140 2860 -9130 {
lab=colon_n[31]}
N 2640 -9110 2650 -9120 {
lab=#net63}
N 2650 -9120 2850 -9120 {
lab=#net63}
N 2850 -9120 2860 -9110 {
lab=#net63}
N 2640 -9090 2650 -9100 {
lab=#net64}
N 2650 -9100 2850 -9100 {
lab=#net64}
N 2850 -9100 2860 -9090 {
lab=#net64}
N 2700 -9250 2700 -9230 {
lab=vcom}
N 2740 -9250 2740 -9230 {
lab=ctop}
N 2620 -9150 2640 -9150 {
lab=col_n[31]}
N 2620 -9130 2640 -9130 {
lab=colon_n[31]}
N 2620 -9110 2640 -9110 {
lab=#net63}
N 2620 -9090 2640 -9090 {
lab=#net64}
N 2860 -9090 2880 -9090 {
lab=#net64}
N 2860 -9110 2880 -9110 {
lab=#net63}
N 2860 -9130 2880 -9130 {
lab=colon_n[31]}
N 2860 -9150 2880 -9150 {
lab=col_n[31]}
N 2680 -9010 2680 -9000 {
lab=VSS}
N 2680 -9240 2680 -9230 {
lab=VDD}
N 3020 -9010 3030 -9020 {
lab=row_n[7]}
N 3030 -9220 3030 -9020 {
lab=row_n[7]}
N 3020 -9230 3030 -9220 {
lab=row_n[7]}
N 3020 -9010 3020 -8990 {
lab=row_n[7]}
N 3020 -9250 3020 -9230 {
lab=row_n[7]}
N 2900 -9150 2910 -9160 {
lab=col_n[31]}
N 2910 -9160 3110 -9160 {
lab=col_n[31]}
N 3110 -9160 3120 -9150 {
lab=col_n[31]}
N 2900 -9130 2910 -9140 {
lab=colon_n[31]}
N 2910 -9140 3110 -9140 {
lab=colon_n[31]}
N 3110 -9140 3120 -9130 {
lab=colon_n[31]}
N 2900 -9110 2910 -9120 {
lab=#net63}
N 2910 -9120 3110 -9120 {
lab=#net63}
N 3110 -9120 3120 -9110 {
lab=#net63}
N 2900 -9090 2910 -9100 {
lab=#net64}
N 2910 -9100 3110 -9100 {
lab=#net64}
N 3110 -9100 3120 -9090 {
lab=#net64}
N 2960 -9250 2960 -9230 {
lab=vcom}
N 3000 -9250 3000 -9230 {
lab=ctop}
N 2880 -9150 2900 -9150 {
lab=col_n[31]}
N 2880 -9130 2900 -9130 {
lab=colon_n[31]}
N 2880 -9110 2900 -9110 {
lab=#net63}
N 2880 -9090 2900 -9090 {
lab=#net64}
N 3120 -9090 3140 -9090 {
lab=#net64}
N 3120 -9110 3140 -9110 {
lab=#net63}
N 3120 -9130 3140 -9130 {
lab=colon_n[31]}
N 3120 -9150 3140 -9150 {
lab=col_n[31]}
N 2940 -9010 2940 -9000 {
lab=VSS}
N 2940 -9240 2940 -9230 {
lab=VDD}
N 3280 -9010 3290 -9020 {
lab=row_n[8]}
N 3290 -9220 3290 -9020 {
lab=row_n[8]}
N 3280 -9230 3290 -9220 {
lab=row_n[8]}
N 3280 -9010 3280 -8990 {
lab=row_n[8]}
N 3280 -9250 3280 -9230 {
lab=row_n[8]}
N 3160 -9150 3170 -9160 {
lab=col_n[31]}
N 3170 -9160 3370 -9160 {
lab=col_n[31]}
N 3370 -9160 3380 -9150 {
lab=col_n[31]}
N 3160 -9130 3170 -9140 {
lab=colon_n[31]}
N 3170 -9140 3370 -9140 {
lab=colon_n[31]}
N 3370 -9140 3380 -9130 {
lab=colon_n[31]}
N 3160 -9110 3170 -9120 {
lab=#net63}
N 3170 -9120 3370 -9120 {
lab=#net63}
N 3370 -9120 3380 -9110 {
lab=#net63}
N 3160 -9090 3170 -9100 {
lab=#net64}
N 3170 -9100 3370 -9100 {
lab=#net64}
N 3370 -9100 3380 -9090 {
lab=#net64}
N 3220 -9250 3220 -9230 {
lab=vcom}
N 3260 -9250 3260 -9230 {
lab=ctop}
N 3140 -9150 3160 -9150 {
lab=col_n[31]}
N 3140 -9130 3160 -9130 {
lab=colon_n[31]}
N 3140 -9110 3160 -9110 {
lab=#net63}
N 3140 -9090 3160 -9090 {
lab=#net64}
N 3380 -9090 3400 -9090 {
lab=#net64}
N 3380 -9110 3400 -9110 {
lab=#net63}
N 3380 -9130 3400 -9130 {
lab=colon_n[31]}
N 3380 -9150 3400 -9150 {
lab=col_n[31]}
N 3200 -9010 3200 -9000 {
lab=VSS}
N 3200 -9240 3200 -9230 {
lab=VDD}
N 3540 -9010 3550 -9020 {
lab=row_n[9]}
N 3550 -9220 3550 -9020 {
lab=row_n[9]}
N 3540 -9230 3550 -9220 {
lab=row_n[9]}
N 3540 -9010 3540 -8990 {
lab=row_n[9]}
N 3540 -9250 3540 -9230 {
lab=row_n[9]}
N 3420 -9150 3430 -9160 {
lab=col_n[31]}
N 3430 -9160 3630 -9160 {
lab=col_n[31]}
N 3630 -9160 3640 -9150 {
lab=col_n[31]}
N 3420 -9130 3430 -9140 {
lab=colon_n[31]}
N 3430 -9140 3630 -9140 {
lab=colon_n[31]}
N 3630 -9140 3640 -9130 {
lab=colon_n[31]}
N 3420 -9110 3430 -9120 {
lab=#net63}
N 3430 -9120 3630 -9120 {
lab=#net63}
N 3630 -9120 3640 -9110 {
lab=#net63}
N 3420 -9090 3430 -9100 {
lab=#net64}
N 3430 -9100 3630 -9100 {
lab=#net64}
N 3630 -9100 3640 -9090 {
lab=#net64}
N 3480 -9250 3480 -9230 {
lab=vcom}
N 3520 -9250 3520 -9230 {
lab=ctop}
N 3400 -9150 3420 -9150 {
lab=col_n[31]}
N 3400 -9130 3420 -9130 {
lab=colon_n[31]}
N 3400 -9110 3420 -9110 {
lab=#net63}
N 3400 -9090 3420 -9090 {
lab=#net64}
N 3640 -9090 3660 -9090 {
lab=#net64}
N 3640 -9110 3660 -9110 {
lab=#net63}
N 3640 -9130 3660 -9130 {
lab=colon_n[31]}
N 3640 -9150 3660 -9150 {
lab=col_n[31]}
N 3460 -9010 3460 -9000 {
lab=VSS}
N 3460 -9240 3460 -9230 {
lab=VDD}
N 3800 -9010 3810 -9020 {
lab=row_n[10]}
N 3810 -9220 3810 -9020 {
lab=row_n[10]}
N 3800 -9230 3810 -9220 {
lab=row_n[10]}
N 3800 -9010 3800 -8990 {
lab=row_n[10]}
N 3800 -9250 3800 -9230 {
lab=row_n[10]}
N 3680 -9150 3690 -9160 {
lab=col_n[31]}
N 3690 -9160 3890 -9160 {
lab=col_n[31]}
N 3890 -9160 3900 -9150 {
lab=col_n[31]}
N 3680 -9130 3690 -9140 {
lab=colon_n[31]}
N 3690 -9140 3890 -9140 {
lab=colon_n[31]}
N 3890 -9140 3900 -9130 {
lab=colon_n[31]}
N 3680 -9110 3690 -9120 {
lab=#net63}
N 3690 -9120 3890 -9120 {
lab=#net63}
N 3890 -9120 3900 -9110 {
lab=#net63}
N 3680 -9090 3690 -9100 {
lab=#net64}
N 3690 -9100 3890 -9100 {
lab=#net64}
N 3890 -9100 3900 -9090 {
lab=#net64}
N 3740 -9250 3740 -9230 {
lab=vcom}
N 3780 -9250 3780 -9230 {
lab=ctop}
N 3660 -9150 3680 -9150 {
lab=col_n[31]}
N 3660 -9130 3680 -9130 {
lab=colon_n[31]}
N 3660 -9110 3680 -9110 {
lab=#net63}
N 3660 -9090 3680 -9090 {
lab=#net64}
N 3900 -9090 3920 -9090 {
lab=#net64}
N 3900 -9110 3920 -9110 {
lab=#net63}
N 3900 -9130 3920 -9130 {
lab=colon_n[31]}
N 3900 -9150 3920 -9150 {
lab=col_n[31]}
N 3720 -9010 3720 -9000 {
lab=VSS}
N 3720 -9240 3720 -9230 {
lab=VDD}
N 4060 -9010 4070 -9020 {
lab=row_n[11]}
N 4070 -9220 4070 -9020 {
lab=row_n[11]}
N 4060 -9230 4070 -9220 {
lab=row_n[11]}
N 4060 -9010 4060 -8990 {
lab=row_n[11]}
N 4060 -9250 4060 -9230 {
lab=row_n[11]}
N 3940 -9150 3950 -9160 {
lab=col_n[31]}
N 3950 -9160 4150 -9160 {
lab=col_n[31]}
N 4150 -9160 4160 -9150 {
lab=col_n[31]}
N 3940 -9130 3950 -9140 {
lab=colon_n[31]}
N 3950 -9140 4150 -9140 {
lab=colon_n[31]}
N 4150 -9140 4160 -9130 {
lab=colon_n[31]}
N 3940 -9110 3950 -9120 {
lab=#net63}
N 3950 -9120 4150 -9120 {
lab=#net63}
N 4150 -9120 4160 -9110 {
lab=#net63}
N 3940 -9090 3950 -9100 {
lab=#net64}
N 3950 -9100 4150 -9100 {
lab=#net64}
N 4150 -9100 4160 -9090 {
lab=#net64}
N 4000 -9250 4000 -9230 {
lab=vcom}
N 4040 -9250 4040 -9230 {
lab=ctop}
N 3920 -9150 3940 -9150 {
lab=col_n[31]}
N 3920 -9130 3940 -9130 {
lab=colon_n[31]}
N 3920 -9110 3940 -9110 {
lab=#net63}
N 3920 -9090 3940 -9090 {
lab=#net64}
N 4160 -9090 4180 -9090 {
lab=#net64}
N 4160 -9110 4180 -9110 {
lab=#net63}
N 4160 -9130 4180 -9130 {
lab=colon_n[31]}
N 4160 -9150 4180 -9150 {
lab=col_n[31]}
N 3980 -9010 3980 -9000 {
lab=VSS}
N 3980 -9240 3980 -9230 {
lab=VDD}
N 4320 -9010 4330 -9020 {
lab=row_n[12]}
N 4330 -9220 4330 -9020 {
lab=row_n[12]}
N 4320 -9230 4330 -9220 {
lab=row_n[12]}
N 4320 -9010 4320 -8990 {
lab=row_n[12]}
N 4320 -9250 4320 -9230 {
lab=row_n[12]}
N 4200 -9150 4210 -9160 {
lab=col_n[31]}
N 4210 -9160 4410 -9160 {
lab=col_n[31]}
N 4410 -9160 4420 -9150 {
lab=col_n[31]}
N 4200 -9130 4210 -9140 {
lab=colon_n[31]}
N 4210 -9140 4410 -9140 {
lab=colon_n[31]}
N 4410 -9140 4420 -9130 {
lab=colon_n[31]}
N 4200 -9110 4210 -9120 {
lab=#net63}
N 4210 -9120 4410 -9120 {
lab=#net63}
N 4410 -9120 4420 -9110 {
lab=#net63}
N 4200 -9090 4210 -9100 {
lab=#net64}
N 4210 -9100 4410 -9100 {
lab=#net64}
N 4410 -9100 4420 -9090 {
lab=#net64}
N 4260 -9250 4260 -9230 {
lab=vcom}
N 4300 -9250 4300 -9230 {
lab=ctop}
N 4180 -9150 4200 -9150 {
lab=col_n[31]}
N 4180 -9130 4200 -9130 {
lab=colon_n[31]}
N 4180 -9110 4200 -9110 {
lab=#net63}
N 4180 -9090 4200 -9090 {
lab=#net64}
N 4420 -9090 4440 -9090 {
lab=#net64}
N 4420 -9110 4440 -9110 {
lab=#net63}
N 4420 -9130 4440 -9130 {
lab=colon_n[31]}
N 4420 -9150 4440 -9150 {
lab=col_n[31]}
N 4240 -9010 4240 -9000 {
lab=VSS}
N 4240 -9240 4240 -9230 {
lab=VDD}
N 4580 -9010 4590 -9020 {
lab=row_n[13]}
N 4590 -9220 4590 -9020 {
lab=row_n[13]}
N 4580 -9230 4590 -9220 {
lab=row_n[13]}
N 4580 -9010 4580 -8990 {
lab=row_n[13]}
N 4580 -9250 4580 -9230 {
lab=row_n[13]}
N 4460 -9150 4470 -9160 {
lab=col_n[31]}
N 4470 -9160 4670 -9160 {
lab=col_n[31]}
N 4670 -9160 4680 -9150 {
lab=col_n[31]}
N 4460 -9130 4470 -9140 {
lab=colon_n[31]}
N 4470 -9140 4670 -9140 {
lab=colon_n[31]}
N 4670 -9140 4680 -9130 {
lab=colon_n[31]}
N 4460 -9110 4470 -9120 {
lab=#net63}
N 4470 -9120 4670 -9120 {
lab=#net63}
N 4670 -9120 4680 -9110 {
lab=#net63}
N 4460 -9090 4470 -9100 {
lab=#net64}
N 4470 -9100 4670 -9100 {
lab=#net64}
N 4670 -9100 4680 -9090 {
lab=#net64}
N 4520 -9250 4520 -9230 {
lab=vcom}
N 4560 -9250 4560 -9230 {
lab=ctop}
N 4440 -9150 4460 -9150 {
lab=col_n[31]}
N 4440 -9130 4460 -9130 {
lab=colon_n[31]}
N 4440 -9110 4460 -9110 {
lab=#net63}
N 4440 -9090 4460 -9090 {
lab=#net64}
N 4680 -9090 4700 -9090 {
lab=#net64}
N 4680 -9110 4700 -9110 {
lab=#net63}
N 4680 -9130 4700 -9130 {
lab=colon_n[31]}
N 4680 -9150 4700 -9150 {
lab=col_n[31]}
N 4500 -9010 4500 -9000 {
lab=VSS}
N 4500 -9240 4500 -9230 {
lab=VDD}
N 4840 -9010 4850 -9020 {
lab=row_n[14]}
N 4850 -9220 4850 -9020 {
lab=row_n[14]}
N 4840 -9230 4850 -9220 {
lab=row_n[14]}
N 4840 -9010 4840 -8990 {
lab=row_n[14]}
N 4840 -9250 4840 -9230 {
lab=row_n[14]}
N 4720 -9150 4730 -9160 {
lab=col_n[31]}
N 4730 -9160 4930 -9160 {
lab=col_n[31]}
N 4930 -9160 4940 -9150 {
lab=col_n[31]}
N 4720 -9130 4730 -9140 {
lab=colon_n[31]}
N 4730 -9140 4930 -9140 {
lab=colon_n[31]}
N 4930 -9140 4940 -9130 {
lab=colon_n[31]}
N 4720 -9110 4730 -9120 {
lab=#net63}
N 4730 -9120 4930 -9120 {
lab=#net63}
N 4930 -9120 4940 -9110 {
lab=#net63}
N 4720 -9090 4730 -9100 {
lab=#net64}
N 4730 -9100 4930 -9100 {
lab=#net64}
N 4930 -9100 4940 -9090 {
lab=#net64}
N 4780 -9250 4780 -9230 {
lab=vcom}
N 4820 -9250 4820 -9230 {
lab=ctop}
N 4700 -9150 4720 -9150 {
lab=col_n[31]}
N 4700 -9130 4720 -9130 {
lab=colon_n[31]}
N 4700 -9110 4720 -9110 {
lab=#net63}
N 4700 -9090 4720 -9090 {
lab=#net64}
N 4940 -9090 4960 -9090 {
lab=#net64}
N 4940 -9110 4960 -9110 {
lab=#net63}
N 4940 -9130 4960 -9130 {
lab=colon_n[31]}
N 4940 -9150 4960 -9150 {
lab=col_n[31]}
N 4760 -9010 4760 -9000 {
lab=VSS}
N 4760 -9240 4760 -9230 {
lab=VDD}
N 5100 -9010 5110 -9020 {
lab=row_n[15]}
N 5110 -9220 5110 -9020 {
lab=row_n[15]}
N 5100 -9230 5110 -9220 {
lab=row_n[15]}
N 5100 -9010 5100 -8990 {
lab=row_n[15]}
N 5100 -9250 5100 -9230 {
lab=row_n[15]}
N 4980 -9150 4990 -9160 {
lab=col_n[31]}
N 4990 -9160 5190 -9160 {
lab=col_n[31]}
N 5190 -9160 5200 -9150 {
lab=col_n[31]}
N 4980 -9130 4990 -9140 {
lab=colon_n[31]}
N 4990 -9140 5190 -9140 {
lab=colon_n[31]}
N 5190 -9140 5200 -9130 {
lab=colon_n[31]}
N 4980 -9110 4990 -9120 {
lab=#net63}
N 4990 -9120 5190 -9120 {
lab=#net63}
N 5190 -9120 5200 -9110 {
lab=#net63}
N 4980 -9090 4990 -9100 {
lab=#net64}
N 4990 -9100 5190 -9100 {
lab=#net64}
N 5190 -9100 5200 -9090 {
lab=#net64}
N 5040 -9250 5040 -9230 {
lab=vcom}
N 5080 -9250 5080 -9230 {
lab=ctop}
N 4960 -9150 4980 -9150 {
lab=col_n[31]}
N 4960 -9130 4980 -9130 {
lab=colon_n[31]}
N 4960 -9110 4980 -9110 {
lab=#net63}
N 4960 -9090 4980 -9090 {
lab=#net64}
N 5200 -9090 5220 -9090 {
lab=#net64}
N 5200 -9110 5220 -9110 {
lab=#net63}
N 5200 -9130 5220 -9130 {
lab=colon_n[31]}
N 5200 -9150 5220 -9150 {
lab=col_n[31]}
N 5020 -9010 5020 -9000 {
lab=VSS}
N 5020 -9240 5020 -9230 {
lab=VDD}
N 5360 -9010 5370 -9020 {
lab=row_n[16]}
N 5370 -9220 5370 -9020 {
lab=row_n[16]}
N 5360 -9230 5370 -9220 {
lab=row_n[16]}
N 5360 -9010 5360 -8990 {
lab=row_n[16]}
N 5360 -9250 5360 -9230 {
lab=row_n[16]}
N 5240 -9150 5250 -9160 {
lab=col_n[31]}
N 5250 -9160 5450 -9160 {
lab=col_n[31]}
N 5450 -9160 5460 -9150 {
lab=col_n[31]}
N 5240 -9130 5250 -9140 {
lab=colon_n[31]}
N 5250 -9140 5450 -9140 {
lab=colon_n[31]}
N 5450 -9140 5460 -9130 {
lab=colon_n[31]}
N 5240 -9110 5250 -9120 {
lab=#net63}
N 5250 -9120 5450 -9120 {
lab=#net63}
N 5450 -9120 5460 -9110 {
lab=#net63}
N 5240 -9090 5250 -9100 {
lab=#net64}
N 5250 -9100 5450 -9100 {
lab=#net64}
N 5450 -9100 5460 -9090 {
lab=#net64}
N 5300 -9250 5300 -9230 {
lab=vcom}
N 5340 -9250 5340 -9230 {
lab=ctop}
N 5220 -9150 5240 -9150 {
lab=col_n[31]}
N 5220 -9130 5240 -9130 {
lab=colon_n[31]}
N 5220 -9110 5240 -9110 {
lab=#net63}
N 5220 -9090 5240 -9090 {
lab=#net64}
N 5460 -9090 5480 -9090 {
lab=#net64}
N 5460 -9110 5480 -9110 {
lab=#net63}
N 5460 -9130 5480 -9130 {
lab=colon_n[31]}
N 5460 -9150 5480 -9150 {
lab=col_n[31]}
N 5280 -9010 5280 -9000 {
lab=VSS}
N 5280 -9240 5280 -9230 {
lab=VDD}
N 5620 -9010 5630 -9020 {
lab=row_n[17]}
N 5630 -9220 5630 -9020 {
lab=row_n[17]}
N 5620 -9230 5630 -9220 {
lab=row_n[17]}
N 5620 -9010 5620 -8990 {
lab=row_n[17]}
N 5620 -9250 5620 -9230 {
lab=row_n[17]}
N 5500 -9150 5510 -9160 {
lab=col_n[31]}
N 5510 -9160 5710 -9160 {
lab=col_n[31]}
N 5710 -9160 5720 -9150 {
lab=col_n[31]}
N 5500 -9130 5510 -9140 {
lab=colon_n[31]}
N 5510 -9140 5710 -9140 {
lab=colon_n[31]}
N 5710 -9140 5720 -9130 {
lab=colon_n[31]}
N 5500 -9110 5510 -9120 {
lab=#net63}
N 5510 -9120 5710 -9120 {
lab=#net63}
N 5710 -9120 5720 -9110 {
lab=#net63}
N 5500 -9090 5510 -9100 {
lab=#net64}
N 5510 -9100 5710 -9100 {
lab=#net64}
N 5710 -9100 5720 -9090 {
lab=#net64}
N 5560 -9250 5560 -9230 {
lab=vcom}
N 5600 -9250 5600 -9230 {
lab=ctop}
N 5480 -9150 5500 -9150 {
lab=col_n[31]}
N 5480 -9130 5500 -9130 {
lab=colon_n[31]}
N 5480 -9110 5500 -9110 {
lab=#net63}
N 5480 -9090 5500 -9090 {
lab=#net64}
N 5720 -9090 5740 -9090 {
lab=#net64}
N 5720 -9110 5740 -9110 {
lab=#net63}
N 5720 -9130 5740 -9130 {
lab=colon_n[31]}
N 5720 -9150 5740 -9150 {
lab=col_n[31]}
N 5540 -9010 5540 -9000 {
lab=VSS}
N 5540 -9240 5540 -9230 {
lab=VDD}
N 5880 -9010 5890 -9020 {
lab=row_n[18]}
N 5890 -9220 5890 -9020 {
lab=row_n[18]}
N 5880 -9230 5890 -9220 {
lab=row_n[18]}
N 5880 -9010 5880 -8990 {
lab=row_n[18]}
N 5880 -9250 5880 -9230 {
lab=row_n[18]}
N 5760 -9150 5770 -9160 {
lab=col_n[31]}
N 5770 -9160 5970 -9160 {
lab=col_n[31]}
N 5970 -9160 5980 -9150 {
lab=col_n[31]}
N 5760 -9130 5770 -9140 {
lab=colon_n[31]}
N 5770 -9140 5970 -9140 {
lab=colon_n[31]}
N 5970 -9140 5980 -9130 {
lab=colon_n[31]}
N 5760 -9110 5770 -9120 {
lab=#net63}
N 5770 -9120 5970 -9120 {
lab=#net63}
N 5970 -9120 5980 -9110 {
lab=#net63}
N 5760 -9090 5770 -9100 {
lab=#net64}
N 5770 -9100 5970 -9100 {
lab=#net64}
N 5970 -9100 5980 -9090 {
lab=#net64}
N 5820 -9250 5820 -9230 {
lab=vcom}
N 5860 -9250 5860 -9230 {
lab=ctop}
N 5740 -9150 5760 -9150 {
lab=col_n[31]}
N 5740 -9130 5760 -9130 {
lab=colon_n[31]}
N 5740 -9110 5760 -9110 {
lab=#net63}
N 5740 -9090 5760 -9090 {
lab=#net64}
N 5980 -9090 6000 -9090 {
lab=#net64}
N 5980 -9110 6000 -9110 {
lab=#net63}
N 5980 -9130 6000 -9130 {
lab=colon_n[31]}
N 5980 -9150 6000 -9150 {
lab=col_n[31]}
N 5800 -9010 5800 -9000 {
lab=VSS}
N 5800 -9240 5800 -9230 {
lab=VDD}
N 6140 -9010 6150 -9020 {
lab=row_n[19]}
N 6150 -9220 6150 -9020 {
lab=row_n[19]}
N 6140 -9230 6150 -9220 {
lab=row_n[19]}
N 6140 -9010 6140 -8990 {
lab=row_n[19]}
N 6140 -9250 6140 -9230 {
lab=row_n[19]}
N 6020 -9150 6030 -9160 {
lab=col_n[31]}
N 6030 -9160 6230 -9160 {
lab=col_n[31]}
N 6230 -9160 6240 -9150 {
lab=col_n[31]}
N 6020 -9130 6030 -9140 {
lab=colon_n[31]}
N 6030 -9140 6230 -9140 {
lab=colon_n[31]}
N 6230 -9140 6240 -9130 {
lab=colon_n[31]}
N 6020 -9110 6030 -9120 {
lab=#net63}
N 6030 -9120 6230 -9120 {
lab=#net63}
N 6230 -9120 6240 -9110 {
lab=#net63}
N 6020 -9090 6030 -9100 {
lab=#net64}
N 6030 -9100 6230 -9100 {
lab=#net64}
N 6230 -9100 6240 -9090 {
lab=#net64}
N 6080 -9250 6080 -9230 {
lab=vcom}
N 6120 -9250 6120 -9230 {
lab=ctop}
N 6000 -9150 6020 -9150 {
lab=col_n[31]}
N 6000 -9130 6020 -9130 {
lab=colon_n[31]}
N 6000 -9110 6020 -9110 {
lab=#net63}
N 6000 -9090 6020 -9090 {
lab=#net64}
N 6240 -9090 6260 -9090 {
lab=#net64}
N 6240 -9110 6260 -9110 {
lab=#net63}
N 6240 -9130 6260 -9130 {
lab=colon_n[31]}
N 6240 -9150 6260 -9150 {
lab=col_n[31]}
N 6060 -9010 6060 -9000 {
lab=VSS}
N 6060 -9240 6060 -9230 {
lab=VDD}
N 6400 -9010 6410 -9020 {
lab=row_n[20]}
N 6410 -9220 6410 -9020 {
lab=row_n[20]}
N 6400 -9230 6410 -9220 {
lab=row_n[20]}
N 6400 -9010 6400 -8990 {
lab=row_n[20]}
N 6400 -9250 6400 -9230 {
lab=row_n[20]}
N 6280 -9150 6290 -9160 {
lab=col_n[31]}
N 6290 -9160 6490 -9160 {
lab=col_n[31]}
N 6490 -9160 6500 -9150 {
lab=col_n[31]}
N 6280 -9130 6290 -9140 {
lab=colon_n[31]}
N 6290 -9140 6490 -9140 {
lab=colon_n[31]}
N 6490 -9140 6500 -9130 {
lab=colon_n[31]}
N 6280 -9110 6290 -9120 {
lab=#net63}
N 6290 -9120 6490 -9120 {
lab=#net63}
N 6490 -9120 6500 -9110 {
lab=#net63}
N 6280 -9090 6290 -9100 {
lab=#net64}
N 6290 -9100 6490 -9100 {
lab=#net64}
N 6490 -9100 6500 -9090 {
lab=#net64}
N 6340 -9250 6340 -9230 {
lab=vcom}
N 6380 -9250 6380 -9230 {
lab=ctop}
N 6260 -9150 6280 -9150 {
lab=col_n[31]}
N 6260 -9130 6280 -9130 {
lab=colon_n[31]}
N 6260 -9110 6280 -9110 {
lab=#net63}
N 6260 -9090 6280 -9090 {
lab=#net64}
N 6500 -9090 6520 -9090 {
lab=#net64}
N 6500 -9110 6520 -9110 {
lab=#net63}
N 6500 -9130 6520 -9130 {
lab=colon_n[31]}
N 6500 -9150 6520 -9150 {
lab=col_n[31]}
N 6320 -9010 6320 -9000 {
lab=VSS}
N 6320 -9240 6320 -9230 {
lab=VDD}
N 6660 -9010 6670 -9020 {
lab=row_n[21]}
N 6670 -9220 6670 -9020 {
lab=row_n[21]}
N 6660 -9230 6670 -9220 {
lab=row_n[21]}
N 6660 -9010 6660 -8990 {
lab=row_n[21]}
N 6660 -9250 6660 -9230 {
lab=row_n[21]}
N 6540 -9150 6550 -9160 {
lab=col_n[31]}
N 6550 -9160 6750 -9160 {
lab=col_n[31]}
N 6750 -9160 6760 -9150 {
lab=col_n[31]}
N 6540 -9130 6550 -9140 {
lab=colon_n[31]}
N 6550 -9140 6750 -9140 {
lab=colon_n[31]}
N 6750 -9140 6760 -9130 {
lab=colon_n[31]}
N 6540 -9110 6550 -9120 {
lab=#net63}
N 6550 -9120 6750 -9120 {
lab=#net63}
N 6750 -9120 6760 -9110 {
lab=#net63}
N 6540 -9090 6550 -9100 {
lab=#net64}
N 6550 -9100 6750 -9100 {
lab=#net64}
N 6750 -9100 6760 -9090 {
lab=#net64}
N 6600 -9250 6600 -9230 {
lab=vcom}
N 6640 -9250 6640 -9230 {
lab=ctop}
N 6520 -9150 6540 -9150 {
lab=col_n[31]}
N 6520 -9130 6540 -9130 {
lab=colon_n[31]}
N 6520 -9110 6540 -9110 {
lab=#net63}
N 6520 -9090 6540 -9090 {
lab=#net64}
N 6760 -9090 6780 -9090 {
lab=#net64}
N 6760 -9110 6780 -9110 {
lab=#net63}
N 6760 -9130 6780 -9130 {
lab=colon_n[31]}
N 6760 -9150 6780 -9150 {
lab=col_n[31]}
N 6580 -9010 6580 -9000 {
lab=VSS}
N 6580 -9240 6580 -9230 {
lab=VDD}
N 6920 -9010 6930 -9020 {
lab=row_n[22]}
N 6930 -9220 6930 -9020 {
lab=row_n[22]}
N 6920 -9230 6930 -9220 {
lab=row_n[22]}
N 6920 -9010 6920 -8990 {
lab=row_n[22]}
N 6920 -9250 6920 -9230 {
lab=row_n[22]}
N 6800 -9150 6810 -9160 {
lab=col_n[31]}
N 6810 -9160 7010 -9160 {
lab=col_n[31]}
N 7010 -9160 7020 -9150 {
lab=col_n[31]}
N 6800 -9130 6810 -9140 {
lab=colon_n[31]}
N 6810 -9140 7010 -9140 {
lab=colon_n[31]}
N 7010 -9140 7020 -9130 {
lab=colon_n[31]}
N 6800 -9110 6810 -9120 {
lab=#net63}
N 6810 -9120 7010 -9120 {
lab=#net63}
N 7010 -9120 7020 -9110 {
lab=#net63}
N 6800 -9090 6810 -9100 {
lab=#net64}
N 6810 -9100 7010 -9100 {
lab=#net64}
N 7010 -9100 7020 -9090 {
lab=#net64}
N 6860 -9250 6860 -9230 {
lab=vcom}
N 6900 -9250 6900 -9230 {
lab=ctop}
N 6780 -9150 6800 -9150 {
lab=col_n[31]}
N 6780 -9130 6800 -9130 {
lab=colon_n[31]}
N 6780 -9110 6800 -9110 {
lab=#net63}
N 6780 -9090 6800 -9090 {
lab=#net64}
N 7020 -9090 7040 -9090 {
lab=#net64}
N 7020 -9110 7040 -9110 {
lab=#net63}
N 7020 -9130 7040 -9130 {
lab=colon_n[31]}
N 7020 -9150 7040 -9150 {
lab=col_n[31]}
N 6840 -9010 6840 -9000 {
lab=VSS}
N 6840 -9240 6840 -9230 {
lab=VDD}
N 7180 -9010 7190 -9020 {
lab=row_n[23]}
N 7190 -9220 7190 -9020 {
lab=row_n[23]}
N 7180 -9230 7190 -9220 {
lab=row_n[23]}
N 7180 -9010 7180 -8990 {
lab=row_n[23]}
N 7180 -9250 7180 -9230 {
lab=row_n[23]}
N 7060 -9150 7070 -9160 {
lab=col_n[31]}
N 7070 -9160 7270 -9160 {
lab=col_n[31]}
N 7270 -9160 7280 -9150 {
lab=col_n[31]}
N 7060 -9130 7070 -9140 {
lab=colon_n[31]}
N 7070 -9140 7270 -9140 {
lab=colon_n[31]}
N 7270 -9140 7280 -9130 {
lab=colon_n[31]}
N 7060 -9110 7070 -9120 {
lab=#net63}
N 7070 -9120 7270 -9120 {
lab=#net63}
N 7270 -9120 7280 -9110 {
lab=#net63}
N 7060 -9090 7070 -9100 {
lab=#net64}
N 7070 -9100 7270 -9100 {
lab=#net64}
N 7270 -9100 7280 -9090 {
lab=#net64}
N 7120 -9250 7120 -9230 {
lab=vcom}
N 7160 -9250 7160 -9230 {
lab=ctop}
N 7040 -9150 7060 -9150 {
lab=col_n[31]}
N 7040 -9130 7060 -9130 {
lab=colon_n[31]}
N 7040 -9110 7060 -9110 {
lab=#net63}
N 7040 -9090 7060 -9090 {
lab=#net64}
N 7280 -9090 7300 -9090 {
lab=#net64}
N 7280 -9110 7300 -9110 {
lab=#net63}
N 7280 -9130 7300 -9130 {
lab=colon_n[31]}
N 7280 -9150 7300 -9150 {
lab=col_n[31]}
N 7100 -9010 7100 -9000 {
lab=VSS}
N 7100 -9240 7100 -9230 {
lab=VDD}
N 7440 -9010 7450 -9020 {
lab=row_n[24]}
N 7450 -9220 7450 -9020 {
lab=row_n[24]}
N 7440 -9230 7450 -9220 {
lab=row_n[24]}
N 7440 -9010 7440 -8990 {
lab=row_n[24]}
N 7440 -9250 7440 -9230 {
lab=row_n[24]}
N 7320 -9150 7330 -9160 {
lab=col_n[31]}
N 7330 -9160 7530 -9160 {
lab=col_n[31]}
N 7530 -9160 7540 -9150 {
lab=col_n[31]}
N 7320 -9130 7330 -9140 {
lab=colon_n[31]}
N 7330 -9140 7530 -9140 {
lab=colon_n[31]}
N 7530 -9140 7540 -9130 {
lab=colon_n[31]}
N 7320 -9110 7330 -9120 {
lab=#net63}
N 7330 -9120 7530 -9120 {
lab=#net63}
N 7530 -9120 7540 -9110 {
lab=#net63}
N 7320 -9090 7330 -9100 {
lab=#net64}
N 7330 -9100 7530 -9100 {
lab=#net64}
N 7530 -9100 7540 -9090 {
lab=#net64}
N 7380 -9250 7380 -9230 {
lab=vcom}
N 7420 -9250 7420 -9230 {
lab=ctop}
N 7300 -9150 7320 -9150 {
lab=col_n[31]}
N 7300 -9130 7320 -9130 {
lab=colon_n[31]}
N 7300 -9110 7320 -9110 {
lab=#net63}
N 7300 -9090 7320 -9090 {
lab=#net64}
N 7540 -9090 7560 -9090 {
lab=#net64}
N 7540 -9110 7560 -9110 {
lab=#net63}
N 7540 -9130 7560 -9130 {
lab=colon_n[31]}
N 7540 -9150 7560 -9150 {
lab=col_n[31]}
N 7360 -9010 7360 -9000 {
lab=VSS}
N 7360 -9240 7360 -9230 {
lab=VDD}
N 7700 -9010 7710 -9020 {
lab=row_n[25]}
N 7710 -9220 7710 -9020 {
lab=row_n[25]}
N 7700 -9230 7710 -9220 {
lab=row_n[25]}
N 7700 -9010 7700 -8990 {
lab=row_n[25]}
N 7700 -9250 7700 -9230 {
lab=row_n[25]}
N 7580 -9150 7590 -9160 {
lab=col_n[31]}
N 7590 -9160 7790 -9160 {
lab=col_n[31]}
N 7790 -9160 7800 -9150 {
lab=col_n[31]}
N 7580 -9130 7590 -9140 {
lab=colon_n[31]}
N 7590 -9140 7790 -9140 {
lab=colon_n[31]}
N 7790 -9140 7800 -9130 {
lab=colon_n[31]}
N 7580 -9110 7590 -9120 {
lab=#net63}
N 7590 -9120 7790 -9120 {
lab=#net63}
N 7790 -9120 7800 -9110 {
lab=#net63}
N 7580 -9090 7590 -9100 {
lab=#net64}
N 7590 -9100 7790 -9100 {
lab=#net64}
N 7790 -9100 7800 -9090 {
lab=#net64}
N 7640 -9250 7640 -9230 {
lab=vcom}
N 7680 -9250 7680 -9230 {
lab=ctop}
N 7560 -9150 7580 -9150 {
lab=col_n[31]}
N 7560 -9130 7580 -9130 {
lab=colon_n[31]}
N 7560 -9110 7580 -9110 {
lab=#net63}
N 7560 -9090 7580 -9090 {
lab=#net64}
N 7800 -9090 7820 -9090 {
lab=#net64}
N 7800 -9110 7820 -9110 {
lab=#net63}
N 7800 -9130 7820 -9130 {
lab=colon_n[31]}
N 7800 -9150 7820 -9150 {
lab=col_n[31]}
N 7620 -9010 7620 -9000 {
lab=VSS}
N 7620 -9240 7620 -9230 {
lab=VDD}
N 7960 -9010 7970 -9020 {
lab=row_n[26]}
N 7970 -9220 7970 -9020 {
lab=row_n[26]}
N 7960 -9230 7970 -9220 {
lab=row_n[26]}
N 7960 -9010 7960 -8990 {
lab=row_n[26]}
N 7960 -9250 7960 -9230 {
lab=row_n[26]}
N 7840 -9150 7850 -9160 {
lab=col_n[31]}
N 7850 -9160 8050 -9160 {
lab=col_n[31]}
N 8050 -9160 8060 -9150 {
lab=col_n[31]}
N 7840 -9130 7850 -9140 {
lab=colon_n[31]}
N 7850 -9140 8050 -9140 {
lab=colon_n[31]}
N 8050 -9140 8060 -9130 {
lab=colon_n[31]}
N 7840 -9110 7850 -9120 {
lab=#net63}
N 7850 -9120 8050 -9120 {
lab=#net63}
N 8050 -9120 8060 -9110 {
lab=#net63}
N 7840 -9090 7850 -9100 {
lab=#net64}
N 7850 -9100 8050 -9100 {
lab=#net64}
N 8050 -9100 8060 -9090 {
lab=#net64}
N 7900 -9250 7900 -9230 {
lab=vcom}
N 7940 -9250 7940 -9230 {
lab=ctop}
N 7820 -9150 7840 -9150 {
lab=col_n[31]}
N 7820 -9130 7840 -9130 {
lab=colon_n[31]}
N 7820 -9110 7840 -9110 {
lab=#net63}
N 7820 -9090 7840 -9090 {
lab=#net64}
N 8060 -9090 8080 -9090 {
lab=#net64}
N 8060 -9110 8080 -9110 {
lab=#net63}
N 8060 -9130 8080 -9130 {
lab=colon_n[31]}
N 8060 -9150 8080 -9150 {
lab=col_n[31]}
N 7880 -9010 7880 -9000 {
lab=VSS}
N 7880 -9240 7880 -9230 {
lab=VDD}
N 8220 -9010 8230 -9020 {
lab=row_n[27]}
N 8230 -9220 8230 -9020 {
lab=row_n[27]}
N 8220 -9230 8230 -9220 {
lab=row_n[27]}
N 8220 -9010 8220 -8990 {
lab=row_n[27]}
N 8220 -9250 8220 -9230 {
lab=row_n[27]}
N 8100 -9150 8110 -9160 {
lab=col_n[31]}
N 8110 -9160 8310 -9160 {
lab=col_n[31]}
N 8310 -9160 8320 -9150 {
lab=col_n[31]}
N 8100 -9130 8110 -9140 {
lab=colon_n[31]}
N 8110 -9140 8310 -9140 {
lab=colon_n[31]}
N 8310 -9140 8320 -9130 {
lab=colon_n[31]}
N 8100 -9110 8110 -9120 {
lab=#net63}
N 8110 -9120 8310 -9120 {
lab=#net63}
N 8310 -9120 8320 -9110 {
lab=#net63}
N 8100 -9090 8110 -9100 {
lab=#net64}
N 8110 -9100 8310 -9100 {
lab=#net64}
N 8310 -9100 8320 -9090 {
lab=#net64}
N 8160 -9250 8160 -9230 {
lab=vcom}
N 8200 -9250 8200 -9230 {
lab=ctop}
N 8080 -9150 8100 -9150 {
lab=col_n[31]}
N 8080 -9130 8100 -9130 {
lab=colon_n[31]}
N 8080 -9110 8100 -9110 {
lab=#net63}
N 8080 -9090 8100 -9090 {
lab=#net64}
N 8320 -9090 8340 -9090 {
lab=#net64}
N 8320 -9110 8340 -9110 {
lab=#net63}
N 8320 -9130 8340 -9130 {
lab=colon_n[31]}
N 8320 -9150 8340 -9150 {
lab=col_n[31]}
N 8140 -9010 8140 -9000 {
lab=VSS}
N 8140 -9240 8140 -9230 {
lab=VDD}
N 8480 -9010 8490 -9020 {
lab=row_n[28]}
N 8490 -9220 8490 -9020 {
lab=row_n[28]}
N 8480 -9230 8490 -9220 {
lab=row_n[28]}
N 8480 -9010 8480 -8990 {
lab=row_n[28]}
N 8480 -9250 8480 -9230 {
lab=row_n[28]}
N 8360 -9150 8370 -9160 {
lab=col_n[31]}
N 8370 -9160 8570 -9160 {
lab=col_n[31]}
N 8570 -9160 8580 -9150 {
lab=col_n[31]}
N 8360 -9130 8370 -9140 {
lab=colon_n[31]}
N 8370 -9140 8570 -9140 {
lab=colon_n[31]}
N 8570 -9140 8580 -9130 {
lab=colon_n[31]}
N 8360 -9110 8370 -9120 {
lab=#net63}
N 8370 -9120 8570 -9120 {
lab=#net63}
N 8570 -9120 8580 -9110 {
lab=#net63}
N 8360 -9090 8370 -9100 {
lab=#net64}
N 8370 -9100 8570 -9100 {
lab=#net64}
N 8570 -9100 8580 -9090 {
lab=#net64}
N 8420 -9250 8420 -9230 {
lab=vcom}
N 8460 -9250 8460 -9230 {
lab=ctop}
N 8340 -9150 8360 -9150 {
lab=col_n[31]}
N 8340 -9130 8360 -9130 {
lab=colon_n[31]}
N 8340 -9110 8360 -9110 {
lab=#net63}
N 8340 -9090 8360 -9090 {
lab=#net64}
N 8580 -9090 8600 -9090 {
lab=#net64}
N 8580 -9110 8600 -9110 {
lab=#net63}
N 8580 -9130 8600 -9130 {
lab=colon_n[31]}
N 8580 -9150 8600 -9150 {
lab=col_n[31]}
N 8400 -9010 8400 -9000 {
lab=VSS}
N 8400 -9240 8400 -9230 {
lab=VDD}
N 8740 -9010 8750 -9020 {
lab=row_n[29]}
N 8750 -9220 8750 -9020 {
lab=row_n[29]}
N 8740 -9230 8750 -9220 {
lab=row_n[29]}
N 8740 -9010 8740 -8990 {
lab=row_n[29]}
N 8740 -9250 8740 -9230 {
lab=row_n[29]}
N 8620 -9150 8630 -9160 {
lab=col_n[31]}
N 8630 -9160 8830 -9160 {
lab=col_n[31]}
N 8830 -9160 8840 -9150 {
lab=col_n[31]}
N 8620 -9130 8630 -9140 {
lab=colon_n[31]}
N 8630 -9140 8830 -9140 {
lab=colon_n[31]}
N 8830 -9140 8840 -9130 {
lab=colon_n[31]}
N 8620 -9110 8630 -9120 {
lab=#net63}
N 8630 -9120 8830 -9120 {
lab=#net63}
N 8830 -9120 8840 -9110 {
lab=#net63}
N 8620 -9090 8630 -9100 {
lab=#net64}
N 8630 -9100 8830 -9100 {
lab=#net64}
N 8830 -9100 8840 -9090 {
lab=#net64}
N 8680 -9250 8680 -9230 {
lab=vcom}
N 8720 -9250 8720 -9230 {
lab=ctop}
N 8600 -9150 8620 -9150 {
lab=col_n[31]}
N 8600 -9130 8620 -9130 {
lab=colon_n[31]}
N 8600 -9110 8620 -9110 {
lab=#net63}
N 8600 -9090 8620 -9090 {
lab=#net64}
N 8840 -9090 8860 -9090 {
lab=#net64}
N 8840 -9110 8860 -9110 {
lab=#net63}
N 8840 -9130 8860 -9130 {
lab=colon_n[31]}
N 8840 -9150 8860 -9150 {
lab=col_n[31]}
N 8660 -9010 8660 -9000 {
lab=VSS}
N 8660 -9240 8660 -9230 {
lab=VDD}
N 9000 -9010 9010 -9020 {
lab=row_n[30]}
N 9010 -9220 9010 -9020 {
lab=row_n[30]}
N 9000 -9230 9010 -9220 {
lab=row_n[30]}
N 9000 -9010 9000 -8990 {
lab=row_n[30]}
N 9000 -9250 9000 -9230 {
lab=row_n[30]}
N 8880 -9150 8890 -9160 {
lab=col_n[31]}
N 8890 -9160 9090 -9160 {
lab=col_n[31]}
N 9090 -9160 9100 -9150 {
lab=col_n[31]}
N 8880 -9130 8890 -9140 {
lab=colon_n[31]}
N 8890 -9140 9090 -9140 {
lab=colon_n[31]}
N 9090 -9140 9100 -9130 {
lab=colon_n[31]}
N 8880 -9110 8890 -9120 {
lab=#net63}
N 8890 -9120 9090 -9120 {
lab=#net63}
N 9090 -9120 9100 -9110 {
lab=#net63}
N 8880 -9090 8890 -9100 {
lab=#net64}
N 8890 -9100 9090 -9100 {
lab=#net64}
N 9090 -9100 9100 -9090 {
lab=#net64}
N 8940 -9250 8940 -9230 {
lab=vcom}
N 8980 -9250 8980 -9230 {
lab=ctop}
N 8860 -9150 8880 -9150 {
lab=col_n[31]}
N 8860 -9130 8880 -9130 {
lab=colon_n[31]}
N 8860 -9110 8880 -9110 {
lab=#net63}
N 8860 -9090 8880 -9090 {
lab=#net64}
N 9100 -9090 9120 -9090 {
lab=#net64}
N 9100 -9110 9120 -9110 {
lab=#net63}
N 9100 -9130 9120 -9130 {
lab=colon_n[31]}
N 9100 -9150 9120 -9150 {
lab=col_n[31]}
N 8920 -9010 8920 -9000 {
lab=VSS}
N 8920 -9240 8920 -9230 {
lab=VDD}
N 9260 -9010 9270 -9020 {
lab=row_n[31]}
N 9270 -9220 9270 -9020 {
lab=row_n[31]}
N 9260 -9230 9270 -9220 {
lab=row_n[31]}
N 9260 -9010 9260 -8990 {
lab=row_n[31]}
N 9260 -9250 9260 -9230 {
lab=row_n[31]}
N 9140 -9150 9150 -9160 {
lab=col_n[31]}
N 9150 -9160 9350 -9160 {
lab=col_n[31]}
N 9350 -9160 9360 -9150 {
lab=col_n[31]}
N 9140 -9130 9150 -9140 {
lab=colon_n[31]}
N 9150 -9140 9350 -9140 {
lab=colon_n[31]}
N 9350 -9140 9360 -9130 {
lab=colon_n[31]}
N 9140 -9110 9150 -9120 {
lab=#net63}
N 9150 -9120 9350 -9120 {
lab=#net63}
N 9350 -9120 9360 -9110 {
lab=#net63}
N 9140 -9090 9150 -9100 {
lab=#net64}
N 9150 -9100 9350 -9100 {
lab=#net64}
N 9350 -9100 9360 -9090 {
lab=#net64}
N 9200 -9250 9200 -9230 {
lab=vcom}
N 9240 -9250 9240 -9230 {
lab=ctop}
N 9120 -9150 9140 -9150 {
lab=col_n[31]}
N 9120 -9130 9140 -9130 {
lab=colon_n[31]}
N 9120 -9110 9140 -9110 {
lab=#net63}
N 9120 -9090 9140 -9090 {
lab=#net64}
N 9360 -9090 9380 -9090 {
lab=#net64}
N 9360 -9110 9380 -9110 {
lab=#net63}
N 9360 -9130 9380 -9130 {
lab=colon_n[31]}
N 9360 -9150 9380 -9150 {
lab=col_n[31]}
N 9180 -9010 9180 -9000 {
lab=VSS}
N 9180 -9240 9180 -9230 {
lab=VDD}
N 1040 -1050 1060 -1050 {
lab=#net1}
N 1040 -1030 1060 -1030 {
lab=#net2}
N 800 -1030 820 -1030 {
lab=sample_n}
N 800 -1050 820 -1050 {
lab=sample}
N 800 -1070 820 -1070 {
lab=colon_n[0]}
N 800 -1090 820 -1090 {
lab=col_n[0]}
N 880 -1190 880 -1170 {
lab=vcom}
N 920 -1190 920 -1170 {
lab=ctop}
N 860 -1180 860 -1170 {
lab=VDD}
N 940 -950 940 -930 {
lab=VDD}
N 940 -950 950 -960 {
lab=VDD}
N 950 -1160 950 -960 {
lab=VDD}
N 940 -1170 950 -1160 {
lab=VDD}
N 940 -1190 940 -1170 {
lab=VDD}
N 860 -950 860 -940 {
lab=VSS}
N 820 -1090 830 -1100 {
lab=col_n[0]}
N 830 -1100 1030 -1100 {
lab=col_n[0]}
N 1030 -1100 1040 -1090 {
lab=col_n[0]}
N 1040 -1090 1060 -1090 {
lab=col_n[0]}
N 820 -1070 830 -1080 {
lab=colon_n[0]}
N 830 -1080 1030 -1080 {
lab=colon_n[0]}
N 1030 -1080 1040 -1070 {
lab=colon_n[0]}
N 1040 -1070 1060 -1070 {
lab=colon_n[0]}
N 1040 -1310 1060 -1310 {
lab=#net3}
N 1040 -1290 1060 -1290 {
lab=#net4}
N 800 -1290 820 -1290 {
lab=sample_n}
N 800 -1310 820 -1310 {
lab=sample}
N 800 -1330 820 -1330 {
lab=colon_n[1]}
N 800 -1350 820 -1350 {
lab=col_n[1]}
N 880 -1450 880 -1430 {
lab=vcom}
N 920 -1450 920 -1430 {
lab=ctop}
N 860 -1440 860 -1430 {
lab=VDD}
N 940 -1210 940 -1190 {
lab=VDD}
N 940 -1210 950 -1220 {
lab=VDD}
N 950 -1420 950 -1220 {
lab=VDD}
N 940 -1430 950 -1420 {
lab=VDD}
N 940 -1450 940 -1430 {
lab=VDD}
N 860 -1210 860 -1200 {
lab=VSS}
N 820 -1350 830 -1360 {
lab=col_n[1]}
N 830 -1360 1030 -1360 {
lab=col_n[1]}
N 1030 -1360 1040 -1350 {
lab=col_n[1]}
N 1040 -1350 1060 -1350 {
lab=col_n[1]}
N 820 -1330 830 -1340 {
lab=colon_n[1]}
N 830 -1340 1030 -1340 {
lab=colon_n[1]}
N 1030 -1340 1040 -1330 {
lab=colon_n[1]}
N 1040 -1330 1060 -1330 {
lab=colon_n[1]}
N 1040 -1570 1060 -1570 {
lab=#net5}
N 1040 -1550 1060 -1550 {
lab=#net6}
N 800 -1550 820 -1550 {
lab=sample_n}
N 800 -1570 820 -1570 {
lab=sample}
N 800 -1590 820 -1590 {
lab=colon_n[2]}
N 800 -1610 820 -1610 {
lab=col_n[2]}
N 880 -1710 880 -1690 {
lab=vcom}
N 920 -1710 920 -1690 {
lab=ctop}
N 860 -1700 860 -1690 {
lab=VDD}
N 940 -1470 940 -1450 {
lab=VDD}
N 940 -1470 950 -1480 {
lab=VDD}
N 950 -1680 950 -1480 {
lab=VDD}
N 940 -1690 950 -1680 {
lab=VDD}
N 940 -1710 940 -1690 {
lab=VDD}
N 860 -1470 860 -1460 {
lab=VSS}
N 820 -1610 830 -1620 {
lab=col_n[2]}
N 830 -1620 1030 -1620 {
lab=col_n[2]}
N 1030 -1620 1040 -1610 {
lab=col_n[2]}
N 1040 -1610 1060 -1610 {
lab=col_n[2]}
N 820 -1590 830 -1600 {
lab=colon_n[2]}
N 830 -1600 1030 -1600 {
lab=colon_n[2]}
N 1030 -1600 1040 -1590 {
lab=colon_n[2]}
N 1040 -1590 1060 -1590 {
lab=colon_n[2]}
N 1040 -1830 1060 -1830 {
lab=#net7}
N 1040 -1810 1060 -1810 {
lab=#net8}
N 800 -1810 820 -1810 {
lab=sample_n}
N 800 -1830 820 -1830 {
lab=sample}
N 800 -1850 820 -1850 {
lab=colon_n[3]}
N 800 -1870 820 -1870 {
lab=col_n[3]}
N 880 -1970 880 -1950 {
lab=vcom}
N 920 -1970 920 -1950 {
lab=ctop}
N 860 -1960 860 -1950 {
lab=VDD}
N 940 -1730 950 -1740 {
lab=VDD}
N 950 -1940 950 -1740 {
lab=VDD}
N 940 -1950 950 -1940 {
lab=VDD}
N 940 -1970 940 -1950 {
lab=VDD}
N 860 -1730 860 -1720 {
lab=VSS}
N 820 -1870 830 -1880 {
lab=col_n[3]}
N 830 -1880 1030 -1880 {
lab=col_n[3]}
N 1030 -1880 1040 -1870 {
lab=col_n[3]}
N 1040 -1870 1060 -1870 {
lab=col_n[3]}
N 820 -1850 830 -1860 {
lab=colon_n[3]}
N 830 -1860 1030 -1860 {
lab=colon_n[3]}
N 1030 -1860 1040 -1850 {
lab=colon_n[3]}
N 1040 -1850 1060 -1850 {
lab=colon_n[3]}
N 1040 -2090 1060 -2090 {
lab=#net9}
N 1040 -2070 1060 -2070 {
lab=#net10}
N 800 -2070 820 -2070 {
lab=sample_n}
N 800 -2090 820 -2090 {
lab=sample}
N 800 -2110 820 -2110 {
lab=colon_n[4]}
N 800 -2130 820 -2130 {
lab=col_n[4]}
N 880 -2230 880 -2210 {
lab=vcom}
N 920 -2230 920 -2210 {
lab=ctop}
N 860 -2220 860 -2210 {
lab=VDD}
N 940 -1990 940 -1970 {
lab=VDD}
N 940 -1990 950 -2000 {
lab=VDD}
N 950 -2200 950 -2000 {
lab=VDD}
N 940 -2210 950 -2200 {
lab=VDD}
N 940 -2230 940 -2210 {
lab=VDD}
N 860 -1990 860 -1980 {
lab=VSS}
N 820 -2130 830 -2140 {
lab=col_n[4]}
N 830 -2140 1030 -2140 {
lab=col_n[4]}
N 1030 -2140 1040 -2130 {
lab=col_n[4]}
N 1040 -2130 1060 -2130 {
lab=col_n[4]}
N 820 -2110 830 -2120 {
lab=colon_n[4]}
N 830 -2120 1030 -2120 {
lab=colon_n[4]}
N 1030 -2120 1040 -2110 {
lab=colon_n[4]}
N 1040 -2110 1060 -2110 {
lab=colon_n[4]}
N 940 -1730 940 -1710 {
lab=VDD}
N 1040 -2350 1060 -2350 {
lab=#net11}
N 1040 -2330 1060 -2330 {
lab=#net12}
N 800 -2330 820 -2330 {
lab=sample_n}
N 800 -2350 820 -2350 {
lab=sample}
N 800 -2370 820 -2370 {
lab=colon_n[5]}
N 800 -2390 820 -2390 {
lab=col_n[5]}
N 880 -2490 880 -2470 {
lab=vcom}
N 920 -2490 920 -2470 {
lab=ctop}
N 860 -2480 860 -2470 {
lab=VDD}
N 940 -2250 940 -2230 {
lab=VDD}
N 940 -2250 950 -2260 {
lab=VDD}
N 950 -2460 950 -2260 {
lab=VDD}
N 940 -2470 950 -2460 {
lab=VDD}
N 940 -2490 940 -2470 {
lab=VDD}
N 860 -2250 860 -2240 {
lab=VSS}
N 820 -2390 830 -2400 {
lab=col_n[5]}
N 830 -2400 1030 -2400 {
lab=col_n[5]}
N 1030 -2400 1040 -2390 {
lab=col_n[5]}
N 1040 -2390 1060 -2390 {
lab=col_n[5]}
N 820 -2370 830 -2380 {
lab=colon_n[5]}
N 830 -2380 1030 -2380 {
lab=colon_n[5]}
N 1030 -2380 1040 -2370 {
lab=colon_n[5]}
N 1040 -2370 1060 -2370 {
lab=colon_n[5]}
N 1040 -2610 1060 -2610 {
lab=#net13}
N 1040 -2590 1060 -2590 {
lab=#net14}
N 800 -2590 820 -2590 {
lab=sample_n}
N 800 -2610 820 -2610 {
lab=sample}
N 800 -2630 820 -2630 {
lab=colon_n[6]}
N 800 -2650 820 -2650 {
lab=col_n[6]}
N 880 -2750 880 -2730 {
lab=vcom}
N 920 -2750 920 -2730 {
lab=ctop}
N 860 -2740 860 -2730 {
lab=VDD}
N 940 -2510 940 -2490 {
lab=VDD}
N 940 -2510 950 -2520 {
lab=VDD}
N 950 -2720 950 -2520 {
lab=VDD}
N 940 -2730 950 -2720 {
lab=VDD}
N 940 -2750 940 -2730 {
lab=VDD}
N 860 -2510 860 -2500 {
lab=VSS}
N 820 -2650 830 -2660 {
lab=col_n[6]}
N 830 -2660 1030 -2660 {
lab=col_n[6]}
N 1030 -2660 1040 -2650 {
lab=col_n[6]}
N 1040 -2650 1060 -2650 {
lab=col_n[6]}
N 820 -2630 830 -2640 {
lab=colon_n[6]}
N 830 -2640 1030 -2640 {
lab=colon_n[6]}
N 1030 -2640 1040 -2630 {
lab=colon_n[6]}
N 1040 -2630 1060 -2630 {
lab=colon_n[6]}
N 1040 -2870 1060 -2870 {
lab=#net15}
N 1040 -2850 1060 -2850 {
lab=#net16}
N 800 -2850 820 -2850 {
lab=sample_n}
N 800 -2870 820 -2870 {
lab=sample}
N 800 -2890 820 -2890 {
lab=colon_n[7]}
N 800 -2910 820 -2910 {
lab=col_n[7]}
N 880 -3010 880 -2990 {
lab=vcom}
N 920 -3010 920 -2990 {
lab=ctop}
N 860 -3000 860 -2990 {
lab=VDD}
N 940 -2770 940 -2750 {
lab=VDD}
N 940 -2770 950 -2780 {
lab=VDD}
N 950 -2980 950 -2780 {
lab=VDD}
N 940 -2990 950 -2980 {
lab=VDD}
N 940 -3010 940 -2990 {
lab=VDD}
N 860 -2770 860 -2760 {
lab=VSS}
N 820 -2910 830 -2920 {
lab=col_n[7]}
N 830 -2920 1030 -2920 {
lab=col_n[7]}
N 1030 -2920 1040 -2910 {
lab=col_n[7]}
N 1040 -2910 1060 -2910 {
lab=col_n[7]}
N 820 -2890 830 -2900 {
lab=colon_n[7]}
N 830 -2900 1030 -2900 {
lab=colon_n[7]}
N 1030 -2900 1040 -2890 {
lab=colon_n[7]}
N 1040 -2890 1060 -2890 {
lab=colon_n[7]}
N 1040 -3130 1060 -3130 {
lab=#net17}
N 1040 -3110 1060 -3110 {
lab=#net18}
N 800 -3110 820 -3110 {
lab=sample_n}
N 800 -3130 820 -3130 {
lab=sample}
N 800 -3150 820 -3150 {
lab=colon_n[8]}
N 800 -3170 820 -3170 {
lab=col_n[8]}
N 880 -3270 880 -3250 {
lab=vcom}
N 920 -3270 920 -3250 {
lab=ctop}
N 860 -3260 860 -3250 {
lab=VDD}
N 940 -3030 950 -3040 {
lab=VDD}
N 950 -3240 950 -3040 {
lab=VDD}
N 940 -3250 950 -3240 {
lab=VDD}
N 940 -3270 940 -3250 {
lab=VDD}
N 860 -3030 860 -3020 {
lab=VSS}
N 820 -3170 830 -3180 {
lab=col_n[8]}
N 830 -3180 1030 -3180 {
lab=col_n[8]}
N 1030 -3180 1040 -3170 {
lab=col_n[8]}
N 1040 -3170 1060 -3170 {
lab=col_n[8]}
N 820 -3150 830 -3160 {
lab=colon_n[8]}
N 830 -3160 1030 -3160 {
lab=colon_n[8]}
N 1030 -3160 1040 -3150 {
lab=colon_n[8]}
N 1040 -3150 1060 -3150 {
lab=colon_n[8]}
N 1040 -3390 1060 -3390 {
lab=#net19}
N 1040 -3370 1060 -3370 {
lab=#net20}
N 800 -3370 820 -3370 {
lab=sample_n}
N 800 -3390 820 -3390 {
lab=sample}
N 800 -3410 820 -3410 {
lab=colon_n[9]}
N 800 -3430 820 -3430 {
lab=col_n[9]}
N 880 -3530 880 -3510 {
lab=vcom}
N 920 -3530 920 -3510 {
lab=ctop}
N 860 -3520 860 -3510 {
lab=VDD}
N 940 -3290 940 -3270 {
lab=VDD}
N 940 -3290 950 -3300 {
lab=VDD}
N 950 -3500 950 -3300 {
lab=VDD}
N 940 -3510 950 -3500 {
lab=VDD}
N 940 -3530 940 -3510 {
lab=VDD}
N 860 -3290 860 -3280 {
lab=VSS}
N 820 -3430 830 -3440 {
lab=col_n[9]}
N 830 -3440 1030 -3440 {
lab=col_n[9]}
N 1030 -3440 1040 -3430 {
lab=col_n[9]}
N 1040 -3430 1060 -3430 {
lab=col_n[9]}
N 820 -3410 830 -3420 {
lab=colon_n[9]}
N 830 -3420 1030 -3420 {
lab=colon_n[9]}
N 1030 -3420 1040 -3410 {
lab=colon_n[9]}
N 1040 -3410 1060 -3410 {
lab=colon_n[9]}
N 940 -3030 940 -3010 {
lab=VDD}
N 1040 -3650 1060 -3650 {
lab=#net21}
N 1040 -3630 1060 -3630 {
lab=#net22}
N 800 -3630 820 -3630 {
lab=sample_n}
N 800 -3650 820 -3650 {
lab=sample}
N 800 -3670 820 -3670 {
lab=colon_n[10]}
N 800 -3690 820 -3690 {
lab=col_n[10]}
N 880 -3790 880 -3770 {
lab=vcom}
N 920 -3790 920 -3770 {
lab=ctop}
N 860 -3780 860 -3770 {
lab=VDD}
N 940 -3550 940 -3530 {
lab=VDD}
N 940 -3550 950 -3560 {
lab=VDD}
N 950 -3760 950 -3560 {
lab=VDD}
N 940 -3770 950 -3760 {
lab=VDD}
N 940 -3790 940 -3770 {
lab=VDD}
N 860 -3550 860 -3540 {
lab=VSS}
N 820 -3690 830 -3700 {
lab=col_n[10]}
N 830 -3700 1030 -3700 {
lab=col_n[10]}
N 1030 -3700 1040 -3690 {
lab=col_n[10]}
N 1040 -3690 1060 -3690 {
lab=col_n[10]}
N 820 -3670 830 -3680 {
lab=colon_n[10]}
N 830 -3680 1030 -3680 {
lab=colon_n[10]}
N 1030 -3680 1040 -3670 {
lab=colon_n[10]}
N 1040 -3670 1060 -3670 {
lab=colon_n[10]}
N 1040 -3910 1060 -3910 {
lab=#net23}
N 1040 -3890 1060 -3890 {
lab=#net24}
N 800 -3890 820 -3890 {
lab=sample_n}
N 800 -3910 820 -3910 {
lab=sample}
N 800 -3930 820 -3930 {
lab=colon_n[11]}
N 800 -3950 820 -3950 {
lab=col_n[11]}
N 880 -4050 880 -4030 {
lab=vcom}
N 920 -4050 920 -4030 {
lab=ctop}
N 860 -4040 860 -4030 {
lab=VDD}
N 940 -3810 940 -3790 {
lab=VDD}
N 940 -3810 950 -3820 {
lab=VDD}
N 950 -4020 950 -3820 {
lab=VDD}
N 940 -4030 950 -4020 {
lab=VDD}
N 940 -4050 940 -4030 {
lab=VDD}
N 860 -3810 860 -3800 {
lab=VSS}
N 820 -3950 830 -3960 {
lab=col_n[11]}
N 830 -3960 1030 -3960 {
lab=col_n[11]}
N 1030 -3960 1040 -3950 {
lab=col_n[11]}
N 1040 -3950 1060 -3950 {
lab=col_n[11]}
N 820 -3930 830 -3940 {
lab=colon_n[11]}
N 830 -3940 1030 -3940 {
lab=colon_n[11]}
N 1030 -3940 1040 -3930 {
lab=colon_n[11]}
N 1040 -3930 1060 -3930 {
lab=colon_n[11]}
N 1040 -4170 1060 -4170 {
lab=#net25}
N 1040 -4150 1060 -4150 {
lab=#net26}
N 800 -4150 820 -4150 {
lab=sample_n}
N 800 -4170 820 -4170 {
lab=sample}
N 800 -4190 820 -4190 {
lab=colon_n[12]}
N 800 -4210 820 -4210 {
lab=col_n[12]}
N 880 -4310 880 -4290 {
lab=vcom}
N 920 -4310 920 -4290 {
lab=ctop}
N 860 -4300 860 -4290 {
lab=VDD}
N 940 -4070 940 -4050 {
lab=VDD}
N 940 -4070 950 -4080 {
lab=VDD}
N 950 -4280 950 -4080 {
lab=VDD}
N 940 -4290 950 -4280 {
lab=VDD}
N 940 -4310 940 -4290 {
lab=VDD}
N 860 -4070 860 -4060 {
lab=VSS}
N 820 -4210 830 -4220 {
lab=col_n[12]}
N 830 -4220 1030 -4220 {
lab=col_n[12]}
N 1030 -4220 1040 -4210 {
lab=col_n[12]}
N 1040 -4210 1060 -4210 {
lab=col_n[12]}
N 820 -4190 830 -4200 {
lab=colon_n[12]}
N 830 -4200 1030 -4200 {
lab=colon_n[12]}
N 1030 -4200 1040 -4190 {
lab=colon_n[12]}
N 1040 -4190 1060 -4190 {
lab=colon_n[12]}
N 1040 -4430 1060 -4430 {
lab=#net27}
N 1040 -4410 1060 -4410 {
lab=#net28}
N 800 -4410 820 -4410 {
lab=sample_n}
N 800 -4430 820 -4430 {
lab=sample}
N 800 -4450 820 -4450 {
lab=colon_n[13]}
N 800 -4470 820 -4470 {
lab=col_n[13]}
N 880 -4570 880 -4550 {
lab=vcom}
N 920 -4570 920 -4550 {
lab=ctop}
N 860 -4560 860 -4550 {
lab=VDD}
N 940 -4330 950 -4340 {
lab=VDD}
N 950 -4540 950 -4340 {
lab=VDD}
N 940 -4550 950 -4540 {
lab=VDD}
N 940 -4570 940 -4550 {
lab=VDD}
N 860 -4330 860 -4320 {
lab=VSS}
N 820 -4470 830 -4480 {
lab=col_n[13]}
N 830 -4480 1030 -4480 {
lab=col_n[13]}
N 1030 -4480 1040 -4470 {
lab=col_n[13]}
N 1040 -4470 1060 -4470 {
lab=col_n[13]}
N 820 -4450 830 -4460 {
lab=colon_n[13]}
N 830 -4460 1030 -4460 {
lab=colon_n[13]}
N 1030 -4460 1040 -4450 {
lab=colon_n[13]}
N 1040 -4450 1060 -4450 {
lab=colon_n[13]}
N 1040 -4690 1060 -4690 {
lab=#net29}
N 1040 -4670 1060 -4670 {
lab=#net30}
N 800 -4670 820 -4670 {
lab=sample_n}
N 800 -4690 820 -4690 {
lab=sample}
N 800 -4710 820 -4710 {
lab=colon_n[14]}
N 800 -4730 820 -4730 {
lab=col_n[14]}
N 880 -4830 880 -4810 {
lab=vcom}
N 920 -4830 920 -4810 {
lab=ctop}
N 860 -4820 860 -4810 {
lab=VDD}
N 940 -4590 940 -4570 {
lab=VDD}
N 940 -4590 950 -4600 {
lab=VDD}
N 950 -4800 950 -4600 {
lab=VDD}
N 940 -4810 950 -4800 {
lab=VDD}
N 940 -4830 940 -4810 {
lab=VDD}
N 860 -4590 860 -4580 {
lab=VSS}
N 820 -4730 830 -4740 {
lab=col_n[14]}
N 830 -4740 1030 -4740 {
lab=col_n[14]}
N 1030 -4740 1040 -4730 {
lab=col_n[14]}
N 1040 -4730 1060 -4730 {
lab=col_n[14]}
N 820 -4710 830 -4720 {
lab=colon_n[14]}
N 830 -4720 1030 -4720 {
lab=colon_n[14]}
N 1030 -4720 1040 -4710 {
lab=colon_n[14]}
N 1040 -4710 1060 -4710 {
lab=colon_n[14]}
N 940 -4330 940 -4310 {
lab=VDD}
N 1040 -4950 1060 -4950 {
lab=#net31}
N 1040 -4930 1060 -4930 {
lab=#net32}
N 800 -4930 820 -4930 {
lab=sample_n}
N 800 -4950 820 -4950 {
lab=sample}
N 800 -4970 820 -4970 {
lab=colon_n[15]}
N 800 -4990 820 -4990 {
lab=col_n[15]}
N 880 -5090 880 -5070 {
lab=vcom}
N 920 -5090 920 -5070 {
lab=ctop}
N 860 -5080 860 -5070 {
lab=VDD}
N 940 -4850 940 -4830 {
lab=VDD}
N 940 -4850 950 -4860 {
lab=VDD}
N 950 -5060 950 -4860 {
lab=VDD}
N 940 -5070 950 -5060 {
lab=VDD}
N 940 -5090 940 -5070 {
lab=VDD}
N 860 -4850 860 -4840 {
lab=VSS}
N 820 -4990 830 -5000 {
lab=col_n[15]}
N 830 -5000 1030 -5000 {
lab=col_n[15]}
N 1030 -5000 1040 -4990 {
lab=col_n[15]}
N 1040 -4990 1060 -4990 {
lab=col_n[15]}
N 820 -4970 830 -4980 {
lab=colon_n[15]}
N 830 -4980 1030 -4980 {
lab=colon_n[15]}
N 1030 -4980 1040 -4970 {
lab=colon_n[15]}
N 1040 -4970 1060 -4970 {
lab=colon_n[15]}
N 1040 -5210 1060 -5210 {
lab=#net33}
N 1040 -5190 1060 -5190 {
lab=#net34}
N 800 -5190 820 -5190 {
lab=sample_n}
N 800 -5210 820 -5210 {
lab=sample}
N 800 -5230 820 -5230 {
lab=colon_n[16]}
N 800 -5250 820 -5250 {
lab=col_n[16]}
N 880 -5350 880 -5330 {
lab=vcom}
N 920 -5350 920 -5330 {
lab=ctop}
N 860 -5340 860 -5330 {
lab=VDD}
N 940 -5110 940 -5090 {
lab=VDD}
N 940 -5110 950 -5120 {
lab=VDD}
N 950 -5320 950 -5120 {
lab=VDD}
N 940 -5330 950 -5320 {
lab=VDD}
N 940 -5350 940 -5330 {
lab=VDD}
N 860 -5110 860 -5100 {
lab=VSS}
N 820 -5250 830 -5260 {
lab=col_n[16]}
N 830 -5260 1030 -5260 {
lab=col_n[16]}
N 1030 -5260 1040 -5250 {
lab=col_n[16]}
N 1040 -5250 1060 -5250 {
lab=col_n[16]}
N 820 -5230 830 -5240 {
lab=colon_n[16]}
N 830 -5240 1030 -5240 {
lab=colon_n[16]}
N 1030 -5240 1040 -5230 {
lab=colon_n[16]}
N 1040 -5230 1060 -5230 {
lab=colon_n[16]}
N 1040 -5470 1060 -5470 {
lab=#net35}
N 1040 -5450 1060 -5450 {
lab=#net36}
N 800 -5450 820 -5450 {
lab=sample_n}
N 800 -5470 820 -5470 {
lab=sample}
N 800 -5490 820 -5490 {
lab=colon_n[17]}
N 800 -5510 820 -5510 {
lab=col_n[17]}
N 880 -5610 880 -5590 {
lab=vcom}
N 920 -5610 920 -5590 {
lab=ctop}
N 860 -5600 860 -5590 {
lab=VDD}
N 940 -5370 940 -5350 {
lab=VDD}
N 940 -5370 950 -5380 {
lab=VDD}
N 950 -5580 950 -5380 {
lab=VDD}
N 940 -5590 950 -5580 {
lab=VDD}
N 940 -5610 940 -5590 {
lab=VDD}
N 860 -5370 860 -5360 {
lab=VSS}
N 820 -5510 830 -5520 {
lab=col_n[17]}
N 830 -5520 1030 -5520 {
lab=col_n[17]}
N 1030 -5520 1040 -5510 {
lab=col_n[17]}
N 1040 -5510 1060 -5510 {
lab=col_n[17]}
N 820 -5490 830 -5500 {
lab=colon_n[17]}
N 830 -5500 1030 -5500 {
lab=colon_n[17]}
N 1030 -5500 1040 -5490 {
lab=colon_n[17]}
N 1040 -5490 1060 -5490 {
lab=colon_n[17]}
N 1040 -5730 1060 -5730 {
lab=#net37}
N 1040 -5710 1060 -5710 {
lab=#net38}
N 800 -5710 820 -5710 {
lab=sample_n}
N 800 -5730 820 -5730 {
lab=sample}
N 800 -5750 820 -5750 {
lab=colon_n[18]}
N 800 -5770 820 -5770 {
lab=col_n[18]}
N 880 -5870 880 -5850 {
lab=vcom}
N 920 -5870 920 -5850 {
lab=ctop}
N 860 -5860 860 -5850 {
lab=VDD}
N 940 -5630 950 -5640 {
lab=VDD}
N 950 -5840 950 -5640 {
lab=VDD}
N 940 -5850 950 -5840 {
lab=VDD}
N 940 -5870 940 -5850 {
lab=VDD}
N 860 -5630 860 -5620 {
lab=VSS}
N 820 -5770 830 -5780 {
lab=col_n[18]}
N 830 -5780 1030 -5780 {
lab=col_n[18]}
N 1030 -5780 1040 -5770 {
lab=col_n[18]}
N 1040 -5770 1060 -5770 {
lab=col_n[18]}
N 820 -5750 830 -5760 {
lab=colon_n[18]}
N 830 -5760 1030 -5760 {
lab=colon_n[18]}
N 1030 -5760 1040 -5750 {
lab=colon_n[18]}
N 1040 -5750 1060 -5750 {
lab=colon_n[18]}
N 1040 -5990 1060 -5990 {
lab=#net39}
N 1040 -5970 1060 -5970 {
lab=#net40}
N 800 -5970 820 -5970 {
lab=sample_n}
N 800 -5990 820 -5990 {
lab=sample}
N 800 -6010 820 -6010 {
lab=colon_n[19]}
N 800 -6030 820 -6030 {
lab=col_n[19]}
N 880 -6130 880 -6110 {
lab=vcom}
N 920 -6130 920 -6110 {
lab=ctop}
N 860 -6120 860 -6110 {
lab=VDD}
N 940 -5890 940 -5870 {
lab=VDD}
N 940 -5890 950 -5900 {
lab=VDD}
N 950 -6100 950 -5900 {
lab=VDD}
N 940 -6110 950 -6100 {
lab=VDD}
N 940 -6130 940 -6110 {
lab=VDD}
N 860 -5890 860 -5880 {
lab=VSS}
N 820 -6030 830 -6040 {
lab=col_n[19]}
N 830 -6040 1030 -6040 {
lab=col_n[19]}
N 1030 -6040 1040 -6030 {
lab=col_n[19]}
N 1040 -6030 1060 -6030 {
lab=col_n[19]}
N 820 -6010 830 -6020 {
lab=colon_n[19]}
N 830 -6020 1030 -6020 {
lab=colon_n[19]}
N 1030 -6020 1040 -6010 {
lab=colon_n[19]}
N 1040 -6010 1060 -6010 {
lab=colon_n[19]}
N 940 -5630 940 -5610 {
lab=VDD}
N 1040 -6250 1060 -6250 {
lab=#net41}
N 1040 -6230 1060 -6230 {
lab=#net42}
N 800 -6230 820 -6230 {
lab=sample_n}
N 800 -6250 820 -6250 {
lab=sample}
N 800 -6270 820 -6270 {
lab=colon_n[20]}
N 800 -6290 820 -6290 {
lab=col_n[20]}
N 880 -6390 880 -6370 {
lab=vcom}
N 920 -6390 920 -6370 {
lab=ctop}
N 860 -6380 860 -6370 {
lab=VDD}
N 940 -6150 940 -6130 {
lab=VDD}
N 940 -6150 950 -6160 {
lab=VDD}
N 950 -6360 950 -6160 {
lab=VDD}
N 940 -6370 950 -6360 {
lab=VDD}
N 940 -6390 940 -6370 {
lab=VDD}
N 860 -6150 860 -6140 {
lab=VSS}
N 820 -6290 830 -6300 {
lab=col_n[20]}
N 830 -6300 1030 -6300 {
lab=col_n[20]}
N 1030 -6300 1040 -6290 {
lab=col_n[20]}
N 1040 -6290 1060 -6290 {
lab=col_n[20]}
N 820 -6270 830 -6280 {
lab=colon_n[20]}
N 830 -6280 1030 -6280 {
lab=colon_n[20]}
N 1030 -6280 1040 -6270 {
lab=colon_n[20]}
N 1040 -6270 1060 -6270 {
lab=colon_n[20]}
N 1040 -6510 1060 -6510 {
lab=#net43}
N 1040 -6490 1060 -6490 {
lab=#net44}
N 800 -6490 820 -6490 {
lab=sample_n}
N 800 -6510 820 -6510 {
lab=sample}
N 800 -6530 820 -6530 {
lab=colon_n[21]}
N 800 -6550 820 -6550 {
lab=col_n[21]}
N 880 -6650 880 -6630 {
lab=vcom}
N 920 -6650 920 -6630 {
lab=ctop}
N 860 -6640 860 -6630 {
lab=VDD}
N 940 -6410 940 -6390 {
lab=VDD}
N 940 -6410 950 -6420 {
lab=VDD}
N 950 -6620 950 -6420 {
lab=VDD}
N 940 -6630 950 -6620 {
lab=VDD}
N 940 -6650 940 -6630 {
lab=VDD}
N 860 -6410 860 -6400 {
lab=VSS}
N 820 -6550 830 -6560 {
lab=col_n[21]}
N 830 -6560 1030 -6560 {
lab=col_n[21]}
N 1030 -6560 1040 -6550 {
lab=col_n[21]}
N 1040 -6550 1060 -6550 {
lab=col_n[21]}
N 820 -6530 830 -6540 {
lab=colon_n[21]}
N 830 -6540 1030 -6540 {
lab=colon_n[21]}
N 1030 -6540 1040 -6530 {
lab=colon_n[21]}
N 1040 -6530 1060 -6530 {
lab=colon_n[21]}
N 1040 -6770 1060 -6770 {
lab=#net45}
N 1040 -6750 1060 -6750 {
lab=#net46}
N 800 -6750 820 -6750 {
lab=sample_n}
N 800 -6770 820 -6770 {
lab=sample}
N 800 -6790 820 -6790 {
lab=colon_n[22]}
N 800 -6810 820 -6810 {
lab=col_n[22]}
N 880 -6910 880 -6890 {
lab=vcom}
N 920 -6910 920 -6890 {
lab=ctop}
N 860 -6900 860 -6890 {
lab=VDD}
N 940 -6670 940 -6650 {
lab=VDD}
N 940 -6670 950 -6680 {
lab=VDD}
N 950 -6880 950 -6680 {
lab=VDD}
N 940 -6890 950 -6880 {
lab=VDD}
N 940 -6910 940 -6890 {
lab=VDD}
N 860 -6670 860 -6660 {
lab=VSS}
N 820 -6810 830 -6820 {
lab=col_n[22]}
N 830 -6820 1030 -6820 {
lab=col_n[22]}
N 1030 -6820 1040 -6810 {
lab=col_n[22]}
N 1040 -6810 1060 -6810 {
lab=col_n[22]}
N 820 -6790 830 -6800 {
lab=colon_n[22]}
N 830 -6800 1030 -6800 {
lab=colon_n[22]}
N 1030 -6800 1040 -6790 {
lab=colon_n[22]}
N 1040 -6790 1060 -6790 {
lab=colon_n[22]}
N 1040 -7030 1060 -7030 {
lab=#net47}
N 1040 -7010 1060 -7010 {
lab=#net48}
N 800 -7010 820 -7010 {
lab=sample_n}
N 800 -7030 820 -7030 {
lab=sample}
N 800 -7050 820 -7050 {
lab=colon_n[23]}
N 800 -7070 820 -7070 {
lab=col_n[23]}
N 880 -7170 880 -7150 {
lab=vcom}
N 920 -7170 920 -7150 {
lab=ctop}
N 860 -7160 860 -7150 {
lab=VDD}
N 940 -6930 950 -6940 {
lab=VDD}
N 950 -7140 950 -6940 {
lab=VDD}
N 940 -7150 950 -7140 {
lab=VDD}
N 940 -7170 940 -7150 {
lab=VDD}
N 860 -6930 860 -6920 {
lab=VSS}
N 820 -7070 830 -7080 {
lab=col_n[23]}
N 830 -7080 1030 -7080 {
lab=col_n[23]}
N 1030 -7080 1040 -7070 {
lab=col_n[23]}
N 1040 -7070 1060 -7070 {
lab=col_n[23]}
N 820 -7050 830 -7060 {
lab=colon_n[23]}
N 830 -7060 1030 -7060 {
lab=colon_n[23]}
N 1030 -7060 1040 -7050 {
lab=colon_n[23]}
N 1040 -7050 1060 -7050 {
lab=colon_n[23]}
N 1040 -7290 1060 -7290 {
lab=#net49}
N 1040 -7270 1060 -7270 {
lab=#net50}
N 800 -7270 820 -7270 {
lab=sample_n}
N 800 -7290 820 -7290 {
lab=sample}
N 800 -7310 820 -7310 {
lab=colon_n[24]}
N 800 -7330 820 -7330 {
lab=col_n[24]}
N 880 -7430 880 -7410 {
lab=vcom}
N 920 -7430 920 -7410 {
lab=ctop}
N 860 -7420 860 -7410 {
lab=VDD}
N 940 -7190 940 -7170 {
lab=VDD}
N 940 -7190 950 -7200 {
lab=VDD}
N 950 -7400 950 -7200 {
lab=VDD}
N 940 -7410 950 -7400 {
lab=VDD}
N 940 -7430 940 -7410 {
lab=VDD}
N 860 -7190 860 -7180 {
lab=VSS}
N 820 -7330 830 -7340 {
lab=col_n[24]}
N 830 -7340 1030 -7340 {
lab=col_n[24]}
N 1030 -7340 1040 -7330 {
lab=col_n[24]}
N 1040 -7330 1060 -7330 {
lab=col_n[24]}
N 820 -7310 830 -7320 {
lab=colon_n[24]}
N 830 -7320 1030 -7320 {
lab=colon_n[24]}
N 1030 -7320 1040 -7310 {
lab=colon_n[24]}
N 1040 -7310 1060 -7310 {
lab=colon_n[24]}
N 940 -6930 940 -6910 {
lab=VDD}
N 1040 -7550 1060 -7550 {
lab=#net51}
N 1040 -7530 1060 -7530 {
lab=#net52}
N 800 -7530 820 -7530 {
lab=sample_n}
N 800 -7550 820 -7550 {
lab=sample}
N 800 -7570 820 -7570 {
lab=colon_n[25]}
N 800 -7590 820 -7590 {
lab=col_n[25]}
N 880 -7690 880 -7670 {
lab=vcom}
N 920 -7690 920 -7670 {
lab=ctop}
N 860 -7680 860 -7670 {
lab=VDD}
N 940 -7450 940 -7430 {
lab=VDD}
N 940 -7450 950 -7460 {
lab=VDD}
N 950 -7660 950 -7460 {
lab=VDD}
N 940 -7670 950 -7660 {
lab=VDD}
N 940 -7690 940 -7670 {
lab=VDD}
N 860 -7450 860 -7440 {
lab=VSS}
N 820 -7590 830 -7600 {
lab=col_n[25]}
N 830 -7600 1030 -7600 {
lab=col_n[25]}
N 1030 -7600 1040 -7590 {
lab=col_n[25]}
N 1040 -7590 1060 -7590 {
lab=col_n[25]}
N 820 -7570 830 -7580 {
lab=colon_n[25]}
N 830 -7580 1030 -7580 {
lab=colon_n[25]}
N 1030 -7580 1040 -7570 {
lab=colon_n[25]}
N 1040 -7570 1060 -7570 {
lab=colon_n[25]}
N 1040 -7810 1060 -7810 {
lab=#net53}
N 1040 -7790 1060 -7790 {
lab=#net54}
N 800 -7790 820 -7790 {
lab=sample_n}
N 800 -7810 820 -7810 {
lab=sample}
N 800 -7830 820 -7830 {
lab=colon_n[26]}
N 800 -7850 820 -7850 {
lab=col_n[26]}
N 880 -7950 880 -7930 {
lab=vcom}
N 920 -7950 920 -7930 {
lab=ctop}
N 860 -7940 860 -7930 {
lab=VDD}
N 940 -7710 940 -7690 {
lab=VDD}
N 940 -7710 950 -7720 {
lab=VDD}
N 950 -7920 950 -7720 {
lab=VDD}
N 940 -7930 950 -7920 {
lab=VDD}
N 940 -7950 940 -7930 {
lab=VDD}
N 860 -7710 860 -7700 {
lab=VSS}
N 820 -7850 830 -7860 {
lab=col_n[26]}
N 830 -7860 1030 -7860 {
lab=col_n[26]}
N 1030 -7860 1040 -7850 {
lab=col_n[26]}
N 1040 -7850 1060 -7850 {
lab=col_n[26]}
N 820 -7830 830 -7840 {
lab=colon_n[26]}
N 830 -7840 1030 -7840 {
lab=colon_n[26]}
N 1030 -7840 1040 -7830 {
lab=colon_n[26]}
N 1040 -7830 1060 -7830 {
lab=colon_n[26]}
N 1040 -8070 1060 -8070 {
lab=#net55}
N 1040 -8050 1060 -8050 {
lab=#net56}
N 800 -8050 820 -8050 {
lab=sample_n}
N 800 -8070 820 -8070 {
lab=sample}
N 800 -8090 820 -8090 {
lab=colon_n[27]}
N 800 -8110 820 -8110 {
lab=col_n[27]}
N 880 -8210 880 -8190 {
lab=vcom}
N 920 -8210 920 -8190 {
lab=ctop}
N 860 -8200 860 -8190 {
lab=VDD}
N 940 -7970 940 -7950 {
lab=VDD}
N 940 -7970 950 -7980 {
lab=VDD}
N 950 -8180 950 -7980 {
lab=VDD}
N 940 -8190 950 -8180 {
lab=VDD}
N 940 -8210 940 -8190 {
lab=VDD}
N 860 -7970 860 -7960 {
lab=VSS}
N 820 -8110 830 -8120 {
lab=col_n[27]}
N 830 -8120 1030 -8120 {
lab=col_n[27]}
N 1030 -8120 1040 -8110 {
lab=col_n[27]}
N 1040 -8110 1060 -8110 {
lab=col_n[27]}
N 820 -8090 830 -8100 {
lab=colon_n[27]}
N 830 -8100 1030 -8100 {
lab=colon_n[27]}
N 1030 -8100 1040 -8090 {
lab=colon_n[27]}
N 1040 -8090 1060 -8090 {
lab=colon_n[27]}
N 1040 -8330 1060 -8330 {
lab=#net57}
N 1040 -8310 1060 -8310 {
lab=#net58}
N 800 -8310 820 -8310 {
lab=sample_n}
N 800 -8330 820 -8330 {
lab=sample}
N 800 -8350 820 -8350 {
lab=colon_n[28]}
N 800 -8370 820 -8370 {
lab=col_n[28]}
N 880 -8470 880 -8450 {
lab=vcom}
N 920 -8470 920 -8450 {
lab=ctop}
N 860 -8460 860 -8450 {
lab=VDD}
N 940 -8230 950 -8240 {
lab=VDD}
N 950 -8440 950 -8240 {
lab=VDD}
N 940 -8450 950 -8440 {
lab=VDD}
N 940 -8470 940 -8450 {
lab=VDD}
N 860 -8230 860 -8220 {
lab=VSS}
N 820 -8370 830 -8380 {
lab=col_n[28]}
N 830 -8380 1030 -8380 {
lab=col_n[28]}
N 1030 -8380 1040 -8370 {
lab=col_n[28]}
N 1040 -8370 1060 -8370 {
lab=col_n[28]}
N 820 -8350 830 -8360 {
lab=colon_n[28]}
N 830 -8360 1030 -8360 {
lab=colon_n[28]}
N 1030 -8360 1040 -8350 {
lab=colon_n[28]}
N 1040 -8350 1060 -8350 {
lab=colon_n[28]}
N 1040 -8590 1060 -8590 {
lab=#net59}
N 1040 -8570 1060 -8570 {
lab=#net60}
N 800 -8570 820 -8570 {
lab=sample_n}
N 800 -8590 820 -8590 {
lab=sample}
N 800 -8610 820 -8610 {
lab=colon_n[29]}
N 800 -8630 820 -8630 {
lab=col_n[29]}
N 880 -8730 880 -8710 {
lab=vcom}
N 920 -8730 920 -8710 {
lab=ctop}
N 860 -8720 860 -8710 {
lab=VDD}
N 940 -8490 940 -8470 {
lab=VDD}
N 940 -8490 950 -8500 {
lab=VDD}
N 950 -8700 950 -8500 {
lab=VDD}
N 940 -8710 950 -8700 {
lab=VDD}
N 940 -8730 940 -8710 {
lab=VDD}
N 860 -8490 860 -8480 {
lab=VSS}
N 820 -8630 830 -8640 {
lab=col_n[29]}
N 830 -8640 1030 -8640 {
lab=col_n[29]}
N 1030 -8640 1040 -8630 {
lab=col_n[29]}
N 1040 -8630 1060 -8630 {
lab=col_n[29]}
N 820 -8610 830 -8620 {
lab=colon_n[29]}
N 830 -8620 1030 -8620 {
lab=colon_n[29]}
N 1030 -8620 1040 -8610 {
lab=colon_n[29]}
N 1040 -8610 1060 -8610 {
lab=colon_n[29]}
N 940 -8230 940 -8210 {
lab=VDD}
N 1040 -8850 1060 -8850 {
lab=#net61}
N 1040 -8830 1060 -8830 {
lab=#net62}
N 800 -8830 820 -8830 {
lab=sample_n}
N 800 -8850 820 -8850 {
lab=sample}
N 800 -8870 820 -8870 {
lab=colon_n[30]}
N 800 -8890 820 -8890 {
lab=col_n[30]}
N 880 -8990 880 -8970 {
lab=vcom}
N 920 -8990 920 -8970 {
lab=ctop}
N 860 -8980 860 -8970 {
lab=VDD}
N 940 -8750 940 -8730 {
lab=VDD}
N 940 -8750 950 -8760 {
lab=VDD}
N 950 -8960 950 -8760 {
lab=VDD}
N 940 -8970 950 -8960 {
lab=VDD}
N 940 -8990 940 -8970 {
lab=VDD}
N 860 -8750 860 -8740 {
lab=VSS}
N 820 -8890 830 -8900 {
lab=col_n[30]}
N 830 -8900 1030 -8900 {
lab=col_n[30]}
N 1030 -8900 1040 -8890 {
lab=col_n[30]}
N 1040 -8890 1060 -8890 {
lab=col_n[30]}
N 820 -8870 830 -8880 {
lab=colon_n[30]}
N 830 -8880 1030 -8880 {
lab=colon_n[30]}
N 1030 -8880 1040 -8870 {
lab=colon_n[30]}
N 1040 -8870 1060 -8870 {
lab=colon_n[30]}
N 1040 -9110 1060 -9110 {
lab=#net63}
N 1040 -9090 1060 -9090 {
lab=#net64}
N 800 -9090 820 -9090 {
lab=sample_n}
N 800 -9110 820 -9110 {
lab=sample}
N 800 -9130 820 -9130 {
lab=colon_n[31]}
N 800 -9150 820 -9150 {
lab=col_n[31]}
N 880 -9250 880 -9230 {
lab=vcom}
N 920 -9250 920 -9230 {
lab=ctop}
N 860 -9240 860 -9230 {
lab=VDD}
N 940 -9010 940 -8990 {
lab=VDD}
N 940 -9010 950 -9020 {
lab=VDD}
N 950 -9220 950 -9020 {
lab=VDD}
N 940 -9230 950 -9220 {
lab=VDD}
N 940 -9250 940 -9230 {
lab=VDD}
N 860 -9010 860 -9000 {
lab=VSS}
N 820 -9150 830 -9160 {
lab=col_n[31]}
N 830 -9160 1030 -9160 {
lab=col_n[31]}
N 1030 -9160 1040 -9150 {
lab=col_n[31]}
N 1040 -9150 1060 -9150 {
lab=col_n[31]}
N 820 -9130 830 -9140 {
lab=colon_n[31]}
N 830 -9140 1030 -9140 {
lab=colon_n[31]}
N 1030 -9140 1040 -9130 {
lab=colon_n[31]}
N 1040 -9130 1060 -9130 {
lab=colon_n[31]}
N 940 -690 950 -700 {
lab=VDD}
N 950 -900 950 -700 {
lab=VDD}
N 940 -910 950 -900 {
lab=VDD}
N 940 -930 940 -910 {
lab=VDD}
N 820 -830 830 -840 {
lab=VDD}
N 830 -840 1030 -840 {
lab=VDD}
N 1030 -840 1040 -830 {
lab=VDD}
N 820 -810 830 -820 {
lab=VDD}
N 830 -820 1030 -820 {
lab=VDD}
N 1030 -820 1040 -810 {
lab=VDD}
N 820 -790 830 -800 {
lab=VSS}
N 830 -800 1030 -800 {
lab=VSS}
N 1030 -800 1040 -790 {
lab=VSS}
N 820 -770 830 -780 {
lab=VDD}
N 830 -780 1030 -780 {
lab=VDD}
N 1030 -780 1040 -770 {
lab=VDD}
N 1040 -770 1060 -770 {
lab=VDD}
N 1040 -790 1060 -790 {
lab=VSS}
N 1040 -810 1060 -810 {
lab=VDD}
N 1040 -830 1060 -830 {
lab=VDD}
N 800 -830 820 -830 {
lab=VDD}
N 800 -810 820 -810 {
lab=VDD}
N 800 -790 820 -790 {
lab=VSS}
N 800 -770 820 -770 {
lab=VDD}
N 860 -690 860 -680 {
lab=VSS}
N 880 -930 880 -910 {
lab=vcom}
N 860 -920 860 -910 {
lab=VDD}
N 1200 -690 1210 -700 {
lab=row_n[0]}
N 1210 -900 1210 -700 {
lab=row_n[0]}
N 1200 -910 1210 -900 {
lab=row_n[0]}
N 1200 -930 1200 -910 {
lab=row_n[0]}
N 1080 -830 1090 -840 {
lab=VDD}
N 1090 -840 1290 -840 {
lab=VDD}
N 1290 -840 1300 -830 {
lab=VDD}
N 1080 -810 1090 -820 {
lab=VDD}
N 1090 -820 1290 -820 {
lab=VDD}
N 1290 -820 1300 -810 {
lab=VDD}
N 1080 -790 1090 -800 {
lab=VSS}
N 1090 -800 1290 -800 {
lab=VSS}
N 1290 -800 1300 -790 {
lab=VSS}
N 1080 -770 1090 -780 {
lab=VDD}
N 1090 -780 1290 -780 {
lab=VDD}
N 1290 -780 1300 -770 {
lab=VDD}
N 1300 -770 1320 -770 {
lab=VDD}
N 1300 -790 1320 -790 {
lab=VSS}
N 1300 -810 1320 -810 {
lab=VDD}
N 1300 -830 1320 -830 {
lab=VDD}
N 1060 -830 1080 -830 {
lab=VDD}
N 1060 -810 1080 -810 {
lab=VDD}
N 1060 -790 1080 -790 {
lab=VSS}
N 1060 -770 1080 -770 {
lab=VDD}
N 1120 -690 1120 -680 {
lab=VSS}
N 1140 -930 1140 -910 {
lab=vcom}
N 1120 -920 1120 -910 {
lab=VDD}
N 1200 -690 1200 -670 {
lab=row_n[0]}
N 920 -930 920 -910 {
lab=ctop}
N 1180 -930 1180 -910 {
lab=ctop}
N 1460 -690 1470 -700 {
lab=row_n[1]}
N 1470 -900 1470 -700 {
lab=row_n[1]}
N 1460 -910 1470 -900 {
lab=row_n[1]}
N 1460 -930 1460 -910 {
lab=row_n[1]}
N 1340 -830 1350 -840 {
lab=VDD}
N 1350 -840 1550 -840 {
lab=VDD}
N 1550 -840 1560 -830 {
lab=VDD}
N 1340 -810 1350 -820 {
lab=VDD}
N 1350 -820 1550 -820 {
lab=VDD}
N 1550 -820 1560 -810 {
lab=VDD}
N 1340 -790 1350 -800 {
lab=VSS}
N 1350 -800 1550 -800 {
lab=VSS}
N 1550 -800 1560 -790 {
lab=VSS}
N 1340 -770 1350 -780 {
lab=VDD}
N 1350 -780 1550 -780 {
lab=VDD}
N 1550 -780 1560 -770 {
lab=VDD}
N 1560 -770 1580 -770 {
lab=VDD}
N 1560 -790 1580 -790 {
lab=VSS}
N 1560 -810 1580 -810 {
lab=VDD}
N 1560 -830 1580 -830 {
lab=VDD}
N 1320 -830 1340 -830 {
lab=VDD}
N 1320 -810 1340 -810 {
lab=VDD}
N 1320 -790 1340 -790 {
lab=VSS}
N 1320 -770 1340 -770 {
lab=VDD}
N 1380 -690 1380 -680 {
lab=VSS}
N 1400 -930 1400 -910 {
lab=vcom}
N 1380 -920 1380 -910 {
lab=VDD}
N 1460 -690 1460 -670 {
lab=row_n[1]}
N 1720 -690 1730 -700 {
lab=row_n[2]}
N 1730 -900 1730 -700 {
lab=row_n[2]}
N 1720 -910 1730 -900 {
lab=row_n[2]}
N 1720 -930 1720 -910 {
lab=row_n[2]}
N 1600 -830 1610 -840 {
lab=VDD}
N 1610 -840 1810 -840 {
lab=VDD}
N 1810 -840 1820 -830 {
lab=VDD}
N 1600 -810 1610 -820 {
lab=VDD}
N 1610 -820 1810 -820 {
lab=VDD}
N 1810 -820 1820 -810 {
lab=VDD}
N 1600 -790 1610 -800 {
lab=VSS}
N 1610 -800 1810 -800 {
lab=VSS}
N 1810 -800 1820 -790 {
lab=VSS}
N 1600 -770 1610 -780 {
lab=VDD}
N 1610 -780 1810 -780 {
lab=VDD}
N 1810 -780 1820 -770 {
lab=VDD}
N 1820 -770 1840 -770 {
lab=VDD}
N 1820 -790 1840 -790 {
lab=VSS}
N 1820 -810 1840 -810 {
lab=VDD}
N 1820 -830 1840 -830 {
lab=VDD}
N 1580 -830 1600 -830 {
lab=VDD}
N 1580 -810 1600 -810 {
lab=VDD}
N 1580 -790 1600 -790 {
lab=VSS}
N 1580 -770 1600 -770 {
lab=VDD}
N 1640 -690 1640 -680 {
lab=VSS}
N 1660 -930 1660 -910 {
lab=vcom}
N 1640 -920 1640 -910 {
lab=VDD}
N 1720 -690 1720 -670 {
lab=row_n[2]}
N 1440 -930 1440 -910 {
lab=ctop}
N 1700 -930 1700 -910 {
lab=ctop}
N 1980 -690 1990 -700 {
