C {devices/lab_wire.sym} 8980 -6650 3 0 {name=l2812 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -6400 0 0 {name=l2813 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -6520 0 0 {name=x704}
C {devices/lab_wire.sym} 9180 -6640 2 1 {name=l2814 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -6650 1 1 {name=l2815 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -6650 3 0 {name=l2816 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -6400 0 0 {name=l2817 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -6780 0 0 {name=x705}
C {devices/lab_wire.sym} 1120 -6900 2 1 {name=l2818 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -6910 1 1 {name=l2819 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -6910 3 0 {name=l2820 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -6660 0 0 {name=l2821 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -6780 0 0 {name=x706}
C {devices/lab_wire.sym} 1380 -6900 2 1 {name=l2822 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -6910 1 1 {name=l2823 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -6910 3 0 {name=l2824 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -6660 0 0 {name=l2825 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -6780 0 0 {name=x707}
C {devices/lab_wire.sym} 1640 -6900 2 1 {name=l2826 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -6910 1 1 {name=l2827 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -6910 3 0 {name=l2828 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -6660 0 0 {name=l2829 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -6780 0 0 {name=x708}
C {devices/lab_wire.sym} 1900 -6900 2 1 {name=l2830 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -6910 1 1 {name=l2831 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -6910 3 0 {name=l2832 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -6660 0 0 {name=l2833 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -6780 0 0 {name=x709}
C {devices/lab_wire.sym} 2160 -6900 2 1 {name=l2834 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -6910 1 1 {name=l2835 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -6910 3 0 {name=l2836 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -6660 0 0 {name=l2837 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -6780 0 0 {name=x710}
C {devices/lab_wire.sym} 2420 -6900 2 1 {name=l2838 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -6910 1 1 {name=l2839 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -6910 3 0 {name=l2840 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -6660 0 0 {name=l2841 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -6780 0 0 {name=x711}
C {devices/lab_wire.sym} 2680 -6900 2 1 {name=l2842 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -6910 1 1 {name=l2843 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -6910 3 0 {name=l2844 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -6660 0 0 {name=l2845 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -6780 0 0 {name=x712}
C {devices/lab_wire.sym} 2940 -6900 2 1 {name=l2846 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -6910 1 1 {name=l2847 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -6910 3 0 {name=l2848 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -6660 0 0 {name=l2849 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -6780 0 0 {name=x713}
C {devices/lab_wire.sym} 3200 -6900 2 1 {name=l2850 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -6910 1 1 {name=l2851 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -6910 3 0 {name=l2852 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -6660 0 0 {name=l2853 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -6780 0 0 {name=x714}
C {devices/lab_wire.sym} 3460 -6900 2 1 {name=l2854 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -6910 1 1 {name=l2855 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -6910 3 0 {name=l2856 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -6660 0 0 {name=l2857 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -6780 0 0 {name=x715}
C {devices/lab_wire.sym} 3720 -6900 2 1 {name=l2858 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -6910 1 1 {name=l2859 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -6910 3 0 {name=l2860 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -6660 0 0 {name=l2861 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -6780 0 0 {name=x716}
C {devices/lab_wire.sym} 3980 -6900 2 1 {name=l2862 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -6910 1 1 {name=l2863 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -6910 3 0 {name=l2864 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -6660 0 0 {name=l2865 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -6780 0 0 {name=x717}
C {devices/lab_wire.sym} 4240 -6900 2 1 {name=l2866 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -6910 1 1 {name=l2867 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -6910 3 0 {name=l2868 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -6660 0 0 {name=l2869 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -6780 0 0 {name=x718}
C {devices/lab_wire.sym} 4500 -6900 2 1 {name=l2870 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -6910 1 1 {name=l2871 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -6910 3 0 {name=l2872 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -6660 0 0 {name=l2873 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -6780 0 0 {name=x719}
C {devices/lab_wire.sym} 4760 -6900 2 1 {name=l2874 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -6910 1 1 {name=l2875 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -6910 3 0 {name=l2876 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -6660 0 0 {name=l2877 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -6780 0 0 {name=x720}
C {devices/lab_wire.sym} 5020 -6900 2 1 {name=l2878 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -6910 1 1 {name=l2879 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -6910 3 0 {name=l2880 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -6660 0 0 {name=l2881 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -6780 0 0 {name=x721}
C {devices/lab_wire.sym} 5280 -6900 2 1 {name=l2882 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -6910 1 1 {name=l2883 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -6910 3 0 {name=l2884 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -6660 0 0 {name=l2885 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -6780 0 0 {name=x722}
C {devices/lab_wire.sym} 5540 -6900 2 1 {name=l2886 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -6910 1 1 {name=l2887 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -6910 3 0 {name=l2888 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -6660 0 0 {name=l2889 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -6780 0 0 {name=x723}
C {devices/lab_wire.sym} 5800 -6900 2 1 {name=l2890 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -6910 1 1 {name=l2891 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -6910 3 0 {name=l2892 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -6660 0 0 {name=l2893 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -6780 0 0 {name=x724}
C {devices/lab_wire.sym} 6060 -6900 2 1 {name=l2894 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -6910 1 1 {name=l2895 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -6910 3 0 {name=l2896 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -6660 0 0 {name=l2897 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -6780 0 0 {name=x725}
C {devices/lab_wire.sym} 6320 -6900 2 1 {name=l2898 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -6910 1 1 {name=l2899 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -6910 3 0 {name=l2900 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -6660 0 0 {name=l2901 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -6780 0 0 {name=x726}
C {devices/lab_wire.sym} 6580 -6900 2 1 {name=l2902 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -6910 1 1 {name=l2903 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -6910 3 0 {name=l2904 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -6660 0 0 {name=l2905 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -6780 0 0 {name=x727}
C {devices/lab_wire.sym} 6840 -6900 2 1 {name=l2906 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -6910 1 1 {name=l2907 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -6910 3 0 {name=l2908 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -6660 0 0 {name=l2909 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -6780 0 0 {name=x728}
C {devices/lab_wire.sym} 7100 -6900 2 1 {name=l2910 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -6910 1 1 {name=l2911 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -6910 3 0 {name=l2912 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -6660 0 0 {name=l2913 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -6780 0 0 {name=x729}
C {devices/lab_wire.sym} 7360 -6900 2 1 {name=l2914 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -6910 1 1 {name=l2915 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -6910 3 0 {name=l2916 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -6660 0 0 {name=l2917 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -6780 0 0 {name=x730}
C {devices/lab_wire.sym} 7620 -6900 2 1 {name=l2918 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -6910 1 1 {name=l2919 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -6910 3 0 {name=l2920 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -6660 0 0 {name=l2921 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -6780 0 0 {name=x731}
C {devices/lab_wire.sym} 7880 -6900 2 1 {name=l2922 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -6910 1 1 {name=l2923 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -6910 3 0 {name=l2924 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -6660 0 0 {name=l2925 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -6780 0 0 {name=x732}
C {devices/lab_wire.sym} 8140 -6900 2 1 {name=l2926 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -6910 1 1 {name=l2927 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -6910 3 0 {name=l2928 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -6660 0 0 {name=l2929 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -6780 0 0 {name=x733}
C {devices/lab_wire.sym} 8400 -6900 2 1 {name=l2930 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -6910 1 1 {name=l2931 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -6910 3 0 {name=l2932 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -6660 0 0 {name=l2933 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -6780 0 0 {name=x734}
C {devices/lab_wire.sym} 8660 -6900 2 1 {name=l2934 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -6910 1 1 {name=l2935 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -6910 3 0 {name=l2936 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -6660 0 0 {name=l2937 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -6780 0 0 {name=x735}
C {devices/lab_wire.sym} 8920 -6900 2 1 {name=l2938 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -6910 1 1 {name=l2939 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -6910 3 0 {name=l2940 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -6660 0 0 {name=l2941 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -6780 0 0 {name=x736}
C {devices/lab_wire.sym} 9180 -6900 2 1 {name=l2942 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -6910 1 1 {name=l2943 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -6910 3 0 {name=l2944 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -6660 0 0 {name=l2945 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -7040 0 0 {name=x737}
C {devices/lab_wire.sym} 1120 -7160 2 1 {name=l2946 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -7170 1 1 {name=l2947 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -7170 3 0 {name=l2948 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -6920 0 0 {name=l2949 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -7040 0 0 {name=x738}
C {devices/lab_wire.sym} 1380 -7160 2 1 {name=l2950 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -7170 1 1 {name=l2951 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -7170 3 0 {name=l2952 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -6920 0 0 {name=l2953 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -7040 0 0 {name=x739}
C {devices/lab_wire.sym} 1640 -7160 2 1 {name=l2954 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -7170 1 1 {name=l2955 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -7170 3 0 {name=l2956 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -6920 0 0 {name=l2957 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -7040 0 0 {name=x740}
C {devices/lab_wire.sym} 1900 -7160 2 1 {name=l2958 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -7170 1 1 {name=l2959 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -7170 3 0 {name=l2960 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -6920 0 0 {name=l2961 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -7040 0 0 {name=x741}
C {devices/lab_wire.sym} 2160 -7160 2 1 {name=l2962 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -7170 1 1 {name=l2963 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -7170 3 0 {name=l2964 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -6920 0 0 {name=l2965 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -7040 0 0 {name=x742}
C {devices/lab_wire.sym} 2420 -7160 2 1 {name=l2966 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -7170 1 1 {name=l2967 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -7170 3 0 {name=l2968 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -6920 0 0 {name=l2969 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -7040 0 0 {name=x743}
C {devices/lab_wire.sym} 2680 -7160 2 1 {name=l2970 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -7170 1 1 {name=l2971 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -7170 3 0 {name=l2972 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -6920 0 0 {name=l2973 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -7040 0 0 {name=x744}
C {devices/lab_wire.sym} 2940 -7160 2 1 {name=l2974 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -7170 1 1 {name=l2975 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -7170 3 0 {name=l2976 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -6920 0 0 {name=l2977 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -7040 0 0 {name=x745}
C {devices/lab_wire.sym} 3200 -7160 2 1 {name=l2978 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -7170 1 1 {name=l2979 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -7170 3 0 {name=l2980 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -6920 0 0 {name=l2981 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -7040 0 0 {name=x746}
C {devices/lab_wire.sym} 3460 -7160 2 1 {name=l2982 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -7170 1 1 {name=l2983 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -7170 3 0 {name=l2984 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -6920 0 0 {name=l2985 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -7040 0 0 {name=x747}
C {devices/lab_wire.sym} 3720 -7160 2 1 {name=l2986 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -7170 1 1 {name=l2987 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -7170 3 0 {name=l2988 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -6920 0 0 {name=l2989 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -7040 0 0 {name=x748}
C {devices/lab_wire.sym} 3980 -7160 2 1 {name=l2990 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -7170 1 1 {name=l2991 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -7170 3 0 {name=l2992 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -6920 0 0 {name=l2993 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -7040 0 0 {name=x749}
C {devices/lab_wire.sym} 4240 -7160 2 1 {name=l2994 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -7170 1 1 {name=l2995 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -7170 3 0 {name=l2996 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -6920 0 0 {name=l2997 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -7040 0 0 {name=x750}
C {devices/lab_wire.sym} 4500 -7160 2 1 {name=l2998 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -7170 1 1 {name=l2999 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -7170 3 0 {name=l3000 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -6920 0 0 {name=l3001 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -7040 0 0 {name=x751}
C {devices/lab_wire.sym} 4760 -7160 2 1 {name=l3002 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -7170 1 1 {name=l3003 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -7170 3 0 {name=l3004 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -6920 0 0 {name=l3005 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -7040 0 0 {name=x752}
C {devices/lab_wire.sym} 5020 -7160 2 1 {name=l3006 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -7170 1 1 {name=l3007 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -7170 3 0 {name=l3008 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -6920 0 0 {name=l3009 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -7040 0 0 {name=x753}
C {devices/lab_wire.sym} 5280 -7160 2 1 {name=l3010 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -7170 1 1 {name=l3011 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -7170 3 0 {name=l3012 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -6920 0 0 {name=l3013 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -7040 0 0 {name=x754}
C {devices/lab_wire.sym} 5540 -7160 2 1 {name=l3014 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -7170 1 1 {name=l3015 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -7170 3 0 {name=l3016 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -6920 0 0 {name=l3017 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -7040 0 0 {name=x755}
C {devices/lab_wire.sym} 5800 -7160 2 1 {name=l3018 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -7170 1 1 {name=l3019 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -7170 3 0 {name=l3020 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -6920 0 0 {name=l3021 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -7040 0 0 {name=x756}
C {devices/lab_wire.sym} 6060 -7160 2 1 {name=l3022 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -7170 1 1 {name=l3023 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -7170 3 0 {name=l3024 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -6920 0 0 {name=l3025 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -7040 0 0 {name=x757}
C {devices/lab_wire.sym} 6320 -7160 2 1 {name=l3026 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -7170 1 1 {name=l3027 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -7170 3 0 {name=l3028 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -6920 0 0 {name=l3029 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -7040 0 0 {name=x758}
C {devices/lab_wire.sym} 6580 -7160 2 1 {name=l3030 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -7170 1 1 {name=l3031 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -7170 3 0 {name=l3032 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -6920 0 0 {name=l3033 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -7040 0 0 {name=x759}
C {devices/lab_wire.sym} 6840 -7160 2 1 {name=l3034 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -7170 1 1 {name=l3035 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -7170 3 0 {name=l3036 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -6920 0 0 {name=l3037 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -7040 0 0 {name=x760}
C {devices/lab_wire.sym} 7100 -7160 2 1 {name=l3038 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -7170 1 1 {name=l3039 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -7170 3 0 {name=l3040 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -6920 0 0 {name=l3041 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -7040 0 0 {name=x761}
C {devices/lab_wire.sym} 7360 -7160 2 1 {name=l3042 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -7170 1 1 {name=l3043 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -7170 3 0 {name=l3044 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -6920 0 0 {name=l3045 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -7040 0 0 {name=x762}
C {devices/lab_wire.sym} 7620 -7160 2 1 {name=l3046 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -7170 1 1 {name=l3047 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -7170 3 0 {name=l3048 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -6920 0 0 {name=l3049 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -7040 0 0 {name=x763}
C {devices/lab_wire.sym} 7880 -7160 2 1 {name=l3050 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -7170 1 1 {name=l3051 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -7170 3 0 {name=l3052 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -6920 0 0 {name=l3053 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -7040 0 0 {name=x764}
C {devices/lab_wire.sym} 8140 -7160 2 1 {name=l3054 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -7170 1 1 {name=l3055 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -7170 3 0 {name=l3056 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -6920 0 0 {name=l3057 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -7040 0 0 {name=x765}
C {devices/lab_wire.sym} 8400 -7160 2 1 {name=l3058 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -7170 1 1 {name=l3059 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -7170 3 0 {name=l3060 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -6920 0 0 {name=l3061 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -7040 0 0 {name=x766}
C {devices/lab_wire.sym} 8660 -7160 2 1 {name=l3062 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -7170 1 1 {name=l3063 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -7170 3 0 {name=l3064 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -6920 0 0 {name=l3065 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -7040 0 0 {name=x767}
C {devices/lab_wire.sym} 8920 -7160 2 1 {name=l3066 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -7170 1 1 {name=l3067 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -7170 3 0 {name=l3068 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -6920 0 0 {name=l3069 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -7040 0 0 {name=x768}
C {devices/lab_wire.sym} 9180 -7160 2 1 {name=l3070 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -7170 1 1 {name=l3071 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -7170 3 0 {name=l3072 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -6920 0 0 {name=l3073 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -7300 0 0 {name=x769}
C {devices/lab_wire.sym} 1120 -7420 2 1 {name=l3074 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -7430 1 1 {name=l3075 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -7430 3 0 {name=l3076 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -7180 0 0 {name=l3077 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -7300 0 0 {name=x770}
C {devices/lab_wire.sym} 1380 -7420 2 1 {name=l3078 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -7430 1 1 {name=l3079 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -7430 3 0 {name=l3080 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -7180 0 0 {name=l3081 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -7300 0 0 {name=x771}
C {devices/lab_wire.sym} 1640 -7420 2 1 {name=l3082 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -7430 1 1 {name=l3083 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -7430 3 0 {name=l3084 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -7180 0 0 {name=l3085 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -7300 0 0 {name=x772}
C {devices/lab_wire.sym} 1900 -7420 2 1 {name=l3086 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -7430 1 1 {name=l3087 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -7430 3 0 {name=l3088 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -7180 0 0 {name=l3089 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -7300 0 0 {name=x773}
C {devices/lab_wire.sym} 2160 -7420 2 1 {name=l3090 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -7430 1 1 {name=l3091 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -7430 3 0 {name=l3092 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -7180 0 0 {name=l3093 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -7300 0 0 {name=x774}
C {devices/lab_wire.sym} 2420 -7420 2 1 {name=l3094 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -7430 1 1 {name=l3095 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -7430 3 0 {name=l3096 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -7180 0 0 {name=l3097 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -7300 0 0 {name=x775}
C {devices/lab_wire.sym} 2680 -7420 2 1 {name=l3098 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -7430 1 1 {name=l3099 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -7430 3 0 {name=l3100 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -7180 0 0 {name=l3101 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -7300 0 0 {name=x776}
C {devices/lab_wire.sym} 2940 -7420 2 1 {name=l3102 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -7430 1 1 {name=l3103 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -7430 3 0 {name=l3104 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -7180 0 0 {name=l3105 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -7300 0 0 {name=x777}
C {devices/lab_wire.sym} 3200 -7420 2 1 {name=l3106 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -7430 1 1 {name=l3107 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -7430 3 0 {name=l3108 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -7180 0 0 {name=l3109 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -7300 0 0 {name=x778}
C {devices/lab_wire.sym} 3460 -7420 2 1 {name=l3110 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -7430 1 1 {name=l3111 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -7430 3 0 {name=l3112 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -7180 0 0 {name=l3113 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -7300 0 0 {name=x779}
C {devices/lab_wire.sym} 3720 -7420 2 1 {name=l3114 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -7430 1 1 {name=l3115 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -7430 3 0 {name=l3116 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -7180 0 0 {name=l3117 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -7300 0 0 {name=x780}
C {devices/lab_wire.sym} 3980 -7420 2 1 {name=l3118 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -7430 1 1 {name=l3119 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -7430 3 0 {name=l3120 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -7180 0 0 {name=l3121 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -7300 0 0 {name=x781}
C {devices/lab_wire.sym} 4240 -7420 2 1 {name=l3122 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -7430 1 1 {name=l3123 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -7430 3 0 {name=l3124 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -7180 0 0 {name=l3125 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -7300 0 0 {name=x782}
C {devices/lab_wire.sym} 4500 -7420 2 1 {name=l3126 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -7430 1 1 {name=l3127 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -7430 3 0 {name=l3128 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -7180 0 0 {name=l3129 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -7300 0 0 {name=x783}
C {devices/lab_wire.sym} 4760 -7420 2 1 {name=l3130 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -7430 1 1 {name=l3131 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -7430 3 0 {name=l3132 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -7180 0 0 {name=l3133 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -7300 0 0 {name=x784}
C {devices/lab_wire.sym} 5020 -7420 2 1 {name=l3134 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -7430 1 1 {name=l3135 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -7430 3 0 {name=l3136 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -7180 0 0 {name=l3137 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -7300 0 0 {name=x785}
C {devices/lab_wire.sym} 5280 -7420 2 1 {name=l3138 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -7430 1 1 {name=l3139 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -7430 3 0 {name=l3140 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -7180 0 0 {name=l3141 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -7300 0 0 {name=x786}
C {devices/lab_wire.sym} 5540 -7420 2 1 {name=l3142 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -7430 1 1 {name=l3143 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -7430 3 0 {name=l3144 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -7180 0 0 {name=l3145 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -7300 0 0 {name=x787}
C {devices/lab_wire.sym} 5800 -7420 2 1 {name=l3146 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -7430 1 1 {name=l3147 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -7430 3 0 {name=l3148 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -7180 0 0 {name=l3149 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -7300 0 0 {name=x788}
C {devices/lab_wire.sym} 6060 -7420 2 1 {name=l3150 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -7430 1 1 {name=l3151 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -7430 3 0 {name=l3152 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -7180 0 0 {name=l3153 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -7300 0 0 {name=x789}
C {devices/lab_wire.sym} 6320 -7420 2 1 {name=l3154 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -7430 1 1 {name=l3155 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -7430 3 0 {name=l3156 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -7180 0 0 {name=l3157 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -7300 0 0 {name=x790}
C {devices/lab_wire.sym} 6580 -7420 2 1 {name=l3158 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -7430 1 1 {name=l3159 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -7430 3 0 {name=l3160 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -7180 0 0 {name=l3161 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -7300 0 0 {name=x791}
C {devices/lab_wire.sym} 6840 -7420 2 1 {name=l3162 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -7430 1 1 {name=l3163 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -7430 3 0 {name=l3164 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -7180 0 0 {name=l3165 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -7300 0 0 {name=x792}
C {devices/lab_wire.sym} 7100 -7420 2 1 {name=l3166 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -7430 1 1 {name=l3167 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -7430 3 0 {name=l3168 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -7180 0 0 {name=l3169 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -7300 0 0 {name=x793}
C {devices/lab_wire.sym} 7360 -7420 2 1 {name=l3170 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -7430 1 1 {name=l3171 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -7430 3 0 {name=l3172 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -7180 0 0 {name=l3173 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -7300 0 0 {name=x794}
C {devices/lab_wire.sym} 7620 -7420 2 1 {name=l3174 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -7430 1 1 {name=l3175 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -7430 3 0 {name=l3176 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -7180 0 0 {name=l3177 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -7300 0 0 {name=x795}
C {devices/lab_wire.sym} 7880 -7420 2 1 {name=l3178 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -7430 1 1 {name=l3179 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -7430 3 0 {name=l3180 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -7180 0 0 {name=l3181 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -7300 0 0 {name=x796}
C {devices/lab_wire.sym} 8140 -7420 2 1 {name=l3182 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -7430 1 1 {name=l3183 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -7430 3 0 {name=l3184 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -7180 0 0 {name=l3185 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -7300 0 0 {name=x797}
C {devices/lab_wire.sym} 8400 -7420 2 1 {name=l3186 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -7430 1 1 {name=l3187 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -7430 3 0 {name=l3188 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -7180 0 0 {name=l3189 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -7300 0 0 {name=x798}
C {devices/lab_wire.sym} 8660 -7420 2 1 {name=l3190 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -7430 1 1 {name=l3191 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -7430 3 0 {name=l3192 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -7180 0 0 {name=l3193 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -7300 0 0 {name=x799}
C {devices/lab_wire.sym} 8920 -7420 2 1 {name=l3194 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -7430 1 1 {name=l3195 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -7430 3 0 {name=l3196 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -7180 0 0 {name=l3197 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -7300 0 0 {name=x800}
C {devices/lab_wire.sym} 9180 -7420 2 1 {name=l3198 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -7430 1 1 {name=l3199 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -7430 3 0 {name=l3200 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -7180 0 0 {name=l3201 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -7560 0 0 {name=x801}
C {devices/lab_wire.sym} 1120 -7680 2 1 {name=l3202 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -7690 1 1 {name=l3203 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -7690 3 0 {name=l3204 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -7440 0 0 {name=l3205 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -7560 0 0 {name=x802}
C {devices/lab_wire.sym} 1380 -7680 2 1 {name=l3206 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -7690 1 1 {name=l3207 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -7690 3 0 {name=l3208 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -7440 0 0 {name=l3209 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -7560 0 0 {name=x803}
C {devices/lab_wire.sym} 1640 -7680 2 1 {name=l3210 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -7690 1 1 {name=l3211 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -7690 3 0 {name=l3212 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -7440 0 0 {name=l3213 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -7560 0 0 {name=x804}
C {devices/lab_wire.sym} 1900 -7680 2 1 {name=l3214 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -7690 1 1 {name=l3215 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -7690 3 0 {name=l3216 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -7440 0 0 {name=l3217 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -7560 0 0 {name=x805}
C {devices/lab_wire.sym} 2160 -7680 2 1 {name=l3218 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -7690 1 1 {name=l3219 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -7690 3 0 {name=l3220 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -7440 0 0 {name=l3221 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -7560 0 0 {name=x806}
C {devices/lab_wire.sym} 2420 -7680 2 1 {name=l3222 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -7690 1 1 {name=l3223 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -7690 3 0 {name=l3224 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -7440 0 0 {name=l3225 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -7560 0 0 {name=x807}
C {devices/lab_wire.sym} 2680 -7680 2 1 {name=l3226 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -7690 1 1 {name=l3227 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -7690 3 0 {name=l3228 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -7440 0 0 {name=l3229 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -7560 0 0 {name=x808}
C {devices/lab_wire.sym} 2940 -7680 2 1 {name=l3230 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -7690 1 1 {name=l3231 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -7690 3 0 {name=l3232 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -7440 0 0 {name=l3233 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -7560 0 0 {name=x809}
C {devices/lab_wire.sym} 3200 -7680 2 1 {name=l3234 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -7690 1 1 {name=l3235 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -7690 3 0 {name=l3236 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -7440 0 0 {name=l3237 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -7560 0 0 {name=x810}
C {devices/lab_wire.sym} 3460 -7680 2 1 {name=l3238 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -7690 1 1 {name=l3239 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -7690 3 0 {name=l3240 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -7440 0 0 {name=l3241 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -7560 0 0 {name=x811}
C {devices/lab_wire.sym} 3720 -7680 2 1 {name=l3242 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -7690 1 1 {name=l3243 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -7690 3 0 {name=l3244 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -7440 0 0 {name=l3245 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -7560 0 0 {name=x812}
C {devices/lab_wire.sym} 3980 -7680 2 1 {name=l3246 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -7690 1 1 {name=l3247 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -7690 3 0 {name=l3248 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -7440 0 0 {name=l3249 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -7560 0 0 {name=x813}
C {devices/lab_wire.sym} 4240 -7680 2 1 {name=l3250 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -7690 1 1 {name=l3251 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -7690 3 0 {name=l3252 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -7440 0 0 {name=l3253 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -7560 0 0 {name=x814}
C {devices/lab_wire.sym} 4500 -7680 2 1 {name=l3254 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -7690 1 1 {name=l3255 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -7690 3 0 {name=l3256 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -7440 0 0 {name=l3257 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -7560 0 0 {name=x815}
C {devices/lab_wire.sym} 4760 -7680 2 1 {name=l3258 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -7690 1 1 {name=l3259 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -7690 3 0 {name=l3260 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -7440 0 0 {name=l3261 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -7560 0 0 {name=x816}
C {devices/lab_wire.sym} 5020 -7680 2 1 {name=l3262 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -7690 1 1 {name=l3263 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -7690 3 0 {name=l3264 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -7440 0 0 {name=l3265 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -7560 0 0 {name=x817}
C {devices/lab_wire.sym} 5280 -7680 2 1 {name=l3266 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -7690 1 1 {name=l3267 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -7690 3 0 {name=l3268 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -7440 0 0 {name=l3269 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -7560 0 0 {name=x818}
C {devices/lab_wire.sym} 5540 -7680 2 1 {name=l3270 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -7690 1 1 {name=l3271 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -7690 3 0 {name=l3272 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -7440 0 0 {name=l3273 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -7560 0 0 {name=x819}
C {devices/lab_wire.sym} 5800 -7680 2 1 {name=l3274 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -7690 1 1 {name=l3275 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -7690 3 0 {name=l3276 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -7440 0 0 {name=l3277 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -7560 0 0 {name=x820}
C {devices/lab_wire.sym} 6060 -7680 2 1 {name=l3278 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -7690 1 1 {name=l3279 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -7690 3 0 {name=l3280 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -7440 0 0 {name=l3281 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -7560 0 0 {name=x821}
C {devices/lab_wire.sym} 6320 -7680 2 1 {name=l3282 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -7690 1 1 {name=l3283 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -7690 3 0 {name=l3284 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -7440 0 0 {name=l3285 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -7560 0 0 {name=x822}
C {devices/lab_wire.sym} 6580 -7680 2 1 {name=l3286 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -7690 1 1 {name=l3287 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -7690 3 0 {name=l3288 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -7440 0 0 {name=l3289 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -7560 0 0 {name=x823}
C {devices/lab_wire.sym} 6840 -7680 2 1 {name=l3290 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -7690 1 1 {name=l3291 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -7690 3 0 {name=l3292 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -7440 0 0 {name=l3293 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -7560 0 0 {name=x824}
C {devices/lab_wire.sym} 7100 -7680 2 1 {name=l3294 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -7690 1 1 {name=l3295 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -7690 3 0 {name=l3296 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -7440 0 0 {name=l3297 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -7560 0 0 {name=x825}
C {devices/lab_wire.sym} 7360 -7680 2 1 {name=l3298 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -7690 1 1 {name=l3299 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -7690 3 0 {name=l3300 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -7440 0 0 {name=l3301 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -7560 0 0 {name=x826}
C {devices/lab_wire.sym} 7620 -7680 2 1 {name=l3302 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -7690 1 1 {name=l3303 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -7690 3 0 {name=l3304 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -7440 0 0 {name=l3305 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -7560 0 0 {name=x827}
C {devices/lab_wire.sym} 7880 -7680 2 1 {name=l3306 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -7690 1 1 {name=l3307 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -7690 3 0 {name=l3308 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -7440 0 0 {name=l3309 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -7560 0 0 {name=x828}
C {devices/lab_wire.sym} 8140 -7680 2 1 {name=l3310 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -7690 1 1 {name=l3311 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -7690 3 0 {name=l3312 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -7440 0 0 {name=l3313 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -7560 0 0 {name=x829}
C {devices/lab_wire.sym} 8400 -7680 2 1 {name=l3314 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -7690 1 1 {name=l3315 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -7690 3 0 {name=l3316 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -7440 0 0 {name=l3317 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -7560 0 0 {name=x830}
C {devices/lab_wire.sym} 8660 -7680 2 1 {name=l3318 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -7690 1 1 {name=l3319 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -7690 3 0 {name=l3320 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -7440 0 0 {name=l3321 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -7560 0 0 {name=x831}
C {devices/lab_wire.sym} 8920 -7680 2 1 {name=l3322 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -7690 1 1 {name=l3323 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -7690 3 0 {name=l3324 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -7440 0 0 {name=l3325 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -7560 0 0 {name=x832}
C {devices/lab_wire.sym} 9180 -7680 2 1 {name=l3326 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -7690 1 1 {name=l3327 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -7690 3 0 {name=l3328 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -7440 0 0 {name=l3329 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -7820 0 0 {name=x833}
C {devices/lab_wire.sym} 1120 -7940 2 1 {name=l3330 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -7950 1 1 {name=l3331 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -7950 3 0 {name=l3332 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -7700 0 0 {name=l3333 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -7820 0 0 {name=x834}
C {devices/lab_wire.sym} 1380 -7940 2 1 {name=l3334 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -7950 1 1 {name=l3335 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -7950 3 0 {name=l3336 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -7700 0 0 {name=l3337 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -7820 0 0 {name=x835}
C {devices/lab_wire.sym} 1640 -7940 2 1 {name=l3338 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -7950 1 1 {name=l3339 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -7950 3 0 {name=l3340 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -7700 0 0 {name=l3341 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -7820 0 0 {name=x836}
C {devices/lab_wire.sym} 1900 -7940 2 1 {name=l3342 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -7950 1 1 {name=l3343 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -7950 3 0 {name=l3344 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -7700 0 0 {name=l3345 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -7820 0 0 {name=x837}
C {devices/lab_wire.sym} 2160 -7940 2 1 {name=l3346 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -7950 1 1 {name=l3347 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -7950 3 0 {name=l3348 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -7700 0 0 {name=l3349 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -7820 0 0 {name=x838}
C {devices/lab_wire.sym} 2420 -7940 2 1 {name=l3350 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -7950 1 1 {name=l3351 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -7950 3 0 {name=l3352 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -7700 0 0 {name=l3353 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -7820 0 0 {name=x839}
C {devices/lab_wire.sym} 2680 -7940 2 1 {name=l3354 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -7950 1 1 {name=l3355 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -7950 3 0 {name=l3356 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -7700 0 0 {name=l3357 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -7820 0 0 {name=x840}
C {devices/lab_wire.sym} 2940 -7940 2 1 {name=l3358 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -7950 1 1 {name=l3359 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -7950 3 0 {name=l3360 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -7700 0 0 {name=l3361 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -7820 0 0 {name=x841}
C {devices/lab_wire.sym} 3200 -7940 2 1 {name=l3362 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -7950 1 1 {name=l3363 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -7950 3 0 {name=l3364 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -7700 0 0 {name=l3365 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -7820 0 0 {name=x842}
C {devices/lab_wire.sym} 3460 -7940 2 1 {name=l3366 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -7950 1 1 {name=l3367 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -7950 3 0 {name=l3368 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -7700 0 0 {name=l3369 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -7820 0 0 {name=x843}
C {devices/lab_wire.sym} 3720 -7940 2 1 {name=l3370 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -7950 1 1 {name=l3371 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -7950 3 0 {name=l3372 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -7700 0 0 {name=l3373 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -7820 0 0 {name=x844}
C {devices/lab_wire.sym} 3980 -7940 2 1 {name=l3374 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -7950 1 1 {name=l3375 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -7950 3 0 {name=l3376 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -7700 0 0 {name=l3377 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -7820 0 0 {name=x845}
C {devices/lab_wire.sym} 4240 -7940 2 1 {name=l3378 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -7950 1 1 {name=l3379 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -7950 3 0 {name=l3380 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -7700 0 0 {name=l3381 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -7820 0 0 {name=x846}
C {devices/lab_wire.sym} 4500 -7940 2 1 {name=l3382 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -7950 1 1 {name=l3383 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -7950 3 0 {name=l3384 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -7700 0 0 {name=l3385 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -7820 0 0 {name=x847}
C {devices/lab_wire.sym} 4760 -7940 2 1 {name=l3386 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -7950 1 1 {name=l3387 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -7950 3 0 {name=l3388 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -7700 0 0 {name=l3389 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -7820 0 0 {name=x848}
C {devices/lab_wire.sym} 5020 -7940 2 1 {name=l3390 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -7950 1 1 {name=l3391 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -7950 3 0 {name=l3392 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -7700 0 0 {name=l3393 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -7820 0 0 {name=x849}
C {devices/lab_wire.sym} 5280 -7940 2 1 {name=l3394 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -7950 1 1 {name=l3395 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -7950 3 0 {name=l3396 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -7700 0 0 {name=l3397 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -7820 0 0 {name=x850}
C {devices/lab_wire.sym} 5540 -7940 2 1 {name=l3398 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -7950 1 1 {name=l3399 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -7950 3 0 {name=l3400 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -7700 0 0 {name=l3401 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -7820 0 0 {name=x851}
C {devices/lab_wire.sym} 5800 -7940 2 1 {name=l3402 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -7950 1 1 {name=l3403 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -7950 3 0 {name=l3404 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -7700 0 0 {name=l3405 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -7820 0 0 {name=x852}
C {devices/lab_wire.sym} 6060 -7940 2 1 {name=l3406 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -7950 1 1 {name=l3407 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -7950 3 0 {name=l3408 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -7700 0 0 {name=l3409 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -7820 0 0 {name=x853}
C {devices/lab_wire.sym} 6320 -7940 2 1 {name=l3410 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -7950 1 1 {name=l3411 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -7950 3 0 {name=l3412 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -7700 0 0 {name=l3413 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -7820 0 0 {name=x854}
C {devices/lab_wire.sym} 6580 -7940 2 1 {name=l3414 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -7950 1 1 {name=l3415 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -7950 3 0 {name=l3416 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -7700 0 0 {name=l3417 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -7820 0 0 {name=x855}
C {devices/lab_wire.sym} 6840 -7940 2 1 {name=l3418 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -7950 1 1 {name=l3419 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -7950 3 0 {name=l3420 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -7700 0 0 {name=l3421 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -7820 0 0 {name=x856}
C {devices/lab_wire.sym} 7100 -7940 2 1 {name=l3422 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -7950 1 1 {name=l3423 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -7950 3 0 {name=l3424 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -7700 0 0 {name=l3425 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -7820 0 0 {name=x857}
C {devices/lab_wire.sym} 7360 -7940 2 1 {name=l3426 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -7950 1 1 {name=l3427 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -7950 3 0 {name=l3428 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -7700 0 0 {name=l3429 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -7820 0 0 {name=x858}
C {devices/lab_wire.sym} 7620 -7940 2 1 {name=l3430 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -7950 1 1 {name=l3431 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -7950 3 0 {name=l3432 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -7700 0 0 {name=l3433 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -7820 0 0 {name=x859}
C {devices/lab_wire.sym} 7880 -7940 2 1 {name=l3434 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -7950 1 1 {name=l3435 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -7950 3 0 {name=l3436 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -7700 0 0 {name=l3437 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -7820 0 0 {name=x860}
C {devices/lab_wire.sym} 8140 -7940 2 1 {name=l3438 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -7950 1 1 {name=l3439 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -7950 3 0 {name=l3440 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -7700 0 0 {name=l3441 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -7820 0 0 {name=x861}
C {devices/lab_wire.sym} 8400 -7940 2 1 {name=l3442 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -7950 1 1 {name=l3443 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -7950 3 0 {name=l3444 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -7700 0 0 {name=l3445 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -7820 0 0 {name=x862}
C {devices/lab_wire.sym} 8660 -7940 2 1 {name=l3446 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -7950 1 1 {name=l3447 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -7950 3 0 {name=l3448 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -7700 0 0 {name=l3449 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -7820 0 0 {name=x863}
C {devices/lab_wire.sym} 8920 -7940 2 1 {name=l3450 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -7950 1 1 {name=l3451 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -7950 3 0 {name=l3452 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -7700 0 0 {name=l3453 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -7820 0 0 {name=x864}
C {devices/lab_wire.sym} 9180 -7940 2 1 {name=l3454 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -7950 1 1 {name=l3455 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -7950 3 0 {name=l3456 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -7700 0 0 {name=l3457 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -8080 0 0 {name=x865}
C {devices/lab_wire.sym} 1120 -8200 2 1 {name=l3458 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -8210 1 1 {name=l3459 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -8210 3 0 {name=l3460 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -7960 0 0 {name=l3461 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -8080 0 0 {name=x866}
C {devices/lab_wire.sym} 1380 -8200 2 1 {name=l3462 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -8210 1 1 {name=l3463 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -8210 3 0 {name=l3464 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -7960 0 0 {name=l3465 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -8080 0 0 {name=x867}
C {devices/lab_wire.sym} 1640 -8200 2 1 {name=l3466 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -8210 1 1 {name=l3467 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -8210 3 0 {name=l3468 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -7960 0 0 {name=l3469 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -8080 0 0 {name=x868}
C {devices/lab_wire.sym} 1900 -8200 2 1 {name=l3470 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -8210 1 1 {name=l3471 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -8210 3 0 {name=l3472 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -7960 0 0 {name=l3473 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -8080 0 0 {name=x869}
C {devices/lab_wire.sym} 2160 -8200 2 1 {name=l3474 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -8210 1 1 {name=l3475 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -8210 3 0 {name=l3476 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -7960 0 0 {name=l3477 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -8080 0 0 {name=x870}
C {devices/lab_wire.sym} 2420 -8200 2 1 {name=l3478 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -8210 1 1 {name=l3479 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -8210 3 0 {name=l3480 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -7960 0 0 {name=l3481 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -8080 0 0 {name=x871}
C {devices/lab_wire.sym} 2680 -8200 2 1 {name=l3482 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -8210 1 1 {name=l3483 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -8210 3 0 {name=l3484 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -7960 0 0 {name=l3485 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -8080 0 0 {name=x872}
C {devices/lab_wire.sym} 2940 -8200 2 1 {name=l3486 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -8210 1 1 {name=l3487 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -8210 3 0 {name=l3488 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -7960 0 0 {name=l3489 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -8080 0 0 {name=x873}
C {devices/lab_wire.sym} 3200 -8200 2 1 {name=l3490 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -8210 1 1 {name=l3491 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -8210 3 0 {name=l3492 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -7960 0 0 {name=l3493 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -8080 0 0 {name=x874}
C {devices/lab_wire.sym} 3460 -8200 2 1 {name=l3494 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -8210 1 1 {name=l3495 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -8210 3 0 {name=l3496 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -7960 0 0 {name=l3497 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -8080 0 0 {name=x875}
C {devices/lab_wire.sym} 3720 -8200 2 1 {name=l3498 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -8210 1 1 {name=l3499 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -8210 3 0 {name=l3500 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -7960 0 0 {name=l3501 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -8080 0 0 {name=x876}
C {devices/lab_wire.sym} 3980 -8200 2 1 {name=l3502 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -8210 1 1 {name=l3503 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -8210 3 0 {name=l3504 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -7960 0 0 {name=l3505 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -8080 0 0 {name=x877}
C {devices/lab_wire.sym} 4240 -8200 2 1 {name=l3506 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -8210 1 1 {name=l3507 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -8210 3 0 {name=l3508 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -7960 0 0 {name=l3509 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -8080 0 0 {name=x878}
C {devices/lab_wire.sym} 4500 -8200 2 1 {name=l3510 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -8210 1 1 {name=l3511 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -8210 3 0 {name=l3512 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -7960 0 0 {name=l3513 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -8080 0 0 {name=x879}
C {devices/lab_wire.sym} 4760 -8200 2 1 {name=l3514 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -8210 1 1 {name=l3515 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -8210 3 0 {name=l3516 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -7960 0 0 {name=l3517 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -8080 0 0 {name=x880}
C {devices/lab_wire.sym} 5020 -8200 2 1 {name=l3518 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -8210 1 1 {name=l3519 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -8210 3 0 {name=l3520 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -7960 0 0 {name=l3521 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -8080 0 0 {name=x881}
C {devices/lab_wire.sym} 5280 -8200 2 1 {name=l3522 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -8210 1 1 {name=l3523 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -8210 3 0 {name=l3524 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -7960 0 0 {name=l3525 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -8080 0 0 {name=x882}
C {devices/lab_wire.sym} 5540 -8200 2 1 {name=l3526 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -8210 1 1 {name=l3527 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -8210 3 0 {name=l3528 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -7960 0 0 {name=l3529 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -8080 0 0 {name=x883}
C {devices/lab_wire.sym} 5800 -8200 2 1 {name=l3530 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -8210 1 1 {name=l3531 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -8210 3 0 {name=l3532 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -7960 0 0 {name=l3533 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -8080 0 0 {name=x884}
C {devices/lab_wire.sym} 6060 -8200 2 1 {name=l3534 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -8210 1 1 {name=l3535 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -8210 3 0 {name=l3536 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -7960 0 0 {name=l3537 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -8080 0 0 {name=x885}
C {devices/lab_wire.sym} 6320 -8200 2 1 {name=l3538 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -8210 1 1 {name=l3539 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -8210 3 0 {name=l3540 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -7960 0 0 {name=l3541 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -8080 0 0 {name=x886}
C {devices/lab_wire.sym} 6580 -8200 2 1 {name=l3542 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -8210 1 1 {name=l3543 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -8210 3 0 {name=l3544 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -7960 0 0 {name=l3545 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -8080 0 0 {name=x887}
C {devices/lab_wire.sym} 6840 -8200 2 1 {name=l3546 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -8210 1 1 {name=l3547 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -8210 3 0 {name=l3548 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -7960 0 0 {name=l3549 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -8080 0 0 {name=x888}
C {devices/lab_wire.sym} 7100 -8200 2 1 {name=l3550 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -8210 1 1 {name=l3551 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -8210 3 0 {name=l3552 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -7960 0 0 {name=l3553 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -8080 0 0 {name=x889}
C {devices/lab_wire.sym} 7360 -8200 2 1 {name=l3554 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -8210 1 1 {name=l3555 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -8210 3 0 {name=l3556 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -7960 0 0 {name=l3557 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -8080 0 0 {name=x890}
C {devices/lab_wire.sym} 7620 -8200 2 1 {name=l3558 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -8210 1 1 {name=l3559 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -8210 3 0 {name=l3560 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -7960 0 0 {name=l3561 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -8080 0 0 {name=x891}
C {devices/lab_wire.sym} 7880 -8200 2 1 {name=l3562 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -8210 1 1 {name=l3563 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -8210 3 0 {name=l3564 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -7960 0 0 {name=l3565 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -8080 0 0 {name=x892}
C {devices/lab_wire.sym} 8140 -8200 2 1 {name=l3566 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -8210 1 1 {name=l3567 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -8210 3 0 {name=l3568 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -7960 0 0 {name=l3569 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -8080 0 0 {name=x893}
C {devices/lab_wire.sym} 8400 -8200 2 1 {name=l3570 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -8210 1 1 {name=l3571 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -8210 3 0 {name=l3572 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -7960 0 0 {name=l3573 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -8080 0 0 {name=x894}
C {devices/lab_wire.sym} 8660 -8200 2 1 {name=l3574 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -8210 1 1 {name=l3575 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -8210 3 0 {name=l3576 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -7960 0 0 {name=l3577 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -8080 0 0 {name=x895}
C {devices/lab_wire.sym} 8920 -8200 2 1 {name=l3578 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -8210 1 1 {name=l3579 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -8210 3 0 {name=l3580 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -7960 0 0 {name=l3581 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -8080 0 0 {name=x896}
C {devices/lab_wire.sym} 9180 -8200 2 1 {name=l3582 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -8210 1 1 {name=l3583 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -8210 3 0 {name=l3584 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -7960 0 0 {name=l3585 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -8340 0 0 {name=x897}
C {devices/lab_wire.sym} 1120 -8460 2 1 {name=l3586 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -8470 1 1 {name=l3587 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -8470 3 0 {name=l3588 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -8220 0 0 {name=l3589 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -8340 0 0 {name=x898}
C {devices/lab_wire.sym} 1380 -8460 2 1 {name=l3590 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -8470 1 1 {name=l3591 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -8470 3 0 {name=l3592 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -8220 0 0 {name=l3593 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -8340 0 0 {name=x899}
C {devices/lab_wire.sym} 1640 -8460 2 1 {name=l3594 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -8470 1 1 {name=l3595 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -8470 3 0 {name=l3596 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -8220 0 0 {name=l3597 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -8340 0 0 {name=x900}
C {devices/lab_wire.sym} 1900 -8460 2 1 {name=l3598 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -8470 1 1 {name=l3599 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -8470 3 0 {name=l3600 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -8220 0 0 {name=l3601 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -8340 0 0 {name=x901}
C {devices/lab_wire.sym} 2160 -8460 2 1 {name=l3602 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -8470 1 1 {name=l3603 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -8470 3 0 {name=l3604 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -8220 0 0 {name=l3605 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -8340 0 0 {name=x902}
C {devices/lab_wire.sym} 2420 -8460 2 1 {name=l3606 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -8470 1 1 {name=l3607 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -8470 3 0 {name=l3608 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -8220 0 0 {name=l3609 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -8340 0 0 {name=x903}
C {devices/lab_wire.sym} 2680 -8460 2 1 {name=l3610 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -8470 1 1 {name=l3611 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -8470 3 0 {name=l3612 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -8220 0 0 {name=l3613 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -8340 0 0 {name=x904}
C {devices/lab_wire.sym} 2940 -8460 2 1 {name=l3614 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -8470 1 1 {name=l3615 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -8470 3 0 {name=l3616 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -8220 0 0 {name=l3617 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -8340 0 0 {name=x905}
C {devices/lab_wire.sym} 3200 -8460 2 1 {name=l3618 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -8470 1 1 {name=l3619 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -8470 3 0 {name=l3620 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -8220 0 0 {name=l3621 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -8340 0 0 {name=x906}
C {devices/lab_wire.sym} 3460 -8460 2 1 {name=l3622 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -8470 1 1 {name=l3623 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -8470 3 0 {name=l3624 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -8220 0 0 {name=l3625 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -8340 0 0 {name=x907}
C {devices/lab_wire.sym} 3720 -8460 2 1 {name=l3626 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -8470 1 1 {name=l3627 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -8470 3 0 {name=l3628 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -8220 0 0 {name=l3629 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -8340 0 0 {name=x908}
C {devices/lab_wire.sym} 3980 -8460 2 1 {name=l3630 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -8470 1 1 {name=l3631 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -8470 3 0 {name=l3632 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -8220 0 0 {name=l3633 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -8340 0 0 {name=x909}
C {devices/lab_wire.sym} 4240 -8460 2 1 {name=l3634 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -8470 1 1 {name=l3635 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -8470 3 0 {name=l3636 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -8220 0 0 {name=l3637 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -8340 0 0 {name=x910}
C {devices/lab_wire.sym} 4500 -8460 2 1 {name=l3638 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -8470 1 1 {name=l3639 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -8470 3 0 {name=l3640 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -8220 0 0 {name=l3641 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -8340 0 0 {name=x911}
C {devices/lab_wire.sym} 4760 -8460 2 1 {name=l3642 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -8470 1 1 {name=l3643 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -8470 3 0 {name=l3644 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -8220 0 0 {name=l3645 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -8340 0 0 {name=x912}
C {devices/lab_wire.sym} 5020 -8460 2 1 {name=l3646 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -8470 1 1 {name=l3647 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -8470 3 0 {name=l3648 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -8220 0 0 {name=l3649 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -8340 0 0 {name=x913}
C {devices/lab_wire.sym} 5280 -8460 2 1 {name=l3650 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -8470 1 1 {name=l3651 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -8470 3 0 {name=l3652 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -8220 0 0 {name=l3653 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -8340 0 0 {name=x914}
C {devices/lab_wire.sym} 5540 -8460 2 1 {name=l3654 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -8470 1 1 {name=l3655 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -8470 3 0 {name=l3656 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -8220 0 0 {name=l3657 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -8340 0 0 {name=x915}
C {devices/lab_wire.sym} 5800 -8460 2 1 {name=l3658 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -8470 1 1 {name=l3659 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -8470 3 0 {name=l3660 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -8220 0 0 {name=l3661 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -8340 0 0 {name=x916}
C {devices/lab_wire.sym} 6060 -8460 2 1 {name=l3662 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -8470 1 1 {name=l3663 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -8470 3 0 {name=l3664 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -8220 0 0 {name=l3665 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -8340 0 0 {name=x917}
C {devices/lab_wire.sym} 6320 -8460 2 1 {name=l3666 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -8470 1 1 {name=l3667 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -8470 3 0 {name=l3668 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -8220 0 0 {name=l3669 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -8340 0 0 {name=x918}
C {devices/lab_wire.sym} 6580 -8460 2 1 {name=l3670 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -8470 1 1 {name=l3671 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -8470 3 0 {name=l3672 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -8220 0 0 {name=l3673 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -8340 0 0 {name=x919}
C {devices/lab_wire.sym} 6840 -8460 2 1 {name=l3674 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -8470 1 1 {name=l3675 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -8470 3 0 {name=l3676 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -8220 0 0 {name=l3677 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -8340 0 0 {name=x920}
C {devices/lab_wire.sym} 7100 -8460 2 1 {name=l3678 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -8470 1 1 {name=l3679 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -8470 3 0 {name=l3680 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -8220 0 0 {name=l3681 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -8340 0 0 {name=x921}
C {devices/lab_wire.sym} 7360 -8460 2 1 {name=l3682 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -8470 1 1 {name=l3683 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -8470 3 0 {name=l3684 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -8220 0 0 {name=l3685 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -8340 0 0 {name=x922}
C {devices/lab_wire.sym} 7620 -8460 2 1 {name=l3686 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -8470 1 1 {name=l3687 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -8470 3 0 {name=l3688 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -8220 0 0 {name=l3689 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -8340 0 0 {name=x923}
C {devices/lab_wire.sym} 7880 -8460 2 1 {name=l3690 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -8470 1 1 {name=l3691 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -8470 3 0 {name=l3692 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -8220 0 0 {name=l3693 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -8340 0 0 {name=x924}
C {devices/lab_wire.sym} 8140 -8460 2 1 {name=l3694 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -8470 1 1 {name=l3695 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -8470 3 0 {name=l3696 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -8220 0 0 {name=l3697 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -8340 0 0 {name=x925}
C {devices/lab_wire.sym} 8400 -8460 2 1 {name=l3698 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -8470 1 1 {name=l3699 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -8470 3 0 {name=l3700 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -8220 0 0 {name=l3701 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -8340 0 0 {name=x926}
C {devices/lab_wire.sym} 8660 -8460 2 1 {name=l3702 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -8470 1 1 {name=l3703 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -8470 3 0 {name=l3704 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -8220 0 0 {name=l3705 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -8340 0 0 {name=x927}
C {devices/lab_wire.sym} 8920 -8460 2 1 {name=l3706 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -8470 1 1 {name=l3707 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -8470 3 0 {name=l3708 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -8220 0 0 {name=l3709 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -8340 0 0 {name=x928}
C {devices/lab_wire.sym} 9180 -8460 2 1 {name=l3710 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -8470 1 1 {name=l3711 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -8470 3 0 {name=l3712 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -8220 0 0 {name=l3713 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -8600 0 0 {name=x929}
C {devices/lab_wire.sym} 1120 -8720 2 1 {name=l3714 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -8730 1 1 {name=l3715 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -8730 3 0 {name=l3716 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -8480 0 0 {name=l3717 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -8600 0 0 {name=x930}
C {devices/lab_wire.sym} 1380 -8720 2 1 {name=l3718 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -8730 1 1 {name=l3719 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -8730 3 0 {name=l3720 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -8480 0 0 {name=l3721 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -8600 0 0 {name=x931}
C {devices/lab_wire.sym} 1640 -8720 2 1 {name=l3722 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -8730 1 1 {name=l3723 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -8730 3 0 {name=l3724 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -8480 0 0 {name=l3725 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -8600 0 0 {name=x932}
C {devices/lab_wire.sym} 1900 -8720 2 1 {name=l3726 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -8730 1 1 {name=l3727 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -8730 3 0 {name=l3728 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -8480 0 0 {name=l3729 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -8600 0 0 {name=x933}
C {devices/lab_wire.sym} 2160 -8720 2 1 {name=l3730 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -8730 1 1 {name=l3731 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -8730 3 0 {name=l3732 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -8480 0 0 {name=l3733 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -8600 0 0 {name=x934}
C {devices/lab_wire.sym} 2420 -8720 2 1 {name=l3734 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -8730 1 1 {name=l3735 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -8730 3 0 {name=l3736 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -8480 0 0 {name=l3737 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -8600 0 0 {name=x935}
C {devices/lab_wire.sym} 2680 -8720 2 1 {name=l3738 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -8730 1 1 {name=l3739 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -8730 3 0 {name=l3740 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -8480 0 0 {name=l3741 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -8600 0 0 {name=x936}
C {devices/lab_wire.sym} 2940 -8720 2 1 {name=l3742 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -8730 1 1 {name=l3743 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -8730 3 0 {name=l3744 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -8480 0 0 {name=l3745 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -8600 0 0 {name=x937}
C {devices/lab_wire.sym} 3200 -8720 2 1 {name=l3746 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -8730 1 1 {name=l3747 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -8730 3 0 {name=l3748 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -8480 0 0 {name=l3749 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -8600 0 0 {name=x938}
C {devices/lab_wire.sym} 3460 -8720 2 1 {name=l3750 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -8730 1 1 {name=l3751 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -8730 3 0 {name=l3752 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -8480 0 0 {name=l3753 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -8600 0 0 {name=x939}
C {devices/lab_wire.sym} 3720 -8720 2 1 {name=l3754 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -8730 1 1 {name=l3755 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -8730 3 0 {name=l3756 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -8480 0 0 {name=l3757 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -8600 0 0 {name=x940}
C {devices/lab_wire.sym} 3980 -8720 2 1 {name=l3758 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -8730 1 1 {name=l3759 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -8730 3 0 {name=l3760 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -8480 0 0 {name=l3761 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -8600 0 0 {name=x941}
C {devices/lab_wire.sym} 4240 -8720 2 1 {name=l3762 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -8730 1 1 {name=l3763 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -8730 3 0 {name=l3764 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -8480 0 0 {name=l3765 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -8600 0 0 {name=x942}
C {devices/lab_wire.sym} 4500 -8720 2 1 {name=l3766 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -8730 1 1 {name=l3767 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -8730 3 0 {name=l3768 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -8480 0 0 {name=l3769 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -8600 0 0 {name=x943}
C {devices/lab_wire.sym} 4760 -8720 2 1 {name=l3770 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -8730 1 1 {name=l3771 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -8730 3 0 {name=l3772 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -8480 0 0 {name=l3773 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -8600 0 0 {name=x944}
C {devices/lab_wire.sym} 5020 -8720 2 1 {name=l3774 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -8730 1 1 {name=l3775 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -8730 3 0 {name=l3776 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -8480 0 0 {name=l3777 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -8600 0 0 {name=x945}
C {devices/lab_wire.sym} 5280 -8720 2 1 {name=l3778 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -8730 1 1 {name=l3779 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -8730 3 0 {name=l3780 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -8480 0 0 {name=l3781 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -8600 0 0 {name=x946}
C {devices/lab_wire.sym} 5540 -8720 2 1 {name=l3782 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -8730 1 1 {name=l3783 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -8730 3 0 {name=l3784 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -8480 0 0 {name=l3785 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -8600 0 0 {name=x947}
C {devices/lab_wire.sym} 5800 -8720 2 1 {name=l3786 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -8730 1 1 {name=l3787 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -8730 3 0 {name=l3788 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -8480 0 0 {name=l3789 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -8600 0 0 {name=x948}
C {devices/lab_wire.sym} 6060 -8720 2 1 {name=l3790 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -8730 1 1 {name=l3791 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -8730 3 0 {name=l3792 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -8480 0 0 {name=l3793 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -8600 0 0 {name=x949}
C {devices/lab_wire.sym} 6320 -8720 2 1 {name=l3794 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -8730 1 1 {name=l3795 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -8730 3 0 {name=l3796 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -8480 0 0 {name=l3797 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -8600 0 0 {name=x950}
C {devices/lab_wire.sym} 6580 -8720 2 1 {name=l3798 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -8730 1 1 {name=l3799 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -8730 3 0 {name=l3800 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -8480 0 0 {name=l3801 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -8600 0 0 {name=x951}
C {devices/lab_wire.sym} 6840 -8720 2 1 {name=l3802 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -8730 1 1 {name=l3803 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -8730 3 0 {name=l3804 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -8480 0 0 {name=l3805 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -8600 0 0 {name=x952}
C {devices/lab_wire.sym} 7100 -8720 2 1 {name=l3806 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -8730 1 1 {name=l3807 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -8730 3 0 {name=l3808 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -8480 0 0 {name=l3809 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -8600 0 0 {name=x953}
C {devices/lab_wire.sym} 7360 -8720 2 1 {name=l3810 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -8730 1 1 {name=l3811 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -8730 3 0 {name=l3812 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -8480 0 0 {name=l3813 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -8600 0 0 {name=x954}
C {devices/lab_wire.sym} 7620 -8720 2 1 {name=l3814 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -8730 1 1 {name=l3815 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -8730 3 0 {name=l3816 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -8480 0 0 {name=l3817 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -8600 0 0 {name=x955}
C {devices/lab_wire.sym} 7880 -8720 2 1 {name=l3818 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -8730 1 1 {name=l3819 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -8730 3 0 {name=l3820 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -8480 0 0 {name=l3821 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -8600 0 0 {name=x956}
C {devices/lab_wire.sym} 8140 -8720 2 1 {name=l3822 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -8730 1 1 {name=l3823 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -8730 3 0 {name=l3824 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -8480 0 0 {name=l3825 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -8600 0 0 {name=x957}
C {devices/lab_wire.sym} 8400 -8720 2 1 {name=l3826 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -8730 1 1 {name=l3827 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -8730 3 0 {name=l3828 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -8480 0 0 {name=l3829 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -8600 0 0 {name=x958}
C {devices/lab_wire.sym} 8660 -8720 2 1 {name=l3830 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -8730 1 1 {name=l3831 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -8730 3 0 {name=l3832 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -8480 0 0 {name=l3833 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -8600 0 0 {name=x959}
C {devices/lab_wire.sym} 8920 -8720 2 1 {name=l3834 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -8730 1 1 {name=l3835 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -8730 3 0 {name=l3836 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -8480 0 0 {name=l3837 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -8600 0 0 {name=x960}
C {devices/lab_wire.sym} 9180 -8720 2 1 {name=l3838 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -8730 1 1 {name=l3839 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -8730 3 0 {name=l3840 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -8480 0 0 {name=l3841 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -8860 0 0 {name=x961}
C {devices/lab_wire.sym} 1120 -8980 2 1 {name=l3842 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -8990 1 1 {name=l3843 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -8990 3 0 {name=l3844 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -8740 0 0 {name=l3845 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -8860 0 0 {name=x962}
C {devices/lab_wire.sym} 1380 -8980 2 1 {name=l3846 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -8990 1 1 {name=l3847 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -8990 3 0 {name=l3848 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -8740 0 0 {name=l3849 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -8860 0 0 {name=x963}
C {devices/lab_wire.sym} 1640 -8980 2 1 {name=l3850 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -8990 1 1 {name=l3851 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -8990 3 0 {name=l3852 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -8740 0 0 {name=l3853 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -8860 0 0 {name=x964}
C {devices/lab_wire.sym} 1900 -8980 2 1 {name=l3854 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -8990 1 1 {name=l3855 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -8990 3 0 {name=l3856 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -8740 0 0 {name=l3857 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -8860 0 0 {name=x965}
C {devices/lab_wire.sym} 2160 -8980 2 1 {name=l3858 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -8990 1 1 {name=l3859 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -8990 3 0 {name=l3860 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -8740 0 0 {name=l3861 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -8860 0 0 {name=x966}
C {devices/lab_wire.sym} 2420 -8980 2 1 {name=l3862 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -8990 1 1 {name=l3863 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -8990 3 0 {name=l3864 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -8740 0 0 {name=l3865 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -8860 0 0 {name=x967}
C {devices/lab_wire.sym} 2680 -8980 2 1 {name=l3866 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -8990 1 1 {name=l3867 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -8990 3 0 {name=l3868 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -8740 0 0 {name=l3869 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -8860 0 0 {name=x968}
C {devices/lab_wire.sym} 2940 -8980 2 1 {name=l3870 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -8990 1 1 {name=l3871 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -8990 3 0 {name=l3872 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -8740 0 0 {name=l3873 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -8860 0 0 {name=x969}
C {devices/lab_wire.sym} 3200 -8980 2 1 {name=l3874 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -8990 1 1 {name=l3875 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -8990 3 0 {name=l3876 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -8740 0 0 {name=l3877 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -8860 0 0 {name=x970}
C {devices/lab_wire.sym} 3460 -8980 2 1 {name=l3878 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -8990 1 1 {name=l3879 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -8990 3 0 {name=l3880 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -8740 0 0 {name=l3881 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -8860 0 0 {name=x971}
C {devices/lab_wire.sym} 3720 -8980 2 1 {name=l3882 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -8990 1 1 {name=l3883 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -8990 3 0 {name=l3884 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -8740 0 0 {name=l3885 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -8860 0 0 {name=x972}
C {devices/lab_wire.sym} 3980 -8980 2 1 {name=l3886 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -8990 1 1 {name=l3887 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -8990 3 0 {name=l3888 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -8740 0 0 {name=l3889 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -8860 0 0 {name=x973}
C {devices/lab_wire.sym} 4240 -8980 2 1 {name=l3890 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -8990 1 1 {name=l3891 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -8990 3 0 {name=l3892 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -8740 0 0 {name=l3893 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -8860 0 0 {name=x974}
C {devices/lab_wire.sym} 4500 -8980 2 1 {name=l3894 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -8990 1 1 {name=l3895 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -8990 3 0 {name=l3896 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -8740 0 0 {name=l3897 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -8860 0 0 {name=x975}
C {devices/lab_wire.sym} 4760 -8980 2 1 {name=l3898 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -8990 1 1 {name=l3899 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -8990 3 0 {name=l3900 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -8740 0 0 {name=l3901 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -8860 0 0 {name=x976}
C {devices/lab_wire.sym} 5020 -8980 2 1 {name=l3902 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -8990 1 1 {name=l3903 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -8990 3 0 {name=l3904 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -8740 0 0 {name=l3905 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -8860 0 0 {name=x977}
C {devices/lab_wire.sym} 5280 -8980 2 1 {name=l3906 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -8990 1 1 {name=l3907 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -8990 3 0 {name=l3908 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -8740 0 0 {name=l3909 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -8860 0 0 {name=x978}
C {devices/lab_wire.sym} 5540 -8980 2 1 {name=l3910 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -8990 1 1 {name=l3911 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -8990 3 0 {name=l3912 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -8740 0 0 {name=l3913 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -8860 0 0 {name=x979}
C {devices/lab_wire.sym} 5800 -8980 2 1 {name=l3914 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -8990 1 1 {name=l3915 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -8990 3 0 {name=l3916 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -8740 0 0 {name=l3917 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -8860 0 0 {name=x980}
C {devices/lab_wire.sym} 6060 -8980 2 1 {name=l3918 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -8990 1 1 {name=l3919 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -8990 3 0 {name=l3920 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -8740 0 0 {name=l3921 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -8860 0 0 {name=x981}
C {devices/lab_wire.sym} 6320 -8980 2 1 {name=l3922 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -8990 1 1 {name=l3923 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -8990 3 0 {name=l3924 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -8740 0 0 {name=l3925 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -8860 0 0 {name=x982}
C {devices/lab_wire.sym} 6580 -8980 2 1 {name=l3926 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -8990 1 1 {name=l3927 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -8990 3 0 {name=l3928 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -8740 0 0 {name=l3929 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -8860 0 0 {name=x983}
C {devices/lab_wire.sym} 6840 -8980 2 1 {name=l3930 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -8990 1 1 {name=l3931 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -8990 3 0 {name=l3932 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -8740 0 0 {name=l3933 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -8860 0 0 {name=x984}
C {devices/lab_wire.sym} 7100 -8980 2 1 {name=l3934 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -8990 1 1 {name=l3935 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -8990 3 0 {name=l3936 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -8740 0 0 {name=l3937 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -8860 0 0 {name=x985}
C {devices/lab_wire.sym} 7360 -8980 2 1 {name=l3938 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -8990 1 1 {name=l3939 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -8990 3 0 {name=l3940 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -8740 0 0 {name=l3941 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -8860 0 0 {name=x986}
C {devices/lab_wire.sym} 7620 -8980 2 1 {name=l3942 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -8990 1 1 {name=l3943 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -8990 3 0 {name=l3944 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -8740 0 0 {name=l3945 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -8860 0 0 {name=x987}
C {devices/lab_wire.sym} 7880 -8980 2 1 {name=l3946 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -8990 1 1 {name=l3947 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -8990 3 0 {name=l3948 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -8740 0 0 {name=l3949 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -8860 0 0 {name=x988}
C {devices/lab_wire.sym} 8140 -8980 2 1 {name=l3950 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -8990 1 1 {name=l3951 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -8990 3 0 {name=l3952 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -8740 0 0 {name=l3953 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -8860 0 0 {name=x989}
C {devices/lab_wire.sym} 8400 -8980 2 1 {name=l3954 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -8990 1 1 {name=l3955 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -8990 3 0 {name=l3956 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -8740 0 0 {name=l3957 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -8860 0 0 {name=x990}
C {devices/lab_wire.sym} 8660 -8980 2 1 {name=l3958 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -8990 1 1 {name=l3959 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -8990 3 0 {name=l3960 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -8740 0 0 {name=l3961 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -8860 0 0 {name=x991}
C {devices/lab_wire.sym} 8920 -8980 2 1 {name=l3962 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -8990 1 1 {name=l3963 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -8990 3 0 {name=l3964 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -8740 0 0 {name=l3965 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -8860 0 0 {name=x992}
C {devices/lab_wire.sym} 9180 -8980 2 1 {name=l3966 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -8990 1 1 {name=l3967 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -8990 3 0 {name=l3968 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -8740 0 0 {name=l3969 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -9120 0 0 {name=x993}
C {devices/lab_wire.sym} 1120 -9240 2 1 {name=l3970 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -9250 1 1 {name=l3971 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -9250 3 0 {name=l3972 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -9000 0 0 {name=l3973 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -9120 0 0 {name=x994}
C {devices/lab_wire.sym} 1380 -9240 2 1 {name=l3974 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -9250 1 1 {name=l3975 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -9250 3 0 {name=l3976 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -9000 0 0 {name=l3977 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -9120 0 0 {name=x995}
C {devices/lab_wire.sym} 1640 -9240 2 1 {name=l3978 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -9250 1 1 {name=l3979 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -9250 3 0 {name=l3980 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -9000 0 0 {name=l3981 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -9120 0 0 {name=x996}
C {devices/lab_wire.sym} 1900 -9240 2 1 {name=l3982 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -9250 1 1 {name=l3983 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -9250 3 0 {name=l3984 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -9000 0 0 {name=l3985 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -9120 0 0 {name=x997}
C {devices/lab_wire.sym} 2160 -9240 2 1 {name=l3986 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -9250 1 1 {name=l3987 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -9250 3 0 {name=l3988 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -9000 0 0 {name=l3989 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -9120 0 0 {name=x998}
C {devices/lab_wire.sym} 2420 -9240 2 1 {name=l3990 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -9250 1 1 {name=l3991 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -9250 3 0 {name=l3992 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -9000 0 0 {name=l3993 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -9120 0 0 {name=x999}
C {devices/lab_wire.sym} 2680 -9240 2 1 {name=l3994 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -9250 1 1 {name=l3995 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -9250 3 0 {name=l3996 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -9000 0 0 {name=l3997 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -9120 0 0 {name=x1000}
C {devices/lab_wire.sym} 2940 -9240 2 1 {name=l3998 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -9250 1 1 {name=l3999 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -9250 3 0 {name=l4000 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -9000 0 0 {name=l4001 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -9120 0 0 {name=x1001}
C {devices/lab_wire.sym} 3200 -9240 2 1 {name=l4002 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -9250 1 1 {name=l4003 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -9250 3 0 {name=l4004 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -9000 0 0 {name=l4005 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -9120 0 0 {name=x1002}
C {devices/lab_wire.sym} 3460 -9240 2 1 {name=l4006 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -9250 1 1 {name=l4007 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -9250 3 0 {name=l4008 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -9000 0 0 {name=l4009 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -9120 0 0 {name=x1003}
C {devices/lab_wire.sym} 3720 -9240 2 1 {name=l4010 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -9250 1 1 {name=l4011 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -9250 3 0 {name=l4012 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -9000 0 0 {name=l4013 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -9120 0 0 {name=x1004}
C {devices/lab_wire.sym} 3980 -9240 2 1 {name=l4014 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -9250 1 1 {name=l4015 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -9250 3 0 {name=l4016 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -9000 0 0 {name=l4017 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -9120 0 0 {name=x1005}
C {devices/lab_wire.sym} 4240 -9240 2 1 {name=l4018 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -9250 1 1 {name=l4019 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -9250 3 0 {name=l4020 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -9000 0 0 {name=l4021 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -9120 0 0 {name=x1006}
C {devices/lab_wire.sym} 4500 -9240 2 1 {name=l4022 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -9250 1 1 {name=l4023 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -9250 3 0 {name=l4024 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -9000 0 0 {name=l4025 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -9120 0 0 {name=x1007}
C {devices/lab_wire.sym} 4760 -9240 2 1 {name=l4026 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -9250 1 1 {name=l4027 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -9250 3 0 {name=l4028 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -9000 0 0 {name=l4029 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -9120 0 0 {name=x1008}
C {devices/lab_wire.sym} 5020 -9240 2 1 {name=l4030 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -9250 1 1 {name=l4031 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -9250 3 0 {name=l4032 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -9000 0 0 {name=l4033 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -9120 0 0 {name=x1009}
C {devices/lab_wire.sym} 5280 -9240 2 1 {name=l4034 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -9250 1 1 {name=l4035 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -9250 3 0 {name=l4036 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -9000 0 0 {name=l4037 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -9120 0 0 {name=x1010}
C {devices/lab_wire.sym} 5540 -9240 2 1 {name=l4038 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -9250 1 1 {name=l4039 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -9250 3 0 {name=l4040 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -9000 0 0 {name=l4041 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -9120 0 0 {name=x1011}
C {devices/lab_wire.sym} 5800 -9240 2 1 {name=l4042 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -9250 1 1 {name=l4043 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -9250 3 0 {name=l4044 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -9000 0 0 {name=l4045 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -9120 0 0 {name=x1012}
C {devices/lab_wire.sym} 6060 -9240 2 1 {name=l4046 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -9250 1 1 {name=l4047 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -9250 3 0 {name=l4048 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -9000 0 0 {name=l4049 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -9120 0 0 {name=x1013}
C {devices/lab_wire.sym} 6320 -9240 2 1 {name=l4050 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -9250 1 1 {name=l4051 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -9250 3 0 {name=l4052 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -9000 0 0 {name=l4053 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -9120 0 0 {name=x1014}
C {devices/lab_wire.sym} 6580 -9240 2 1 {name=l4054 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -9250 1 1 {name=l4055 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -9250 3 0 {name=l4056 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -9000 0 0 {name=l4057 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -9120 0 0 {name=x1015}
C {devices/lab_wire.sym} 6840 -9240 2 1 {name=l4058 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -9250 1 1 {name=l4059 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -9250 3 0 {name=l4060 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -9000 0 0 {name=l4061 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -9120 0 0 {name=x1016}
C {devices/lab_wire.sym} 7100 -9240 2 1 {name=l4062 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -9250 1 1 {name=l4063 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -9250 3 0 {name=l4064 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -9000 0 0 {name=l4065 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -9120 0 0 {name=x1017}
C {devices/lab_wire.sym} 7360 -9240 2 1 {name=l4066 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -9250 1 1 {name=l4067 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -9250 3 0 {name=l4068 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -9000 0 0 {name=l4069 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -9120 0 0 {name=x1018}
C {devices/lab_wire.sym} 7620 -9240 2 1 {name=l4070 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -9250 1 1 {name=l4071 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -9250 3 0 {name=l4072 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -9000 0 0 {name=l4073 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -9120 0 0 {name=x1019}
C {devices/lab_wire.sym} 7880 -9240 2 1 {name=l4074 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -9250 1 1 {name=l4075 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -9250 3 0 {name=l4076 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -9000 0 0 {name=l4077 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -9120 0 0 {name=x1020}
C {devices/lab_wire.sym} 8140 -9240 2 1 {name=l4078 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -9250 1 1 {name=l4079 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -9250 3 0 {name=l4080 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -9000 0 0 {name=l4081 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -9120 0 0 {name=x1021}
C {devices/lab_wire.sym} 8400 -9240 2 1 {name=l4082 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -9250 1 1 {name=l4083 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -9250 3 0 {name=l4084 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -9000 0 0 {name=l4085 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -9120 0 0 {name=x1022}
C {devices/lab_wire.sym} 8660 -9240 2 1 {name=l4086 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -9250 1 1 {name=l4087 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -9250 3 0 {name=l4088 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -9000 0 0 {name=l4089 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -9120 0 0 {name=x1023}
C {devices/lab_wire.sym} 8920 -9240 2 1 {name=l4090 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -9250 1 1 {name=l4091 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -9250 3 0 {name=l4092 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -9000 0 0 {name=l4093 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -9120 0 0 {name=x1024}
C {devices/lab_wire.sym} 9180 -9240 2 1 {name=l4094 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -9250 1 1 {name=l4095 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -9250 3 0 {name=l4096 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -9000 0 0 {name=l4097 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -1060 0 0 {name=x1025}
C {devices/lab_wire.sym} 860 -1180 2 1 {name=l4098 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -1190 1 1 {name=l4099 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -1190 3 0 {name=l4100 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -940 0 0 {name=l4101 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -1030 0 0 {name=l4102 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -1090 0 0 {name=l4105 sig_type=std_logic lab=col_n[0]}
C {devices/lab_wire.sym} 800 -1070 0 0 {name=l4104 sig_type=std_logic lab=colon_n[0]}
C {devices/lab_wire.sym} 800 -1050 0 0 {name=l4103 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -1320 0 0 {name=x1026}
C {devices/lab_wire.sym} 860 -1440 2 1 {name=l4106 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -1450 1 1 {name=l4107 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -1450 3 0 {name=l4108 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -1200 0 0 {name=l4109 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -1290 0 0 {name=l4110 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -1350 0 0 {name=l4111 sig_type=std_logic lab=col_n[1]}
C {devices/lab_wire.sym} 800 -1330 0 0 {name=l4112 sig_type=std_logic lab=colon_n[1]}
C {devices/lab_wire.sym} 800 -1310 0 0 {name=l4113 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -1580 0 0 {name=x1027}
C {devices/lab_wire.sym} 860 -1700 2 1 {name=l4114 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -1710 1 1 {name=l4115 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -1710 3 0 {name=l4116 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -1460 0 0 {name=l4117 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -1550 0 0 {name=l4118 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -1610 0 0 {name=l4119 sig_type=std_logic lab=col_n[2]}
C {devices/lab_wire.sym} 800 -1590 0 0 {name=l4120 sig_type=std_logic lab=colon_n[2]}
C {devices/lab_wire.sym} 800 -1570 0 0 {name=l4121 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -1840 0 0 {name=x1028}
C {devices/lab_wire.sym} 860 -1960 2 1 {name=l4122 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -1970 1 1 {name=l4123 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -1970 3 0 {name=l4124 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -2100 0 0 {name=x1029}
C {devices/lab_wire.sym} 860 -2220 2 1 {name=l4129 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -2230 1 1 {name=l4130 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -2230 3 0 {name=l4131 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -1980 0 0 {name=l4132 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -1810 0 0 {name=l4133 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -1870 0 0 {name=l4134 sig_type=std_logic lab=col_n[3]}
C {devices/lab_wire.sym} 800 -1850 0 0 {name=l4135 sig_type=std_logic lab=colon_n[3]}
C {devices/lab_wire.sym} 800 -1830 0 0 {name=l4136 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 860 -1720 0 0 {name=l4137 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -2360 0 0 {name=x1030}
C {devices/lab_wire.sym} 860 -2480 2 1 {name=l4138 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -2490 1 1 {name=l4139 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -2490 3 0 {name=l4140 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -2240 0 0 {name=l4141 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -2070 0 0 {name=l4142 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -2130 0 0 {name=l4143 sig_type=std_logic lab=col_n[4]}
C {devices/lab_wire.sym} 800 -2110 0 0 {name=l4144 sig_type=std_logic lab=colon_n[4]}
C {devices/lab_wire.sym} 800 -2090 0 0 {name=l4145 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -2620 0 0 {name=x1031}
C {devices/lab_wire.sym} 860 -2740 2 1 {name=l4146 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -2750 1 1 {name=l4147 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -2750 3 0 {name=l4148 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -2500 0 0 {name=l4149 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -2330 0 0 {name=l4150 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -2390 0 0 {name=l4151 sig_type=std_logic lab=col_n[5]}
C {devices/lab_wire.sym} 800 -2370 0 0 {name=l4152 sig_type=std_logic lab=colon_n[5]}
C {devices/lab_wire.sym} 800 -2350 0 0 {name=l4153 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -2880 0 0 {name=x1032}
C {devices/lab_wire.sym} 860 -3000 2 1 {name=l4154 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -3010 1 1 {name=l4155 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -3010 3 0 {name=l4156 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -2760 0 0 {name=l4157 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -2590 0 0 {name=l4158 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -2650 0 0 {name=l4159 sig_type=std_logic lab=col_n[6]}
C {devices/lab_wire.sym} 800 -2630 0 0 {name=l4160 sig_type=std_logic lab=colon_n[6]}
C {devices/lab_wire.sym} 800 -2610 0 0 {name=l4161 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -3140 0 0 {name=x1033}
C {devices/lab_wire.sym} 860 -3260 2 1 {name=l4162 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -3270 1 1 {name=l4163 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -3270 3 0 {name=l4164 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 800 -2850 0 0 {name=l4165 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -2910 0 0 {name=l4166 sig_type=std_logic lab=col_n[7]}
C {devices/lab_wire.sym} 800 -2890 0 0 {name=l4167 sig_type=std_logic lab=colon_n[7]}
C {devices/lab_wire.sym} 800 -2870 0 0 {name=l4168 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -3400 0 0 {name=x1034}
C {devices/lab_wire.sym} 860 -3520 2 1 {name=l4169 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -3530 1 1 {name=l4170 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -3530 3 0 {name=l4171 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -3280 0 0 {name=l4172 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -3110 0 0 {name=l4173 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -3170 0 0 {name=l4174 sig_type=std_logic lab=col_n[8]}
C {devices/lab_wire.sym} 800 -3150 0 0 {name=l4175 sig_type=std_logic lab=colon_n[8]}
C {devices/lab_wire.sym} 800 -3130 0 0 {name=l4176 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 860 -3020 0 0 {name=l4177 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -3660 0 0 {name=x1035}
C {devices/lab_wire.sym} 860 -3780 2 1 {name=l4178 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -3790 1 1 {name=l4179 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -3790 3 0 {name=l4180 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -3540 0 0 {name=l4181 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -3370 0 0 {name=l4182 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -3430 0 0 {name=l4183 sig_type=std_logic lab=col_n[9]}
C {devices/lab_wire.sym} 800 -3410 0 0 {name=l4184 sig_type=std_logic lab=colon_n[9]}
C {devices/lab_wire.sym} 800 -3390 0 0 {name=l4185 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -3920 0 0 {name=x1036}
C {devices/lab_wire.sym} 860 -4040 2 1 {name=l4186 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -4050 1 1 {name=l4187 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -4050 3 0 {name=l4188 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -3800 0 0 {name=l4189 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -3630 0 0 {name=l4190 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -3690 0 0 {name=l4191 sig_type=std_logic lab=col_n[10]}
C {devices/lab_wire.sym} 800 -3670 0 0 {name=l4192 sig_type=std_logic lab=colon_n[10]}
C {devices/lab_wire.sym} 800 -3650 0 0 {name=l4193 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -4180 0 0 {name=x1037}
C {devices/lab_wire.sym} 860 -4300 2 1 {name=l4194 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -4310 1 1 {name=l4195 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -4310 3 0 {name=l4196 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -4060 0 0 {name=l4197 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -3890 0 0 {name=l4198 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -3950 0 0 {name=l4199 sig_type=std_logic lab=col_n[11]}
C {devices/lab_wire.sym} 800 -3930 0 0 {name=l4200 sig_type=std_logic lab=colon_n[11]}
C {devices/lab_wire.sym} 800 -3910 0 0 {name=l4201 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -4440 0 0 {name=x1038}
C {devices/lab_wire.sym} 860 -4560 2 1 {name=l4202 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -4570 1 1 {name=l4203 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -4570 3 0 {name=l4204 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 800 -4150 0 0 {name=l4205 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -4210 0 0 {name=l4206 sig_type=std_logic lab=col_n[12]}
C {devices/lab_wire.sym} 800 -4190 0 0 {name=l4207 sig_type=std_logic lab=colon_n[12]}
C {devices/lab_wire.sym} 800 -4170 0 0 {name=l4208 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -4700 0 0 {name=x1039}
C {devices/lab_wire.sym} 860 -4820 2 1 {name=l4209 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -4830 1 1 {name=l4210 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -4830 3 0 {name=l4211 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -4580 0 0 {name=l4212 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -4410 0 0 {name=l4213 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -4470 0 0 {name=l4214 sig_type=std_logic lab=col_n[13]}
C {devices/lab_wire.sym} 800 -4450 0 0 {name=l4215 sig_type=std_logic lab=colon_n[13]}
C {devices/lab_wire.sym} 800 -4430 0 0 {name=l4216 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 860 -4320 0 0 {name=l4217 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -4960 0 0 {name=x1040}
C {devices/lab_wire.sym} 860 -5080 2 1 {name=l4218 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -5090 1 1 {name=l4219 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -5090 3 0 {name=l4220 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -4840 0 0 {name=l4221 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -4670 0 0 {name=l4222 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -4730 0 0 {name=l4223 sig_type=std_logic lab=col_n[14]}
C {devices/lab_wire.sym} 800 -4710 0 0 {name=l4224 sig_type=std_logic lab=colon_n[14]}
C {devices/lab_wire.sym} 800 -4690 0 0 {name=l4225 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -5220 0 0 {name=x1041}
C {devices/lab_wire.sym} 860 -5340 2 1 {name=l4226 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -5350 1 1 {name=l4227 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -5350 3 0 {name=l4228 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -5100 0 0 {name=l4229 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -4930 0 0 {name=l4230 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -4990 0 0 {name=l4231 sig_type=std_logic lab=col_n[15]}
C {devices/lab_wire.sym} 800 -4970 0 0 {name=l4232 sig_type=std_logic lab=colon_n[15]}
C {devices/lab_wire.sym} 800 -4950 0 0 {name=l4233 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -5480 0 0 {name=x1042}
C {devices/lab_wire.sym} 860 -5600 2 1 {name=l4234 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -5610 1 1 {name=l4235 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -5610 3 0 {name=l4236 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -5360 0 0 {name=l4237 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -5190 0 0 {name=l4238 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -5250 0 0 {name=l4239 sig_type=std_logic lab=col_n[16]}
C {devices/lab_wire.sym} 800 -5230 0 0 {name=l4240 sig_type=std_logic lab=colon_n[16]}
C {devices/lab_wire.sym} 800 -5210 0 0 {name=l4241 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -5740 0 0 {name=x1043}
C {devices/lab_wire.sym} 860 -5860 2 1 {name=l4242 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -5870 1 1 {name=l4243 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -5870 3 0 {name=l4244 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 800 -5450 0 0 {name=l4245 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -5510 0 0 {name=l4246 sig_type=std_logic lab=col_n[17]}
C {devices/lab_wire.sym} 800 -5490 0 0 {name=l4247 sig_type=std_logic lab=colon_n[17]}
C {devices/lab_wire.sym} 800 -5470 0 0 {name=l4248 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -6000 0 0 {name=x1044}
C {devices/lab_wire.sym} 860 -6120 2 1 {name=l4249 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -6130 1 1 {name=l4250 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -6130 3 0 {name=l4251 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -5880 0 0 {name=l4252 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -5710 0 0 {name=l4253 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -5770 0 0 {name=l4254 sig_type=std_logic lab=col_n[18]}
C {devices/lab_wire.sym} 800 -5750 0 0 {name=l4255 sig_type=std_logic lab=colon_n[18]}
C {devices/lab_wire.sym} 800 -5730 0 0 {name=l4256 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 860 -5620 0 0 {name=l4257 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -6260 0 0 {name=x1045}
C {devices/lab_wire.sym} 860 -6380 2 1 {name=l4258 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -6390 1 1 {name=l4259 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -6390 3 0 {name=l4260 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -6140 0 0 {name=l4261 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -5970 0 0 {name=l4262 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -6030 0 0 {name=l4263 sig_type=std_logic lab=col_n[19]}
C {devices/lab_wire.sym} 800 -6010 0 0 {name=l4264 sig_type=std_logic lab=colon_n[19]}
C {devices/lab_wire.sym} 800 -5990 0 0 {name=l4265 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -6520 0 0 {name=x1046}
C {devices/lab_wire.sym} 860 -6640 2 1 {name=l4266 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -6650 1 1 {name=l4267 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -6650 3 0 {name=l4268 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -6400 0 0 {name=l4269 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -6230 0 0 {name=l4270 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -6290 0 0 {name=l4271 sig_type=std_logic lab=col_n[20]}
C {devices/lab_wire.sym} 800 -6270 0 0 {name=l4272 sig_type=std_logic lab=colon_n[20]}
C {devices/lab_wire.sym} 800 -6250 0 0 {name=l4273 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -6780 0 0 {name=x1047}
C {devices/lab_wire.sym} 860 -6900 2 1 {name=l4274 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -6910 1 1 {name=l4275 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -6910 3 0 {name=l4276 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -6660 0 0 {name=l4277 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -6490 0 0 {name=l4278 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -6550 0 0 {name=l4279 sig_type=std_logic lab=col_n[21]}
C {devices/lab_wire.sym} 800 -6530 0 0 {name=l4280 sig_type=std_logic lab=colon_n[21]}
C {devices/lab_wire.sym} 800 -6510 0 0 {name=l4281 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -7040 0 0 {name=x1048}
C {devices/lab_wire.sym} 860 -7160 2 1 {name=l4282 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -7170 1 1 {name=l4283 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -7170 3 0 {name=l4284 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 800 -6750 0 0 {name=l4285 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -6810 0 0 {name=l4286 sig_type=std_logic lab=col_n[22]}
C {devices/lab_wire.sym} 800 -6790 0 0 {name=l4287 sig_type=std_logic lab=colon_n[22]}
C {devices/lab_wire.sym} 800 -6770 0 0 {name=l4288 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -7300 0 0 {name=x1049}
C {devices/lab_wire.sym} 860 -7420 2 1 {name=l4289 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -7430 1 1 {name=l4290 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -7430 3 0 {name=l4291 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -7180 0 0 {name=l4292 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -7010 0 0 {name=l4293 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -7070 0 0 {name=l4294 sig_type=std_logic lab=col_n[23]}
C {devices/lab_wire.sym} 800 -7050 0 0 {name=l4295 sig_type=std_logic lab=colon_n[23]}
C {devices/lab_wire.sym} 800 -7030 0 0 {name=l4296 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 860 -6920 0 0 {name=l4297 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -7560 0 0 {name=x1050}
C {devices/lab_wire.sym} 860 -7680 2 1 {name=l4298 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -7690 1 1 {name=l4299 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -7690 3 0 {name=l4300 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -7440 0 0 {name=l4301 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -7270 0 0 {name=l4302 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -7330 0 0 {name=l4303 sig_type=std_logic lab=col_n[24]}
C {devices/lab_wire.sym} 800 -7310 0 0 {name=l4304 sig_type=std_logic lab=colon_n[24]}
C {devices/lab_wire.sym} 800 -7290 0 0 {name=l4305 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -7820 0 0 {name=x1051}
C {devices/lab_wire.sym} 860 -7940 2 1 {name=l4306 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -7950 1 1 {name=l4307 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -7950 3 0 {name=l4308 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -7700 0 0 {name=l4309 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -7530 0 0 {name=l4310 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -7590 0 0 {name=l4311 sig_type=std_logic lab=col_n[25]}
C {devices/lab_wire.sym} 800 -7570 0 0 {name=l4312 sig_type=std_logic lab=colon_n[25]}
C {devices/lab_wire.sym} 800 -7550 0 0 {name=l4313 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -8080 0 0 {name=x1052}
C {devices/lab_wire.sym} 860 -8200 2 1 {name=l4314 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -8210 1 1 {name=l4315 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -8210 3 0 {name=l4316 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -7960 0 0 {name=l4317 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -7790 0 0 {name=l4318 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -7850 0 0 {name=l4319 sig_type=std_logic lab=col_n[26]}
C {devices/lab_wire.sym} 800 -7830 0 0 {name=l4320 sig_type=std_logic lab=colon_n[26]}
C {devices/lab_wire.sym} 800 -7810 0 0 {name=l4321 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -8340 0 0 {name=x1053}
C {devices/lab_wire.sym} 860 -8460 2 1 {name=l4322 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -8470 1 1 {name=l4323 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -8470 3 0 {name=l4324 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 800 -8050 0 0 {name=l4325 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -8110 0 0 {name=l4326 sig_type=std_logic lab=col_n[27]}
C {devices/lab_wire.sym} 800 -8090 0 0 {name=l4327 sig_type=std_logic lab=colon_n[27]}
C {devices/lab_wire.sym} 800 -8070 0 0 {name=l4328 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -8600 0 0 {name=x1054}
C {devices/lab_wire.sym} 860 -8720 2 1 {name=l4329 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -8730 1 1 {name=l4330 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -8730 3 0 {name=l4331 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -8480 0 0 {name=l4332 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -8310 0 0 {name=l4333 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -8370 0 0 {name=l4334 sig_type=std_logic lab=col_n[28]}
C {devices/lab_wire.sym} 800 -8350 0 0 {name=l4335 sig_type=std_logic lab=colon_n[28]}
C {devices/lab_wire.sym} 800 -8330 0 0 {name=l4336 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 860 -8220 0 0 {name=l4337 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -8860 0 0 {name=x1055}
C {devices/lab_wire.sym} 860 -8980 2 1 {name=l4338 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -8990 1 1 {name=l4339 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -8990 3 0 {name=l4340 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -8740 0 0 {name=l4341 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -8570 0 0 {name=l4342 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -8630 0 0 {name=l4343 sig_type=std_logic lab=col_n[29]}
C {devices/lab_wire.sym} 800 -8610 0 0 {name=l4344 sig_type=std_logic lab=colon_n[29]}
C {devices/lab_wire.sym} 800 -8590 0 0 {name=l4345 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_drv.sym} 930 -9120 0 0 {name=x1056}
C {devices/lab_wire.sym} 860 -9240 2 1 {name=l4346 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -9250 1 1 {name=l4347 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -9250 3 0 {name=l4348 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -9000 0 0 {name=l4349 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -8830 0 0 {name=l4350 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -8890 0 0 {name=l4351 sig_type=std_logic lab=col_n[30]}
C {devices/lab_wire.sym} 800 -8870 0 0 {name=l4352 sig_type=std_logic lab=colon_n[30]}
C {devices/lab_wire.sym} 800 -8850 0 0 {name=l4353 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 930 -800 0 0 {name=x1057}
C {devices/lab_wire.sym} 860 -680 0 0 {name=l4354 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 860 -920 2 1 {name=l4355 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -930 1 1 {name=l4356 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 1190 -800 0 0 {name=x1058}
C {devices/lab_wire.sym} 1120 -680 0 0 {name=l4359 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1120 -920 2 1 {name=l4360 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -930 1 1 {name=l4361 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1200 -670 3 0 {name=l4363 sig_type=std_logic lab=row_n[0]}
C {devices/lab_wire.sym} 920 -930 3 0 {name=l4357 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1180 -930 3 0 {name=l4362 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 1450 -800 0 0 {name=x1059}
C {devices/lab_wire.sym} 1380 -680 0 0 {name=l4364 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1380 -920 2 1 {name=l4365 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -930 1 1 {name=l4366 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1460 -670 3 0 {name=l4367 sig_type=std_logic lab=row_n[1]}
C {devices/lab_wire.sym} 1640 -680 0 0 {name=l4368 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1640 -920 2 1 {name=l4369 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -930 1 1 {name=l4370 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1720 -670 3 0 {name=l4371 sig_type=std_logic lab=row_n[2]}
C {devices/lab_wire.sym} 1440 -930 3 0 {name=l4372 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1700 -930 3 0 {name=l4373 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 1970 -800 0 0 {name=x1061}
C {devices/lab_wire.sym} 1900 -680 0 0 {name=l4374 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1900 -920 2 1 {name=l4375 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -930 1 1 {name=l4376 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1980 -670 3 0 {name=l4377 sig_type=std_logic lab=row_n[3]}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 2230 -800 0 0 {name=x1062}
C {devices/lab_wire.sym} 2160 -680 0 0 {name=l4378 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2160 -920 2 1 {name=l4379 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -930 1 1 {name=l4380 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2240 -670 3 0 {name=l4381 sig_type=std_logic lab=row_n[4]}
C {devices/lab_wire.sym} 1960 -930 3 0 {name=l4382 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2220 -930 3 0 {name=l4383 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 2490 -800 0 0 {name=x1063}
C {devices/lab_wire.sym} 2420 -680 0 0 {name=l4384 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2420 -920 2 1 {name=l4385 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -930 1 1 {name=l4386 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2500 -670 3 0 {name=l4387 sig_type=std_logic lab=row_n[5]}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 2750 -800 0 0 {name=x1064}
C {devices/lab_wire.sym} 2680 -680 0 0 {name=l4388 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2680 -920 2 1 {name=l4389 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -930 1 1 {name=l4390 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2760 -670 3 0 {name=l4391 sig_type=std_logic lab=row_n[6]}
C {devices/lab_wire.sym} 2480 -930 3 0 {name=l4392 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2740 -930 3 0 {name=l4393 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 3010 -800 0 0 {name=x1065}
C {devices/lab_wire.sym} 2940 -680 0 0 {name=l4394 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2940 -920 2 1 {name=l4395 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -930 1 1 {name=l4396 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3020 -670 3 0 {name=l4397 sig_type=std_logic lab=row_n[7]}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 3270 -800 0 0 {name=x1066}
C {devices/lab_wire.sym} 3200 -680 0 0 {name=l4398 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3200 -920 2 1 {name=l4399 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -930 1 1 {name=l4400 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3280 -670 3 0 {name=l4401 sig_type=std_logic lab=row_n[8]}
C {devices/lab_wire.sym} 3000 -930 3 0 {name=l4402 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3260 -930 3 0 {name=l4403 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 3530 -800 0 0 {name=x1067}
C {devices/lab_wire.sym} 3460 -680 0 0 {name=l4404 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3460 -920 2 1 {name=l4405 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -930 1 1 {name=l4406 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3540 -670 3 0 {name=l4407 sig_type=std_logic lab=row_n[9]}
C {devices/lab_wire.sym} 3720 -680 0 0 {name=l4408 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3720 -920 2 1 {name=l4409 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -930 1 1 {name=l4410 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3800 -670 3 0 {name=l4411 sig_type=std_logic lab=row_n[10]}
C {devices/lab_wire.sym} 3520 -930 3 0 {name=l4412 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3780 -930 3 0 {name=l4413 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 4050 -800 0 0 {name=x1069}
C {devices/lab_wire.sym} 3980 -680 0 0 {name=l4414 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3980 -920 2 1 {name=l4415 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -930 1 1 {name=l4416 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4060 -670 3 0 {name=l4417 sig_type=std_logic lab=row_n[11]}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 4310 -800 0 0 {name=x1070}
C {devices/lab_wire.sym} 4240 -680 0 0 {name=l4418 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4240 -920 2 1 {name=l4419 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -930 1 1 {name=l4420 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4320 -670 3 0 {name=l4421 sig_type=std_logic lab=row_n[12]}
C {devices/lab_wire.sym} 4040 -930 3 0 {name=l4422 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4300 -930 3 0 {name=l4423 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 4570 -800 0 0 {name=x1071}
C {devices/lab_wire.sym} 4500 -680 0 0 {name=l4424 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4500 -920 2 1 {name=l4425 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -930 1 1 {name=l4426 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4580 -670 3 0 {name=l4427 sig_type=std_logic lab=row_n[13]}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 4830 -800 0 0 {name=x1072}
C {devices/lab_wire.sym} 4760 -680 0 0 {name=l4428 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4760 -920 2 1 {name=l4429 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -930 1 1 {name=l4430 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4840 -670 3 0 {name=l4431 sig_type=std_logic lab=row_n[14]}
C {devices/lab_wire.sym} 4560 -930 3 0 {name=l4432 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4820 -930 3 0 {name=l4433 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 5090 -800 0 0 {name=x1073}
C {devices/lab_wire.sym} 5020 -680 0 0 {name=l4434 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5020 -920 2 1 {name=l4435 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -930 1 1 {name=l4436 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5100 -670 3 0 {name=l4437 sig_type=std_logic lab=row_n[15]}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 5350 -800 0 0 {name=x1074}
C {devices/lab_wire.sym} 5280 -680 0 0 {name=l4438 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5280 -920 2 1 {name=l4439 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -930 1 1 {name=l4440 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5360 -670 3 0 {name=l4441 sig_type=std_logic lab=row_n[16]}
C {devices/lab_wire.sym} 5080 -930 3 0 {name=l4442 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5340 -930 3 0 {name=l4443 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 5610 -800 0 0 {name=x1075}
C {devices/lab_wire.sym} 5540 -680 0 0 {name=l4444 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5540 -920 2 1 {name=l4445 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -930 1 1 {name=l4446 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5620 -670 3 0 {name=l4447 sig_type=std_logic lab=row_n[17]}
C {devices/lab_wire.sym} 5800 -680 0 0 {name=l4448 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5800 -920 2 1 {name=l4449 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -930 1 1 {name=l4450 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5880 -670 3 0 {name=l4451 sig_type=std_logic lab=row_n[18]}
C {devices/lab_wire.sym} 5600 -930 3 0 {name=l4452 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5860 -930 3 0 {name=l4453 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 6130 -800 0 0 {name=x1077}
C {devices/lab_wire.sym} 6060 -680 0 0 {name=l4454 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6060 -920 2 1 {name=l4455 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -930 1 1 {name=l4456 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6140 -670 3 0 {name=l4457 sig_type=std_logic lab=row_n[19]}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 6390 -800 0 0 {name=x1078}
C {devices/lab_wire.sym} 6320 -680 0 0 {name=l4458 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6320 -920 2 1 {name=l4459 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -930 1 1 {name=l4460 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6400 -670 3 0 {name=l4461 sig_type=std_logic lab=row_n[20]}
C {devices/lab_wire.sym} 6120 -930 3 0 {name=l4462 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6380 -930 3 0 {name=l4463 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 6650 -800 0 0 {name=x1079}
C {devices/lab_wire.sym} 6580 -680 0 0 {name=l4464 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6580 -920 2 1 {name=l4465 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -930 1 1 {name=l4466 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6660 -670 3 0 {name=l4467 sig_type=std_logic lab=row_n[21]}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 6910 -800 0 0 {name=x1080}
C {devices/lab_wire.sym} 6840 -680 0 0 {name=l4468 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6840 -920 2 1 {name=l4469 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -930 1 1 {name=l4470 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6920 -670 3 0 {name=l4471 sig_type=std_logic lab=row_n[22]}
C {devices/lab_wire.sym} 6640 -930 3 0 {name=l4472 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6900 -930 3 0 {name=l4473 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 7170 -800 0 0 {name=x1081}
C {devices/lab_wire.sym} 7100 -680 0 0 {name=l4474 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 7100 -920 2 1 {name=l4475 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -930 1 1 {name=l4476 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7180 -670 3 0 {name=l4477 sig_type=std_logic lab=row_n[23]}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 7430 -800 0 0 {name=x1082}
C {devices/lab_wire.sym} 7360 -680 0 0 {name=l4478 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 7360 -920 2 1 {name=l4479 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -930 1 1 {name=l4480 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7440 -670 3 0 {name=l4481 sig_type=std_logic lab=row_n[24]}
C {devices/lab_wire.sym} 7160 -930 3 0 {name=l4482 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7420 -930 3 0 {name=l4483 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 7690 -800 0 0 {name=x1083}
C {devices/lab_wire.sym} 7620 -680 0 0 {name=l4484 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 7620 -920 2 1 {name=l4485 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -930 1 1 {name=l4486 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7700 -670 3 0 {name=l4487 sig_type=std_logic lab=row_n[25]}
C {devices/lab_wire.sym} 7880 -680 0 0 {name=l4488 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 7880 -920 2 1 {name=l4489 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -930 1 1 {name=l4490 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7960 -670 3 0 {name=l4491 sig_type=std_logic lab=row_n[26]}
C {devices/lab_wire.sym} 7680 -930 3 0 {name=l4492 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7940 -930 3 0 {name=l4493 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 8210 -800 0 0 {name=x1085}
C {devices/lab_wire.sym} 8140 -680 0 0 {name=l4494 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8140 -920 2 1 {name=l4495 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -930 1 1 {name=l4496 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8220 -670 3 0 {name=l4497 sig_type=std_logic lab=row_n[27]}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 8470 -800 0 0 {name=x1086}
C {devices/lab_wire.sym} 8400 -680 0 0 {name=l4498 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8400 -920 2 1 {name=l4499 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -930 1 1 {name=l4500 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8480 -670 3 0 {name=l4501 sig_type=std_logic lab=row_n[28]}
C {devices/lab_wire.sym} 8200 -930 3 0 {name=l4502 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8460 -930 3 0 {name=l4503 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 8730 -800 0 0 {name=x1087}
C {devices/lab_wire.sym} 8660 -680 0 0 {name=l4504 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8660 -920 2 1 {name=l4505 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -930 1 1 {name=l4506 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8740 -670 3 0 {name=l4507 sig_type=std_logic lab=row_n[29]}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 8990 -800 0 0 {name=x1088}
C {devices/lab_wire.sym} 8920 -680 0 0 {name=l4508 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8920 -920 2 1 {name=l4509 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -930 1 1 {name=l4510 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9000 -670 3 0 {name=l4511 sig_type=std_logic lab=row_n[30]}
C {devices/lab_wire.sym} 8720 -930 3 0 {name=l4512 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8980 -930 3 0 {name=l4513 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9250 -800 0 0 {name=x1089}
C {devices/lab_wire.sym} 9180 -680 0 0 {name=l4514 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9180 -920 2 1 {name=l4515 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -930 1 1 {name=l4516 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9260 -670 3 0 {name=l4517 sig_type=std_logic lab=row_n[31]}
C {devices/lab_wire.sym} 9240 -930 3 0 {name=l4518 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -800 0 0 {name=x1090}
C {devices/lab_wire.sym} 9440 -680 0 0 {name=l4519 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -920 2 1 {name=l4520 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -930 1 1 {name=l4521 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9520 -670 3 0 {name=l4522 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9500 -930 3 0 {name=l4523 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 930 -9380 0 0 {name=x1091}
C {devices/lab_wire.sym} 860 -9260 0 0 {name=l4524 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 860 -9500 2 1 {name=l4525 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -9510 1 1 {name=l4526 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 1190 -9380 0 0 {name=x1092}
C {devices/lab_wire.sym} 1120 -9260 0 0 {name=l4528 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1120 -9500 2 1 {name=l4529 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -9510 1 1 {name=l4530 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -9510 3 0 {name=l4532 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1180 -9510 3 0 {name=l4533 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 1450 -9380 0 0 {name=x1093}
C {devices/lab_wire.sym} 1380 -9260 0 0 {name=l4534 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1380 -9500 2 1 {name=l4535 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -9510 1 1 {name=l4536 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 1710 -9380 0 0 {name=x1094}
C {devices/lab_wire.sym} 1640 -9260 0 0 {name=l4538 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1640 -9500 2 1 {name=l4539 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -9510 1 1 {name=l4540 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -9510 3 0 {name=l4542 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1700 -9510 3 0 {name=l4543 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 1970 -9380 0 0 {name=x1095}
C {devices/lab_wire.sym} 1900 -9260 0 0 {name=l4544 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1900 -9500 2 1 {name=l4545 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -9510 1 1 {name=l4546 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 2230 -9380 0 0 {name=x1096}
C {devices/lab_wire.sym} 2160 -9260 0 0 {name=l4548 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2160 -9500 2 1 {name=l4549 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -9510 1 1 {name=l4550 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -9510 3 0 {name=l4552 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2220 -9510 3 0 {name=l4553 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 2490 -9380 0 0 {name=x1097}
C {devices/lab_wire.sym} 2420 -9260 0 0 {name=l4554 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2420 -9500 2 1 {name=l4555 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -9510 1 1 {name=l4556 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 2750 -9380 0 0 {name=x1098}
C {devices/lab_wire.sym} 2680 -9260 0 0 {name=l4558 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2680 -9500 2 1 {name=l4559 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -9510 1 1 {name=l4560 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -9510 3 0 {name=l4562 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2740 -9510 3 0 {name=l4563 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 3010 -9380 0 0 {name=x1099}
C {devices/lab_wire.sym} 2940 -9260 0 0 {name=l4564 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2940 -9500 2 1 {name=l4565 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -9510 1 1 {name=l4566 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 3270 -9380 0 0 {name=x1100}
C {devices/lab_wire.sym} 3200 -9260 0 0 {name=l4568 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3200 -9500 2 1 {name=l4569 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -9510 1 1 {name=l4570 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -9510 3 0 {name=l4572 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3260 -9510 3 0 {name=l4573 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 3530 -9380 0 0 {name=x1101}
C {devices/lab_wire.sym} 3460 -9260 0 0 {name=l4574 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3460 -9500 2 1 {name=l4575 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -9510 1 1 {name=l4576 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 3790 -9380 0 0 {name=x1102}
C {devices/lab_wire.sym} 3720 -9260 0 0 {name=l4578 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3720 -9500 2 1 {name=l4579 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -9510 1 1 {name=l4580 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -9510 3 0 {name=l4582 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3780 -9510 3 0 {name=l4583 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 4050 -9380 0 0 {name=x1103}
C {devices/lab_wire.sym} 3980 -9260 0 0 {name=l4584 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3980 -9500 2 1 {name=l4585 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -9510 1 1 {name=l4586 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 4310 -9380 0 0 {name=x1104}
C {devices/lab_wire.sym} 4240 -9260 0 0 {name=l4588 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4240 -9500 2 1 {name=l4589 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -9510 1 1 {name=l4590 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -9510 3 0 {name=l4592 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4300 -9510 3 0 {name=l4593 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 4570 -9380 0 0 {name=x1105}
C {devices/lab_wire.sym} 4500 -9260 0 0 {name=l4594 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4500 -9500 2 1 {name=l4595 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -9510 1 1 {name=l4596 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 4830 -9380 0 0 {name=x1106}
C {devices/lab_wire.sym} 4760 -9260 0 0 {name=l4598 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4760 -9500 2 1 {name=l4599 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -9510 1 1 {name=l4600 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -9510 3 0 {name=l4602 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4820 -9510 3 0 {name=l4603 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 5090 -9380 0 0 {name=x1107}
C {devices/lab_wire.sym} 5020 -9260 0 0 {name=l4604 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5020 -9500 2 1 {name=l4605 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -9510 1 1 {name=l4606 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 5350 -9380 0 0 {name=x1108}
C {devices/lab_wire.sym} 5280 -9260 0 0 {name=l4608 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5280 -9500 2 1 {name=l4609 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -9510 1 1 {name=l4610 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -9510 3 0 {name=l4612 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5340 -9510 3 0 {name=l4613 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 5610 -9380 0 0 {name=x1109}
C {devices/lab_wire.sym} 5540 -9260 0 0 {name=l4614 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5540 -9500 2 1 {name=l4615 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -9510 1 1 {name=l4616 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 5870 -9380 0 0 {name=x1110}
C {devices/lab_wire.sym} 5800 -9260 0 0 {name=l4618 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5800 -9500 2 1 {name=l4619 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -9510 1 1 {name=l4620 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -9510 3 0 {name=l4622 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5860 -9510 3 0 {name=l4623 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 6130 -9380 0 0 {name=x1111}
C {devices/lab_wire.sym} 6060 -9260 0 0 {name=l4624 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6060 -9500 2 1 {name=l4625 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -9510 1 1 {name=l4626 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 6390 -9380 0 0 {name=x1112}
C {devices/lab_wire.sym} 6320 -9260 0 0 {name=l4628 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6320 -9500 2 1 {name=l4629 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -9510 1 1 {name=l4630 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -9510 3 0 {name=l4632 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6380 -9510 3 0 {name=l4633 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 6650 -9380 0 0 {name=x1113}
C {devices/lab_wire.sym} 6580 -9260 0 0 {name=l4634 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6580 -9500 2 1 {name=l4635 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -9510 1 1 {name=l4636 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 6910 -9380 0 0 {name=x1114}
C {devices/lab_wire.sym} 6840 -9260 0 0 {name=l4638 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6840 -9500 2 1 {name=l4639 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -9510 1 1 {name=l4640 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -9510 3 0 {name=l4642 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6900 -9510 3 0 {name=l4643 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 7170 -9380 0 0 {name=x1115}
C {devices/lab_wire.sym} 7100 -9260 0 0 {name=l4644 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 7100 -9500 2 1 {name=l4645 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -9510 1 1 {name=l4646 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 7430 -9380 0 0 {name=x1116}
C {devices/lab_wire.sym} 7360 -9260 0 0 {name=l4648 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 7360 -9500 2 1 {name=l4649 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -9510 1 1 {name=l4650 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -9510 3 0 {name=l4652 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7420 -9510 3 0 {name=l4653 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 7690 -9380 0 0 {name=x1117}
C {devices/lab_wire.sym} 7620 -9260 0 0 {name=l4654 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 7620 -9500 2 1 {name=l4655 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -9510 1 1 {name=l4656 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 7950 -9380 0 0 {name=x1118}
C {devices/lab_wire.sym} 7880 -9260 0 0 {name=l4658 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 7880 -9500 2 1 {name=l4659 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -9510 1 1 {name=l4660 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -9510 3 0 {name=l4662 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7940 -9510 3 0 {name=l4663 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 8210 -9380 0 0 {name=x1119}
C {devices/lab_wire.sym} 8140 -9260 0 0 {name=l4664 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8140 -9500 2 1 {name=l4665 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -9510 1 1 {name=l4666 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 8470 -9380 0 0 {name=x1120}
C {devices/lab_wire.sym} 8400 -9260 0 0 {name=l4668 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8400 -9500 2 1 {name=l4669 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -9510 1 1 {name=l4670 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -9510 3 0 {name=l4672 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8460 -9510 3 0 {name=l4673 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 8730 -9380 0 0 {name=x1121}
C {devices/lab_wire.sym} 8660 -9260 0 0 {name=l4674 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8660 -9500 2 1 {name=l4675 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -9510 1 1 {name=l4676 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 8990 -9380 0 0 {name=x1122}
C {devices/lab_wire.sym} 8920 -9260 0 0 {name=l4678 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8920 -9500 2 1 {name=l4679 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -9510 1 1 {name=l4680 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -9510 3 0 {name=l4682 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8980 -9510 3 0 {name=l4683 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9250 -9380 0 0 {name=x1123}
C {devices/lab_wire.sym} 9180 -9260 0 0 {name=l4684 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9180 -9500 2 1 {name=l4685 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -9510 1 1 {name=l4686 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -9510 3 0 {name=l4688 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -9380 0 0 {name=x1124}
C {devices/lab_wire.sym} 9440 -9260 0 0 {name=l4689 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -9500 2 1 {name=l4690 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -9510 1 1 {name=l4691 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -9510 3 0 {name=l4693 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -1060 0 0 {name=x1125}
C {devices/lab_wire.sym} 9440 -1180 2 1 {name=l4527 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -1190 1 1 {name=l4531 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -1190 3 0 {name=l4537 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -1320 0 0 {name=x1126}
C {devices/lab_wire.sym} 9440 -1440 2 1 {name=l4541 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -1450 1 1 {name=l4557 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -1450 3 0 {name=l4561 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -1580 0 0 {name=x1127}
C {devices/lab_wire.sym} 9440 -1700 2 1 {name=l4567 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -1710 1 1 {name=l4571 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -1710 3 0 {name=l4577 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -1840 0 0 {name=x1128}
C {devices/lab_wire.sym} 9440 -1960 2 1 {name=l4581 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -1970 1 1 {name=l4587 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -1970 3 0 {name=l4591 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -2100 0 0 {name=x1129}
C {devices/lab_wire.sym} 9440 -2220 2 1 {name=l4547 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -2230 1 1 {name=l4551 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -2230 3 0 {name=l4597 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -2360 0 0 {name=x1130}
C {devices/lab_wire.sym} 9440 -2480 2 1 {name=l4601 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -2490 1 1 {name=l4607 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -2490 3 0 {name=l4611 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -2620 0 0 {name=x1131}
C {devices/lab_wire.sym} 9440 -2740 2 1 {name=l4617 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -2750 1 1 {name=l4621 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -2750 3 0 {name=l4627 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -2880 0 0 {name=x1132}
C {devices/lab_wire.sym} 9440 -3000 2 1 {name=l4631 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -3010 1 1 {name=l4637 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -3010 3 0 {name=l4641 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -3140 0 0 {name=x1133}
C {devices/lab_wire.sym} 9440 -3260 2 1 {name=l4647 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -3270 1 1 {name=l4651 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -3270 3 0 {name=l4657 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -3400 0 0 {name=x1134}
C {devices/lab_wire.sym} 9440 -3520 2 1 {name=l4661 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -3530 1 1 {name=l4667 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -3530 3 0 {name=l4671 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -3660 0 0 {name=x1135}
C {devices/lab_wire.sym} 9440 -3780 2 1 {name=l4677 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -3790 1 1 {name=l4681 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -3790 3 0 {name=l4687 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -3920 0 0 {name=x1136}
C {devices/lab_wire.sym} 9440 -4040 2 1 {name=l4692 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -4050 1 1 {name=l4694 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -4050 3 0 {name=l4695 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -4180 0 0 {name=x1137}
C {devices/lab_wire.sym} 9440 -4300 2 1 {name=l4696 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -4310 1 1 {name=l4697 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -4310 3 0 {name=l4698 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -4440 0 0 {name=x1138}
C {devices/lab_wire.sym} 9440 -4560 2 1 {name=l4699 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -4570 1 1 {name=l4700 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -4570 3 0 {name=l4701 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -4700 0 0 {name=x1139}
C {devices/lab_wire.sym} 9440 -4820 2 1 {name=l4702 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -4830 1 1 {name=l4703 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -4830 3 0 {name=l4704 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -4960 0 0 {name=x1140}
C {devices/lab_wire.sym} 9440 -5080 2 1 {name=l4705 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -5090 1 1 {name=l4706 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -5090 3 0 {name=l4707 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -5220 0 0 {name=x1141}
C {devices/lab_wire.sym} 9440 -5340 2 1 {name=l4708 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -5350 1 1 {name=l4709 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -5350 3 0 {name=l4710 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -5480 0 0 {name=x1142}
C {devices/lab_wire.sym} 9440 -5600 2 1 {name=l4711 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -5610 1 1 {name=l4712 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -5610 3 0 {name=l4713 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -5740 0 0 {name=x1143}
C {devices/lab_wire.sym} 9440 -5860 2 1 {name=l4714 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -5870 1 1 {name=l4715 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -5870 3 0 {name=l4716 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -6000 0 0 {name=x1144}
C {devices/lab_wire.sym} 9440 -6120 2 1 {name=l4717 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -6130 1 1 {name=l4718 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -6130 3 0 {name=l4719 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -6260 0 0 {name=x1145}
C {devices/lab_wire.sym} 9440 -6380 2 1 {name=l4720 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -6390 1 1 {name=l4721 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -6390 3 0 {name=l4722 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -6520 0 0 {name=x1146}
C {devices/lab_wire.sym} 9440 -6640 2 1 {name=l4723 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -6650 1 1 {name=l4724 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -6650 3 0 {name=l4725 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -6780 0 0 {name=x1147}
C {devices/lab_wire.sym} 9440 -6900 2 1 {name=l4726 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -6910 1 1 {name=l4727 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -6910 3 0 {name=l4728 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -7040 0 0 {name=x1148}
C {devices/lab_wire.sym} 9440 -7160 2 1 {name=l4729 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -7170 1 1 {name=l4730 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -7170 3 0 {name=l4731 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -7300 0 0 {name=x1149}
C {devices/lab_wire.sym} 9440 -7420 2 1 {name=l4732 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -7430 1 1 {name=l4733 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -7430 3 0 {name=l4734 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -7560 0 0 {name=x1150}
C {devices/lab_wire.sym} 9440 -7680 2 1 {name=l4735 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -7690 1 1 {name=l4736 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -7690 3 0 {name=l4737 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -7820 0 0 {name=x1151}
C {devices/lab_wire.sym} 9440 -7940 2 1 {name=l4738 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -7950 1 1 {name=l4739 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -7950 3 0 {name=l4740 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -8080 0 0 {name=x1152}
C {devices/lab_wire.sym} 9440 -8200 2 1 {name=l4741 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -8210 1 1 {name=l4742 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -8210 3 0 {name=l4743 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -8340 0 0 {name=x1153}
C {devices/lab_wire.sym} 9440 -8460 2 1 {name=l4744 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -8470 1 1 {name=l4745 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -8470 3 0 {name=l4746 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -8600 0 0 {name=x1154}
C {devices/lab_wire.sym} 9440 -8720 2 1 {name=l4747 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -8730 1 1 {name=l4748 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -8730 3 0 {name=l4749 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -8860 0 0 {name=x1155}
C {devices/lab_wire.sym} 9440 -8980 2 1 {name=l4750 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -8990 1 1 {name=l4751 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -8990 3 0 {name=l4752 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_dummy.sym} 9510 -9120 0 0 {name=x1156}
C {devices/lab_wire.sym} 9440 -9240 2 1 {name=l4753 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -9250 1 1 {name=l4754 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -9250 3 0 {name=l4755 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 800 -9090 0 0 {name=l4125 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -9150 0 0 {name=l4126 sig_type=std_logic lab=col_n[31]}
C {devices/lab_wire.sym} 800 -9130 0 0 {name=l4127 sig_type=std_logic lab=colon_n[31]}
C {devices/lab_wire.sym} 800 -9110 0 0 {name=l4128 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 800 -830 0 0 {name=l4756 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 800 -810 0 0 {name=l4757 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 800 -770 0 0 {name=l4758 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 800 -790 0 0 {name=l4759 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -9410 0 0 {name=l4760 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 800 -9390 0 0 {name=l4761 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 800 -9350 0 0 {name=l4762 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 800 -9370 0 0 {name=l4763 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 940 -680 0 0 {name=l4358 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9440 -940 0 0 {name=l4764 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -1200 0 0 {name=l4765 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -1460 0 0 {name=l4766 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -1720 0 0 {name=l4767 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -1980 0 0 {name=l4768 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -2240 0 0 {name=l4769 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -2500 0 0 {name=l4770 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -2760 0 0 {name=l4771 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -3020 0 0 {name=l4772 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -3280 0 0 {name=l4773 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -3540 0 0 {name=l4774 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -3800 0 0 {name=l4775 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -4060 0 0 {name=l4776 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -4320 0 0 {name=l4777 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -4580 0 0 {name=l4778 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -4840 0 0 {name=l4779 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -5100 0 0 {name=l4780 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -5360 0 0 {name=l4781 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -5620 0 0 {name=l4782 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -5880 0 0 {name=l4783 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -6140 0 0 {name=l4784 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -6400 0 0 {name=l4785 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -6660 0 0 {name=l4786 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -6920 0 0 {name=l4787 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -7180 0 0 {name=l4788 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -7440 0 0 {name=l4789 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -7700 0 0 {name=l4790 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -7960 0 0 {name=l4791 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -8220 0 0 {name=l4792 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -8480 0 0 {name=l4793 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -8740 0 0 {name=l4794 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -9000 0 0 {name=l4795 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_bin.sym} 1710 -800 0 0 {name=x1060}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_bin.sym} 3790 -800 0 0 {name=x1068}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_bin.sym} 5870 -800 0 0 {name=x1076}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap_bin.sym} 7950 -800 0 0 {name=x1084}
C {devices/lab_wire.sym} 7910 -680 3 0 {name=l4796 sig_type=std_logic lab=en_n_bit[0]}
C {devices/lab_wire.sym} 5830 -670 3 0 {name=l4797 sig_type=std_logic lab=en_n_bit[1]}
C {devices/lab_wire.sym} 3750 -670 3 0 {name=l4798 sig_type=std_logic lab=en_n_bit[2]}
C {devices/lab_wire.sym} 1670 -670 3 0 {name=l4799 sig_type=std_logic lab=en_n_bit[3]}
