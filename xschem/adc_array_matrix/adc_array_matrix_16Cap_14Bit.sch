lab=row_n[3]}
N 1990 -900 1990 -700 {
lab=row_n[3]}
N 1980 -910 1990 -900 {
lab=row_n[3]}
N 1980 -930 1980 -910 {
lab=row_n[3]}
N 1860 -830 1870 -840 {
lab=VDD}
N 1870 -840 2070 -840 {
lab=VDD}
N 2070 -840 2080 -830 {
lab=VDD}
N 1860 -810 1870 -820 {
lab=VDD}
N 1870 -820 2070 -820 {
lab=VDD}
N 2070 -820 2080 -810 {
lab=VDD}
N 1860 -790 1870 -800 {
lab=VSS}
N 1870 -800 2070 -800 {
lab=VSS}
N 2070 -800 2080 -790 {
lab=VSS}
N 1860 -770 1870 -780 {
lab=VDD}
N 1870 -780 2070 -780 {
lab=VDD}
N 2070 -780 2080 -770 {
lab=VDD}
N 2080 -770 2100 -770 {
lab=VDD}
N 2080 -790 2100 -790 {
lab=VSS}
N 2080 -810 2100 -810 {
lab=VDD}
N 2080 -830 2100 -830 {
lab=VDD}
N 1840 -830 1860 -830 {
lab=VDD}
N 1840 -810 1860 -810 {
lab=VDD}
N 1840 -790 1860 -790 {
lab=VSS}
N 1840 -770 1860 -770 {
lab=VDD}
N 1900 -690 1900 -680 {
lab=VSS}
N 1920 -930 1920 -910 {
lab=vcom}
N 1900 -920 1900 -910 {
lab=VDD}
N 1980 -690 1980 -670 {
lab=row_n[3]}
N 2240 -690 2250 -700 {
lab=row_n[4]}
N 2250 -900 2250 -700 {
lab=row_n[4]}
N 2240 -910 2250 -900 {
lab=row_n[4]}
N 2240 -930 2240 -910 {
lab=row_n[4]}
N 2120 -830 2130 -840 {
lab=VDD}
N 2130 -840 2330 -840 {
lab=VDD}
N 2330 -840 2340 -830 {
lab=VDD}
N 2120 -810 2130 -820 {
lab=VDD}
N 2130 -820 2330 -820 {
lab=VDD}
N 2330 -820 2340 -810 {
lab=VDD}
N 2120 -790 2130 -800 {
lab=VSS}
N 2130 -800 2330 -800 {
lab=VSS}
N 2330 -800 2340 -790 {
lab=VSS}
N 2120 -770 2130 -780 {
lab=VDD}
N 2130 -780 2330 -780 {
lab=VDD}
N 2330 -780 2340 -770 {
lab=VDD}
N 2340 -770 2360 -770 {
lab=VDD}
N 2340 -790 2360 -790 {
lab=VSS}
N 2340 -810 2360 -810 {
lab=VDD}
N 2340 -830 2360 -830 {
lab=VDD}
N 2100 -830 2120 -830 {
lab=VDD}
N 2100 -810 2120 -810 {
lab=VDD}
N 2100 -790 2120 -790 {
lab=VSS}
N 2100 -770 2120 -770 {
lab=VDD}
N 2160 -690 2160 -680 {
lab=VSS}
N 2180 -930 2180 -910 {
lab=vcom}
N 2160 -920 2160 -910 {
lab=VDD}
N 2240 -690 2240 -670 {
lab=row_n[4]}
N 1960 -930 1960 -910 {
lab=ctop}
N 2220 -930 2220 -910 {
lab=ctop}
N 2500 -690 2510 -700 {
lab=row_n[5]}
N 2510 -900 2510 -700 {
lab=row_n[5]}
N 2500 -910 2510 -900 {
lab=row_n[5]}
N 2500 -930 2500 -910 {
lab=row_n[5]}
N 2380 -830 2390 -840 {
lab=VDD}
N 2390 -840 2590 -840 {
lab=VDD}
N 2590 -840 2600 -830 {
lab=VDD}
N 2380 -810 2390 -820 {
lab=VDD}
N 2390 -820 2590 -820 {
lab=VDD}
N 2590 -820 2600 -810 {
lab=VDD}
N 2380 -790 2390 -800 {
lab=VSS}
N 2390 -800 2590 -800 {
lab=VSS}
N 2590 -800 2600 -790 {
lab=VSS}
N 2380 -770 2390 -780 {
lab=VDD}
N 2390 -780 2590 -780 {
lab=VDD}
N 2590 -780 2600 -770 {
lab=VDD}
N 2600 -770 2620 -770 {
lab=VDD}
N 2600 -790 2620 -790 {
lab=VSS}
N 2600 -810 2620 -810 {
lab=VDD}
N 2600 -830 2620 -830 {
lab=VDD}
N 2360 -830 2380 -830 {
lab=VDD}
N 2360 -810 2380 -810 {
lab=VDD}
N 2360 -790 2380 -790 {
lab=VSS}
N 2360 -770 2380 -770 {
lab=VDD}
N 2420 -690 2420 -680 {
lab=VSS}
N 2440 -930 2440 -910 {
lab=vcom}
N 2420 -920 2420 -910 {
lab=VDD}
N 2500 -690 2500 -670 {
lab=row_n[5]}
N 2760 -690 2770 -700 {
lab=row_n[6]}
N 2770 -900 2770 -700 {
lab=row_n[6]}
N 2760 -910 2770 -900 {
lab=row_n[6]}
N 2760 -930 2760 -910 {
lab=row_n[6]}
N 2640 -830 2650 -840 {
lab=VDD}
N 2650 -840 2850 -840 {
lab=VDD}
N 2850 -840 2860 -830 {
lab=VDD}
N 2640 -810 2650 -820 {
lab=VDD}
N 2650 -820 2850 -820 {
lab=VDD}
N 2850 -820 2860 -810 {
lab=VDD}
N 2640 -790 2650 -800 {
lab=VSS}
N 2650 -800 2850 -800 {
lab=VSS}
N 2850 -800 2860 -790 {
lab=VSS}
N 2640 -770 2650 -780 {
lab=VDD}
N 2650 -780 2850 -780 {
lab=VDD}
N 2850 -780 2860 -770 {
lab=VDD}
N 2860 -770 2880 -770 {
lab=VDD}
N 2860 -790 2880 -790 {
lab=VSS}
N 2860 -810 2880 -810 {
lab=VDD}
N 2860 -830 2880 -830 {
lab=VDD}
N 2620 -830 2640 -830 {
lab=VDD}
N 2620 -810 2640 -810 {
lab=VDD}
N 2620 -790 2640 -790 {
lab=VSS}
N 2620 -770 2640 -770 {
lab=VDD}
N 2680 -690 2680 -680 {
lab=VSS}
N 2700 -930 2700 -910 {
lab=vcom}
N 2680 -920 2680 -910 {
lab=VDD}
N 2760 -690 2760 -670 {
lab=row_n[6]}
N 2480 -930 2480 -910 {
lab=ctop}
N 2740 -930 2740 -910 {
lab=ctop}
N 3020 -690 3030 -700 {
lab=row_n[7]}
N 3030 -900 3030 -700 {
lab=row_n[7]}
N 3020 -910 3030 -900 {
lab=row_n[7]}
N 3020 -930 3020 -910 {
lab=row_n[7]}
N 2900 -830 2910 -840 {
lab=VDD}
N 2910 -840 3110 -840 {
lab=VDD}
N 3110 -840 3120 -830 {
lab=VDD}
N 2900 -810 2910 -820 {
lab=VDD}
N 2910 -820 3110 -820 {
lab=VDD}
N 3110 -820 3120 -810 {
lab=VDD}
N 2900 -790 2910 -800 {
lab=VSS}
N 2910 -800 3110 -800 {
lab=VSS}
N 3110 -800 3120 -790 {
lab=VSS}
N 2900 -770 2910 -780 {
lab=VDD}
N 2910 -780 3110 -780 {
lab=VDD}
N 3110 -780 3120 -770 {
lab=VDD}
N 3120 -770 3140 -770 {
lab=VDD}
N 3120 -790 3140 -790 {
lab=VSS}
N 3120 -810 3140 -810 {
lab=VDD}
N 3120 -830 3140 -830 {
lab=VDD}
N 2880 -830 2900 -830 {
lab=VDD}
N 2880 -810 2900 -810 {
lab=VDD}
N 2880 -790 2900 -790 {
lab=VSS}
N 2880 -770 2900 -770 {
lab=VDD}
N 2940 -690 2940 -680 {
lab=VSS}
N 2960 -930 2960 -910 {
lab=vcom}
N 2940 -920 2940 -910 {
lab=VDD}
N 3020 -690 3020 -670 {
lab=row_n[7]}
N 3280 -690 3290 -700 {
lab=row_n[8]}
N 3290 -900 3290 -700 {
lab=row_n[8]}
N 3280 -910 3290 -900 {
lab=row_n[8]}
N 3280 -930 3280 -910 {
lab=row_n[8]}
N 3160 -830 3170 -840 {
lab=VDD}
N 3170 -840 3370 -840 {
lab=VDD}
N 3370 -840 3380 -830 {
lab=VDD}
N 3160 -810 3170 -820 {
lab=VDD}
N 3170 -820 3370 -820 {
lab=VDD}
N 3370 -820 3380 -810 {
lab=VDD}
N 3160 -790 3170 -800 {
lab=VSS}
N 3170 -800 3370 -800 {
lab=VSS}
N 3370 -800 3380 -790 {
lab=VSS}
N 3160 -770 3170 -780 {
lab=VDD}
N 3170 -780 3370 -780 {
lab=VDD}
N 3370 -780 3380 -770 {
lab=VDD}
N 3380 -770 3400 -770 {
lab=VDD}
N 3380 -790 3400 -790 {
lab=VSS}
N 3380 -810 3400 -810 {
lab=VDD}
N 3380 -830 3400 -830 {
lab=VDD}
N 3140 -830 3160 -830 {
lab=VDD}
N 3140 -810 3160 -810 {
lab=VDD}
N 3140 -790 3160 -790 {
lab=VSS}
N 3140 -770 3160 -770 {
lab=VDD}
N 3200 -690 3200 -680 {
lab=VSS}
N 3220 -930 3220 -910 {
lab=vcom}
N 3200 -920 3200 -910 {
lab=VDD}
N 3280 -690 3280 -670 {
lab=row_n[8]}
N 3000 -930 3000 -910 {
lab=ctop}
N 3260 -930 3260 -910 {
lab=ctop}
N 3540 -690 3550 -700 {
lab=row_n[9]}
N 3550 -900 3550 -700 {
lab=row_n[9]}
N 3540 -910 3550 -900 {
lab=row_n[9]}
N 3540 -930 3540 -910 {
lab=row_n[9]}
N 3420 -830 3430 -840 {
lab=VDD}
N 3430 -840 3630 -840 {
lab=VDD}
N 3630 -840 3640 -830 {
lab=VDD}
N 3420 -810 3430 -820 {
lab=VDD}
N 3430 -820 3630 -820 {
lab=VDD}
N 3630 -820 3640 -810 {
lab=VDD}
N 3420 -790 3430 -800 {
lab=VSS}
N 3430 -800 3630 -800 {
lab=VSS}
N 3630 -800 3640 -790 {
lab=VSS}
N 3420 -770 3430 -780 {
lab=VDD}
N 3430 -780 3630 -780 {
lab=VDD}
N 3630 -780 3640 -770 {
lab=VDD}
N 3640 -770 3660 -770 {
lab=VDD}
N 3640 -790 3660 -790 {
lab=VSS}
N 3640 -810 3660 -810 {
lab=VDD}
N 3640 -830 3660 -830 {
lab=VDD}
N 3400 -830 3420 -830 {
lab=VDD}
N 3400 -810 3420 -810 {
lab=VDD}
N 3400 -790 3420 -790 {
lab=VSS}
N 3400 -770 3420 -770 {
lab=VDD}
N 3460 -690 3460 -680 {
lab=VSS}
N 3480 -930 3480 -910 {
lab=vcom}
N 3460 -920 3460 -910 {
lab=VDD}
N 3540 -690 3540 -670 {
lab=row_n[9]}
N 3800 -690 3810 -700 {
lab=row_n[10]}
N 3810 -900 3810 -700 {
lab=row_n[10]}
N 3800 -910 3810 -900 {
lab=row_n[10]}
N 3800 -930 3800 -910 {
lab=row_n[10]}
N 3680 -830 3690 -840 {
lab=VDD}
N 3690 -840 3890 -840 {
lab=VDD}
N 3890 -840 3900 -830 {
lab=VDD}
N 3680 -810 3690 -820 {
lab=VDD}
N 3690 -820 3890 -820 {
lab=VDD}
N 3890 -820 3900 -810 {
lab=VDD}
N 3680 -790 3690 -800 {
lab=VSS}
N 3690 -800 3890 -800 {
lab=VSS}
N 3890 -800 3900 -790 {
lab=VSS}
N 3680 -770 3690 -780 {
lab=VDD}
N 3690 -780 3890 -780 {
lab=VDD}
N 3890 -780 3900 -770 {
lab=VDD}
N 3900 -770 3920 -770 {
lab=VDD}
N 3900 -790 3920 -790 {
lab=VSS}
N 3900 -810 3920 -810 {
lab=VDD}
N 3900 -830 3920 -830 {
lab=VDD}
N 3660 -830 3680 -830 {
lab=VDD}
N 3660 -810 3680 -810 {
lab=VDD}
N 3660 -790 3680 -790 {
lab=VSS}
N 3660 -770 3680 -770 {
lab=VDD}
N 3720 -690 3720 -680 {
lab=VSS}
N 3740 -930 3740 -910 {
lab=vcom}
N 3720 -920 3720 -910 {
lab=VDD}
N 3800 -690 3800 -670 {
lab=row_n[10]}
N 3520 -930 3520 -910 {
lab=ctop}
N 3780 -930 3780 -910 {
lab=ctop}
N 4060 -690 4070 -700 {
lab=row_n[11]}
N 4070 -900 4070 -700 {
lab=row_n[11]}
N 4060 -910 4070 -900 {
lab=row_n[11]}
N 4060 -930 4060 -910 {
lab=row_n[11]}
N 3940 -830 3950 -840 {
lab=VDD}
N 3950 -840 4150 -840 {
lab=VDD}
N 4150 -840 4160 -830 {
lab=VDD}
N 3940 -810 3950 -820 {
lab=VDD}
N 3950 -820 4150 -820 {
lab=VDD}
N 4150 -820 4160 -810 {
lab=VDD}
N 3940 -790 3950 -800 {
lab=VSS}
N 3950 -800 4150 -800 {
lab=VSS}
N 4150 -800 4160 -790 {
lab=VSS}
N 3940 -770 3950 -780 {
lab=VDD}
N 3950 -780 4150 -780 {
lab=VDD}
N 4150 -780 4160 -770 {
lab=VDD}
N 4160 -770 4180 -770 {
lab=VDD}
N 4160 -790 4180 -790 {
lab=VSS}
N 4160 -810 4180 -810 {
lab=VDD}
N 4160 -830 4180 -830 {
lab=VDD}
N 3920 -830 3940 -830 {
lab=VDD}
N 3920 -810 3940 -810 {
lab=VDD}
N 3920 -790 3940 -790 {
lab=VSS}
N 3920 -770 3940 -770 {
lab=VDD}
N 3980 -690 3980 -680 {
lab=VSS}
N 4000 -930 4000 -910 {
lab=vcom}
N 3980 -920 3980 -910 {
lab=VDD}
N 4060 -690 4060 -670 {
lab=row_n[11]}
N 4320 -690 4330 -700 {
lab=row_n[12]}
N 4330 -900 4330 -700 {
lab=row_n[12]}
N 4320 -910 4330 -900 {
lab=row_n[12]}
N 4320 -930 4320 -910 {
lab=row_n[12]}
N 4200 -830 4210 -840 {
lab=VDD}
N 4210 -840 4410 -840 {
lab=VDD}
N 4410 -840 4420 -830 {
lab=VDD}
N 4200 -810 4210 -820 {
lab=VDD}
N 4210 -820 4410 -820 {
lab=VDD}
N 4410 -820 4420 -810 {
lab=VDD}
N 4200 -790 4210 -800 {
lab=VSS}
N 4210 -800 4410 -800 {
lab=VSS}
N 4410 -800 4420 -790 {
lab=VSS}
N 4200 -770 4210 -780 {
lab=VDD}
N 4210 -780 4410 -780 {
lab=VDD}
N 4410 -780 4420 -770 {
lab=VDD}
N 4420 -770 4440 -770 {
lab=VDD}
N 4420 -790 4440 -790 {
lab=VSS}
N 4420 -810 4440 -810 {
lab=VDD}
N 4420 -830 4440 -830 {
lab=VDD}
N 4180 -830 4200 -830 {
lab=VDD}
N 4180 -810 4200 -810 {
lab=VDD}
N 4180 -790 4200 -790 {
lab=VSS}
N 4180 -770 4200 -770 {
lab=VDD}
N 4240 -690 4240 -680 {
lab=VSS}
N 4260 -930 4260 -910 {
lab=vcom}
N 4240 -920 4240 -910 {
lab=VDD}
N 4320 -690 4320 -670 {
lab=row_n[12]}
N 4040 -930 4040 -910 {
lab=ctop}
N 4300 -930 4300 -910 {
lab=ctop}
N 4580 -690 4590 -700 {
lab=row_n[13]}
N 4590 -900 4590 -700 {
lab=row_n[13]}
N 4580 -910 4590 -900 {
lab=row_n[13]}
N 4580 -930 4580 -910 {
lab=row_n[13]}
N 4460 -830 4470 -840 {
lab=VDD}
N 4470 -840 4670 -840 {
lab=VDD}
N 4670 -840 4680 -830 {
lab=VDD}
N 4460 -810 4470 -820 {
lab=VDD}
N 4470 -820 4670 -820 {
lab=VDD}
N 4670 -820 4680 -810 {
lab=VDD}
N 4460 -790 4470 -800 {
lab=VSS}
N 4470 -800 4670 -800 {
lab=VSS}
N 4670 -800 4680 -790 {
lab=VSS}
N 4460 -770 4470 -780 {
lab=VDD}
N 4470 -780 4670 -780 {
lab=VDD}
N 4670 -780 4680 -770 {
lab=VDD}
N 4680 -770 4700 -770 {
lab=VDD}
N 4680 -790 4700 -790 {
lab=VSS}
N 4680 -810 4700 -810 {
lab=VDD}
N 4680 -830 4700 -830 {
lab=VDD}
N 4440 -830 4460 -830 {
lab=VDD}
N 4440 -810 4460 -810 {
lab=VDD}
N 4440 -790 4460 -790 {
lab=VSS}
N 4440 -770 4460 -770 {
lab=VDD}
N 4500 -690 4500 -680 {
lab=VSS}
N 4520 -930 4520 -910 {
lab=vcom}
N 4500 -920 4500 -910 {
lab=VDD}
N 4580 -690 4580 -670 {
lab=row_n[13]}
N 4840 -690 4850 -700 {
lab=row_n[14]}
N 4850 -900 4850 -700 {
lab=row_n[14]}
N 4840 -910 4850 -900 {
lab=row_n[14]}
N 4840 -930 4840 -910 {
lab=row_n[14]}
N 4720 -830 4730 -840 {
lab=VDD}
N 4730 -840 4930 -840 {
lab=VDD}
N 4930 -840 4940 -830 {
lab=VDD}
N 4720 -810 4730 -820 {
lab=VDD}
N 4730 -820 4930 -820 {
lab=VDD}
N 4930 -820 4940 -810 {
lab=VDD}
N 4720 -790 4730 -800 {
lab=VSS}
N 4730 -800 4930 -800 {
lab=VSS}
N 4930 -800 4940 -790 {
lab=VSS}
N 4720 -770 4730 -780 {
lab=VDD}
N 4730 -780 4930 -780 {
lab=VDD}
N 4930 -780 4940 -770 {
lab=VDD}
N 4940 -770 4960 -770 {
lab=VDD}
N 4940 -790 4960 -790 {
lab=VSS}
N 4940 -810 4960 -810 {
lab=VDD}
N 4940 -830 4960 -830 {
lab=VDD}
N 4700 -830 4720 -830 {
lab=VDD}
N 4700 -810 4720 -810 {
lab=VDD}
N 4700 -790 4720 -790 {
lab=VSS}
N 4700 -770 4720 -770 {
lab=VDD}
N 4760 -690 4760 -680 {
lab=VSS}
N 4780 -930 4780 -910 {
lab=vcom}
N 4760 -920 4760 -910 {
lab=VDD}
N 4840 -690 4840 -670 {
lab=row_n[14]}
N 4560 -930 4560 -910 {
lab=ctop}
N 4820 -930 4820 -910 {
lab=ctop}
N 5100 -690 5110 -700 {
lab=row_n[15]}
N 5110 -900 5110 -700 {
lab=row_n[15]}
N 5100 -910 5110 -900 {
lab=row_n[15]}
N 5100 -930 5100 -910 {
lab=row_n[15]}
N 4980 -830 4990 -840 {
lab=VDD}
N 4990 -840 5190 -840 {
lab=VDD}
N 5190 -840 5200 -830 {
lab=VDD}
N 4980 -810 4990 -820 {
lab=VDD}
N 4990 -820 5190 -820 {
lab=VDD}
N 5190 -820 5200 -810 {
lab=VDD}
N 4980 -790 4990 -800 {
lab=VSS}
N 4990 -800 5190 -800 {
lab=VSS}
N 5190 -800 5200 -790 {
lab=VSS}
N 4980 -770 4990 -780 {
lab=VDD}
N 4990 -780 5190 -780 {
lab=VDD}
N 5190 -780 5200 -770 {
lab=VDD}
N 5200 -770 5220 -770 {
lab=VDD}
N 5200 -790 5220 -790 {
lab=VSS}
N 5200 -810 5220 -810 {
lab=VDD}
N 5200 -830 5220 -830 {
lab=VDD}
N 4960 -830 4980 -830 {
lab=VDD}
N 4960 -810 4980 -810 {
lab=VDD}
N 4960 -790 4980 -790 {
lab=VSS}
N 4960 -770 4980 -770 {
lab=VDD}
N 5020 -690 5020 -680 {
lab=VSS}
N 5040 -930 5040 -910 {
lab=vcom}
N 5020 -920 5020 -910 {
lab=VDD}
N 5100 -690 5100 -670 {
lab=row_n[15]}
N 5360 -690 5370 -700 {
lab=row_n[16]}
N 5370 -900 5370 -700 {
lab=row_n[16]}
N 5360 -910 5370 -900 {
lab=row_n[16]}
N 5360 -930 5360 -910 {
lab=row_n[16]}
N 5240 -830 5250 -840 {
lab=VDD}
N 5250 -840 5450 -840 {
lab=VDD}
N 5450 -840 5460 -830 {
lab=VDD}
N 5240 -810 5250 -820 {
lab=VDD}
N 5250 -820 5450 -820 {
lab=VDD}
N 5450 -820 5460 -810 {
lab=VDD}
N 5240 -790 5250 -800 {
lab=VSS}
N 5250 -800 5450 -800 {
lab=VSS}
N 5450 -800 5460 -790 {
lab=VSS}
N 5240 -770 5250 -780 {
lab=VDD}
N 5250 -780 5450 -780 {
lab=VDD}
N 5450 -780 5460 -770 {
lab=VDD}
N 5460 -770 5480 -770 {
lab=VDD}
N 5460 -790 5480 -790 {
lab=VSS}
N 5460 -810 5480 -810 {
lab=VDD}
N 5460 -830 5480 -830 {
lab=VDD}
N 5220 -830 5240 -830 {
lab=VDD}
N 5220 -810 5240 -810 {
lab=VDD}
N 5220 -790 5240 -790 {
lab=VSS}
N 5220 -770 5240 -770 {
lab=VDD}
N 5280 -690 5280 -680 {
lab=VSS}
N 5300 -930 5300 -910 {
lab=vcom}
N 5280 -920 5280 -910 {
lab=VDD}
N 5360 -690 5360 -670 {
lab=row_n[16]}
N 5080 -930 5080 -910 {
lab=ctop}
N 5340 -930 5340 -910 {
lab=ctop}
N 5620 -690 5630 -700 {
lab=row_n[17]}
N 5630 -900 5630 -700 {
lab=row_n[17]}
N 5620 -910 5630 -900 {
lab=row_n[17]}
N 5620 -930 5620 -910 {
lab=row_n[17]}
N 5500 -830 5510 -840 {
lab=VDD}
N 5510 -840 5710 -840 {
lab=VDD}
N 5710 -840 5720 -830 {
lab=VDD}
N 5500 -810 5510 -820 {
lab=VDD}
N 5510 -820 5710 -820 {
lab=VDD}
N 5710 -820 5720 -810 {
lab=VDD}
N 5500 -790 5510 -800 {
lab=VSS}
N 5510 -800 5710 -800 {
lab=VSS}
N 5710 -800 5720 -790 {
lab=VSS}
N 5500 -770 5510 -780 {
lab=VDD}
N 5510 -780 5710 -780 {
lab=VDD}
N 5710 -780 5720 -770 {
lab=VDD}
N 5720 -770 5740 -770 {
lab=VDD}
N 5720 -790 5740 -790 {
lab=VSS}
N 5720 -810 5740 -810 {
lab=VDD}
N 5720 -830 5740 -830 {
lab=VDD}
N 5480 -830 5500 -830 {
lab=VDD}
N 5480 -810 5500 -810 {
lab=VDD}
N 5480 -790 5500 -790 {
lab=VSS}
N 5480 -770 5500 -770 {
lab=VDD}
N 5540 -690 5540 -680 {
lab=VSS}
N 5560 -930 5560 -910 {
lab=vcom}
N 5540 -920 5540 -910 {
lab=VDD}
N 5620 -690 5620 -670 {
lab=row_n[17]}
N 5880 -690 5890 -700 {
lab=row_n[18]}
N 5890 -900 5890 -700 {
lab=row_n[18]}
N 5880 -910 5890 -900 {
lab=row_n[18]}
N 5880 -930 5880 -910 {
lab=row_n[18]}
N 5760 -830 5770 -840 {
lab=VDD}
N 5770 -840 5970 -840 {
lab=VDD}
N 5970 -840 5980 -830 {
lab=VDD}
N 5760 -810 5770 -820 {
lab=VDD}
N 5770 -820 5970 -820 {
lab=VDD}
N 5970 -820 5980 -810 {
lab=VDD}
N 5760 -790 5770 -800 {
lab=VSS}
N 5770 -800 5970 -800 {
lab=VSS}
N 5970 -800 5980 -790 {
lab=VSS}
N 5760 -770 5770 -780 {
lab=VDD}
N 5770 -780 5970 -780 {
lab=VDD}
N 5970 -780 5980 -770 {
lab=VDD}
N 5980 -770 6000 -770 {
lab=VDD}
N 5980 -790 6000 -790 {
lab=VSS}
N 5980 -810 6000 -810 {
lab=VDD}
N 5980 -830 6000 -830 {
lab=VDD}
N 5740 -830 5760 -830 {
lab=VDD}
N 5740 -810 5760 -810 {
lab=VDD}
N 5740 -790 5760 -790 {
lab=VSS}
N 5740 -770 5760 -770 {
lab=VDD}
N 5800 -690 5800 -680 {
lab=VSS}
N 5820 -930 5820 -910 {
lab=vcom}
N 5800 -920 5800 -910 {
lab=VDD}
N 5880 -690 5880 -670 {
lab=row_n[18]}
N 5600 -930 5600 -910 {
lab=ctop}
N 5860 -930 5860 -910 {
lab=ctop}
N 6140 -690 6150 -700 {
lab=row_n[19]}
N 6150 -900 6150 -700 {
lab=row_n[19]}
N 6140 -910 6150 -900 {
lab=row_n[19]}
N 6140 -930 6140 -910 {
lab=row_n[19]}
N 6020 -830 6030 -840 {
lab=VDD}
N 6030 -840 6230 -840 {
lab=VDD}
N 6230 -840 6240 -830 {
lab=VDD}
N 6020 -810 6030 -820 {
lab=VDD}
N 6030 -820 6230 -820 {
lab=VDD}
N 6230 -820 6240 -810 {
lab=VDD}
N 6020 -790 6030 -800 {
lab=VSS}
N 6030 -800 6230 -800 {
lab=VSS}
N 6230 -800 6240 -790 {
lab=VSS}
N 6020 -770 6030 -780 {
lab=VDD}
N 6030 -780 6230 -780 {
lab=VDD}
N 6230 -780 6240 -770 {
lab=VDD}
N 6240 -770 6260 -770 {
lab=VDD}
N 6240 -790 6260 -790 {
lab=VSS}
N 6240 -810 6260 -810 {
lab=VDD}
N 6240 -830 6260 -830 {
lab=VDD}
N 6000 -830 6020 -830 {
lab=VDD}
N 6000 -810 6020 -810 {
lab=VDD}
N 6000 -790 6020 -790 {
lab=VSS}
N 6000 -770 6020 -770 {
lab=VDD}
N 6060 -690 6060 -680 {
lab=VSS}
N 6080 -930 6080 -910 {
lab=vcom}
N 6060 -920 6060 -910 {
lab=VDD}
N 6140 -690 6140 -670 {
lab=row_n[19]}
N 6400 -690 6410 -700 {
lab=row_n[20]}
N 6410 -900 6410 -700 {
lab=row_n[20]}
N 6400 -910 6410 -900 {
lab=row_n[20]}
N 6400 -930 6400 -910 {
lab=row_n[20]}
N 6280 -830 6290 -840 {
lab=VDD}
N 6290 -840 6490 -840 {
lab=VDD}
N 6490 -840 6500 -830 {
lab=VDD}
N 6280 -810 6290 -820 {
lab=VDD}
N 6290 -820 6490 -820 {
lab=VDD}
N 6490 -820 6500 -810 {
lab=VDD}
N 6280 -790 6290 -800 {
lab=VSS}
N 6290 -800 6490 -800 {
lab=VSS}
N 6490 -800 6500 -790 {
lab=VSS}
N 6280 -770 6290 -780 {
lab=VDD}
N 6290 -780 6490 -780 {
lab=VDD}
N 6490 -780 6500 -770 {
lab=VDD}
N 6500 -770 6520 -770 {
lab=VDD}
N 6500 -790 6520 -790 {
lab=VSS}
N 6500 -810 6520 -810 {
lab=VDD}
N 6500 -830 6520 -830 {
lab=VDD}
N 6260 -830 6280 -830 {
lab=VDD}
N 6260 -810 6280 -810 {
lab=VDD}
N 6260 -790 6280 -790 {
lab=VSS}
N 6260 -770 6280 -770 {
lab=VDD}
N 6320 -690 6320 -680 {
lab=VSS}
N 6340 -930 6340 -910 {
lab=vcom}
N 6320 -920 6320 -910 {
lab=VDD}
N 6400 -690 6400 -670 {
lab=row_n[20]}
N 6120 -930 6120 -910 {
lab=ctop}
N 6380 -930 6380 -910 {
lab=ctop}
N 6660 -690 6670 -700 {
lab=row_n[21]}
N 6670 -900 6670 -700 {
lab=row_n[21]}
N 6660 -910 6670 -900 {
lab=row_n[21]}
N 6660 -930 6660 -910 {
lab=row_n[21]}
N 6540 -830 6550 -840 {
lab=VDD}
N 6550 -840 6750 -840 {
lab=VDD}
N 6750 -840 6760 -830 {
lab=VDD}
N 6540 -810 6550 -820 {
lab=VDD}
N 6550 -820 6750 -820 {
lab=VDD}
N 6750 -820 6760 -810 {
lab=VDD}
N 6540 -790 6550 -800 {
lab=VSS}
N 6550 -800 6750 -800 {
lab=VSS}
N 6750 -800 6760 -790 {
lab=VSS}
N 6540 -770 6550 -780 {
lab=VDD}
N 6550 -780 6750 -780 {
lab=VDD}
N 6750 -780 6760 -770 {
lab=VDD}
N 6760 -770 6780 -770 {
lab=VDD}
N 6760 -790 6780 -790 {
lab=VSS}
N 6760 -810 6780 -810 {
lab=VDD}
N 6760 -830 6780 -830 {
lab=VDD}
N 6520 -830 6540 -830 {
lab=VDD}
N 6520 -810 6540 -810 {
lab=VDD}
N 6520 -790 6540 -790 {
lab=VSS}
N 6520 -770 6540 -770 {
lab=VDD}
N 6580 -690 6580 -680 {
lab=VSS}
N 6600 -930 6600 -910 {
lab=vcom}
N 6580 -920 6580 -910 {
lab=VDD}
N 6660 -690 6660 -670 {
lab=row_n[21]}
N 6920 -690 6930 -700 {
lab=row_n[22]}
N 6930 -900 6930 -700 {
lab=row_n[22]}
N 6920 -910 6930 -900 {
lab=row_n[22]}
N 6920 -930 6920 -910 {
lab=row_n[22]}
N 6800 -830 6810 -840 {
lab=VDD}
N 6810 -840 7010 -840 {
lab=VDD}
N 7010 -840 7020 -830 {
lab=VDD}
N 6800 -810 6810 -820 {
lab=VDD}
N 6810 -820 7010 -820 {
lab=VDD}
N 7010 -820 7020 -810 {
lab=VDD}
N 6800 -790 6810 -800 {
lab=VSS}
N 6810 -800 7010 -800 {
lab=VSS}
N 7010 -800 7020 -790 {
lab=VSS}
N 6800 -770 6810 -780 {
lab=VDD}
N 6810 -780 7010 -780 {
lab=VDD}
N 7010 -780 7020 -770 {
lab=VDD}
N 7020 -770 7040 -770 {
lab=VDD}
N 7020 -790 7040 -790 {
lab=VSS}
N 7020 -810 7040 -810 {
lab=VDD}
N 7020 -830 7040 -830 {
lab=VDD}
N 6780 -830 6800 -830 {
lab=VDD}
N 6780 -810 6800 -810 {
lab=VDD}
N 6780 -790 6800 -790 {
lab=VSS}
N 6780 -770 6800 -770 {
lab=VDD}
N 6840 -690 6840 -680 {
lab=VSS}
N 6860 -930 6860 -910 {
lab=vcom}
N 6840 -920 6840 -910 {
lab=VDD}
N 6920 -690 6920 -670 {
lab=row_n[22]}
N 6640 -930 6640 -910 {
lab=ctop}
N 6900 -930 6900 -910 {
lab=ctop}
N 7180 -690 7190 -700 {
lab=row_n[23]}
N 7190 -900 7190 -700 {
lab=row_n[23]}
N 7180 -910 7190 -900 {
lab=row_n[23]}
N 7180 -930 7180 -910 {
lab=row_n[23]}
N 7060 -830 7070 -840 {
lab=VDD}
N 7070 -840 7270 -840 {
lab=VDD}
N 7270 -840 7280 -830 {
lab=VDD}
N 7060 -810 7070 -820 {
lab=VDD}
N 7070 -820 7270 -820 {
lab=VDD}
N 7270 -820 7280 -810 {
lab=VDD}
N 7060 -790 7070 -800 {
lab=VSS}
N 7070 -800 7270 -800 {
lab=VSS}
N 7270 -800 7280 -790 {
lab=VSS}
N 7060 -770 7070 -780 {
lab=VDD}
N 7070 -780 7270 -780 {
lab=VDD}
N 7270 -780 7280 -770 {
lab=VDD}
N 7280 -770 7300 -770 {
lab=VDD}
N 7280 -790 7300 -790 {
lab=VSS}
N 7280 -810 7300 -810 {
lab=VDD}
N 7280 -830 7300 -830 {
lab=VDD}
N 7040 -830 7060 -830 {
lab=VDD}
N 7040 -810 7060 -810 {
lab=VDD}
N 7040 -790 7060 -790 {
lab=VSS}
N 7040 -770 7060 -770 {
lab=VDD}
N 7100 -690 7100 -680 {
lab=VSS}
N 7120 -930 7120 -910 {
lab=vcom}
N 7100 -920 7100 -910 {
lab=VDD}
N 7180 -690 7180 -670 {
lab=row_n[23]}
N 7440 -690 7450 -700 {
lab=row_n[24]}
N 7450 -900 7450 -700 {
lab=row_n[24]}
N 7440 -910 7450 -900 {
lab=row_n[24]}
N 7440 -930 7440 -910 {
lab=row_n[24]}
N 7320 -830 7330 -840 {
lab=VDD}
N 7330 -840 7530 -840 {
lab=VDD}
N 7530 -840 7540 -830 {
lab=VDD}
N 7320 -810 7330 -820 {
lab=VDD}
N 7330 -820 7530 -820 {
lab=VDD}
N 7530 -820 7540 -810 {
lab=VDD}
N 7320 -790 7330 -800 {
lab=VSS}
N 7330 -800 7530 -800 {
lab=VSS}
N 7530 -800 7540 -790 {
lab=VSS}
N 7320 -770 7330 -780 {
lab=VDD}
N 7330 -780 7530 -780 {
lab=VDD}
N 7530 -780 7540 -770 {
lab=VDD}
N 7540 -770 7560 -770 {
lab=VDD}
N 7540 -790 7560 -790 {
lab=VSS}
N 7540 -810 7560 -810 {
lab=VDD}
N 7540 -830 7560 -830 {
lab=VDD}
N 7300 -830 7320 -830 {
lab=VDD}
N 7300 -810 7320 -810 {
lab=VDD}
N 7300 -790 7320 -790 {
lab=VSS}
N 7300 -770 7320 -770 {
lab=VDD}
N 7360 -690 7360 -680 {
lab=VSS}
N 7380 -930 7380 -910 {
lab=vcom}
N 7360 -920 7360 -910 {
lab=VDD}
N 7440 -690 7440 -670 {
lab=row_n[24]}
N 7160 -930 7160 -910 {
lab=ctop}
N 7420 -930 7420 -910 {
lab=ctop}
N 7700 -690 7710 -700 {
lab=row_n[25]}
N 7710 -900 7710 -700 {
lab=row_n[25]}
N 7700 -910 7710 -900 {
lab=row_n[25]}
N 7700 -930 7700 -910 {
lab=row_n[25]}
N 7580 -830 7590 -840 {
lab=VDD}
N 7590 -840 7790 -840 {
lab=VDD}
N 7790 -840 7800 -830 {
lab=VDD}
N 7580 -810 7590 -820 {
lab=VDD}
N 7590 -820 7790 -820 {
lab=VDD}
N 7790 -820 7800 -810 {
lab=VDD}
N 7580 -790 7590 -800 {
lab=VSS}
N 7590 -800 7790 -800 {
lab=VSS}
N 7790 -800 7800 -790 {
lab=VSS}
N 7580 -770 7590 -780 {
lab=VDD}
N 7590 -780 7790 -780 {
lab=VDD}
N 7790 -780 7800 -770 {
lab=VDD}
N 7800 -770 7820 -770 {
lab=VDD}
N 7800 -790 7820 -790 {
lab=VSS}
N 7800 -810 7820 -810 {
lab=VDD}
N 7800 -830 7820 -830 {
lab=VDD}
N 7560 -830 7580 -830 {
lab=VDD}
N 7560 -810 7580 -810 {
lab=VDD}
N 7560 -790 7580 -790 {
lab=VSS}
N 7560 -770 7580 -770 {
lab=VDD}
N 7620 -690 7620 -680 {
lab=VSS}
N 7640 -930 7640 -910 {
lab=vcom}
N 7620 -920 7620 -910 {
lab=VDD}
N 7700 -690 7700 -670 {
lab=row_n[25]}
N 7960 -690 7970 -700 {
lab=row_n[26]}
N 7970 -900 7970 -700 {
lab=row_n[26]}
N 7960 -910 7970 -900 {
lab=row_n[26]}
N 7960 -930 7960 -910 {
lab=row_n[26]}
N 7840 -830 7850 -840 {
lab=VDD}
N 7850 -840 8050 -840 {
lab=VDD}
N 8050 -840 8060 -830 {
lab=VDD}
N 7840 -810 7850 -820 {
lab=VDD}
N 7850 -820 8050 -820 {
lab=VDD}
N 8050 -820 8060 -810 {
lab=VDD}
N 7840 -790 7850 -800 {
lab=VSS}
N 7850 -800 8050 -800 {
lab=VSS}
N 8050 -800 8060 -790 {
lab=VSS}
N 7840 -770 7850 -780 {
lab=VDD}
N 7850 -780 8050 -780 {
lab=VDD}
N 8050 -780 8060 -770 {
lab=VDD}
N 8060 -770 8080 -770 {
lab=VDD}
N 8060 -790 8080 -790 {
lab=VSS}
N 8060 -810 8080 -810 {
lab=VDD}
N 8060 -830 8080 -830 {
lab=VDD}
N 7820 -830 7840 -830 {
lab=VDD}
N 7820 -810 7840 -810 {
lab=VDD}
N 7820 -790 7840 -790 {
lab=VSS}
N 7820 -770 7840 -770 {
lab=VDD}
N 7880 -690 7880 -680 {
lab=VSS}
N 7900 -930 7900 -910 {
lab=vcom}
N 7880 -920 7880 -910 {
lab=VDD}
N 7960 -690 7960 -670 {
lab=row_n[26]}
N 7680 -930 7680 -910 {
lab=ctop}
N 7940 -930 7940 -910 {
lab=ctop}
N 8220 -690 8230 -700 {
lab=row_n[27]}
N 8230 -900 8230 -700 {
lab=row_n[27]}
N 8220 -910 8230 -900 {
lab=row_n[27]}
N 8220 -930 8220 -910 {
lab=row_n[27]}
N 8100 -830 8110 -840 {
lab=VDD}
N 8110 -840 8310 -840 {
lab=VDD}
N 8310 -840 8320 -830 {
lab=VDD}
N 8100 -810 8110 -820 {
lab=VDD}
N 8110 -820 8310 -820 {
lab=VDD}
N 8310 -820 8320 -810 {
lab=VDD}
N 8100 -790 8110 -800 {
lab=VSS}
N 8110 -800 8310 -800 {
lab=VSS}
N 8310 -800 8320 -790 {
lab=VSS}
N 8100 -770 8110 -780 {
lab=VDD}
N 8110 -780 8310 -780 {
lab=VDD}
N 8310 -780 8320 -770 {
lab=VDD}
N 8320 -770 8340 -770 {
lab=VDD}
N 8320 -790 8340 -790 {
lab=VSS}
N 8320 -810 8340 -810 {
lab=VDD}
N 8320 -830 8340 -830 {
lab=VDD}
N 8080 -830 8100 -830 {
lab=VDD}
N 8080 -810 8100 -810 {
lab=VDD}
N 8080 -790 8100 -790 {
lab=VSS}
N 8080 -770 8100 -770 {
lab=VDD}
N 8140 -690 8140 -680 {
lab=VSS}
N 8160 -930 8160 -910 {
lab=vcom}
N 8140 -920 8140 -910 {
lab=VDD}
N 8220 -690 8220 -670 {
lab=row_n[27]}
N 8480 -690 8490 -700 {
lab=row_n[28]}
N 8490 -900 8490 -700 {
lab=row_n[28]}
N 8480 -910 8490 -900 {
lab=row_n[28]}
N 8480 -930 8480 -910 {
lab=row_n[28]}
N 8360 -830 8370 -840 {
lab=VDD}
N 8370 -840 8570 -840 {
lab=VDD}
N 8570 -840 8580 -830 {
lab=VDD}
N 8360 -810 8370 -820 {
lab=VDD}
N 8370 -820 8570 -820 {
lab=VDD}
N 8570 -820 8580 -810 {
lab=VDD}
N 8360 -790 8370 -800 {
lab=VSS}
N 8370 -800 8570 -800 {
lab=VSS}
N 8570 -800 8580 -790 {
lab=VSS}
N 8360 -770 8370 -780 {
lab=VDD}
N 8370 -780 8570 -780 {
lab=VDD}
N 8570 -780 8580 -770 {
lab=VDD}
N 8580 -770 8600 -770 {
lab=VDD}
N 8580 -790 8600 -790 {
lab=VSS}
N 8580 -810 8600 -810 {
lab=VDD}
N 8580 -830 8600 -830 {
lab=VDD}
N 8340 -830 8360 -830 {
lab=VDD}
N 8340 -810 8360 -810 {
lab=VDD}
N 8340 -790 8360 -790 {
lab=VSS}
N 8340 -770 8360 -770 {
lab=VDD}
N 8400 -690 8400 -680 {
lab=VSS}
N 8420 -930 8420 -910 {
lab=vcom}
N 8400 -920 8400 -910 {
lab=VDD}
N 8480 -690 8480 -670 {
lab=row_n[28]}
N 8200 -930 8200 -910 {
lab=ctop}
N 8460 -930 8460 -910 {
lab=ctop}
N 8740 -690 8750 -700 {
lab=row_n[29]}
N 8750 -900 8750 -700 {
lab=row_n[29]}
N 8740 -910 8750 -900 {
lab=row_n[29]}
N 8740 -930 8740 -910 {
lab=row_n[29]}
N 8620 -830 8630 -840 {
lab=VDD}
N 8630 -840 8830 -840 {
lab=VDD}
N 8830 -840 8840 -830 {
lab=VDD}
N 8620 -810 8630 -820 {
lab=VDD}
N 8630 -820 8830 -820 {
lab=VDD}
N 8830 -820 8840 -810 {
lab=VDD}
N 8620 -790 8630 -800 {
lab=VSS}
N 8630 -800 8830 -800 {
lab=VSS}
N 8830 -800 8840 -790 {
lab=VSS}
N 8620 -770 8630 -780 {
lab=VDD}
N 8630 -780 8830 -780 {
lab=VDD}
N 8830 -780 8840 -770 {
lab=VDD}
N 8840 -770 8860 -770 {
lab=VDD}
N 8840 -790 8860 -790 {
lab=VSS}
N 8840 -810 8860 -810 {
lab=VDD}
N 8840 -830 8860 -830 {
lab=VDD}
N 8600 -830 8620 -830 {
lab=VDD}
N 8600 -810 8620 -810 {
lab=VDD}
N 8600 -790 8620 -790 {
lab=VSS}
N 8600 -770 8620 -770 {
lab=VDD}
N 8660 -690 8660 -680 {
lab=VSS}
N 8680 -930 8680 -910 {
lab=vcom}
N 8660 -920 8660 -910 {
lab=VDD}
N 8740 -690 8740 -670 {
lab=row_n[29]}
N 9000 -690 9010 -700 {
lab=row_n[30]}
N 9010 -900 9010 -700 {
lab=row_n[30]}
N 9000 -910 9010 -900 {
lab=row_n[30]}
N 9000 -930 9000 -910 {
lab=row_n[30]}
N 8880 -830 8890 -840 {
lab=VDD}
N 8890 -840 9090 -840 {
lab=VDD}
N 9090 -840 9100 -830 {
lab=VDD}
N 8880 -810 8890 -820 {
lab=VDD}
N 8890 -820 9090 -820 {
lab=VDD}
N 9090 -820 9100 -810 {
lab=VDD}
N 8880 -790 8890 -800 {
lab=VSS}
N 8890 -800 9090 -800 {
lab=VSS}
N 9090 -800 9100 -790 {
lab=VSS}
N 8880 -770 8890 -780 {
lab=VDD}
N 8890 -780 9090 -780 {
lab=VDD}
N 9090 -780 9100 -770 {
lab=VDD}
N 9100 -770 9120 -770 {
lab=VDD}
N 9100 -790 9120 -790 {
lab=VSS}
N 9100 -810 9120 -810 {
lab=VDD}
N 9100 -830 9120 -830 {
lab=VDD}
N 8860 -830 8880 -830 {
lab=VDD}
N 8860 -810 8880 -810 {
lab=VDD}
N 8860 -790 8880 -790 {
lab=VSS}
N 8860 -770 8880 -770 {
lab=VDD}
N 8920 -690 8920 -680 {
lab=VSS}
N 8940 -930 8940 -910 {
lab=vcom}
N 8920 -920 8920 -910 {
lab=VDD}
N 9000 -690 9000 -670 {
lab=row_n[30]}
N 8720 -930 8720 -910 {
lab=ctop}
N 8980 -930 8980 -910 {
lab=ctop}
N 9260 -690 9270 -700 {
lab=row_n[31]}
N 9270 -900 9270 -700 {
lab=row_n[31]}
N 9260 -910 9270 -900 {
lab=row_n[31]}
N 9260 -930 9260 -910 {
lab=row_n[31]}
N 9140 -830 9150 -840 {
lab=VDD}
N 9150 -840 9350 -840 {
lab=VDD}
N 9350 -840 9360 -830 {
lab=VDD}
N 9140 -810 9150 -820 {
lab=VDD}
N 9150 -820 9350 -820 {
lab=VDD}
N 9350 -820 9360 -810 {
lab=VDD}
N 9140 -790 9150 -800 {
lab=VSS}
N 9150 -800 9350 -800 {
lab=VSS}
N 9350 -800 9360 -790 {
lab=VSS}
N 9140 -770 9150 -780 {
lab=VDD}
N 9150 -780 9350 -780 {
lab=VDD}
N 9350 -780 9360 -770 {
lab=VDD}
N 9360 -770 9380 -770 {
lab=VDD}
N 9360 -790 9380 -790 {
lab=VSS}
N 9360 -810 9380 -810 {
lab=VDD}
N 9360 -830 9380 -830 {
lab=VDD}
N 9120 -830 9140 -830 {
lab=VDD}
N 9120 -810 9140 -810 {
lab=VDD}
N 9120 -790 9140 -790 {
lab=VSS}
N 9120 -770 9140 -770 {
lab=VDD}
N 9180 -690 9180 -680 {
lab=VSS}
N 9200 -930 9200 -910 {
lab=vcom}
N 9180 -920 9180 -910 {
lab=VDD}
N 9260 -690 9260 -670 {
lab=row_n[31]}
N 9240 -930 9240 -910 {
lab=ctop}
N 9520 -690 9530 -700 {
lab=VDD}
N 9530 -900 9530 -700 {
lab=VDD}
N 9520 -910 9530 -900 {
lab=VDD}
N 9520 -930 9520 -910 {
lab=VDD}
N 9400 -830 9410 -840 {
lab=VDD}
N 9410 -840 9610 -840 {
lab=VDD}
N 9610 -840 9620 -830 {
lab=VDD}
N 9400 -810 9410 -820 {
lab=VDD}
N 9410 -820 9610 -820 {
lab=VDD}
N 9610 -820 9620 -810 {
lab=VDD}
N 9400 -790 9410 -800 {
lab=VSS}
N 9410 -800 9610 -800 {
lab=VSS}
N 9610 -800 9620 -790 {
lab=VSS}
N 9400 -770 9410 -780 {
lab=VDD}
N 9410 -780 9610 -780 {
lab=VDD}
N 9610 -780 9620 -770 {
lab=VDD}
N 9620 -770 9640 -770 {
lab=VDD}
N 9620 -790 9640 -790 {
lab=VSS}
N 9620 -810 9640 -810 {
lab=VDD}
N 9620 -830 9640 -830 {
lab=VDD}
N 9380 -830 9400 -830 {
lab=VDD}
N 9380 -810 9400 -810 {
lab=VDD}
N 9380 -790 9400 -790 {
lab=VSS}
N 9380 -770 9400 -770 {
lab=VDD}
N 9440 -690 9440 -680 {
lab=VSS}
N 9460 -930 9460 -910 {
lab=vcom}
N 9440 -920 9440 -910 {
lab=VDD}
N 9520 -690 9520 -670 {
lab=VDD}
N 9500 -930 9500 -910 {
lab=ctop}
N 940 -9270 950 -9280 {
lab=VDD}
N 950 -9480 950 -9280 {
lab=VDD}
N 940 -9490 950 -9480 {
lab=VDD}
N 940 -9510 940 -9490 {
lab=VDD}
N 820 -9410 830 -9420 {
lab=VDD}
N 830 -9420 1030 -9420 {
lab=VDD}
N 1030 -9420 1040 -9410 {
lab=VDD}
N 820 -9390 830 -9400 {
lab=VDD}
N 830 -9400 1030 -9400 {
lab=VDD}
N 1030 -9400 1040 -9390 {
lab=VDD}
N 820 -9370 830 -9380 {
lab=VSS}
N 830 -9380 1030 -9380 {
lab=VSS}
N 1030 -9380 1040 -9370 {
lab=VSS}
N 820 -9350 830 -9360 {
lab=VDD}
N 830 -9360 1030 -9360 {
lab=VDD}
N 1030 -9360 1040 -9350 {
lab=VDD}
N 1040 -9350 1060 -9350 {
lab=VDD}
N 1040 -9370 1060 -9370 {
lab=VSS}
N 1040 -9390 1060 -9390 {
lab=VDD}
N 1040 -9410 1060 -9410 {
lab=VDD}
N 800 -9410 820 -9410 {
lab=VDD}
N 800 -9390 820 -9390 {
lab=VDD}
N 800 -9370 820 -9370 {
lab=VSS}
N 800 -9350 820 -9350 {
lab=VDD}
N 860 -9270 860 -9260 {
lab=VSS}
N 880 -9510 880 -9490 {
lab=vcom}
N 860 -9500 860 -9490 {
lab=VDD}
N 940 -9270 940 -9250 {
lab=VDD}
N 1200 -9270 1210 -9280 {
lab=row_n[0]}
N 1210 -9480 1210 -9280 {
lab=row_n[0]}
N 1200 -9490 1210 -9480 {
lab=row_n[0]}
N 1200 -9510 1200 -9490 {
lab=row_n[0]}
N 1080 -9410 1090 -9420 {
lab=VDD}
N 1090 -9420 1290 -9420 {
lab=VDD}
N 1290 -9420 1300 -9410 {
lab=VDD}
N 1080 -9390 1090 -9400 {
lab=VDD}
N 1090 -9400 1290 -9400 {
lab=VDD}
N 1290 -9400 1300 -9390 {
lab=VDD}
N 1080 -9370 1090 -9380 {
lab=VSS}
N 1090 -9380 1290 -9380 {
lab=VSS}
N 1290 -9380 1300 -9370 {
lab=VSS}
N 1080 -9350 1090 -9360 {
lab=VDD}
N 1090 -9360 1290 -9360 {
lab=VDD}
N 1290 -9360 1300 -9350 {
lab=VDD}
N 1300 -9350 1320 -9350 {
lab=VDD}
N 1300 -9370 1320 -9370 {
lab=VSS}
N 1300 -9390 1320 -9390 {
lab=VDD}
N 1300 -9410 1320 -9410 {
lab=VDD}
N 1060 -9410 1080 -9410 {
lab=VDD}
N 1060 -9390 1080 -9390 {
lab=VDD}
N 1060 -9370 1080 -9370 {
lab=VSS}
N 1060 -9350 1080 -9350 {
lab=VDD}
N 1120 -9270 1120 -9260 {
lab=VSS}
N 1140 -9510 1140 -9490 {
lab=vcom}
N 1120 -9500 1120 -9490 {
lab=VDD}
N 1200 -9270 1200 -9250 {
lab=row_n[0]}
N 920 -9510 920 -9490 {
lab=ctop}
N 1180 -9510 1180 -9490 {
lab=ctop}
N 1460 -9270 1470 -9280 {
lab=row_n[1]}
N 1470 -9480 1470 -9280 {
lab=row_n[1]}
N 1460 -9490 1470 -9480 {
lab=row_n[1]}
N 1460 -9510 1460 -9490 {
lab=row_n[1]}
N 1340 -9410 1350 -9420 {
lab=VDD}
N 1350 -9420 1550 -9420 {
lab=VDD}
N 1550 -9420 1560 -9410 {
lab=VDD}
N 1340 -9390 1350 -9400 {
lab=VDD}
N 1350 -9400 1550 -9400 {
lab=VDD}
N 1550 -9400 1560 -9390 {
lab=VDD}
N 1340 -9370 1350 -9380 {
lab=VSS}
N 1350 -9380 1550 -9380 {
lab=VSS}
N 1550 -9380 1560 -9370 {
lab=VSS}
N 1340 -9350 1350 -9360 {
lab=VDD}
N 1350 -9360 1550 -9360 {
lab=VDD}
N 1550 -9360 1560 -9350 {
lab=VDD}
N 1560 -9350 1580 -9350 {
lab=VDD}
N 1560 -9370 1580 -9370 {
lab=VSS}
N 1560 -9390 1580 -9390 {
lab=VDD}
N 1560 -9410 1580 -9410 {
lab=VDD}
N 1320 -9410 1340 -9410 {
lab=VDD}
N 1320 -9390 1340 -9390 {
lab=VDD}
N 1320 -9370 1340 -9370 {
lab=VSS}
N 1320 -9350 1340 -9350 {
lab=VDD}
N 1380 -9270 1380 -9260 {
lab=VSS}
N 1400 -9510 1400 -9490 {
lab=vcom}
N 1380 -9500 1380 -9490 {
lab=VDD}
N 1460 -9270 1460 -9250 {
lab=row_n[1]}
N 1720 -9270 1730 -9280 {
lab=row_n[2]}
N 1730 -9480 1730 -9280 {
lab=row_n[2]}
N 1720 -9490 1730 -9480 {
lab=row_n[2]}
N 1720 -9510 1720 -9490 {
lab=row_n[2]}
N 1600 -9410 1610 -9420 {
lab=VDD}
N 1610 -9420 1810 -9420 {
lab=VDD}
N 1810 -9420 1820 -9410 {
lab=VDD}
N 1600 -9390 1610 -9400 {
lab=VDD}
N 1610 -9400 1810 -9400 {
lab=VDD}
N 1810 -9400 1820 -9390 {
lab=VDD}
N 1600 -9370 1610 -9380 {
lab=VSS}
N 1610 -9380 1810 -9380 {
lab=VSS}
N 1810 -9380 1820 -9370 {
lab=VSS}
N 1600 -9350 1610 -9360 {
lab=VDD}
N 1610 -9360 1810 -9360 {
lab=VDD}
N 1810 -9360 1820 -9350 {
lab=VDD}
N 1820 -9350 1840 -9350 {
lab=VDD}
N 1820 -9370 1840 -9370 {
lab=VSS}
N 1820 -9390 1840 -9390 {
lab=VDD}
N 1820 -9410 1840 -9410 {
lab=VDD}
N 1580 -9410 1600 -9410 {
lab=VDD}
N 1580 -9390 1600 -9390 {
lab=VDD}
N 1580 -9370 1600 -9370 {
lab=VSS}
N 1580 -9350 1600 -9350 {
lab=VDD}
N 1640 -9270 1640 -9260 {
lab=VSS}
N 1660 -9510 1660 -9490 {
lab=vcom}
N 1640 -9500 1640 -9490 {
lab=VDD}
N 1720 -9270 1720 -9250 {
lab=row_n[2]}
N 1440 -9510 1440 -9490 {
lab=ctop}
N 1700 -9510 1700 -9490 {
lab=ctop}
N 1980 -9270 1990 -9280 {
lab=row_n[3]}
N 1990 -9480 1990 -9280 {
lab=row_n[3]}
N 1980 -9490 1990 -9480 {
lab=row_n[3]}
N 1980 -9510 1980 -9490 {
lab=row_n[3]}
N 1860 -9410 1870 -9420 {
lab=VDD}
N 1870 -9420 2070 -9420 {
lab=VDD}
N 2070 -9420 2080 -9410 {
lab=VDD}
N 1860 -9390 1870 -9400 {
lab=VDD}
N 1870 -9400 2070 -9400 {
lab=VDD}
N 2070 -9400 2080 -9390 {
lab=VDD}
N 1860 -9370 1870 -9380 {
lab=VSS}
N 1870 -9380 2070 -9380 {
lab=VSS}
N 2070 -9380 2080 -9370 {
lab=VSS}
N 1860 -9350 1870 -9360 {
lab=VDD}
N 1870 -9360 2070 -9360 {
lab=VDD}
N 2070 -9360 2080 -9350 {
lab=VDD}
N 2080 -9350 2100 -9350 {
lab=VDD}
N 2080 -9370 2100 -9370 {
lab=VSS}
N 2080 -9390 2100 -9390 {
lab=VDD}
N 2080 -9410 2100 -9410 {
lab=VDD}
N 1840 -9410 1860 -9410 {
lab=VDD}
N 1840 -9390 1860 -9390 {
lab=VDD}
N 1840 -9370 1860 -9370 {
lab=VSS}
N 1840 -9350 1860 -9350 {
lab=VDD}
N 1900 -9270 1900 -9260 {
lab=VSS}
N 1920 -9510 1920 -9490 {
lab=vcom}
N 1900 -9500 1900 -9490 {
lab=VDD}
N 1980 -9270 1980 -9250 {
lab=row_n[3]}
N 2240 -9270 2250 -9280 {
lab=row_n[4]}
N 2250 -9480 2250 -9280 {
lab=row_n[4]}
N 2240 -9490 2250 -9480 {
lab=row_n[4]}
N 2240 -9510 2240 -9490 {
lab=row_n[4]}
N 2120 -9410 2130 -9420 {
lab=VDD}
N 2130 -9420 2330 -9420 {
lab=VDD}
N 2330 -9420 2340 -9410 {
lab=VDD}
N 2120 -9390 2130 -9400 {
lab=VDD}
N 2130 -9400 2330 -9400 {
lab=VDD}
N 2330 -9400 2340 -9390 {
lab=VDD}
N 2120 -9370 2130 -9380 {
lab=VSS}
N 2130 -9380 2330 -9380 {
lab=VSS}
N 2330 -9380 2340 -9370 {
lab=VSS}
N 2120 -9350 2130 -9360 {
lab=VDD}
N 2130 -9360 2330 -9360 {
lab=VDD}
N 2330 -9360 2340 -9350 {
lab=VDD}
N 2340 -9350 2360 -9350 {
lab=VDD}
N 2340 -9370 2360 -9370 {
lab=VSS}
N 2340 -9390 2360 -9390 {
lab=VDD}
N 2340 -9410 2360 -9410 {
lab=VDD}
N 2100 -9410 2120 -9410 {
lab=VDD}
N 2100 -9390 2120 -9390 {
lab=VDD}
N 2100 -9370 2120 -9370 {
lab=VSS}
N 2100 -9350 2120 -9350 {
lab=VDD}
N 2160 -9270 2160 -9260 {
lab=VSS}
N 2180 -9510 2180 -9490 {
lab=vcom}
N 2160 -9500 2160 -9490 {
lab=VDD}
N 2240 -9270 2240 -9250 {
lab=row_n[4]}
N 1960 -9510 1960 -9490 {
lab=ctop}
N 2220 -9510 2220 -9490 {
lab=ctop}
N 2500 -9270 2510 -9280 {
lab=row_n[5]}
N 2510 -9480 2510 -9280 {
lab=row_n[5]}
N 2500 -9490 2510 -9480 {
lab=row_n[5]}
N 2500 -9510 2500 -9490 {
lab=row_n[5]}
N 2380 -9410 2390 -9420 {
lab=VDD}
N 2390 -9420 2590 -9420 {
lab=VDD}
N 2590 -9420 2600 -9410 {
lab=VDD}
N 2380 -9390 2390 -9400 {
lab=VDD}
N 2390 -9400 2590 -9400 {
lab=VDD}
N 2590 -9400 2600 -9390 {
lab=VDD}
N 2380 -9370 2390 -9380 {
lab=VSS}
N 2390 -9380 2590 -9380 {
lab=VSS}
N 2590 -9380 2600 -9370 {
lab=VSS}
N 2380 -9350 2390 -9360 {
lab=VDD}
N 2390 -9360 2590 -9360 {
lab=VDD}
N 2590 -9360 2600 -9350 {
lab=VDD}
N 2600 -9350 2620 -9350 {
lab=VDD}
N 2600 -9370 2620 -9370 {
lab=VSS}
N 2600 -9390 2620 -9390 {
lab=VDD}
N 2600 -9410 2620 -9410 {
lab=VDD}
N 2360 -9410 2380 -9410 {
lab=VDD}
N 2360 -9390 2380 -9390 {
lab=VDD}
N 2360 -9370 2380 -9370 {
lab=VSS}
N 2360 -9350 2380 -9350 {
lab=VDD}
N 2420 -9270 2420 -9260 {
lab=VSS}
N 2440 -9510 2440 -9490 {
lab=vcom}
N 2420 -9500 2420 -9490 {
lab=VDD}
N 2500 -9270 2500 -9250 {
lab=row_n[5]}
N 2760 -9270 2770 -9280 {
lab=row_n[6]}
N 2770 -9480 2770 -9280 {
lab=row_n[6]}
N 2760 -9490 2770 -9480 {
lab=row_n[6]}
N 2760 -9510 2760 -9490 {
lab=row_n[6]}
N 2640 -9410 2650 -9420 {
lab=VDD}
N 2650 -9420 2850 -9420 {
lab=VDD}
N 2850 -9420 2860 -9410 {
lab=VDD}
N 2640 -9390 2650 -9400 {
lab=VDD}
N 2650 -9400 2850 -9400 {
lab=VDD}
N 2850 -9400 2860 -9390 {
lab=VDD}
N 2640 -9370 2650 -9380 {
lab=VSS}
N 2650 -9380 2850 -9380 {
lab=VSS}
N 2850 -9380 2860 -9370 {
lab=VSS}
N 2640 -9350 2650 -9360 {
lab=VDD}
N 2650 -9360 2850 -9360 {
lab=VDD}
N 2850 -9360 2860 -9350 {
lab=VDD}
N 2860 -9350 2880 -9350 {
lab=VDD}
N 2860 -9370 2880 -9370 {
lab=VSS}
N 2860 -9390 2880 -9390 {
lab=VDD}
N 2860 -9410 2880 -9410 {
lab=VDD}
N 2620 -9410 2640 -9410 {
lab=VDD}
N 2620 -9390 2640 -9390 {
lab=VDD}
N 2620 -9370 2640 -9370 {
lab=VSS}
N 2620 -9350 2640 -9350 {
lab=VDD}
N 2680 -9270 2680 -9260 {
lab=VSS}
N 2700 -9510 2700 -9490 {
lab=vcom}
N 2680 -9500 2680 -9490 {
lab=VDD}
N 2760 -9270 2760 -9250 {
lab=row_n[6]}
N 2480 -9510 2480 -9490 {
lab=ctop}
N 2740 -9510 2740 -9490 {
lab=ctop}
N 3020 -9270 3030 -9280 {
lab=row_n[7]}
N 3030 -9480 3030 -9280 {
lab=row_n[7]}
N 3020 -9490 3030 -9480 {
lab=row_n[7]}
N 3020 -9510 3020 -9490 {
lab=row_n[7]}
N 2900 -9410 2910 -9420 {
lab=VDD}
N 2910 -9420 3110 -9420 {
lab=VDD}
N 3110 -9420 3120 -9410 {
lab=VDD}
N 2900 -9390 2910 -9400 {
lab=VDD}
N 2910 -9400 3110 -9400 {
lab=VDD}
N 3110 -9400 3120 -9390 {
lab=VDD}
N 2900 -9370 2910 -9380 {
lab=VSS}
N 2910 -9380 3110 -9380 {
lab=VSS}
N 3110 -9380 3120 -9370 {
lab=VSS}
N 2900 -9350 2910 -9360 {
lab=VDD}
N 2910 -9360 3110 -9360 {
lab=VDD}
N 3110 -9360 3120 -9350 {
lab=VDD}
N 3120 -9350 3140 -9350 {
lab=VDD}
N 3120 -9370 3140 -9370 {
lab=VSS}
N 3120 -9390 3140 -9390 {
lab=VDD}
N 3120 -9410 3140 -9410 {
lab=VDD}
N 2880 -9410 2900 -9410 {
lab=VDD}
N 2880 -9390 2900 -9390 {
lab=VDD}
N 2880 -9370 2900 -9370 {
lab=VSS}
N 2880 -9350 2900 -9350 {
lab=VDD}
N 2940 -9270 2940 -9260 {
lab=VSS}
N 2960 -9510 2960 -9490 {
lab=vcom}
N 2940 -9500 2940 -9490 {
lab=VDD}
N 3020 -9270 3020 -9250 {
lab=row_n[7]}
N 3280 -9270 3290 -9280 {
lab=row_n[8]}
N 3290 -9480 3290 -9280 {
lab=row_n[8]}
N 3280 -9490 3290 -9480 {
lab=row_n[8]}
N 3280 -9510 3280 -9490 {
lab=row_n[8]}
N 3160 -9410 3170 -9420 {
lab=VDD}
N 3170 -9420 3370 -9420 {
lab=VDD}
N 3370 -9420 3380 -9410 {
lab=VDD}
N 3160 -9390 3170 -9400 {
lab=VDD}
N 3170 -9400 3370 -9400 {
lab=VDD}
N 3370 -9400 3380 -9390 {
lab=VDD}
N 3160 -9370 3170 -9380 {
lab=VSS}
N 3170 -9380 3370 -9380 {
lab=VSS}
N 3370 -9380 3380 -9370 {
lab=VSS}
N 3160 -9350 3170 -9360 {
lab=VDD}
N 3170 -9360 3370 -9360 {
lab=VDD}
N 3370 -9360 3380 -9350 {
lab=VDD}
N 3380 -9350 3400 -9350 {
lab=VDD}
N 3380 -9370 3400 -9370 {
lab=VSS}
N 3380 -9390 3400 -9390 {
lab=VDD}
N 3380 -9410 3400 -9410 {
lab=VDD}
N 3140 -9410 3160 -9410 {
lab=VDD}
N 3140 -9390 3160 -9390 {
lab=VDD}
N 3140 -9370 3160 -9370 {
lab=VSS}
N 3140 -9350 3160 -9350 {
lab=VDD}
N 3200 -9270 3200 -9260 {
lab=VSS}
N 3220 -9510 3220 -9490 {
lab=vcom}
N 3200 -9500 3200 -9490 {
lab=VDD}
N 3280 -9270 3280 -9250 {
lab=row_n[8]}
N 3000 -9510 3000 -9490 {
lab=ctop}
N 3260 -9510 3260 -9490 {
lab=ctop}
N 3540 -9270 3550 -9280 {
lab=row_n[9]}
N 3550 -9480 3550 -9280 {
lab=row_n[9]}
N 3540 -9490 3550 -9480 {
lab=row_n[9]}
N 3540 -9510 3540 -9490 {
lab=row_n[9]}
N 3420 -9410 3430 -9420 {
lab=VDD}
N 3430 -9420 3630 -9420 {
lab=VDD}
N 3630 -9420 3640 -9410 {
lab=VDD}
N 3420 -9390 3430 -9400 {
lab=VDD}
N 3430 -9400 3630 -9400 {
lab=VDD}
N 3630 -9400 3640 -9390 {
lab=VDD}
N 3420 -9370 3430 -9380 {
lab=VSS}
N 3430 -9380 3630 -9380 {
lab=VSS}
N 3630 -9380 3640 -9370 {
lab=VSS}
N 3420 -9350 3430 -9360 {
lab=VDD}
N 3430 -9360 3630 -9360 {
lab=VDD}
N 3630 -9360 3640 -9350 {
lab=VDD}
N 3640 -9350 3660 -9350 {
lab=VDD}
N 3640 -9370 3660 -9370 {
lab=VSS}
N 3640 -9390 3660 -9390 {
lab=VDD}
N 3640 -9410 3660 -9410 {
lab=VDD}
N 3400 -9410 3420 -9410 {
lab=VDD}
N 3400 -9390 3420 -9390 {
lab=VDD}
N 3400 -9370 3420 -9370 {
lab=VSS}
N 3400 -9350 3420 -9350 {
lab=VDD}
N 3460 -9270 3460 -9260 {
lab=VSS}
N 3480 -9510 3480 -9490 {
lab=vcom}
N 3460 -9500 3460 -9490 {
lab=VDD}
N 3540 -9270 3540 -9250 {
lab=row_n[9]}
N 3800 -9270 3810 -9280 {
lab=row_n[10]}
N 3810 -9480 3810 -9280 {
lab=row_n[10]}
N 3800 -9490 3810 -9480 {
lab=row_n[10]}
N 3800 -9510 3800 -9490 {
lab=row_n[10]}
N 3680 -9410 3690 -9420 {
lab=VDD}
N 3690 -9420 3890 -9420 {
lab=VDD}
N 3890 -9420 3900 -9410 {
lab=VDD}
N 3680 -9390 3690 -9400 {
lab=VDD}
N 3690 -9400 3890 -9400 {
lab=VDD}
N 3890 -9400 3900 -9390 {
lab=VDD}
N 3680 -9370 3690 -9380 {
lab=VSS}
N 3690 -9380 3890 -9380 {
lab=VSS}
N 3890 -9380 3900 -9370 {
lab=VSS}
N 3680 -9350 3690 -9360 {
lab=VDD}
N 3690 -9360 3890 -9360 {
lab=VDD}
N 3890 -9360 3900 -9350 {
lab=VDD}
N 3900 -9350 3920 -9350 {
lab=VDD}
N 3900 -9370 3920 -9370 {
lab=VSS}
N 3900 -9390 3920 -9390 {
lab=VDD}
N 3900 -9410 3920 -9410 {
lab=VDD}
N 3660 -9410 3680 -9410 {
lab=VDD}
N 3660 -9390 3680 -9390 {
lab=VDD}
N 3660 -9370 3680 -9370 {
lab=VSS}
N 3660 -9350 3680 -9350 {
lab=VDD}
N 3720 -9270 3720 -9260 {
lab=VSS}
N 3740 -9510 3740 -9490 {
lab=vcom}
N 3720 -9500 3720 -9490 {
lab=VDD}
N 3800 -9270 3800 -9250 {
lab=row_n[10]}
N 3520 -9510 3520 -9490 {
lab=ctop}
N 3780 -9510 3780 -9490 {
lab=ctop}
N 4060 -9270 4070 -9280 {
lab=row_n[11]}
N 4070 -9480 4070 -9280 {
lab=row_n[11]}
N 4060 -9490 4070 -9480 {
lab=row_n[11]}
N 4060 -9510 4060 -9490 {
lab=row_n[11]}
N 3940 -9410 3950 -9420 {
lab=VDD}
N 3950 -9420 4150 -9420 {
lab=VDD}
N 4150 -9420 4160 -9410 {
lab=VDD}
N 3940 -9390 3950 -9400 {
lab=VDD}
N 3950 -9400 4150 -9400 {
lab=VDD}
N 4150 -9400 4160 -9390 {
lab=VDD}
N 3940 -9370 3950 -9380 {
lab=VSS}
N 3950 -9380 4150 -9380 {
lab=VSS}
N 4150 -9380 4160 -9370 {
lab=VSS}
N 3940 -9350 3950 -9360 {
lab=VDD}
N 3950 -9360 4150 -9360 {
lab=VDD}
N 4150 -9360 4160 -9350 {
lab=VDD}
N 4160 -9350 4180 -9350 {
lab=VDD}
N 4160 -9370 4180 -9370 {
lab=VSS}
N 4160 -9390 4180 -9390 {
lab=VDD}
N 4160 -9410 4180 -9410 {
lab=VDD}
N 3920 -9410 3940 -9410 {
lab=VDD}
N 3920 -9390 3940 -9390 {
lab=VDD}
N 3920 -9370 3940 -9370 {
lab=VSS}
N 3920 -9350 3940 -9350 {
lab=VDD}
N 3980 -9270 3980 -9260 {
lab=VSS}
N 4000 -9510 4000 -9490 {
lab=vcom}
N 3980 -9500 3980 -9490 {
lab=VDD}
N 4060 -9270 4060 -9250 {
lab=row_n[11]}
N 4320 -9270 4330 -9280 {
lab=row_n[12]}
N 4330 -9480 4330 -9280 {
lab=row_n[12]}
N 4320 -9490 4330 -9480 {
lab=row_n[12]}
N 4320 -9510 4320 -9490 {
lab=row_n[12]}
N 4200 -9410 4210 -9420 {
lab=VDD}
N 4210 -9420 4410 -9420 {
lab=VDD}
N 4410 -9420 4420 -9410 {
lab=VDD}
N 4200 -9390 4210 -9400 {
lab=VDD}
N 4210 -9400 4410 -9400 {
lab=VDD}
N 4410 -9400 4420 -9390 {
lab=VDD}
N 4200 -9370 4210 -9380 {
lab=VSS}
N 4210 -9380 4410 -9380 {
lab=VSS}
N 4410 -9380 4420 -9370 {
lab=VSS}
N 4200 -9350 4210 -9360 {
lab=VDD}
N 4210 -9360 4410 -9360 {
lab=VDD}
N 4410 -9360 4420 -9350 {
lab=VDD}
N 4420 -9350 4440 -9350 {
lab=VDD}
N 4420 -9370 4440 -9370 {
lab=VSS}
N 4420 -9390 4440 -9390 {
lab=VDD}
N 4420 -9410 4440 -9410 {
lab=VDD}
N 4180 -9410 4200 -9410 {
lab=VDD}
N 4180 -9390 4200 -9390 {
lab=VDD}
N 4180 -9370 4200 -9370 {
lab=VSS}
N 4180 -9350 4200 -9350 {
lab=VDD}
N 4240 -9270 4240 -9260 {
lab=VSS}
N 4260 -9510 4260 -9490 {
lab=vcom}
N 4240 -9500 4240 -9490 {
lab=VDD}
N 4320 -9270 4320 -9250 {
lab=row_n[12]}
N 4040 -9510 4040 -9490 {
lab=ctop}
N 4300 -9510 4300 -9490 {
lab=ctop}
N 4580 -9270 4590 -9280 {
lab=row_n[13]}
N 4590 -9480 4590 -9280 {
lab=row_n[13]}
N 4580 -9490 4590 -9480 {
lab=row_n[13]}
N 4580 -9510 4580 -9490 {
lab=row_n[13]}
N 4460 -9410 4470 -9420 {
lab=VDD}
N 4470 -9420 4670 -9420 {
lab=VDD}
N 4670 -9420 4680 -9410 {
lab=VDD}
N 4460 -9390 4470 -9400 {
lab=VDD}
N 4470 -9400 4670 -9400 {
lab=VDD}
N 4670 -9400 4680 -9390 {
lab=VDD}
N 4460 -9370 4470 -9380 {
lab=VSS}
N 4470 -9380 4670 -9380 {
lab=VSS}
N 4670 -9380 4680 -9370 {
lab=VSS}
N 4460 -9350 4470 -9360 {
lab=VDD}
N 4470 -9360 4670 -9360 {
lab=VDD}
N 4670 -9360 4680 -9350 {
lab=VDD}
N 4680 -9350 4700 -9350 {
lab=VDD}
N 4680 -9370 4700 -9370 {
lab=VSS}
N 4680 -9390 4700 -9390 {
lab=VDD}
N 4680 -9410 4700 -9410 {
lab=VDD}
N 4440 -9410 4460 -9410 {
lab=VDD}
N 4440 -9390 4460 -9390 {
lab=VDD}
N 4440 -9370 4460 -9370 {
lab=VSS}
N 4440 -9350 4460 -9350 {
lab=VDD}
N 4500 -9270 4500 -9260 {
lab=VSS}
N 4520 -9510 4520 -9490 {
lab=vcom}
N 4500 -9500 4500 -9490 {
lab=VDD}
N 4580 -9270 4580 -9250 {
lab=row_n[13]}
N 4840 -9270 4850 -9280 {
lab=row_n[14]}
N 4850 -9480 4850 -9280 {
lab=row_n[14]}
N 4840 -9490 4850 -9480 {
lab=row_n[14]}
N 4840 -9510 4840 -9490 {
lab=row_n[14]}
N 4720 -9410 4730 -9420 {
lab=VDD}
N 4730 -9420 4930 -9420 {
lab=VDD}
N 4930 -9420 4940 -9410 {
lab=VDD}
N 4720 -9390 4730 -9400 {
lab=VDD}
N 4730 -9400 4930 -9400 {
lab=VDD}
N 4930 -9400 4940 -9390 {
lab=VDD}
N 4720 -9370 4730 -9380 {
lab=VSS}
N 4730 -9380 4930 -9380 {
lab=VSS}
N 4930 -9380 4940 -9370 {
lab=VSS}
N 4720 -9350 4730 -9360 {
lab=VDD}
N 4730 -9360 4930 -9360 {
lab=VDD}
N 4930 -9360 4940 -9350 {
lab=VDD}
N 4940 -9350 4960 -9350 {
lab=VDD}
N 4940 -9370 4960 -9370 {
lab=VSS}
N 4940 -9390 4960 -9390 {
lab=VDD}
N 4940 -9410 4960 -9410 {
lab=VDD}
N 4700 -9410 4720 -9410 {
lab=VDD}
N 4700 -9390 4720 -9390 {
lab=VDD}
N 4700 -9370 4720 -9370 {
lab=VSS}
N 4700 -9350 4720 -9350 {
lab=VDD}
N 4760 -9270 4760 -9260 {
lab=VSS}
N 4780 -9510 4780 -9490 {
lab=vcom}
N 4760 -9500 4760 -9490 {
lab=VDD}
N 4840 -9270 4840 -9250 {
lab=row_n[14]}
N 4560 -9510 4560 -9490 {
lab=ctop}
N 4820 -9510 4820 -9490 {
lab=ctop}
N 5100 -9270 5110 -9280 {
lab=row_n[15]}
N 5110 -9480 5110 -9280 {
lab=row_n[15]}
N 5100 -9490 5110 -9480 {
lab=row_n[15]}
N 5100 -9510 5100 -9490 {
lab=row_n[15]}
N 4980 -9410 4990 -9420 {
lab=VDD}
N 4990 -9420 5190 -9420 {
lab=VDD}
N 5190 -9420 5200 -9410 {
lab=VDD}
N 4980 -9390 4990 -9400 {
lab=VDD}
N 4990 -9400 5190 -9400 {
lab=VDD}
N 5190 -9400 5200 -9390 {
lab=VDD}
N 4980 -9370 4990 -9380 {
lab=VSS}
N 4990 -9380 5190 -9380 {
lab=VSS}
N 5190 -9380 5200 -9370 {
lab=VSS}
N 4980 -9350 4990 -9360 {
lab=VDD}
N 4990 -9360 5190 -9360 {
lab=VDD}
N 5190 -9360 5200 -9350 {
lab=VDD}
N 5200 -9350 5220 -9350 {
lab=VDD}
N 5200 -9370 5220 -9370 {
lab=VSS}
N 5200 -9390 5220 -9390 {
lab=VDD}
N 5200 -9410 5220 -9410 {
lab=VDD}
N 4960 -9410 4980 -9410 {
lab=VDD}
N 4960 -9390 4980 -9390 {
lab=VDD}
N 4960 -9370 4980 -9370 {
lab=VSS}
N 4960 -9350 4980 -9350 {
lab=VDD}
N 5020 -9270 5020 -9260 {
lab=VSS}
N 5040 -9510 5040 -9490 {
lab=vcom}
N 5020 -9500 5020 -9490 {
lab=VDD}
N 5100 -9270 5100 -9250 {
lab=row_n[15]}
N 5360 -9270 5370 -9280 {
lab=row_n[16]}
N 5370 -9480 5370 -9280 {
lab=row_n[16]}
N 5360 -9490 5370 -9480 {
lab=row_n[16]}
N 5360 -9510 5360 -9490 {
lab=row_n[16]}
N 5240 -9410 5250 -9420 {
lab=VDD}
N 5250 -9420 5450 -9420 {
lab=VDD}
N 5450 -9420 5460 -9410 {
lab=VDD}
N 5240 -9390 5250 -9400 {
lab=VDD}
N 5250 -9400 5450 -9400 {
lab=VDD}
N 5450 -9400 5460 -9390 {
lab=VDD}
N 5240 -9370 5250 -9380 {
lab=VSS}
N 5250 -9380 5450 -9380 {
lab=VSS}
N 5450 -9380 5460 -9370 {
lab=VSS}
N 5240 -9350 5250 -9360 {
lab=VDD}
N 5250 -9360 5450 -9360 {
lab=VDD}
N 5450 -9360 5460 -9350 {
lab=VDD}
N 5460 -9350 5480 -9350 {
lab=VDD}
N 5460 -9370 5480 -9370 {
lab=VSS}
N 5460 -9390 5480 -9390 {
lab=VDD}
N 5460 -9410 5480 -9410 {
lab=VDD}
N 5220 -9410 5240 -9410 {
lab=VDD}
N 5220 -9390 5240 -9390 {
lab=VDD}
N 5220 -9370 5240 -9370 {
lab=VSS}
N 5220 -9350 5240 -9350 {
lab=VDD}
N 5280 -9270 5280 -9260 {
lab=VSS}
N 5300 -9510 5300 -9490 {
lab=vcom}
N 5280 -9500 5280 -9490 {
lab=VDD}
N 5360 -9270 5360 -9250 {
lab=row_n[16]}
N 5080 -9510 5080 -9490 {
lab=ctop}
N 5340 -9510 5340 -9490 {
lab=ctop}
N 5620 -9270 5630 -9280 {
lab=row_n[17]}
N 5630 -9480 5630 -9280 {
lab=row_n[17]}
N 5620 -9490 5630 -9480 {
lab=row_n[17]}
N 5620 -9510 5620 -9490 {
lab=row_n[17]}
N 5500 -9410 5510 -9420 {
lab=VDD}
N 5510 -9420 5710 -9420 {
lab=VDD}
N 5710 -9420 5720 -9410 {
lab=VDD}
N 5500 -9390 5510 -9400 {
lab=VDD}
N 5510 -9400 5710 -9400 {
lab=VDD}
N 5710 -9400 5720 -9390 {
lab=VDD}
N 5500 -9370 5510 -9380 {
lab=VSS}
N 5510 -9380 5710 -9380 {
lab=VSS}
N 5710 -9380 5720 -9370 {
lab=VSS}
N 5500 -9350 5510 -9360 {
lab=VDD}
N 5510 -9360 5710 -9360 {
lab=VDD}
N 5710 -9360 5720 -9350 {
lab=VDD}
N 5720 -9350 5740 -9350 {
lab=VDD}
N 5720 -9370 5740 -9370 {
lab=VSS}
N 5720 -9390 5740 -9390 {
lab=VDD}
N 5720 -9410 5740 -9410 {
lab=VDD}
N 5480 -9410 5500 -9410 {
lab=VDD}
N 5480 -9390 5500 -9390 {
lab=VDD}
N 5480 -9370 5500 -9370 {
lab=VSS}
N 5480 -9350 5500 -9350 {
lab=VDD}
N 5540 -9270 5540 -9260 {
lab=VSS}
N 5560 -9510 5560 -9490 {
lab=vcom}
N 5540 -9500 5540 -9490 {
lab=VDD}
N 5620 -9270 5620 -9250 {
lab=row_n[17]}
N 5880 -9270 5890 -9280 {
lab=row_n[18]}
N 5890 -9480 5890 -9280 {
lab=row_n[18]}
N 5880 -9490 5890 -9480 {
lab=row_n[18]}
N 5880 -9510 5880 -9490 {
lab=row_n[18]}
N 5760 -9410 5770 -9420 {
lab=VDD}
N 5770 -9420 5970 -9420 {
lab=VDD}
N 5970 -9420 5980 -9410 {
lab=VDD}
N 5760 -9390 5770 -9400 {
lab=VDD}
N 5770 -9400 5970 -9400 {
lab=VDD}
N 5970 -9400 5980 -9390 {
lab=VDD}
N 5760 -9370 5770 -9380 {
lab=VSS}
N 5770 -9380 5970 -9380 {
lab=VSS}
N 5970 -9380 5980 -9370 {
lab=VSS}
N 5760 -9350 5770 -9360 {
lab=VDD}
N 5770 -9360 5970 -9360 {
lab=VDD}
N 5970 -9360 5980 -9350 {
lab=VDD}
N 5980 -9350 6000 -9350 {
lab=VDD}
N 5980 -9370 6000 -9370 {
lab=VSS}
N 5980 -9390 6000 -9390 {
lab=VDD}
N 5980 -9410 6000 -9410 {
lab=VDD}
N 5740 -9410 5760 -9410 {
lab=VDD}
N 5740 -9390 5760 -9390 {
lab=VDD}
N 5740 -9370 5760 -9370 {
lab=VSS}
N 5740 -9350 5760 -9350 {
lab=VDD}
N 5800 -9270 5800 -9260 {
lab=VSS}
N 5820 -9510 5820 -9490 {
lab=vcom}
N 5800 -9500 5800 -9490 {
lab=VDD}
N 5880 -9270 5880 -9250 {
lab=row_n[18]}
N 5600 -9510 5600 -9490 {
lab=ctop}
N 5860 -9510 5860 -9490 {
lab=ctop}
N 6140 -9270 6150 -9280 {
lab=row_n[19]}
N 6150 -9480 6150 -9280 {
lab=row_n[19]}
N 6140 -9490 6150 -9480 {
lab=row_n[19]}
N 6140 -9510 6140 -9490 {
lab=row_n[19]}
N 6020 -9410 6030 -9420 {
lab=VDD}
N 6030 -9420 6230 -9420 {
lab=VDD}
N 6230 -9420 6240 -9410 {
lab=VDD}
N 6020 -9390 6030 -9400 {
lab=VDD}
N 6030 -9400 6230 -9400 {
lab=VDD}
N 6230 -9400 6240 -9390 {
lab=VDD}
N 6020 -9370 6030 -9380 {
lab=VSS}
N 6030 -9380 6230 -9380 {
lab=VSS}
N 6230 -9380 6240 -9370 {
lab=VSS}
N 6020 -9350 6030 -9360 {
lab=VDD}
N 6030 -9360 6230 -9360 {
lab=VDD}
N 6230 -9360 6240 -9350 {
lab=VDD}
N 6240 -9350 6260 -9350 {
lab=VDD}
N 6240 -9370 6260 -9370 {
lab=VSS}
N 6240 -9390 6260 -9390 {
lab=VDD}
N 6240 -9410 6260 -9410 {
lab=VDD}
N 6000 -9410 6020 -9410 {
lab=VDD}
N 6000 -9390 6020 -9390 {
lab=VDD}
N 6000 -9370 6020 -9370 {
lab=VSS}
N 6000 -9350 6020 -9350 {
lab=VDD}
N 6060 -9270 6060 -9260 {
lab=VSS}
N 6080 -9510 6080 -9490 {
lab=vcom}
N 6060 -9500 6060 -9490 {
lab=VDD}
N 6140 -9270 6140 -9250 {
lab=row_n[19]}
N 6400 -9270 6410 -9280 {
lab=row_n[20]}
N 6410 -9480 6410 -9280 {
lab=row_n[20]}
N 6400 -9490 6410 -9480 {
lab=row_n[20]}
N 6400 -9510 6400 -9490 {
lab=row_n[20]}
N 6280 -9410 6290 -9420 {
lab=VDD}
N 6290 -9420 6490 -9420 {
lab=VDD}
N 6490 -9420 6500 -9410 {
lab=VDD}
N 6280 -9390 6290 -9400 {
lab=VDD}
N 6290 -9400 6490 -9400 {
lab=VDD}
N 6490 -9400 6500 -9390 {
lab=VDD}
N 6280 -9370 6290 -9380 {
lab=VSS}
N 6290 -9380 6490 -9380 {
lab=VSS}
N 6490 -9380 6500 -9370 {
lab=VSS}
N 6280 -9350 6290 -9360 {
lab=VDD}
N 6290 -9360 6490 -9360 {
lab=VDD}
N 6490 -9360 6500 -9350 {
lab=VDD}
N 6500 -9350 6520 -9350 {
lab=VDD}
N 6500 -9370 6520 -9370 {
lab=VSS}
N 6500 -9390 6520 -9390 {
lab=VDD}
N 6500 -9410 6520 -9410 {
lab=VDD}
N 6260 -9410 6280 -9410 {
lab=VDD}
N 6260 -9390 6280 -9390 {
lab=VDD}
N 6260 -9370 6280 -9370 {
lab=VSS}
N 6260 -9350 6280 -9350 {
lab=VDD}
N 6320 -9270 6320 -9260 {
lab=VSS}
N 6340 -9510 6340 -9490 {
lab=vcom}
N 6320 -9500 6320 -9490 {
lab=VDD}
N 6400 -9270 6400 -9250 {
lab=row_n[20]}
N 6120 -9510 6120 -9490 {
lab=ctop}
N 6380 -9510 6380 -9490 {
lab=ctop}
N 6660 -9270 6670 -9280 {
lab=row_n[21]}
N 6670 -9480 6670 -9280 {
lab=row_n[21]}
N 6660 -9490 6670 -9480 {
lab=row_n[21]}
N 6660 -9510 6660 -9490 {
lab=row_n[21]}
N 6540 -9410 6550 -9420 {
lab=VDD}
N 6550 -9420 6750 -9420 {
lab=VDD}
N 6750 -9420 6760 -9410 {
lab=VDD}
N 6540 -9390 6550 -9400 {
lab=VDD}
N 6550 -9400 6750 -9400 {
lab=VDD}
N 6750 -9400 6760 -9390 {
lab=VDD}
N 6540 -9370 6550 -9380 {
lab=VSS}
N 6550 -9380 6750 -9380 {
lab=VSS}
N 6750 -9380 6760 -9370 {
lab=VSS}
N 6540 -9350 6550 -9360 {
lab=VDD}
N 6550 -9360 6750 -9360 {
lab=VDD}
N 6750 -9360 6760 -9350 {
lab=VDD}
N 6760 -9350 6780 -9350 {
lab=VDD}
N 6760 -9370 6780 -9370 {
lab=VSS}
N 6760 -9390 6780 -9390 {
lab=VDD}
N 6760 -9410 6780 -9410 {
lab=VDD}
N 6520 -9410 6540 -9410 {
lab=VDD}
N 6520 -9390 6540 -9390 {
lab=VDD}
N 6520 -9370 6540 -9370 {
lab=VSS}
N 6520 -9350 6540 -9350 {
lab=VDD}
N 6580 -9270 6580 -9260 {
lab=VSS}
N 6600 -9510 6600 -9490 {
lab=vcom}
N 6580 -9500 6580 -9490 {
lab=VDD}
N 6660 -9270 6660 -9250 {
lab=row_n[21]}
N 6920 -9270 6930 -9280 {
lab=row_n[22]}
N 6930 -9480 6930 -9280 {
lab=row_n[22]}
N 6920 -9490 6930 -9480 {
lab=row_n[22]}
N 6920 -9510 6920 -9490 {
lab=row_n[22]}
N 6800 -9410 6810 -9420 {
lab=VDD}
N 6810 -9420 7010 -9420 {
lab=VDD}
N 7010 -9420 7020 -9410 {
lab=VDD}
N 6800 -9390 6810 -9400 {
lab=VDD}
N 6810 -9400 7010 -9400 {
lab=VDD}
N 7010 -9400 7020 -9390 {
lab=VDD}
N 6800 -9370 6810 -9380 {
lab=VSS}
N 6810 -9380 7010 -9380 {
lab=VSS}
N 7010 -9380 7020 -9370 {
lab=VSS}
N 6800 -9350 6810 -9360 {
lab=VDD}
N 6810 -9360 7010 -9360 {
lab=VDD}
N 7010 -9360 7020 -9350 {
lab=VDD}
N 7020 -9350 7040 -9350 {
lab=VDD}
N 7020 -9370 7040 -9370 {
lab=VSS}
N 7020 -9390 7040 -9390 {
lab=VDD}
N 7020 -9410 7040 -9410 {
lab=VDD}
N 6780 -9410 6800 -9410 {
lab=VDD}
N 6780 -9390 6800 -9390 {
lab=VDD}
N 6780 -9370 6800 -9370 {
lab=VSS}
N 6780 -9350 6800 -9350 {
lab=VDD}
N 6840 -9270 6840 -9260 {
lab=VSS}
N 6860 -9510 6860 -9490 {
lab=vcom}
N 6840 -9500 6840 -9490 {
lab=VDD}
N 6920 -9270 6920 -9250 {
lab=row_n[22]}
N 6640 -9510 6640 -9490 {
lab=ctop}
N 6900 -9510 6900 -9490 {
lab=ctop}
N 7180 -9270 7190 -9280 {
lab=row_n[23]}
N 7190 -9480 7190 -9280 {
lab=row_n[23]}
N 7180 -9490 7190 -9480 {
lab=row_n[23]}
N 7180 -9510 7180 -9490 {
lab=row_n[23]}
N 7060 -9410 7070 -9420 {
lab=VDD}
N 7070 -9420 7270 -9420 {
lab=VDD}
N 7270 -9420 7280 -9410 {
lab=VDD}
N 7060 -9390 7070 -9400 {
lab=VDD}
N 7070 -9400 7270 -9400 {
lab=VDD}
N 7270 -9400 7280 -9390 {
lab=VDD}
N 7060 -9370 7070 -9380 {
lab=VSS}
N 7070 -9380 7270 -9380 {
lab=VSS}
N 7270 -9380 7280 -9370 {
lab=VSS}
N 7060 -9350 7070 -9360 {
lab=VDD}
N 7070 -9360 7270 -9360 {
lab=VDD}
N 7270 -9360 7280 -9350 {
lab=VDD}
N 7280 -9350 7300 -9350 {
lab=VDD}
N 7280 -9370 7300 -9370 {
lab=VSS}
N 7280 -9390 7300 -9390 {
lab=VDD}
N 7280 -9410 7300 -9410 {
lab=VDD}
N 7040 -9410 7060 -9410 {
lab=VDD}
N 7040 -9390 7060 -9390 {
lab=VDD}
N 7040 -9370 7060 -9370 {
lab=VSS}
N 7040 -9350 7060 -9350 {
lab=VDD}
N 7100 -9270 7100 -9260 {
lab=VSS}
N 7120 -9510 7120 -9490 {
lab=vcom}
N 7100 -9500 7100 -9490 {
lab=VDD}
N 7180 -9270 7180 -9250 {
lab=row_n[23]}
N 7440 -9270 7450 -9280 {
lab=row_n[24]}
N 7450 -9480 7450 -9280 {
lab=row_n[24]}
N 7440 -9490 7450 -9480 {
lab=row_n[24]}
N 7440 -9510 7440 -9490 {
lab=row_n[24]}
N 7320 -9410 7330 -9420 {
lab=VDD}
N 7330 -9420 7530 -9420 {
lab=VDD}
N 7530 -9420 7540 -9410 {
lab=VDD}
N 7320 -9390 7330 -9400 {
lab=VDD}
N 7330 -9400 7530 -9400 {
lab=VDD}
N 7530 -9400 7540 -9390 {
lab=VDD}
N 7320 -9370 7330 -9380 {
lab=VSS}
N 7330 -9380 7530 -9380 {
lab=VSS}
N 7530 -9380 7540 -9370 {
lab=VSS}
N 7320 -9350 7330 -9360 {
lab=VDD}
N 7330 -9360 7530 -9360 {
lab=VDD}
N 7530 -9360 7540 -9350 {
lab=VDD}
N 7540 -9350 7560 -9350 {
lab=VDD}
N 7540 -9370 7560 -9370 {
lab=VSS}
N 7540 -9390 7560 -9390 {
lab=VDD}
N 7540 -9410 7560 -9410 {
lab=VDD}
N 7300 -9410 7320 -9410 {
lab=VDD}
N 7300 -9390 7320 -9390 {
lab=VDD}
N 7300 -9370 7320 -9370 {
lab=VSS}
N 7300 -9350 7320 -9350 {
lab=VDD}
N 7360 -9270 7360 -9260 {
lab=VSS}
N 7380 -9510 7380 -9490 {
lab=vcom}
N 7360 -9500 7360 -9490 {
lab=VDD}
N 7440 -9270 7440 -9250 {
lab=row_n[24]}
N 7160 -9510 7160 -9490 {
lab=ctop}
N 7420 -9510 7420 -9490 {
lab=ctop}
N 7700 -9270 7710 -9280 {
lab=row_n[25]}
N 7710 -9480 7710 -9280 {
lab=row_n[25]}
N 7700 -9490 7710 -9480 {
lab=row_n[25]}
N 7700 -9510 7700 -9490 {
lab=row_n[25]}
N 7580 -9410 7590 -9420 {
lab=VDD}
N 7590 -9420 7790 -9420 {
lab=VDD}
N 7790 -9420 7800 -9410 {
lab=VDD}
N 7580 -9390 7590 -9400 {
lab=VDD}
N 7590 -9400 7790 -9400 {
lab=VDD}
N 7790 -9400 7800 -9390 {
lab=VDD}
N 7580 -9370 7590 -9380 {
lab=VSS}
N 7590 -9380 7790 -9380 {
lab=VSS}
N 7790 -9380 7800 -9370 {
lab=VSS}
N 7580 -9350 7590 -9360 {
lab=VDD}
N 7590 -9360 7790 -9360 {
lab=VDD}
N 7790 -9360 7800 -9350 {
lab=VDD}
N 7800 -9350 7820 -9350 {
lab=VDD}
N 7800 -9370 7820 -9370 {
lab=VSS}
N 7800 -9390 7820 -9390 {
lab=VDD}
N 7800 -9410 7820 -9410 {
lab=VDD}
N 7560 -9410 7580 -9410 {
lab=VDD}
N 7560 -9390 7580 -9390 {
lab=VDD}
N 7560 -9370 7580 -9370 {
lab=VSS}
N 7560 -9350 7580 -9350 {
lab=VDD}
N 7620 -9270 7620 -9260 {
lab=VSS}
N 7640 -9510 7640 -9490 {
lab=vcom}
N 7620 -9500 7620 -9490 {
lab=VDD}
N 7700 -9270 7700 -9250 {
lab=row_n[25]}
N 7960 -9270 7970 -9280 {
lab=row_n[26]}
N 7970 -9480 7970 -9280 {
lab=row_n[26]}
N 7960 -9490 7970 -9480 {
lab=row_n[26]}
N 7960 -9510 7960 -9490 {
lab=row_n[26]}
N 7840 -9410 7850 -9420 {
lab=VDD}
N 7850 -9420 8050 -9420 {
lab=VDD}
N 8050 -9420 8060 -9410 {
lab=VDD}
N 7840 -9390 7850 -9400 {
lab=VDD}
N 7850 -9400 8050 -9400 {
lab=VDD}
N 8050 -9400 8060 -9390 {
lab=VDD}
N 7840 -9370 7850 -9380 {
lab=VSS}
N 7850 -9380 8050 -9380 {
lab=VSS}
N 8050 -9380 8060 -9370 {
lab=VSS}
N 7840 -9350 7850 -9360 {
lab=VDD}
N 7850 -9360 8050 -9360 {
lab=VDD}
N 8050 -9360 8060 -9350 {
lab=VDD}
N 8060 -9350 8080 -9350 {
lab=VDD}
N 8060 -9370 8080 -9370 {
lab=VSS}
N 8060 -9390 8080 -9390 {
lab=VDD}
N 8060 -9410 8080 -9410 {
lab=VDD}
N 7820 -9410 7840 -9410 {
lab=VDD}
N 7820 -9390 7840 -9390 {
lab=VDD}
N 7820 -9370 7840 -9370 {
lab=VSS}
N 7820 -9350 7840 -9350 {
lab=VDD}
N 7880 -9270 7880 -9260 {
lab=VSS}
N 7900 -9510 7900 -9490 {
lab=vcom}
N 7880 -9500 7880 -9490 {
lab=VDD}
N 7960 -9270 7960 -9250 {
lab=row_n[26]}
N 7680 -9510 7680 -9490 {
lab=ctop}
N 7940 -9510 7940 -9490 {
lab=ctop}
N 8220 -9270 8230 -9280 {
lab=row_n[27]}
N 8230 -9480 8230 -9280 {
lab=row_n[27]}
N 8220 -9490 8230 -9480 {
lab=row_n[27]}
N 8220 -9510 8220 -9490 {
lab=row_n[27]}
N 8100 -9410 8110 -9420 {
lab=VDD}
N 8110 -9420 8310 -9420 {
lab=VDD}
N 8310 -9420 8320 -9410 {
lab=VDD}
N 8100 -9390 8110 -9400 {
lab=VDD}
N 8110 -9400 8310 -9400 {
lab=VDD}
N 8310 -9400 8320 -9390 {
lab=VDD}
N 8100 -9370 8110 -9380 {
lab=VSS}
N 8110 -9380 8310 -9380 {
lab=VSS}
N 8310 -9380 8320 -9370 {
lab=VSS}
N 8100 -9350 8110 -9360 {
lab=VDD}
N 8110 -9360 8310 -9360 {
lab=VDD}
N 8310 -9360 8320 -9350 {
lab=VDD}
N 8320 -9350 8340 -9350 {
lab=VDD}
N 8320 -9370 8340 -9370 {
lab=VSS}
N 8320 -9390 8340 -9390 {
lab=VDD}
N 8320 -9410 8340 -9410 {
lab=VDD}
N 8080 -9410 8100 -9410 {
lab=VDD}
N 8080 -9390 8100 -9390 {
lab=VDD}
N 8080 -9370 8100 -9370 {
lab=VSS}
N 8080 -9350 8100 -9350 {
lab=VDD}
N 8140 -9270 8140 -9260 {
lab=VSS}
N 8160 -9510 8160 -9490 {
lab=vcom}
N 8140 -9500 8140 -9490 {
lab=VDD}
N 8220 -9270 8220 -9250 {
lab=row_n[27]}
N 8480 -9270 8490 -9280 {
lab=row_n[28]}
N 8490 -9480 8490 -9280 {
lab=row_n[28]}
N 8480 -9490 8490 -9480 {
lab=row_n[28]}
N 8480 -9510 8480 -9490 {
lab=row_n[28]}
N 8360 -9410 8370 -9420 {
lab=VDD}
N 8370 -9420 8570 -9420 {
lab=VDD}
N 8570 -9420 8580 -9410 {
lab=VDD}
N 8360 -9390 8370 -9400 {
lab=VDD}
N 8370 -9400 8570 -9400 {
lab=VDD}
N 8570 -9400 8580 -9390 {
lab=VDD}
N 8360 -9370 8370 -9380 {
lab=VSS}
N 8370 -9380 8570 -9380 {
lab=VSS}
N 8570 -9380 8580 -9370 {
lab=VSS}
N 8360 -9350 8370 -9360 {
lab=VDD}
N 8370 -9360 8570 -9360 {
lab=VDD}
N 8570 -9360 8580 -9350 {
lab=VDD}
N 8580 -9350 8600 -9350 {
lab=VDD}
N 8580 -9370 8600 -9370 {
lab=VSS}
N 8580 -9390 8600 -9390 {
lab=VDD}
N 8580 -9410 8600 -9410 {
lab=VDD}
N 8340 -9410 8360 -9410 {
lab=VDD}
N 8340 -9390 8360 -9390 {
lab=VDD}
N 8340 -9370 8360 -9370 {
lab=VSS}
N 8340 -9350 8360 -9350 {
lab=VDD}
N 8400 -9270 8400 -9260 {
lab=VSS}
N 8420 -9510 8420 -9490 {
lab=vcom}
N 8400 -9500 8400 -9490 {
lab=VDD}
N 8480 -9270 8480 -9250 {
lab=row_n[28]}
N 8200 -9510 8200 -9490 {
lab=ctop}
N 8460 -9510 8460 -9490 {
lab=ctop}
N 8740 -9270 8750 -9280 {
lab=row_n[29]}
N 8750 -9480 8750 -9280 {
lab=row_n[29]}
N 8740 -9490 8750 -9480 {
lab=row_n[29]}
N 8740 -9510 8740 -9490 {
lab=row_n[29]}
N 8620 -9410 8630 -9420 {
lab=VDD}
N 8630 -9420 8830 -9420 {
lab=VDD}
N 8830 -9420 8840 -9410 {
lab=VDD}
N 8620 -9390 8630 -9400 {
lab=VDD}
N 8630 -9400 8830 -9400 {
lab=VDD}
N 8830 -9400 8840 -9390 {
lab=VDD}
N 8620 -9370 8630 -9380 {
lab=VSS}
N 8630 -9380 8830 -9380 {
lab=VSS}
N 8830 -9380 8840 -9370 {
lab=VSS}
N 8620 -9350 8630 -9360 {
lab=VDD}
N 8630 -9360 8830 -9360 {
lab=VDD}
N 8830 -9360 8840 -9350 {
lab=VDD}
N 8840 -9350 8860 -9350 {
lab=VDD}
N 8840 -9370 8860 -9370 {
lab=VSS}
N 8840 -9390 8860 -9390 {
lab=VDD}
N 8840 -9410 8860 -9410 {
lab=VDD}
N 8600 -9410 8620 -9410 {
lab=VDD}
N 8600 -9390 8620 -9390 {
lab=VDD}
N 8600 -9370 8620 -9370 {
lab=VSS}
N 8600 -9350 8620 -9350 {
lab=VDD}
N 8660 -9270 8660 -9260 {
lab=VSS}
N 8680 -9510 8680 -9490 {
lab=vcom}
N 8660 -9500 8660 -9490 {
lab=VDD}
N 8740 -9270 8740 -9250 {
lab=row_n[29]}
N 9000 -9270 9010 -9280 {
lab=row_n[30]}
N 9010 -9480 9010 -9280 {
lab=row_n[30]}
N 9000 -9490 9010 -9480 {
lab=row_n[30]}
N 9000 -9510 9000 -9490 {
lab=row_n[30]}
N 8880 -9410 8890 -9420 {
lab=VDD}
N 8890 -9420 9090 -9420 {
lab=VDD}
N 9090 -9420 9100 -9410 {
lab=VDD}
N 8880 -9390 8890 -9400 {
lab=VDD}
N 8890 -9400 9090 -9400 {
lab=VDD}
N 9090 -9400 9100 -9390 {
lab=VDD}
N 8880 -9370 8890 -9380 {
lab=VSS}
N 8890 -9380 9090 -9380 {
lab=VSS}
N 9090 -9380 9100 -9370 {
lab=VSS}
N 8880 -9350 8890 -9360 {
lab=VDD}
N 8890 -9360 9090 -9360 {
lab=VDD}
N 9090 -9360 9100 -9350 {
lab=VDD}
N 9100 -9350 9120 -9350 {
lab=VDD}
N 9100 -9370 9120 -9370 {
lab=VSS}
N 9100 -9390 9120 -9390 {
lab=VDD}
N 9100 -9410 9120 -9410 {
lab=VDD}
N 8860 -9410 8880 -9410 {
lab=VDD}
N 8860 -9390 8880 -9390 {
lab=VDD}
N 8860 -9370 8880 -9370 {
lab=VSS}
N 8860 -9350 8880 -9350 {
lab=VDD}
N 8920 -9270 8920 -9260 {
lab=VSS}
N 8940 -9510 8940 -9490 {
lab=vcom}
N 8920 -9500 8920 -9490 {
lab=VDD}
N 9000 -9270 9000 -9250 {
lab=row_n[30]}
N 8720 -9510 8720 -9490 {
lab=ctop}
N 8980 -9510 8980 -9490 {
lab=ctop}
N 9260 -9270 9270 -9280 {
lab=row_n[31]}
N 9270 -9480 9270 -9280 {
lab=row_n[31]}
N 9260 -9490 9270 -9480 {
lab=row_n[31]}
N 9260 -9510 9260 -9490 {
lab=row_n[31]}
N 9140 -9410 9150 -9420 {
lab=VDD}
N 9150 -9420 9350 -9420 {
lab=VDD}
N 9350 -9420 9360 -9410 {
lab=VDD}
N 9140 -9390 9150 -9400 {
lab=VDD}
N 9150 -9400 9350 -9400 {
lab=VDD}
N 9350 -9400 9360 -9390 {
lab=VDD}
N 9140 -9370 9150 -9380 {
lab=VSS}
N 9150 -9380 9350 -9380 {
lab=VSS}
N 9350 -9380 9360 -9370 {
lab=VSS}
N 9140 -9350 9150 -9360 {
lab=VDD}
N 9150 -9360 9350 -9360 {
lab=VDD}
N 9350 -9360 9360 -9350 {
lab=VDD}
N 9360 -9350 9380 -9350 {
lab=VDD}
N 9360 -9370 9380 -9370 {
lab=VSS}
N 9360 -9390 9380 -9390 {
lab=VDD}
N 9360 -9410 9380 -9410 {
lab=VDD}
N 9120 -9410 9140 -9410 {
lab=VDD}
N 9120 -9390 9140 -9390 {
lab=VDD}
N 9120 -9370 9140 -9370 {
lab=VSS}
N 9120 -9350 9140 -9350 {
lab=VDD}
N 9180 -9270 9180 -9260 {
lab=VSS}
N 9200 -9510 9200 -9490 {
lab=vcom}
N 9180 -9500 9180 -9490 {
lab=VDD}
N 9260 -9270 9260 -9250 {
lab=row_n[31]}
N 9240 -9510 9240 -9490 {
lab=ctop}
N 9520 -9270 9530 -9280 {
lab=VDD}
N 9530 -9480 9530 -9280 {
lab=VDD}
N 9520 -9490 9530 -9480 {
lab=VDD}
N 9520 -9510 9520 -9490 {
lab=VDD}
N 9400 -9410 9410 -9420 {
lab=VDD}
N 9410 -9420 9610 -9420 {
lab=VDD}
N 9610 -9420 9620 -9410 {
lab=VDD}
N 9400 -9390 9410 -9400 {
lab=VDD}
N 9410 -9400 9610 -9400 {
lab=VDD}
N 9610 -9400 9620 -9390 {
lab=VDD}
N 9400 -9370 9410 -9380 {
lab=VSS}
N 9410 -9380 9610 -9380 {
lab=VSS}
N 9610 -9380 9620 -9370 {
lab=VSS}
N 9400 -9350 9410 -9360 {
lab=VDD}
N 9410 -9360 9610 -9360 {
lab=VDD}
N 9610 -9360 9620 -9350 {
lab=VDD}
N 9620 -9350 9640 -9350 {
lab=VDD}
N 9620 -9370 9640 -9370 {
lab=VSS}
N 9620 -9390 9640 -9390 {
lab=VDD}
N 9620 -9410 9640 -9410 {
lab=VDD}
N 9380 -9410 9400 -9410 {
lab=VDD}
N 9380 -9390 9400 -9390 {
lab=VDD}
N 9380 -9370 9400 -9370 {
lab=VSS}
N 9380 -9350 9400 -9350 {
lab=VDD}
N 9440 -9270 9440 -9260 {
lab=VSS}
N 9460 -9510 9460 -9490 {
lab=vcom}
N 9440 -9500 9440 -9490 {
lab=VDD}
N 9520 -9270 9520 -9250 {
lab=VDD}
N 9500 -9510 9500 -9490 {
lab=ctop}
N 9520 -950 9530 -960 {
lab=VDD}
N 9530 -1160 9530 -960 {
lab=VDD}
N 9520 -1170 9530 -1160 {
lab=VDD}
N 9520 -1190 9520 -1170 {
lab=VDD}
N 9400 -1090 9410 -1100 {
lab=col_n[0]}
N 9410 -1100 9610 -1100 {
lab=col_n[0]}
N 9610 -1100 9620 -1090 {
lab=col_n[0]}
N 9400 -1070 9410 -1080 {
lab=colon_n[0]}
N 9410 -1080 9610 -1080 {
lab=colon_n[0]}
N 9610 -1080 9620 -1070 {
lab=colon_n[0]}
N 9400 -1050 9410 -1060 {
lab=#net1}
N 9410 -1060 9610 -1060 {
lab=#net1}
N 9610 -1060 9620 -1050 {
lab=#net1}
N 9400 -1030 9410 -1040 {
lab=#net2}
N 9410 -1040 9610 -1040 {
lab=#net2}
N 9610 -1040 9620 -1030 {
lab=#net2}
N 9620 -1030 9640 -1030 {
lab=#net2}
N 9620 -1050 9640 -1050 {
lab=#net1}
N 9620 -1070 9640 -1070 {
lab=colon_n[0]}
N 9620 -1090 9640 -1090 {
lab=col_n[0]}
N 9380 -1090 9400 -1090 {
lab=col_n[0]}
N 9380 -1070 9400 -1070 {
lab=colon_n[0]}
N 9380 -1050 9400 -1050 {
lab=#net1}
N 9380 -1030 9400 -1030 {
lab=#net2}
N 9440 -950 9440 -940 {
lab=VSS}
N 9460 -1190 9460 -1170 {
lab=vcom}
N 9440 -1180 9440 -1170 {
lab=VDD}
N 9500 -1190 9500 -1170 {
lab=ctop}
N 9520 -950 9520 -930 {
lab=VDD}
N 9520 -1210 9530 -1220 {
lab=VDD}
N 9530 -1420 9530 -1220 {
lab=VDD}
N 9520 -1430 9530 -1420 {
lab=VDD}
N 9520 -1450 9520 -1430 {
lab=VDD}
N 9400 -1350 9410 -1360 {
lab=col_n[1]}
N 9410 -1360 9610 -1360 {
lab=col_n[1]}
N 9610 -1360 9620 -1350 {
lab=col_n[1]}
N 9400 -1330 9410 -1340 {
lab=colon_n[1]}
N 9410 -1340 9610 -1340 {
lab=colon_n[1]}
N 9610 -1340 9620 -1330 {
lab=colon_n[1]}
N 9400 -1310 9410 -1320 {
lab=#net3}
N 9410 -1320 9610 -1320 {
lab=#net3}
N 9610 -1320 9620 -1310 {
lab=#net3}
N 9400 -1290 9410 -1300 {
lab=#net4}
N 9410 -1300 9610 -1300 {
lab=#net4}
N 9610 -1300 9620 -1290 {
lab=#net4}
N 9620 -1290 9640 -1290 {
lab=#net4}
N 9620 -1310 9640 -1310 {
lab=#net3}
N 9620 -1330 9640 -1330 {
lab=colon_n[1]}
N 9620 -1350 9640 -1350 {
lab=col_n[1]}
N 9380 -1350 9400 -1350 {
lab=col_n[1]}
N 9380 -1330 9400 -1330 {
lab=colon_n[1]}
N 9380 -1310 9400 -1310 {
lab=#net3}
N 9380 -1290 9400 -1290 {
lab=#net4}
N 9440 -1210 9440 -1200 {
lab=VSS}
N 9460 -1450 9460 -1430 {
lab=vcom}
N 9440 -1440 9440 -1430 {
lab=VDD}
N 9500 -1450 9500 -1430 {
lab=ctop}
N 9520 -1210 9520 -1190 {
lab=VDD}
N 9520 -1470 9530 -1480 {
lab=VDD}
N 9530 -1680 9530 -1480 {
lab=VDD}
N 9520 -1690 9530 -1680 {
lab=VDD}
N 9520 -1710 9520 -1690 {
lab=VDD}
N 9400 -1610 9410 -1620 {
lab=col_n[2]}
N 9410 -1620 9610 -1620 {
lab=col_n[2]}
N 9610 -1620 9620 -1610 {
lab=col_n[2]}
N 9400 -1590 9410 -1600 {
lab=colon_n[2]}
N 9410 -1600 9610 -1600 {
lab=colon_n[2]}
N 9610 -1600 9620 -1590 {
lab=colon_n[2]}
N 9400 -1570 9410 -1580 {
lab=#net5}
N 9410 -1580 9610 -1580 {
lab=#net5}
N 9610 -1580 9620 -1570 {
lab=#net5}
N 9400 -1550 9410 -1560 {
lab=#net6}
N 9410 -1560 9610 -1560 {
lab=#net6}
N 9610 -1560 9620 -1550 {
lab=#net6}
N 9620 -1550 9640 -1550 {
lab=#net6}
N 9620 -1570 9640 -1570 {
lab=#net5}
N 9620 -1590 9640 -1590 {
lab=colon_n[2]}
N 9620 -1610 9640 -1610 {
lab=col_n[2]}
N 9380 -1610 9400 -1610 {
lab=col_n[2]}
N 9380 -1590 9400 -1590 {
lab=colon_n[2]}
N 9380 -1570 9400 -1570 {
lab=#net5}
N 9380 -1550 9400 -1550 {
lab=#net6}
N 9440 -1470 9440 -1460 {
lab=VSS}
N 9460 -1710 9460 -1690 {
lab=vcom}
N 9440 -1700 9440 -1690 {
lab=VDD}
N 9500 -1710 9500 -1690 {
lab=ctop}
N 9520 -1470 9520 -1450 {
lab=VDD}
N 9520 -1730 9530 -1740 {
lab=VDD}
N 9530 -1940 9530 -1740 {
lab=VDD}
N 9520 -1950 9530 -1940 {
lab=VDD}
N 9520 -1970 9520 -1950 {
lab=VDD}
N 9400 -1870 9410 -1880 {
lab=col_n[3]}
N 9410 -1880 9610 -1880 {
lab=col_n[3]}
N 9610 -1880 9620 -1870 {
lab=col_n[3]}
N 9400 -1850 9410 -1860 {
lab=colon_n[3]}
N 9410 -1860 9610 -1860 {
lab=colon_n[3]}
N 9610 -1860 9620 -1850 {
lab=colon_n[3]}
N 9400 -1830 9410 -1840 {
lab=#net7}
N 9410 -1840 9610 -1840 {
lab=#net7}
N 9610 -1840 9620 -1830 {
lab=#net7}
N 9400 -1810 9410 -1820 {
lab=#net8}
N 9410 -1820 9610 -1820 {
lab=#net8}
N 9610 -1820 9620 -1810 {
lab=#net8}
N 9620 -1810 9640 -1810 {
lab=#net8}
N 9620 -1830 9640 -1830 {
lab=#net7}
N 9620 -1850 9640 -1850 {
lab=colon_n[3]}
N 9620 -1870 9640 -1870 {
lab=col_n[3]}
N 9380 -1870 9400 -1870 {
lab=col_n[3]}
N 9380 -1850 9400 -1850 {
lab=colon_n[3]}
N 9380 -1830 9400 -1830 {
lab=#net7}
N 9380 -1810 9400 -1810 {
lab=#net8}
N 9440 -1730 9440 -1720 {
lab=VSS}
N 9460 -1970 9460 -1950 {
lab=vcom}
N 9440 -1960 9440 -1950 {
lab=VDD}
N 9500 -1970 9500 -1950 {
lab=ctop}
N 9520 -1730 9520 -1710 {
lab=VDD}
N 9520 -1990 9530 -2000 {
lab=VDD}
N 9530 -2200 9530 -2000 {
lab=VDD}
N 9520 -2210 9530 -2200 {
lab=VDD}
N 9520 -2230 9520 -2210 {
lab=VDD}
N 9400 -2130 9410 -2140 {
lab=col_n[4]}
N 9410 -2140 9610 -2140 {
lab=col_n[4]}
N 9610 -2140 9620 -2130 {
lab=col_n[4]}
N 9400 -2110 9410 -2120 {
lab=colon_n[4]}
N 9410 -2120 9610 -2120 {
lab=colon_n[4]}
N 9610 -2120 9620 -2110 {
lab=colon_n[4]}
N 9400 -2090 9410 -2100 {
lab=#net9}
N 9410 -2100 9610 -2100 {
lab=#net9}
N 9610 -2100 9620 -2090 {
lab=#net9}
N 9400 -2070 9410 -2080 {
lab=#net10}
N 9410 -2080 9610 -2080 {
lab=#net10}
N 9610 -2080 9620 -2070 {
lab=#net10}
N 9620 -2070 9640 -2070 {
lab=#net10}
N 9620 -2090 9640 -2090 {
lab=#net9}
N 9620 -2110 9640 -2110 {
lab=colon_n[4]}
N 9620 -2130 9640 -2130 {
lab=col_n[4]}
N 9380 -2130 9400 -2130 {
lab=col_n[4]}
N 9380 -2110 9400 -2110 {
lab=colon_n[4]}
N 9380 -2090 9400 -2090 {
lab=#net9}
N 9380 -2070 9400 -2070 {
lab=#net10}
N 9440 -1990 9440 -1980 {
lab=VSS}
N 9460 -2230 9460 -2210 {
lab=vcom}
N 9440 -2220 9440 -2210 {
lab=VDD}
N 9500 -2230 9500 -2210 {
lab=ctop}
N 9520 -1990 9520 -1970 {
lab=VDD}
N 9520 -2250 9530 -2260 {
lab=VDD}
N 9530 -2460 9530 -2260 {
lab=VDD}
N 9520 -2470 9530 -2460 {
lab=VDD}
N 9520 -2490 9520 -2470 {
lab=VDD}
N 9400 -2390 9410 -2400 {
lab=col_n[5]}
N 9410 -2400 9610 -2400 {
lab=col_n[5]}
N 9610 -2400 9620 -2390 {
lab=col_n[5]}
N 9400 -2370 9410 -2380 {
lab=colon_n[5]}
N 9410 -2380 9610 -2380 {
lab=colon_n[5]}
N 9610 -2380 9620 -2370 {
lab=colon_n[5]}
N 9400 -2350 9410 -2360 {
lab=#net11}
N 9410 -2360 9610 -2360 {
lab=#net11}
N 9610 -2360 9620 -2350 {
lab=#net11}
N 9400 -2330 9410 -2340 {
lab=#net12}
N 9410 -2340 9610 -2340 {
lab=#net12}
N 9610 -2340 9620 -2330 {
lab=#net12}
N 9620 -2330 9640 -2330 {
lab=#net12}
N 9620 -2350 9640 -2350 {
lab=#net11}
N 9620 -2370 9640 -2370 {
lab=colon_n[5]}
N 9620 -2390 9640 -2390 {
lab=col_n[5]}
N 9380 -2390 9400 -2390 {
lab=col_n[5]}
N 9380 -2370 9400 -2370 {
lab=colon_n[5]}
N 9380 -2350 9400 -2350 {
lab=#net11}
N 9380 -2330 9400 -2330 {
lab=#net12}
N 9440 -2250 9440 -2240 {
lab=VSS}
N 9460 -2490 9460 -2470 {
lab=vcom}
N 9440 -2480 9440 -2470 {
lab=VDD}
N 9500 -2490 9500 -2470 {
lab=ctop}
N 9520 -2250 9520 -2230 {
lab=VDD}
N 9520 -2510 9530 -2520 {
lab=VDD}
N 9530 -2720 9530 -2520 {
lab=VDD}
N 9520 -2730 9530 -2720 {
lab=VDD}
N 9520 -2750 9520 -2730 {
lab=VDD}
N 9400 -2650 9410 -2660 {
lab=col_n[6]}
N 9410 -2660 9610 -2660 {
lab=col_n[6]}
N 9610 -2660 9620 -2650 {
lab=col_n[6]}
N 9400 -2630 9410 -2640 {
lab=colon_n[6]}
N 9410 -2640 9610 -2640 {
lab=colon_n[6]}
N 9610 -2640 9620 -2630 {
lab=colon_n[6]}
N 9400 -2610 9410 -2620 {
lab=#net13}
N 9410 -2620 9610 -2620 {
lab=#net13}
N 9610 -2620 9620 -2610 {
lab=#net13}
N 9400 -2590 9410 -2600 {
lab=#net14}
N 9410 -2600 9610 -2600 {
lab=#net14}
N 9610 -2600 9620 -2590 {
lab=#net14}
N 9620 -2590 9640 -2590 {
lab=#net14}
N 9620 -2610 9640 -2610 {
lab=#net13}
N 9620 -2630 9640 -2630 {
lab=colon_n[6]}
N 9620 -2650 9640 -2650 {
lab=col_n[6]}
N 9380 -2650 9400 -2650 {
lab=col_n[6]}
N 9380 -2630 9400 -2630 {
lab=colon_n[6]}
N 9380 -2610 9400 -2610 {
lab=#net13}
N 9380 -2590 9400 -2590 {
lab=#net14}
N 9440 -2510 9440 -2500 {
lab=VSS}
N 9460 -2750 9460 -2730 {
lab=vcom}
N 9440 -2740 9440 -2730 {
lab=VDD}
N 9500 -2750 9500 -2730 {
lab=ctop}
N 9520 -2510 9520 -2490 {
lab=VDD}
N 9520 -2770 9530 -2780 {
lab=VDD}
N 9530 -2980 9530 -2780 {
lab=VDD}
N 9520 -2990 9530 -2980 {
lab=VDD}
N 9520 -3010 9520 -2990 {
lab=VDD}
N 9400 -2910 9410 -2920 {
lab=col_n[7]}
N 9410 -2920 9610 -2920 {
lab=col_n[7]}
N 9610 -2920 9620 -2910 {
lab=col_n[7]}
N 9400 -2890 9410 -2900 {
lab=colon_n[7]}
N 9410 -2900 9610 -2900 {
lab=colon_n[7]}
N 9610 -2900 9620 -2890 {
lab=colon_n[7]}
N 9400 -2870 9410 -2880 {
lab=#net15}
N 9410 -2880 9610 -2880 {
lab=#net15}
N 9610 -2880 9620 -2870 {
lab=#net15}
N 9400 -2850 9410 -2860 {
lab=#net16}
N 9410 -2860 9610 -2860 {
lab=#net16}
N 9610 -2860 9620 -2850 {
lab=#net16}
N 9620 -2850 9640 -2850 {
lab=#net16}
N 9620 -2870 9640 -2870 {
lab=#net15}
N 9620 -2890 9640 -2890 {
lab=colon_n[7]}
N 9620 -2910 9640 -2910 {
lab=col_n[7]}
N 9380 -2910 9400 -2910 {
lab=col_n[7]}
N 9380 -2890 9400 -2890 {
lab=colon_n[7]}
N 9380 -2870 9400 -2870 {
lab=#net15}
N 9380 -2850 9400 -2850 {
lab=#net16}
N 9440 -2770 9440 -2760 {
lab=VSS}
N 9460 -3010 9460 -2990 {
lab=vcom}
N 9440 -3000 9440 -2990 {
lab=VDD}
N 9500 -3010 9500 -2990 {
lab=ctop}
N 9520 -2770 9520 -2750 {
lab=VDD}
N 9520 -3030 9530 -3040 {
lab=VDD}
N 9530 -3240 9530 -3040 {
lab=VDD}
N 9520 -3250 9530 -3240 {
lab=VDD}
N 9520 -3270 9520 -3250 {
lab=VDD}
N 9400 -3170 9410 -3180 {
lab=col_n[8]}
N 9410 -3180 9610 -3180 {
lab=col_n[8]}
N 9610 -3180 9620 -3170 {
lab=col_n[8]}
N 9400 -3150 9410 -3160 {
lab=colon_n[8]}
N 9410 -3160 9610 -3160 {
lab=colon_n[8]}
N 9610 -3160 9620 -3150 {
lab=colon_n[8]}
N 9400 -3130 9410 -3140 {
lab=#net17}
N 9410 -3140 9610 -3140 {
lab=#net17}
N 9610 -3140 9620 -3130 {
lab=#net17}
N 9400 -3110 9410 -3120 {
lab=#net18}
N 9410 -3120 9610 -3120 {
lab=#net18}
N 9610 -3120 9620 -3110 {
lab=#net18}
N 9620 -3110 9640 -3110 {
lab=#net18}
N 9620 -3130 9640 -3130 {
lab=#net17}
N 9620 -3150 9640 -3150 {
lab=colon_n[8]}
N 9620 -3170 9640 -3170 {
lab=col_n[8]}
N 9380 -3170 9400 -3170 {
lab=col_n[8]}
N 9380 -3150 9400 -3150 {
lab=colon_n[8]}
N 9380 -3130 9400 -3130 {
lab=#net17}
N 9380 -3110 9400 -3110 {
lab=#net18}
N 9440 -3030 9440 -3020 {
lab=VSS}
N 9460 -3270 9460 -3250 {
lab=vcom}
N 9440 -3260 9440 -3250 {
lab=VDD}
N 9500 -3270 9500 -3250 {
lab=ctop}
N 9520 -3030 9520 -3010 {
lab=VDD}
N 9520 -3290 9530 -3300 {
lab=VDD}
N 9530 -3500 9530 -3300 {
lab=VDD}
N 9520 -3510 9530 -3500 {
lab=VDD}
N 9520 -3530 9520 -3510 {
lab=VDD}
N 9400 -3430 9410 -3440 {
lab=col_n[9]}
N 9410 -3440 9610 -3440 {
lab=col_n[9]}
N 9610 -3440 9620 -3430 {
lab=col_n[9]}
N 9400 -3410 9410 -3420 {
lab=colon_n[9]}
N 9410 -3420 9610 -3420 {
lab=colon_n[9]}
N 9610 -3420 9620 -3410 {
lab=colon_n[9]}
N 9400 -3390 9410 -3400 {
lab=#net19}
N 9410 -3400 9610 -3400 {
lab=#net19}
N 9610 -3400 9620 -3390 {
lab=#net19}
N 9400 -3370 9410 -3380 {
lab=#net20}
N 9410 -3380 9610 -3380 {
lab=#net20}
N 9610 -3380 9620 -3370 {
lab=#net20}
N 9620 -3370 9640 -3370 {
lab=#net20}
N 9620 -3390 9640 -3390 {
lab=#net19}
N 9620 -3410 9640 -3410 {
lab=colon_n[9]}
N 9620 -3430 9640 -3430 {
lab=col_n[9]}
N 9380 -3430 9400 -3430 {
lab=col_n[9]}
N 9380 -3410 9400 -3410 {
lab=colon_n[9]}
N 9380 -3390 9400 -3390 {
lab=#net19}
N 9380 -3370 9400 -3370 {
lab=#net20}
N 9440 -3290 9440 -3280 {
lab=VSS}
N 9460 -3530 9460 -3510 {
lab=vcom}
N 9440 -3520 9440 -3510 {
lab=VDD}
N 9500 -3530 9500 -3510 {
lab=ctop}
N 9520 -3290 9520 -3270 {
lab=VDD}
N 9520 -3550 9530 -3560 {
lab=VDD}
N 9530 -3760 9530 -3560 {
lab=VDD}
N 9520 -3770 9530 -3760 {
lab=VDD}
N 9520 -3790 9520 -3770 {
lab=VDD}
N 9400 -3690 9410 -3700 {
lab=col_n[10]}
N 9410 -3700 9610 -3700 {
lab=col_n[10]}
N 9610 -3700 9620 -3690 {
lab=col_n[10]}
N 9400 -3670 9410 -3680 {
lab=colon_n[10]}
N 9410 -3680 9610 -3680 {
lab=colon_n[10]}
N 9610 -3680 9620 -3670 {
lab=colon_n[10]}
N 9400 -3650 9410 -3660 {
lab=#net21}
N 9410 -3660 9610 -3660 {
lab=#net21}
N 9610 -3660 9620 -3650 {
lab=#net21}
N 9400 -3630 9410 -3640 {
lab=#net22}
N 9410 -3640 9610 -3640 {
lab=#net22}
N 9610 -3640 9620 -3630 {
lab=#net22}
N 9620 -3630 9640 -3630 {
lab=#net22}
N 9620 -3650 9640 -3650 {
lab=#net21}
N 9620 -3670 9640 -3670 {
lab=colon_n[10]}
N 9620 -3690 9640 -3690 {
lab=col_n[10]}
N 9380 -3690 9400 -3690 {
lab=col_n[10]}
N 9380 -3670 9400 -3670 {
lab=colon_n[10]}
N 9380 -3650 9400 -3650 {
lab=#net21}
N 9380 -3630 9400 -3630 {
lab=#net22}
N 9440 -3550 9440 -3540 {
lab=VSS}
N 9460 -3790 9460 -3770 {
lab=vcom}
N 9440 -3780 9440 -3770 {
lab=VDD}
N 9500 -3790 9500 -3770 {
lab=ctop}
N 9520 -3550 9520 -3530 {
lab=VDD}
N 9520 -3810 9530 -3820 {
lab=VDD}
N 9530 -4020 9530 -3820 {
lab=VDD}
N 9520 -4030 9530 -4020 {
lab=VDD}
N 9520 -4050 9520 -4030 {
lab=VDD}
N 9400 -3950 9410 -3960 {
lab=col_n[11]}
N 9410 -3960 9610 -3960 {
lab=col_n[11]}
N 9610 -3960 9620 -3950 {
lab=col_n[11]}
N 9400 -3930 9410 -3940 {
lab=colon_n[11]}
N 9410 -3940 9610 -3940 {
lab=colon_n[11]}
N 9610 -3940 9620 -3930 {
lab=colon_n[11]}
N 9400 -3910 9410 -3920 {
lab=#net23}
N 9410 -3920 9610 -3920 {
lab=#net23}
N 9610 -3920 9620 -3910 {
lab=#net23}
N 9400 -3890 9410 -3900 {
lab=#net24}
N 9410 -3900 9610 -3900 {
lab=#net24}
N 9610 -3900 9620 -3890 {
lab=#net24}
N 9620 -3890 9640 -3890 {
lab=#net24}
N 9620 -3910 9640 -3910 {
lab=#net23}
N 9620 -3930 9640 -3930 {
lab=colon_n[11]}
N 9620 -3950 9640 -3950 {
lab=col_n[11]}
N 9380 -3950 9400 -3950 {
lab=col_n[11]}
N 9380 -3930 9400 -3930 {
lab=colon_n[11]}
N 9380 -3910 9400 -3910 {
lab=#net23}
N 9380 -3890 9400 -3890 {
lab=#net24}
N 9440 -3810 9440 -3800 {
lab=VSS}
N 9460 -4050 9460 -4030 {
lab=vcom}
N 9440 -4040 9440 -4030 {
lab=VDD}
N 9500 -4050 9500 -4030 {
lab=ctop}
N 9520 -3810 9520 -3790 {
lab=VDD}
N 9520 -4070 9530 -4080 {
lab=VDD}
N 9530 -4280 9530 -4080 {
lab=VDD}
N 9520 -4290 9530 -4280 {
lab=VDD}
N 9520 -4310 9520 -4290 {
lab=VDD}
N 9400 -4210 9410 -4220 {
lab=col_n[12]}
N 9410 -4220 9610 -4220 {
lab=col_n[12]}
N 9610 -4220 9620 -4210 {
lab=col_n[12]}
N 9400 -4190 9410 -4200 {
lab=colon_n[12]}
N 9410 -4200 9610 -4200 {
lab=colon_n[12]}
N 9610 -4200 9620 -4190 {
lab=colon_n[12]}
N 9400 -4170 9410 -4180 {
lab=#net25}
N 9410 -4180 9610 -4180 {
lab=#net25}
N 9610 -4180 9620 -4170 {
lab=#net25}
N 9400 -4150 9410 -4160 {
lab=#net26}
N 9410 -4160 9610 -4160 {
lab=#net26}
N 9610 -4160 9620 -4150 {
lab=#net26}
N 9620 -4150 9640 -4150 {
lab=#net26}
N 9620 -4170 9640 -4170 {
lab=#net25}
N 9620 -4190 9640 -4190 {
lab=colon_n[12]}
N 9620 -4210 9640 -4210 {
lab=col_n[12]}
N 9380 -4210 9400 -4210 {
lab=col_n[12]}
N 9380 -4190 9400 -4190 {
lab=colon_n[12]}
N 9380 -4170 9400 -4170 {
lab=#net25}
N 9380 -4150 9400 -4150 {
lab=#net26}
N 9460 -4310 9460 -4290 {
lab=vcom}
N 9440 -4300 9440 -4290 {
lab=VDD}
N 9500 -4310 9500 -4290 {
lab=ctop}
N 9520 -4070 9520 -4050 {
lab=VDD}
N 9520 -4330 9530 -4340 {
lab=VDD}
N 9530 -4540 9530 -4340 {
lab=VDD}
N 9520 -4550 9530 -4540 {
lab=VDD}
N 9520 -4570 9520 -4550 {
lab=VDD}
N 9400 -4470 9410 -4480 {
lab=col_n[13]}
N 9410 -4480 9610 -4480 {
lab=col_n[13]}
N 9610 -4480 9620 -4470 {
lab=col_n[13]}
N 9400 -4450 9410 -4460 {
lab=colon_n[13]}
N 9410 -4460 9610 -4460 {
lab=colon_n[13]}
N 9610 -4460 9620 -4450 {
lab=colon_n[13]}
N 9400 -4430 9410 -4440 {
lab=#net27}
N 9410 -4440 9610 -4440 {
lab=#net27}
N 9610 -4440 9620 -4430 {
lab=#net27}
N 9400 -4410 9410 -4420 {
lab=#net28}
N 9410 -4420 9610 -4420 {
lab=#net28}
N 9610 -4420 9620 -4410 {
lab=#net28}
N 9620 -4410 9640 -4410 {
lab=#net28}
N 9620 -4430 9640 -4430 {
lab=#net27}
N 9620 -4450 9640 -4450 {
lab=colon_n[13]}
N 9620 -4470 9640 -4470 {
lab=col_n[13]}
N 9380 -4470 9400 -4470 {
lab=col_n[13]}
N 9380 -4450 9400 -4450 {
lab=colon_n[13]}
N 9380 -4430 9400 -4430 {
lab=#net27}
N 9380 -4410 9400 -4410 {
lab=#net28}
N 9440 -4330 9440 -4320 {
lab=VSS}
N 9460 -4570 9460 -4550 {
lab=vcom}
N 9440 -4560 9440 -4550 {
lab=VDD}
N 9500 -4570 9500 -4550 {
lab=ctop}
N 9520 -4330 9520 -4310 {
lab=VDD}
N 9520 -4590 9530 -4600 {
lab=VDD}
N 9530 -4800 9530 -4600 {
lab=VDD}
N 9520 -4810 9530 -4800 {
lab=VDD}
N 9520 -4830 9520 -4810 {
lab=VDD}
N 9400 -4730 9410 -4740 {
lab=col_n[14]}
N 9410 -4740 9610 -4740 {
lab=col_n[14]}
N 9610 -4740 9620 -4730 {
lab=col_n[14]}
N 9400 -4710 9410 -4720 {
lab=colon_n[14]}
N 9410 -4720 9610 -4720 {
lab=colon_n[14]}
N 9610 -4720 9620 -4710 {
lab=colon_n[14]}
N 9400 -4690 9410 -4700 {
lab=#net29}
N 9410 -4700 9610 -4700 {
lab=#net29}
N 9610 -4700 9620 -4690 {
lab=#net29}
N 9400 -4670 9410 -4680 {
lab=#net30}
N 9410 -4680 9610 -4680 {
lab=#net30}
N 9610 -4680 9620 -4670 {
lab=#net30}
N 9620 -4670 9640 -4670 {
lab=#net30}
N 9620 -4690 9640 -4690 {
lab=#net29}
N 9620 -4710 9640 -4710 {
lab=colon_n[14]}
N 9620 -4730 9640 -4730 {
lab=col_n[14]}
N 9380 -4730 9400 -4730 {
lab=col_n[14]}
N 9380 -4710 9400 -4710 {
lab=colon_n[14]}
N 9380 -4690 9400 -4690 {
lab=#net29}
N 9380 -4670 9400 -4670 {
lab=#net30}
N 9440 -4590 9440 -4580 {
lab=VSS}
N 9460 -4830 9460 -4810 {
lab=vcom}
N 9440 -4820 9440 -4810 {
lab=VDD}
N 9500 -4830 9500 -4810 {
lab=ctop}
N 9520 -4590 9520 -4570 {
lab=VDD}
N 9520 -4850 9530 -4860 {
lab=VDD}
N 9530 -5060 9530 -4860 {
lab=VDD}
N 9520 -5070 9530 -5060 {
lab=VDD}
N 9520 -5090 9520 -5070 {
lab=VDD}
N 9400 -4990 9410 -5000 {
lab=col_n[15]}
N 9410 -5000 9610 -5000 {
lab=col_n[15]}
N 9610 -5000 9620 -4990 {
lab=col_n[15]}
N 9400 -4970 9410 -4980 {
lab=colon_n[15]}
N 9410 -4980 9610 -4980 {
lab=colon_n[15]}
N 9610 -4980 9620 -4970 {
lab=colon_n[15]}
N 9400 -4950 9410 -4960 {
lab=#net31}
N 9410 -4960 9610 -4960 {
lab=#net31}
N 9610 -4960 9620 -4950 {
lab=#net31}
N 9400 -4930 9410 -4940 {
lab=#net32}
N 9410 -4940 9610 -4940 {
lab=#net32}
N 9610 -4940 9620 -4930 {
lab=#net32}
N 9620 -4930 9640 -4930 {
lab=#net32}
N 9620 -4950 9640 -4950 {
lab=#net31}
N 9620 -4970 9640 -4970 {
lab=colon_n[15]}
N 9620 -4990 9640 -4990 {
lab=col_n[15]}
N 9380 -4990 9400 -4990 {
lab=col_n[15]}
N 9380 -4970 9400 -4970 {
lab=colon_n[15]}
N 9380 -4950 9400 -4950 {
lab=#net31}
N 9380 -4930 9400 -4930 {
lab=#net32}
N 9440 -4850 9440 -4840 {
lab=VSS}
N 9460 -5090 9460 -5070 {
lab=vcom}
N 9440 -5080 9440 -5070 {
lab=VDD}
N 9500 -5090 9500 -5070 {
lab=ctop}
N 9520 -4850 9520 -4830 {
lab=VDD}
N 9520 -5110 9530 -5120 {
lab=VDD}
N 9530 -5320 9530 -5120 {
lab=VDD}
N 9520 -5330 9530 -5320 {
lab=VDD}
N 9520 -5350 9520 -5330 {
lab=VDD}
N 9400 -5250 9410 -5260 {
lab=col_n[16]}
N 9410 -5260 9610 -5260 {
lab=col_n[16]}
N 9610 -5260 9620 -5250 {
lab=col_n[16]}
N 9400 -5230 9410 -5240 {
lab=colon_n[16]}
N 9410 -5240 9610 -5240 {
lab=colon_n[16]}
N 9610 -5240 9620 -5230 {
lab=colon_n[16]}
N 9400 -5210 9410 -5220 {
lab=#net33}
N 9410 -5220 9610 -5220 {
lab=#net33}
N 9610 -5220 9620 -5210 {
lab=#net33}
N 9400 -5190 9410 -5200 {
lab=#net34}
N 9410 -5200 9610 -5200 {
lab=#net34}
N 9610 -5200 9620 -5190 {
lab=#net34}
N 9620 -5190 9640 -5190 {
lab=#net34}
N 9620 -5210 9640 -5210 {
lab=#net33}
N 9620 -5230 9640 -5230 {
lab=colon_n[16]}
N 9620 -5250 9640 -5250 {
lab=col_n[16]}
N 9380 -5250 9400 -5250 {
lab=col_n[16]}
N 9380 -5230 9400 -5230 {
lab=colon_n[16]}
N 9380 -5210 9400 -5210 {
lab=#net33}
N 9380 -5190 9400 -5190 {
lab=#net34}
N 9440 -5110 9440 -5100 {
lab=VSS}
N 9460 -5350 9460 -5330 {
lab=vcom}
N 9440 -5340 9440 -5330 {
lab=VDD}
N 9500 -5350 9500 -5330 {
lab=ctop}
N 9520 -5110 9520 -5090 {
lab=VDD}
N 9520 -5370 9530 -5380 {
lab=VDD}
N 9530 -5580 9530 -5380 {
lab=VDD}
N 9520 -5590 9530 -5580 {
lab=VDD}
N 9520 -5610 9520 -5590 {
lab=VDD}
N 9400 -5510 9410 -5520 {
lab=col_n[17]}
N 9410 -5520 9610 -5520 {
lab=col_n[17]}
N 9610 -5520 9620 -5510 {
lab=col_n[17]}
N 9400 -5490 9410 -5500 {
lab=colon_n[17]}
N 9410 -5500 9610 -5500 {
lab=colon_n[17]}
N 9610 -5500 9620 -5490 {
lab=colon_n[17]}
N 9400 -5470 9410 -5480 {
lab=#net35}
N 9410 -5480 9610 -5480 {
lab=#net35}
N 9610 -5480 9620 -5470 {
lab=#net35}
N 9400 -5450 9410 -5460 {
lab=#net36}
N 9410 -5460 9610 -5460 {
lab=#net36}
N 9610 -5460 9620 -5450 {
lab=#net36}
N 9620 -5450 9640 -5450 {
lab=#net36}
N 9620 -5470 9640 -5470 {
lab=#net35}
N 9620 -5490 9640 -5490 {
lab=colon_n[17]}
N 9620 -5510 9640 -5510 {
lab=col_n[17]}
N 9380 -5510 9400 -5510 {
lab=col_n[17]}
N 9380 -5490 9400 -5490 {
lab=colon_n[17]}
N 9380 -5470 9400 -5470 {
lab=#net35}
N 9380 -5450 9400 -5450 {
lab=#net36}
N 9440 -5370 9440 -5360 {
lab=VSS}
N 9460 -5610 9460 -5590 {
lab=vcom}
N 9440 -5600 9440 -5590 {
lab=VDD}
N 9500 -5610 9500 -5590 {
lab=ctop}
N 9520 -5370 9520 -5350 {
lab=VDD}
N 9520 -5630 9530 -5640 {
lab=VDD}
N 9530 -5840 9530 -5640 {
lab=VDD}
N 9520 -5850 9530 -5840 {
lab=VDD}
N 9520 -5870 9520 -5850 {
lab=VDD}
N 9400 -5770 9410 -5780 {
lab=col_n[18]}
N 9410 -5780 9610 -5780 {
lab=col_n[18]}
N 9610 -5780 9620 -5770 {
lab=col_n[18]}
N 9400 -5750 9410 -5760 {
lab=colon_n[18]}
N 9410 -5760 9610 -5760 {
lab=colon_n[18]}
N 9610 -5760 9620 -5750 {
lab=colon_n[18]}
N 9400 -5730 9410 -5740 {
lab=#net37}
N 9410 -5740 9610 -5740 {
lab=#net37}
N 9610 -5740 9620 -5730 {
lab=#net37}
N 9400 -5710 9410 -5720 {
lab=#net38}
N 9410 -5720 9610 -5720 {
lab=#net38}
N 9610 -5720 9620 -5710 {
lab=#net38}
N 9620 -5710 9640 -5710 {
lab=#net38}
N 9620 -5730 9640 -5730 {
lab=#net37}
N 9620 -5750 9640 -5750 {
lab=colon_n[18]}
N 9620 -5770 9640 -5770 {
lab=col_n[18]}
N 9380 -5770 9400 -5770 {
lab=col_n[18]}
N 9380 -5750 9400 -5750 {
lab=colon_n[18]}
N 9380 -5730 9400 -5730 {
lab=#net37}
N 9380 -5710 9400 -5710 {
lab=#net38}
N 9440 -5630 9440 -5620 {
lab=VSS}
N 9460 -5870 9460 -5850 {
lab=vcom}
N 9440 -5860 9440 -5850 {
lab=VDD}
N 9500 -5870 9500 -5850 {
lab=ctop}
N 9520 -5630 9520 -5610 {
lab=VDD}
N 9520 -5890 9530 -5900 {
lab=VDD}
N 9530 -6100 9530 -5900 {
lab=VDD}
N 9520 -6110 9530 -6100 {
lab=VDD}
N 9520 -6130 9520 -6110 {
lab=VDD}
N 9400 -6030 9410 -6040 {
lab=col_n[19]}
N 9410 -6040 9610 -6040 {
lab=col_n[19]}
N 9610 -6040 9620 -6030 {
lab=col_n[19]}
N 9400 -6010 9410 -6020 {
lab=colon_n[19]}
N 9410 -6020 9610 -6020 {
lab=colon_n[19]}
N 9610 -6020 9620 -6010 {
lab=colon_n[19]}
N 9400 -5990 9410 -6000 {
lab=#net39}
N 9410 -6000 9610 -6000 {
lab=#net39}
N 9610 -6000 9620 -5990 {
lab=#net39}
N 9400 -5970 9410 -5980 {
lab=#net40}
N 9410 -5980 9610 -5980 {
lab=#net40}
N 9610 -5980 9620 -5970 {
lab=#net40}
N 9620 -5970 9640 -5970 {
lab=#net40}
N 9620 -5990 9640 -5990 {
lab=#net39}
N 9620 -6010 9640 -6010 {
lab=colon_n[19]}
N 9620 -6030 9640 -6030 {
lab=col_n[19]}
N 9380 -6030 9400 -6030 {
lab=col_n[19]}
N 9380 -6010 9400 -6010 {
lab=colon_n[19]}
N 9380 -5990 9400 -5990 {
lab=#net39}
N 9380 -5970 9400 -5970 {
lab=#net40}
N 9440 -5890 9440 -5880 {
lab=VSS}
N 9460 -6130 9460 -6110 {
lab=vcom}
N 9440 -6120 9440 -6110 {
lab=VDD}
N 9500 -6130 9500 -6110 {
lab=ctop}
N 9520 -5890 9520 -5870 {
lab=VDD}
N 9520 -6150 9530 -6160 {
lab=VDD}
N 9530 -6360 9530 -6160 {
lab=VDD}
N 9520 -6370 9530 -6360 {
lab=VDD}
N 9520 -6390 9520 -6370 {
lab=VDD}
N 9400 -6290 9410 -6300 {
lab=col_n[20]}
N 9410 -6300 9610 -6300 {
lab=col_n[20]}
N 9610 -6300 9620 -6290 {
lab=col_n[20]}
N 9400 -6270 9410 -6280 {
lab=colon_n[20]}
N 9410 -6280 9610 -6280 {
lab=colon_n[20]}
N 9610 -6280 9620 -6270 {
lab=colon_n[20]}
N 9400 -6250 9410 -6260 {
lab=#net41}
N 9410 -6260 9610 -6260 {
lab=#net41}
N 9610 -6260 9620 -6250 {
lab=#net41}
N 9400 -6230 9410 -6240 {
lab=#net42}
N 9410 -6240 9610 -6240 {
lab=#net42}
N 9610 -6240 9620 -6230 {
lab=#net42}
N 9620 -6230 9640 -6230 {
lab=#net42}
N 9620 -6250 9640 -6250 {
lab=#net41}
N 9620 -6270 9640 -6270 {
lab=colon_n[20]}
N 9620 -6290 9640 -6290 {
lab=col_n[20]}
N 9380 -6290 9400 -6290 {
lab=col_n[20]}
N 9380 -6270 9400 -6270 {
lab=colon_n[20]}
N 9380 -6250 9400 -6250 {
lab=#net41}
N 9380 -6230 9400 -6230 {
lab=#net42}
N 9440 -6150 9440 -6140 {
lab=VSS}
N 9460 -6390 9460 -6370 {
lab=vcom}
N 9440 -6380 9440 -6370 {
lab=VDD}
N 9500 -6390 9500 -6370 {
lab=ctop}
N 9520 -6150 9520 -6130 {
lab=VDD}
N 9520 -6410 9530 -6420 {
lab=VDD}
N 9530 -6620 9530 -6420 {
lab=VDD}
N 9520 -6630 9530 -6620 {
lab=VDD}
N 9520 -6650 9520 -6630 {
lab=VDD}
N 9400 -6550 9410 -6560 {
lab=col_n[21]}
N 9410 -6560 9610 -6560 {
lab=col_n[21]}
N 9610 -6560 9620 -6550 {
lab=col_n[21]}
N 9400 -6530 9410 -6540 {
lab=colon_n[21]}
N 9410 -6540 9610 -6540 {
lab=colon_n[21]}
N 9610 -6540 9620 -6530 {
lab=colon_n[21]}
N 9400 -6510 9410 -6520 {
lab=#net43}
N 9410 -6520 9610 -6520 {
lab=#net43}
N 9610 -6520 9620 -6510 {
lab=#net43}
N 9400 -6490 9410 -6500 {
lab=#net44}
N 9410 -6500 9610 -6500 {
lab=#net44}
N 9610 -6500 9620 -6490 {
lab=#net44}
N 9620 -6490 9640 -6490 {
lab=#net44}
N 9620 -6510 9640 -6510 {
lab=#net43}
N 9620 -6530 9640 -6530 {
lab=colon_n[21]}
N 9620 -6550 9640 -6550 {
lab=col_n[21]}
N 9380 -6550 9400 -6550 {
lab=col_n[21]}
N 9380 -6530 9400 -6530 {
lab=colon_n[21]}
N 9380 -6510 9400 -6510 {
lab=#net43}
N 9380 -6490 9400 -6490 {
lab=#net44}
N 9440 -6410 9440 -6400 {
lab=VSS}
N 9460 -6650 9460 -6630 {
lab=vcom}
N 9440 -6640 9440 -6630 {
lab=VDD}
N 9500 -6650 9500 -6630 {
lab=ctop}
N 9520 -6410 9520 -6390 {
lab=VDD}
N 9520 -6670 9530 -6680 {
lab=VDD}
N 9530 -6880 9530 -6680 {
lab=VDD}
N 9520 -6890 9530 -6880 {
lab=VDD}
N 9520 -6910 9520 -6890 {
lab=VDD}
N 9400 -6810 9410 -6820 {
lab=col_n[22]}
N 9410 -6820 9610 -6820 {
lab=col_n[22]}
N 9610 -6820 9620 -6810 {
lab=col_n[22]}
N 9400 -6790 9410 -6800 {
lab=colon_n[22]}
N 9410 -6800 9610 -6800 {
lab=colon_n[22]}
N 9610 -6800 9620 -6790 {
lab=colon_n[22]}
N 9400 -6770 9410 -6780 {
lab=#net45}
N 9410 -6780 9610 -6780 {
lab=#net45}
N 9610 -6780 9620 -6770 {
lab=#net45}
N 9400 -6750 9410 -6760 {
lab=#net46}
N 9410 -6760 9610 -6760 {
lab=#net46}
N 9610 -6760 9620 -6750 {
lab=#net46}
N 9620 -6750 9640 -6750 {
lab=#net46}
N 9620 -6770 9640 -6770 {
lab=#net45}
N 9620 -6790 9640 -6790 {
lab=colon_n[22]}
N 9620 -6810 9640 -6810 {
lab=col_n[22]}
N 9380 -6810 9400 -6810 {
lab=col_n[22]}
N 9380 -6790 9400 -6790 {
lab=colon_n[22]}
N 9380 -6770 9400 -6770 {
lab=#net45}
N 9380 -6750 9400 -6750 {
lab=#net46}
N 9440 -6670 9440 -6660 {
lab=VSS}
N 9460 -6910 9460 -6890 {
lab=vcom}
N 9440 -6900 9440 -6890 {
lab=VDD}
N 9500 -6910 9500 -6890 {
lab=ctop}
N 9520 -6670 9520 -6650 {
lab=VDD}
N 9520 -6930 9530 -6940 {
lab=VDD}
N 9530 -7140 9530 -6940 {
lab=VDD}
N 9520 -7150 9530 -7140 {
lab=VDD}
N 9520 -7170 9520 -7150 {
lab=VDD}
N 9400 -7070 9410 -7080 {
lab=col_n[23]}
N 9410 -7080 9610 -7080 {
lab=col_n[23]}
N 9610 -7080 9620 -7070 {
lab=col_n[23]}
N 9400 -7050 9410 -7060 {
lab=colon_n[23]}
N 9410 -7060 9610 -7060 {
lab=colon_n[23]}
N 9610 -7060 9620 -7050 {
lab=colon_n[23]}
N 9400 -7030 9410 -7040 {
lab=#net47}
N 9410 -7040 9610 -7040 {
lab=#net47}
N 9610 -7040 9620 -7030 {
lab=#net47}
N 9400 -7010 9410 -7020 {
lab=#net48}
N 9410 -7020 9610 -7020 {
lab=#net48}
N 9610 -7020 9620 -7010 {
lab=#net48}
N 9620 -7010 9640 -7010 {
lab=#net48}
N 9620 -7030 9640 -7030 {
lab=#net47}
N 9620 -7050 9640 -7050 {
lab=colon_n[23]}
N 9620 -7070 9640 -7070 {
lab=col_n[23]}
N 9380 -7070 9400 -7070 {
lab=col_n[23]}
N 9380 -7050 9400 -7050 {
lab=colon_n[23]}
N 9380 -7030 9400 -7030 {
lab=#net47}
N 9380 -7010 9400 -7010 {
lab=#net48}
N 9440 -6930 9440 -6920 {
lab=VSS}
N 9460 -7170 9460 -7150 {
lab=vcom}
N 9440 -7160 9440 -7150 {
lab=VDD}
N 9500 -7170 9500 -7150 {
lab=ctop}
N 9520 -6930 9520 -6910 {
lab=VDD}
N 9520 -7190 9530 -7200 {
lab=VDD}
N 9530 -7400 9530 -7200 {
lab=VDD}
N 9520 -7410 9530 -7400 {
lab=VDD}
N 9520 -7430 9520 -7410 {
lab=VDD}
N 9400 -7330 9410 -7340 {
lab=col_n[24]}
N 9410 -7340 9610 -7340 {
lab=col_n[24]}
N 9610 -7340 9620 -7330 {
lab=col_n[24]}
N 9400 -7310 9410 -7320 {
lab=colon_n[24]}
N 9410 -7320 9610 -7320 {
lab=colon_n[24]}
N 9610 -7320 9620 -7310 {
lab=colon_n[24]}
N 9400 -7290 9410 -7300 {
lab=#net49}
N 9410 -7300 9610 -7300 {
lab=#net49}
N 9610 -7300 9620 -7290 {
lab=#net49}
N 9400 -7270 9410 -7280 {
lab=#net50}
N 9410 -7280 9610 -7280 {
lab=#net50}
N 9610 -7280 9620 -7270 {
lab=#net50}
N 9620 -7270 9640 -7270 {
lab=#net50}
N 9620 -7290 9640 -7290 {
lab=#net49}
N 9620 -7310 9640 -7310 {
lab=colon_n[24]}
N 9620 -7330 9640 -7330 {
lab=col_n[24]}
N 9380 -7330 9400 -7330 {
lab=col_n[24]}
N 9380 -7310 9400 -7310 {
lab=colon_n[24]}
N 9380 -7290 9400 -7290 {
lab=#net49}
N 9380 -7270 9400 -7270 {
lab=#net50}
N 9440 -7190 9440 -7180 {
lab=VSS}
N 9460 -7430 9460 -7410 {
lab=vcom}
N 9440 -7420 9440 -7410 {
lab=VDD}
N 9500 -7430 9500 -7410 {
lab=ctop}
N 9520 -7190 9520 -7170 {
lab=VDD}
N 9520 -7450 9530 -7460 {
lab=VDD}
N 9530 -7660 9530 -7460 {
lab=VDD}
N 9520 -7670 9530 -7660 {
lab=VDD}
N 9520 -7690 9520 -7670 {
lab=VDD}
N 9400 -7590 9410 -7600 {
lab=col_n[25]}
N 9410 -7600 9610 -7600 {
lab=col_n[25]}
N 9610 -7600 9620 -7590 {
lab=col_n[25]}
N 9400 -7570 9410 -7580 {
lab=colon_n[25]}
N 9410 -7580 9610 -7580 {
lab=colon_n[25]}
N 9610 -7580 9620 -7570 {
lab=colon_n[25]}
N 9400 -7550 9410 -7560 {
lab=#net51}
N 9410 -7560 9610 -7560 {
lab=#net51}
N 9610 -7560 9620 -7550 {
lab=#net51}
N 9400 -7530 9410 -7540 {
lab=#net52}
N 9410 -7540 9610 -7540 {
lab=#net52}
N 9610 -7540 9620 -7530 {
lab=#net52}
N 9620 -7530 9640 -7530 {
lab=#net52}
N 9620 -7550 9640 -7550 {
lab=#net51}
N 9620 -7570 9640 -7570 {
lab=colon_n[25]}
N 9620 -7590 9640 -7590 {
lab=col_n[25]}
N 9380 -7590 9400 -7590 {
lab=col_n[25]}
N 9380 -7570 9400 -7570 {
lab=colon_n[25]}
N 9380 -7550 9400 -7550 {
lab=#net51}
N 9380 -7530 9400 -7530 {
lab=#net52}
N 9440 -7450 9440 -7440 {
lab=VSS}
N 9460 -7690 9460 -7670 {
lab=vcom}
N 9440 -7680 9440 -7670 {
lab=VDD}
N 9500 -7690 9500 -7670 {
lab=ctop}
N 9520 -7450 9520 -7430 {
lab=VDD}
N 9520 -7710 9530 -7720 {
lab=VDD}
N 9530 -7920 9530 -7720 {
lab=VDD}
N 9520 -7930 9530 -7920 {
lab=VDD}
N 9520 -7950 9520 -7930 {
lab=VDD}
N 9400 -7850 9410 -7860 {
lab=col_n[26]}
N 9410 -7860 9610 -7860 {
lab=col_n[26]}
N 9610 -7860 9620 -7850 {
lab=col_n[26]}
N 9400 -7830 9410 -7840 {
lab=colon_n[26]}
N 9410 -7840 9610 -7840 {
lab=colon_n[26]}
N 9610 -7840 9620 -7830 {
lab=colon_n[26]}
N 9400 -7810 9410 -7820 {
lab=#net53}
N 9410 -7820 9610 -7820 {
lab=#net53}
N 9610 -7820 9620 -7810 {
lab=#net53}
N 9400 -7790 9410 -7800 {
lab=#net54}
N 9410 -7800 9610 -7800 {
lab=#net54}
N 9610 -7800 9620 -7790 {
lab=#net54}
N 9620 -7790 9640 -7790 {
lab=#net54}
N 9620 -7810 9640 -7810 {
lab=#net53}
N 9620 -7830 9640 -7830 {
lab=colon_n[26]}
N 9620 -7850 9640 -7850 {
lab=col_n[26]}
N 9380 -7850 9400 -7850 {
lab=col_n[26]}
N 9380 -7830 9400 -7830 {
lab=colon_n[26]}
N 9380 -7810 9400 -7810 {
lab=#net53}
N 9380 -7790 9400 -7790 {
lab=#net54}
N 9440 -7710 9440 -7700 {
lab=VSS}
N 9460 -7950 9460 -7930 {
lab=vcom}
N 9440 -7940 9440 -7930 {
lab=VDD}
N 9500 -7950 9500 -7930 {
lab=ctop}
N 9520 -7710 9520 -7690 {
lab=VDD}
N 9520 -7970 9530 -7980 {
lab=VDD}
N 9530 -8180 9530 -7980 {
lab=VDD}
N 9520 -8190 9530 -8180 {
lab=VDD}
N 9520 -8210 9520 -8190 {
lab=VDD}
N 9400 -8110 9410 -8120 {
lab=col_n[27]}
N 9410 -8120 9610 -8120 {
lab=col_n[27]}
N 9610 -8120 9620 -8110 {
lab=col_n[27]}
N 9400 -8090 9410 -8100 {
lab=colon_n[27]}
N 9410 -8100 9610 -8100 {
lab=colon_n[27]}
N 9610 -8100 9620 -8090 {
lab=colon_n[27]}
N 9400 -8070 9410 -8080 {
lab=#net55}
N 9410 -8080 9610 -8080 {
lab=#net55}
N 9610 -8080 9620 -8070 {
lab=#net55}
N 9400 -8050 9410 -8060 {
lab=#net56}
N 9410 -8060 9610 -8060 {
lab=#net56}
N 9610 -8060 9620 -8050 {
lab=#net56}
N 9620 -8050 9640 -8050 {
lab=#net56}
N 9620 -8070 9640 -8070 {
lab=#net55}
N 9620 -8090 9640 -8090 {
lab=colon_n[27]}
N 9620 -8110 9640 -8110 {
lab=col_n[27]}
N 9380 -8110 9400 -8110 {
lab=col_n[27]}
N 9380 -8090 9400 -8090 {
lab=colon_n[27]}
N 9380 -8070 9400 -8070 {
lab=#net55}
N 9380 -8050 9400 -8050 {
lab=#net56}
N 9440 -7970 9440 -7960 {
lab=VSS}
N 9460 -8210 9460 -8190 {
lab=vcom}
N 9440 -8200 9440 -8190 {
lab=VDD}
N 9500 -8210 9500 -8190 {
lab=ctop}
N 9520 -7970 9520 -7950 {
lab=VDD}
N 9520 -8230 9530 -8240 {
lab=VDD}
N 9530 -8440 9530 -8240 {
lab=VDD}
N 9520 -8450 9530 -8440 {
lab=VDD}
N 9520 -8470 9520 -8450 {
lab=VDD}
N 9400 -8370 9410 -8380 {
lab=col_n[28]}
N 9410 -8380 9610 -8380 {
lab=col_n[28]}
N 9610 -8380 9620 -8370 {
lab=col_n[28]}
N 9400 -8350 9410 -8360 {
lab=colon_n[28]}
N 9410 -8360 9610 -8360 {
lab=colon_n[28]}
N 9610 -8360 9620 -8350 {
lab=colon_n[28]}
N 9400 -8330 9410 -8340 {
lab=#net57}
N 9410 -8340 9610 -8340 {
lab=#net57}
N 9610 -8340 9620 -8330 {
lab=#net57}
N 9400 -8310 9410 -8320 {
lab=#net58}
N 9410 -8320 9610 -8320 {
lab=#net58}
N 9610 -8320 9620 -8310 {
lab=#net58}
N 9620 -8310 9640 -8310 {
lab=#net58}
N 9620 -8330 9640 -8330 {
lab=#net57}
N 9620 -8350 9640 -8350 {
lab=colon_n[28]}
N 9620 -8370 9640 -8370 {
lab=col_n[28]}
N 9380 -8370 9400 -8370 {
lab=col_n[28]}
N 9380 -8350 9400 -8350 {
lab=colon_n[28]}
N 9380 -8330 9400 -8330 {
lab=#net57}
N 9380 -8310 9400 -8310 {
lab=#net58}
N 9440 -8230 9440 -8220 {
lab=VSS}
N 9460 -8470 9460 -8450 {
lab=vcom}
N 9440 -8460 9440 -8450 {
lab=VDD}
N 9500 -8470 9500 -8450 {
lab=ctop}
N 9520 -8230 9520 -8210 {
lab=VDD}
N 9520 -8490 9530 -8500 {
lab=VDD}
N 9530 -8700 9530 -8500 {
lab=VDD}
N 9520 -8710 9530 -8700 {
lab=VDD}
N 9520 -8730 9520 -8710 {
lab=VDD}
N 9400 -8630 9410 -8640 {
lab=col_n[29]}
N 9410 -8640 9610 -8640 {
lab=col_n[29]}
N 9610 -8640 9620 -8630 {
lab=col_n[29]}
N 9400 -8610 9410 -8620 {
lab=colon_n[29]}
N 9410 -8620 9610 -8620 {
lab=colon_n[29]}
N 9610 -8620 9620 -8610 {
lab=colon_n[29]}
N 9400 -8590 9410 -8600 {
lab=#net59}
N 9410 -8600 9610 -8600 {
lab=#net59}
N 9610 -8600 9620 -8590 {
lab=#net59}
N 9400 -8570 9410 -8580 {
lab=#net60}
N 9410 -8580 9610 -8580 {
lab=#net60}
N 9610 -8580 9620 -8570 {
lab=#net60}
N 9620 -8570 9640 -8570 {
lab=#net60}
N 9620 -8590 9640 -8590 {
lab=#net59}
N 9620 -8610 9640 -8610 {
lab=colon_n[29]}
N 9620 -8630 9640 -8630 {
lab=col_n[29]}
N 9380 -8630 9400 -8630 {
lab=col_n[29]}
N 9380 -8610 9400 -8610 {
lab=colon_n[29]}
N 9380 -8590 9400 -8590 {
lab=#net59}
N 9380 -8570 9400 -8570 {
lab=#net60}
N 9440 -8490 9440 -8480 {
lab=VSS}
N 9460 -8730 9460 -8710 {
lab=vcom}
N 9440 -8720 9440 -8710 {
lab=VDD}
N 9500 -8730 9500 -8710 {
lab=ctop}
N 9520 -8490 9520 -8470 {
lab=VDD}
N 9520 -8750 9530 -8760 {
lab=VDD}
N 9530 -8960 9530 -8760 {
lab=VDD}
N 9520 -8970 9530 -8960 {
lab=VDD}
N 9520 -8990 9520 -8970 {
lab=VDD}
N 9400 -8890 9410 -8900 {
lab=col_n[30]}
N 9410 -8900 9610 -8900 {
lab=col_n[30]}
N 9610 -8900 9620 -8890 {
lab=col_n[30]}
N 9400 -8870 9410 -8880 {
lab=colon_n[30]}
N 9410 -8880 9610 -8880 {
lab=colon_n[30]}
N 9610 -8880 9620 -8870 {
lab=colon_n[30]}
N 9400 -8850 9410 -8860 {
lab=#net61}
N 9410 -8860 9610 -8860 {
lab=#net61}
N 9610 -8860 9620 -8850 {
lab=#net61}
N 9400 -8830 9410 -8840 {
lab=#net62}
N 9410 -8840 9610 -8840 {
lab=#net62}
N 9610 -8840 9620 -8830 {
lab=#net62}
N 9620 -8830 9640 -8830 {
lab=#net62}
N 9620 -8850 9640 -8850 {
lab=#net61}
N 9620 -8870 9640 -8870 {
lab=colon_n[30]}
N 9620 -8890 9640 -8890 {
lab=col_n[30]}
N 9380 -8890 9400 -8890 {
lab=col_n[30]}
N 9380 -8870 9400 -8870 {
lab=colon_n[30]}
N 9380 -8850 9400 -8850 {
lab=#net61}
N 9380 -8830 9400 -8830 {
lab=#net62}
N 9440 -8750 9440 -8740 {
lab=VSS}
N 9460 -8990 9460 -8970 {
lab=vcom}
N 9440 -8980 9440 -8970 {
lab=VDD}
N 9500 -8990 9500 -8970 {
lab=ctop}
N 9520 -8750 9520 -8730 {
lab=VDD}
N 9520 -9010 9530 -9020 {
lab=VDD}
N 9530 -9220 9530 -9020 {
lab=VDD}
N 9520 -9230 9530 -9220 {
lab=VDD}
N 9520 -9250 9520 -9230 {
lab=VDD}
N 9400 -9150 9410 -9160 {
lab=col_n[31]}
N 9410 -9160 9610 -9160 {
lab=col_n[31]}
N 9610 -9160 9620 -9150 {
lab=col_n[31]}
N 9400 -9130 9410 -9140 {
lab=colon_n[31]}
N 9410 -9140 9610 -9140 {
lab=colon_n[31]}
N 9610 -9140 9620 -9130 {
lab=colon_n[31]}
N 9400 -9110 9410 -9120 {
lab=#net63}
N 9410 -9120 9610 -9120 {
lab=#net63}
N 9610 -9120 9620 -9110 {
lab=#net63}
N 9400 -9090 9410 -9100 {
lab=#net64}
N 9410 -9100 9610 -9100 {
lab=#net64}
N 9610 -9100 9620 -9090 {
lab=#net64}
N 9620 -9090 9640 -9090 {
lab=#net64}
N 9620 -9110 9640 -9110 {
lab=#net63}
N 9620 -9130 9640 -9130 {
lab=colon_n[31]}
N 9620 -9150 9640 -9150 {
lab=col_n[31]}
N 9380 -9150 9400 -9150 {
lab=col_n[31]}
N 9380 -9130 9400 -9130 {
lab=colon_n[31]}
N 9380 -9110 9400 -9110 {
lab=#net63}
N 9380 -9090 9400 -9090 {
lab=#net64}
N 9440 -9010 9440 -9000 {
lab=VSS}
N 9460 -9250 9460 -9230 {
lab=vcom}
N 9440 -9240 9440 -9230 {
lab=VDD}
N 9500 -9250 9500 -9230 {
lab=ctop}
N 9520 -9010 9520 -8990 {
lab=VDD}
N 940 -690 940 -680 {
lab=VDD}
N 9440 -950 9440 -940 {
lab=VSS}
N 9440 -1210 9440 -1200 {
lab=VSS}
N 9440 -1470 9440 -1460 {
lab=VSS}
N 9440 -1730 9440 -1720 {
lab=VSS}
N 9440 -1990 9440 -1980 {
lab=VSS}
N 9440 -2250 9440 -2240 {
lab=VSS}
N 9440 -2510 9440 -2500 {
lab=VSS}
N 9440 -2770 9440 -2760 {
lab=VSS}
N 9440 -3030 9440 -3020 {
lab=VSS}
N 9440 -3290 9440 -3280 {
lab=VSS}
N 9440 -3550 9440 -3540 {
lab=VSS}
N 9440 -3810 9440 -3800 {
lab=VSS}
N 9440 -4070 9440 -4060 {
lab=VSS}
N 9440 -4070 9440 -4060 {
lab=VSS}
N 7910 -690 7910 -680 {
lab=en_n_bit[0]}
N 5830 -690 5830 -670 {
lab=en_n_bit[1]}
N 3750 -690 3750 -670 {
lab=en_n_bit[2]}
N 1670 -690 1670 -670 {
lab=en_n_bit[3]}
C {devices/title.sym} 170 -40 0 0 {name=l1 author="Manuel Moser"}
C {devices/iopin.sym} 200 -570 0 1 {name=p1 lab=VDD}
C {devices/iopin.sym} 200 -550 0 1 {name=p2 lab=VSS}
C {devices/ipin.sym} 200 -470 0 0 {name=p3 lab=sample}
C {devices/ipin.sym} 200 -450 0 0 {name=p4 lab=sample_n}
C {devices/ipin.sym} 200 -420 0 0 {name=p5 lab=col_n[31:0]}
C {devices/ipin.sym} 200 -400 0 0 {name=p6 lab=colon_n[31:0]}
C {devices/ipin.sym} 200 -380 0 0 {name=p7 lab=row_n[31:0]}
C {devices/iopin.sym} 200 -500 0 1 {name=p8 lab=ctop}
C {devices/iopin.sym} 200 -520 0 1 {name=p9 lab=vcom}
C {devices/ipin.sym} 200 -360 0 0 {name=p10 lab=en_n_bit[3:0]}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -1060 0 0 {name=x1}
C {devices/lab_wire.sym} 1120 -1180 2 1 {name=l2 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -1190 1 1 {name=l3 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -1190 3 0 {name=l4 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -940 0 0 {name=l5 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -1060 0 0 {name=x2}
C {devices/lab_wire.sym} 1380 -1180 2 1 {name=l6 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -1190 1 1 {name=l7 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -1190 3 0 {name=l8 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -940 0 0 {name=l9 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -1060 0 0 {name=x3}
C {devices/lab_wire.sym} 1640 -1180 2 1 {name=l10 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -1190 1 1 {name=l11 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -1190 3 0 {name=l12 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -940 0 0 {name=l13 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -1060 0 0 {name=x4}
C {devices/lab_wire.sym} 1900 -1180 2 1 {name=l14 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -1190 1 1 {name=l15 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -1190 3 0 {name=l16 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -940 0 0 {name=l17 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -1060 0 0 {name=x5}
C {devices/lab_wire.sym} 2160 -1180 2 1 {name=l18 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -1190 1 1 {name=l19 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -1190 3 0 {name=l20 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -940 0 0 {name=l21 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -1060 0 0 {name=x6}
C {devices/lab_wire.sym} 2420 -1180 2 1 {name=l22 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -1190 1 1 {name=l23 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -1190 3 0 {name=l24 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -940 0 0 {name=l25 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -1060 0 0 {name=x7}
C {devices/lab_wire.sym} 2680 -1180 2 1 {name=l26 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -1190 1 1 {name=l27 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -1190 3 0 {name=l28 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -940 0 0 {name=l29 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -1060 0 0 {name=x8}
C {devices/lab_wire.sym} 2940 -1180 2 1 {name=l30 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -1190 1 1 {name=l31 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -1190 3 0 {name=l32 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -940 0 0 {name=l33 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -1060 0 0 {name=x9}
C {devices/lab_wire.sym} 3200 -1180 2 1 {name=l34 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -1190 1 1 {name=l35 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -1190 3 0 {name=l36 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -940 0 0 {name=l37 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -1060 0 0 {name=x10}
C {devices/lab_wire.sym} 3460 -1180 2 1 {name=l38 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -1190 1 1 {name=l39 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -1190 3 0 {name=l40 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -940 0 0 {name=l41 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -1060 0 0 {name=x11}
C {devices/lab_wire.sym} 3720 -1180 2 1 {name=l42 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -1190 1 1 {name=l43 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -1190 3 0 {name=l44 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -940 0 0 {name=l45 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -1060 0 0 {name=x12}
C {devices/lab_wire.sym} 3980 -1180 2 1 {name=l46 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -1190 1 1 {name=l47 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -1190 3 0 {name=l48 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -940 0 0 {name=l49 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -1060 0 0 {name=x13}
C {devices/lab_wire.sym} 4240 -1180 2 1 {name=l50 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -1190 1 1 {name=l51 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -1190 3 0 {name=l52 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -940 0 0 {name=l53 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -1060 0 0 {name=x14}
C {devices/lab_wire.sym} 4500 -1180 2 1 {name=l54 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -1190 1 1 {name=l55 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -1190 3 0 {name=l56 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -940 0 0 {name=l57 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -1060 0 0 {name=x15}
C {devices/lab_wire.sym} 4760 -1180 2 1 {name=l58 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -1190 1 1 {name=l59 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -1190 3 0 {name=l60 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -940 0 0 {name=l61 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -1060 0 0 {name=x16}
C {devices/lab_wire.sym} 5020 -1180 2 1 {name=l62 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -1190 1 1 {name=l63 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -1190 3 0 {name=l64 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -940 0 0 {name=l65 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -1060 0 0 {name=x17}
C {devices/lab_wire.sym} 5280 -1180 2 1 {name=l66 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -1190 1 1 {name=l67 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -1190 3 0 {name=l68 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -940 0 0 {name=l69 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -1060 0 0 {name=x18}
C {devices/lab_wire.sym} 5540 -1180 2 1 {name=l70 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -1190 1 1 {name=l71 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -1190 3 0 {name=l72 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -940 0 0 {name=l73 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -1060 0 0 {name=x19}
C {devices/lab_wire.sym} 5800 -1180 2 1 {name=l74 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -1190 1 1 {name=l75 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -1190 3 0 {name=l76 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -940 0 0 {name=l77 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -1060 0 0 {name=x20}
C {devices/lab_wire.sym} 6060 -1180 2 1 {name=l78 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -1190 1 1 {name=l79 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -1190 3 0 {name=l80 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -940 0 0 {name=l81 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -1060 0 0 {name=x21}
C {devices/lab_wire.sym} 6320 -1180 2 1 {name=l82 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -1190 1 1 {name=l83 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -1190 3 0 {name=l84 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -940 0 0 {name=l85 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -1060 0 0 {name=x22}
C {devices/lab_wire.sym} 6580 -1180 2 1 {name=l86 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -1190 1 1 {name=l87 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -1190 3 0 {name=l88 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -940 0 0 {name=l89 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -1060 0 0 {name=x23}
C {devices/lab_wire.sym} 6840 -1180 2 1 {name=l90 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -1190 1 1 {name=l91 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -1190 3 0 {name=l92 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -940 0 0 {name=l93 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -1060 0 0 {name=x24}
C {devices/lab_wire.sym} 7100 -1180 2 1 {name=l94 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -1190 1 1 {name=l95 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -1190 3 0 {name=l96 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -940 0 0 {name=l97 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -1060 0 0 {name=x25}
C {devices/lab_wire.sym} 7360 -1180 2 1 {name=l98 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -1190 1 1 {name=l99 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -1190 3 0 {name=l100 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -940 0 0 {name=l101 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -1060 0 0 {name=x26}
C {devices/lab_wire.sym} 7620 -1180 2 1 {name=l102 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -1190 1 1 {name=l103 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -1190 3 0 {name=l104 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -940 0 0 {name=l105 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -1060 0 0 {name=x27}
C {devices/lab_wire.sym} 7880 -1180 2 1 {name=l106 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -1190 1 1 {name=l107 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -1190 3 0 {name=l108 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -940 0 0 {name=l109 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -1060 0 0 {name=x28}
C {devices/lab_wire.sym} 8140 -1180 2 1 {name=l110 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -1190 1 1 {name=l111 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -1190 3 0 {name=l112 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -940 0 0 {name=l113 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -1060 0 0 {name=x29}
C {devices/lab_wire.sym} 8400 -1180 2 1 {name=l114 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -1190 1 1 {name=l115 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -1190 3 0 {name=l116 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -940 0 0 {name=l117 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -1060 0 0 {name=x30}
C {devices/lab_wire.sym} 8660 -1180 2 1 {name=l118 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -1190 1 1 {name=l119 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -1190 3 0 {name=l120 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -940 0 0 {name=l121 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -1060 0 0 {name=x31}
C {devices/lab_wire.sym} 8920 -1180 2 1 {name=l122 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -1190 1 1 {name=l123 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -1190 3 0 {name=l124 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -940 0 0 {name=l125 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -1060 0 0 {name=x32}
C {devices/lab_wire.sym} 9180 -1180 2 1 {name=l126 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -1190 1 1 {name=l127 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -1190 3 0 {name=l128 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -940 0 0 {name=l129 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -1320 0 0 {name=x33}
C {devices/lab_wire.sym} 1120 -1440 2 1 {name=l130 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -1450 1 1 {name=l131 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -1450 3 0 {name=l132 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -1200 0 0 {name=l133 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -1320 0 0 {name=x34}
C {devices/lab_wire.sym} 1380 -1440 2 1 {name=l134 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -1450 1 1 {name=l135 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -1450 3 0 {name=l136 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -1200 0 0 {name=l137 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -1320 0 0 {name=x35}
C {devices/lab_wire.sym} 1640 -1440 2 1 {name=l138 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -1450 1 1 {name=l139 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -1450 3 0 {name=l140 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -1200 0 0 {name=l141 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -1320 0 0 {name=x36}
C {devices/lab_wire.sym} 1900 -1440 2 1 {name=l142 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -1450 1 1 {name=l143 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -1450 3 0 {name=l144 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -1200 0 0 {name=l145 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -1320 0 0 {name=x37}
C {devices/lab_wire.sym} 2160 -1440 2 1 {name=l146 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -1450 1 1 {name=l147 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -1450 3 0 {name=l148 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -1200 0 0 {name=l149 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -1320 0 0 {name=x38}
C {devices/lab_wire.sym} 2420 -1440 2 1 {name=l150 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -1450 1 1 {name=l151 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -1450 3 0 {name=l152 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -1200 0 0 {name=l153 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -1320 0 0 {name=x39}
C {devices/lab_wire.sym} 2680 -1440 2 1 {name=l154 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -1450 1 1 {name=l155 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -1450 3 0 {name=l156 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -1200 0 0 {name=l157 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -1320 0 0 {name=x40}
C {devices/lab_wire.sym} 2940 -1440 2 1 {name=l158 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -1450 1 1 {name=l159 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -1450 3 0 {name=l160 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -1200 0 0 {name=l161 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -1320 0 0 {name=x41}
C {devices/lab_wire.sym} 3200 -1440 2 1 {name=l162 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -1450 1 1 {name=l163 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -1450 3 0 {name=l164 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -1200 0 0 {name=l165 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -1320 0 0 {name=x42}
C {devices/lab_wire.sym} 3460 -1440 2 1 {name=l166 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -1450 1 1 {name=l167 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -1450 3 0 {name=l168 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -1200 0 0 {name=l169 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -1320 0 0 {name=x43}
C {devices/lab_wire.sym} 3720 -1440 2 1 {name=l170 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -1450 1 1 {name=l171 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -1450 3 0 {name=l172 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -1200 0 0 {name=l173 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -1320 0 0 {name=x44}
C {devices/lab_wire.sym} 3980 -1440 2 1 {name=l174 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -1450 1 1 {name=l175 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -1450 3 0 {name=l176 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -1200 0 0 {name=l177 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -1320 0 0 {name=x45}
C {devices/lab_wire.sym} 4240 -1440 2 1 {name=l178 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -1450 1 1 {name=l179 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -1450 3 0 {name=l180 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -1200 0 0 {name=l181 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -1320 0 0 {name=x46}
C {devices/lab_wire.sym} 4500 -1440 2 1 {name=l182 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -1450 1 1 {name=l183 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -1450 3 0 {name=l184 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -1200 0 0 {name=l185 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -1320 0 0 {name=x47}
C {devices/lab_wire.sym} 4760 -1440 2 1 {name=l186 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -1450 1 1 {name=l187 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -1450 3 0 {name=l188 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -1200 0 0 {name=l189 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -1320 0 0 {name=x48}
C {devices/lab_wire.sym} 5020 -1440 2 1 {name=l190 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -1450 1 1 {name=l191 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -1450 3 0 {name=l192 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -1200 0 0 {name=l193 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -1320 0 0 {name=x49}
C {devices/lab_wire.sym} 5280 -1440 2 1 {name=l194 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -1450 1 1 {name=l195 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -1450 3 0 {name=l196 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -1200 0 0 {name=l197 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -1320 0 0 {name=x50}
C {devices/lab_wire.sym} 5540 -1440 2 1 {name=l198 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -1450 1 1 {name=l199 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -1450 3 0 {name=l200 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -1200 0 0 {name=l201 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -1320 0 0 {name=x51}
C {devices/lab_wire.sym} 5800 -1440 2 1 {name=l202 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -1450 1 1 {name=l203 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -1450 3 0 {name=l204 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -1200 0 0 {name=l205 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -1320 0 0 {name=x52}
C {devices/lab_wire.sym} 6060 -1440 2 1 {name=l206 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -1450 1 1 {name=l207 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -1450 3 0 {name=l208 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -1200 0 0 {name=l209 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -1320 0 0 {name=x53}
C {devices/lab_wire.sym} 6320 -1440 2 1 {name=l210 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -1450 1 1 {name=l211 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -1450 3 0 {name=l212 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -1200 0 0 {name=l213 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -1320 0 0 {name=x54}
C {devices/lab_wire.sym} 6580 -1440 2 1 {name=l214 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -1450 1 1 {name=l215 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -1450 3 0 {name=l216 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -1200 0 0 {name=l217 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -1320 0 0 {name=x55}
C {devices/lab_wire.sym} 6840 -1440 2 1 {name=l218 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -1450 1 1 {name=l219 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -1450 3 0 {name=l220 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -1200 0 0 {name=l221 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -1320 0 0 {name=x56}
C {devices/lab_wire.sym} 7100 -1440 2 1 {name=l222 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -1450 1 1 {name=l223 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -1450 3 0 {name=l224 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -1200 0 0 {name=l225 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -1320 0 0 {name=x57}
C {devices/lab_wire.sym} 7360 -1440 2 1 {name=l226 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -1450 1 1 {name=l227 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -1450 3 0 {name=l228 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -1200 0 0 {name=l229 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -1320 0 0 {name=x58}
C {devices/lab_wire.sym} 7620 -1440 2 1 {name=l230 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -1450 1 1 {name=l231 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -1450 3 0 {name=l232 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -1200 0 0 {name=l233 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -1320 0 0 {name=x59}
C {devices/lab_wire.sym} 7880 -1440 2 1 {name=l234 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -1450 1 1 {name=l235 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -1450 3 0 {name=l236 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -1200 0 0 {name=l237 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -1320 0 0 {name=x60}
C {devices/lab_wire.sym} 8140 -1440 2 1 {name=l238 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -1450 1 1 {name=l239 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -1450 3 0 {name=l240 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -1200 0 0 {name=l241 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -1320 0 0 {name=x61}
C {devices/lab_wire.sym} 8400 -1440 2 1 {name=l242 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -1450 1 1 {name=l243 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -1450 3 0 {name=l244 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -1200 0 0 {name=l245 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -1320 0 0 {name=x62}
C {devices/lab_wire.sym} 8660 -1440 2 1 {name=l246 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -1450 1 1 {name=l247 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -1450 3 0 {name=l248 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -1200 0 0 {name=l249 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -1320 0 0 {name=x63}
C {devices/lab_wire.sym} 8920 -1440 2 1 {name=l250 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -1450 1 1 {name=l251 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -1450 3 0 {name=l252 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -1200 0 0 {name=l253 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -1320 0 0 {name=x64}
C {devices/lab_wire.sym} 9180 -1440 2 1 {name=l254 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -1450 1 1 {name=l255 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -1450 3 0 {name=l256 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -1200 0 0 {name=l257 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -1580 0 0 {name=x65}
C {devices/lab_wire.sym} 1120 -1700 2 1 {name=l258 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -1710 1 1 {name=l259 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -1710 3 0 {name=l260 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -1460 0 0 {name=l261 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -1580 0 0 {name=x66}
C {devices/lab_wire.sym} 1380 -1700 2 1 {name=l262 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -1710 1 1 {name=l263 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -1710 3 0 {name=l264 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -1460 0 0 {name=l265 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -1580 0 0 {name=x67}
C {devices/lab_wire.sym} 1640 -1700 2 1 {name=l266 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -1710 1 1 {name=l267 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -1710 3 0 {name=l268 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -1460 0 0 {name=l269 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -1580 0 0 {name=x68}
C {devices/lab_wire.sym} 1900 -1700 2 1 {name=l270 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -1710 1 1 {name=l271 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -1710 3 0 {name=l272 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -1460 0 0 {name=l273 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -1580 0 0 {name=x69}
C {devices/lab_wire.sym} 2160 -1700 2 1 {name=l274 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -1710 1 1 {name=l275 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -1710 3 0 {name=l276 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -1460 0 0 {name=l277 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -1580 0 0 {name=x70}
C {devices/lab_wire.sym} 2420 -1700 2 1 {name=l278 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -1710 1 1 {name=l279 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -1710 3 0 {name=l280 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -1460 0 0 {name=l281 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -1580 0 0 {name=x71}
C {devices/lab_wire.sym} 2680 -1700 2 1 {name=l282 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -1710 1 1 {name=l283 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -1710 3 0 {name=l284 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -1460 0 0 {name=l285 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -1580 0 0 {name=x72}
C {devices/lab_wire.sym} 2940 -1700 2 1 {name=l286 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -1710 1 1 {name=l287 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -1710 3 0 {name=l288 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -1460 0 0 {name=l289 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -1580 0 0 {name=x73}
C {devices/lab_wire.sym} 3200 -1700 2 1 {name=l290 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -1710 1 1 {name=l291 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -1710 3 0 {name=l292 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -1460 0 0 {name=l293 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -1580 0 0 {name=x74}
C {devices/lab_wire.sym} 3460 -1700 2 1 {name=l294 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -1710 1 1 {name=l295 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -1710 3 0 {name=l296 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -1460 0 0 {name=l297 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -1580 0 0 {name=x75}
C {devices/lab_wire.sym} 3720 -1700 2 1 {name=l298 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -1710 1 1 {name=l299 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -1710 3 0 {name=l300 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -1460 0 0 {name=l301 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -1580 0 0 {name=x76}
C {devices/lab_wire.sym} 3980 -1700 2 1 {name=l302 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -1710 1 1 {name=l303 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -1710 3 0 {name=l304 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -1460 0 0 {name=l305 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -1580 0 0 {name=x77}
C {devices/lab_wire.sym} 4240 -1700 2 1 {name=l306 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -1710 1 1 {name=l307 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -1710 3 0 {name=l308 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -1460 0 0 {name=l309 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -1580 0 0 {name=x78}
C {devices/lab_wire.sym} 4500 -1700 2 1 {name=l310 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -1710 1 1 {name=l311 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -1710 3 0 {name=l312 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -1460 0 0 {name=l313 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -1580 0 0 {name=x79}
C {devices/lab_wire.sym} 4760 -1700 2 1 {name=l314 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -1710 1 1 {name=l315 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -1710 3 0 {name=l316 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -1460 0 0 {name=l317 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -1580 0 0 {name=x80}
C {devices/lab_wire.sym} 5020 -1700 2 1 {name=l318 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -1710 1 1 {name=l319 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -1710 3 0 {name=l320 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -1460 0 0 {name=l321 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -1580 0 0 {name=x81}
C {devices/lab_wire.sym} 5280 -1700 2 1 {name=l322 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -1710 1 1 {name=l323 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -1710 3 0 {name=l324 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -1460 0 0 {name=l325 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -1580 0 0 {name=x82}
C {devices/lab_wire.sym} 5540 -1700 2 1 {name=l326 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -1710 1 1 {name=l327 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -1710 3 0 {name=l328 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -1460 0 0 {name=l329 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -1580 0 0 {name=x83}
C {devices/lab_wire.sym} 5800 -1700 2 1 {name=l330 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -1710 1 1 {name=l331 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -1710 3 0 {name=l332 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -1460 0 0 {name=l333 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -1580 0 0 {name=x84}
C {devices/lab_wire.sym} 6060 -1700 2 1 {name=l334 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -1710 1 1 {name=l335 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -1710 3 0 {name=l336 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -1460 0 0 {name=l337 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -1580 0 0 {name=x85}
C {devices/lab_wire.sym} 6320 -1700 2 1 {name=l338 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -1710 1 1 {name=l339 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -1710 3 0 {name=l340 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -1460 0 0 {name=l341 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -1580 0 0 {name=x86}
C {devices/lab_wire.sym} 6580 -1700 2 1 {name=l342 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -1710 1 1 {name=l343 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -1710 3 0 {name=l344 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -1460 0 0 {name=l345 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -1580 0 0 {name=x87}
C {devices/lab_wire.sym} 6840 -1700 2 1 {name=l346 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -1710 1 1 {name=l347 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -1710 3 0 {name=l348 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -1460 0 0 {name=l349 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -1580 0 0 {name=x88}
C {devices/lab_wire.sym} 7100 -1700 2 1 {name=l350 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -1710 1 1 {name=l351 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -1710 3 0 {name=l352 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -1460 0 0 {name=l353 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -1580 0 0 {name=x89}
C {devices/lab_wire.sym} 7360 -1700 2 1 {name=l354 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -1710 1 1 {name=l355 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -1710 3 0 {name=l356 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -1460 0 0 {name=l357 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -1580 0 0 {name=x90}
C {devices/lab_wire.sym} 7620 -1700 2 1 {name=l358 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -1710 1 1 {name=l359 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -1710 3 0 {name=l360 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -1460 0 0 {name=l361 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -1580 0 0 {name=x91}
C {devices/lab_wire.sym} 7880 -1700 2 1 {name=l362 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -1710 1 1 {name=l363 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -1710 3 0 {name=l364 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -1460 0 0 {name=l365 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -1580 0 0 {name=x92}
C {devices/lab_wire.sym} 8140 -1700 2 1 {name=l366 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -1710 1 1 {name=l367 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -1710 3 0 {name=l368 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -1460 0 0 {name=l369 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -1580 0 0 {name=x93}
C {devices/lab_wire.sym} 8400 -1700 2 1 {name=l370 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -1710 1 1 {name=l371 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -1710 3 0 {name=l372 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -1460 0 0 {name=l373 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -1580 0 0 {name=x94}
C {devices/lab_wire.sym} 8660 -1700 2 1 {name=l374 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -1710 1 1 {name=l375 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -1710 3 0 {name=l376 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -1460 0 0 {name=l377 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -1580 0 0 {name=x95}
C {devices/lab_wire.sym} 8920 -1700 2 1 {name=l378 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -1710 1 1 {name=l379 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -1710 3 0 {name=l380 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -1460 0 0 {name=l381 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -1580 0 0 {name=x96}
C {devices/lab_wire.sym} 9180 -1700 2 1 {name=l382 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -1710 1 1 {name=l383 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -1710 3 0 {name=l384 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -1460 0 0 {name=l385 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -1840 0 0 {name=x97}
C {devices/lab_wire.sym} 1120 -1960 2 1 {name=l386 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -1970 1 1 {name=l387 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -1970 3 0 {name=l388 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -1720 0 0 {name=l389 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -1840 0 0 {name=x98}
C {devices/lab_wire.sym} 1380 -1960 2 1 {name=l390 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -1970 1 1 {name=l391 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -1970 3 0 {name=l392 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -1720 0 0 {name=l393 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -1840 0 0 {name=x99}
C {devices/lab_wire.sym} 1640 -1960 2 1 {name=l394 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -1970 1 1 {name=l395 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -1970 3 0 {name=l396 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -1720 0 0 {name=l397 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -1840 0 0 {name=x100}
C {devices/lab_wire.sym} 1900 -1960 2 1 {name=l398 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -1970 1 1 {name=l399 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -1970 3 0 {name=l400 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -1720 0 0 {name=l401 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -1840 0 0 {name=x101}
C {devices/lab_wire.sym} 2160 -1960 2 1 {name=l402 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -1970 1 1 {name=l403 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -1970 3 0 {name=l404 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -1720 0 0 {name=l405 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -1840 0 0 {name=x102}
C {devices/lab_wire.sym} 2420 -1960 2 1 {name=l406 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -1970 1 1 {name=l407 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -1970 3 0 {name=l408 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -1720 0 0 {name=l409 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -1840 0 0 {name=x103}
C {devices/lab_wire.sym} 2680 -1960 2 1 {name=l410 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -1970 1 1 {name=l411 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -1970 3 0 {name=l412 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -1720 0 0 {name=l413 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -1840 0 0 {name=x104}
C {devices/lab_wire.sym} 2940 -1960 2 1 {name=l414 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -1970 1 1 {name=l415 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -1970 3 0 {name=l416 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -1720 0 0 {name=l417 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -1840 0 0 {name=x105}
C {devices/lab_wire.sym} 3200 -1960 2 1 {name=l418 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -1970 1 1 {name=l419 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -1970 3 0 {name=l420 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -1720 0 0 {name=l421 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -1840 0 0 {name=x106}
C {devices/lab_wire.sym} 3460 -1960 2 1 {name=l422 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -1970 1 1 {name=l423 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -1970 3 0 {name=l424 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -1720 0 0 {name=l425 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -1840 0 0 {name=x107}
C {devices/lab_wire.sym} 3720 -1960 2 1 {name=l426 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -1970 1 1 {name=l427 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -1970 3 0 {name=l428 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -1720 0 0 {name=l429 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -1840 0 0 {name=x108}
C {devices/lab_wire.sym} 3980 -1960 2 1 {name=l430 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -1970 1 1 {name=l431 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -1970 3 0 {name=l432 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -1720 0 0 {name=l433 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -1840 0 0 {name=x109}
C {devices/lab_wire.sym} 4240 -1960 2 1 {name=l434 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -1970 1 1 {name=l435 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -1970 3 0 {name=l436 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -1720 0 0 {name=l437 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -1840 0 0 {name=x110}
C {devices/lab_wire.sym} 4500 -1960 2 1 {name=l438 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -1970 1 1 {name=l439 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -1970 3 0 {name=l440 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -1720 0 0 {name=l441 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -1840 0 0 {name=x111}
C {devices/lab_wire.sym} 4760 -1960 2 1 {name=l442 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -1970 1 1 {name=l443 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -1970 3 0 {name=l444 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -1720 0 0 {name=l445 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -1840 0 0 {name=x112}
C {devices/lab_wire.sym} 5020 -1960 2 1 {name=l446 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -1970 1 1 {name=l447 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -1970 3 0 {name=l448 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -1720 0 0 {name=l449 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -1840 0 0 {name=x113}
C {devices/lab_wire.sym} 5280 -1960 2 1 {name=l450 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -1970 1 1 {name=l451 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -1970 3 0 {name=l452 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -1720 0 0 {name=l453 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -1840 0 0 {name=x114}
C {devices/lab_wire.sym} 5540 -1960 2 1 {name=l454 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -1970 1 1 {name=l455 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -1970 3 0 {name=l456 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -1720 0 0 {name=l457 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -1840 0 0 {name=x115}
C {devices/lab_wire.sym} 5800 -1960 2 1 {name=l458 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -1970 1 1 {name=l459 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -1970 3 0 {name=l460 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -1720 0 0 {name=l461 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -1840 0 0 {name=x116}
C {devices/lab_wire.sym} 6060 -1960 2 1 {name=l462 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -1970 1 1 {name=l463 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -1970 3 0 {name=l464 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -1720 0 0 {name=l465 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -1840 0 0 {name=x117}
C {devices/lab_wire.sym} 6320 -1960 2 1 {name=l466 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -1970 1 1 {name=l467 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -1970 3 0 {name=l468 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -1720 0 0 {name=l469 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -1840 0 0 {name=x118}
C {devices/lab_wire.sym} 6580 -1960 2 1 {name=l470 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -1970 1 1 {name=l471 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -1970 3 0 {name=l472 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -1720 0 0 {name=l473 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -1840 0 0 {name=x119}
C {devices/lab_wire.sym} 6840 -1960 2 1 {name=l474 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -1970 1 1 {name=l475 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -1970 3 0 {name=l476 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -1720 0 0 {name=l477 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -1840 0 0 {name=x120}
C {devices/lab_wire.sym} 7100 -1960 2 1 {name=l478 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -1970 1 1 {name=l479 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -1970 3 0 {name=l480 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -1720 0 0 {name=l481 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -1840 0 0 {name=x121}
C {devices/lab_wire.sym} 7360 -1960 2 1 {name=l482 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -1970 1 1 {name=l483 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -1970 3 0 {name=l484 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -1720 0 0 {name=l485 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -1840 0 0 {name=x122}
C {devices/lab_wire.sym} 7620 -1960 2 1 {name=l486 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -1970 1 1 {name=l487 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -1970 3 0 {name=l488 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -1720 0 0 {name=l489 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -1840 0 0 {name=x123}
C {devices/lab_wire.sym} 7880 -1960 2 1 {name=l490 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -1970 1 1 {name=l491 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -1970 3 0 {name=l492 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -1720 0 0 {name=l493 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -1840 0 0 {name=x124}
C {devices/lab_wire.sym} 8140 -1960 2 1 {name=l494 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -1970 1 1 {name=l495 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -1970 3 0 {name=l496 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -1720 0 0 {name=l497 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -1840 0 0 {name=x125}
C {devices/lab_wire.sym} 8400 -1960 2 1 {name=l498 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -1970 1 1 {name=l499 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -1970 3 0 {name=l500 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -1720 0 0 {name=l501 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -1840 0 0 {name=x126}
C {devices/lab_wire.sym} 8660 -1960 2 1 {name=l502 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -1970 1 1 {name=l503 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -1970 3 0 {name=l504 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -1720 0 0 {name=l505 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -1840 0 0 {name=x127}
C {devices/lab_wire.sym} 8920 -1960 2 1 {name=l506 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -1970 1 1 {name=l507 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -1970 3 0 {name=l508 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -1720 0 0 {name=l509 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -1840 0 0 {name=x128}
C {devices/lab_wire.sym} 9180 -1960 2 1 {name=l510 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -1970 1 1 {name=l511 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -1970 3 0 {name=l512 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -1720 0 0 {name=l513 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -2100 0 0 {name=x129}
C {devices/lab_wire.sym} 1120 -2220 2 1 {name=l514 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -2230 1 1 {name=l515 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -2230 3 0 {name=l516 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -1980 0 0 {name=l517 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -2100 0 0 {name=x130}
C {devices/lab_wire.sym} 1380 -2220 2 1 {name=l518 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -2230 1 1 {name=l519 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -2230 3 0 {name=l520 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -1980 0 0 {name=l521 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -2100 0 0 {name=x131}
C {devices/lab_wire.sym} 1640 -2220 2 1 {name=l522 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -2230 1 1 {name=l523 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -2230 3 0 {name=l524 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -1980 0 0 {name=l525 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -2100 0 0 {name=x132}
C {devices/lab_wire.sym} 1900 -2220 2 1 {name=l526 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -2230 1 1 {name=l527 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -2230 3 0 {name=l528 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -1980 0 0 {name=l529 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -2100 0 0 {name=x133}
C {devices/lab_wire.sym} 2160 -2220 2 1 {name=l530 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -2230 1 1 {name=l531 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -2230 3 0 {name=l532 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -1980 0 0 {name=l533 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -2100 0 0 {name=x134}
C {devices/lab_wire.sym} 2420 -2220 2 1 {name=l534 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -2230 1 1 {name=l535 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -2230 3 0 {name=l536 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -1980 0 0 {name=l537 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -2100 0 0 {name=x135}
C {devices/lab_wire.sym} 2680 -2220 2 1 {name=l538 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -2230 1 1 {name=l539 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -2230 3 0 {name=l540 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -1980 0 0 {name=l541 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -2100 0 0 {name=x136}
C {devices/lab_wire.sym} 2940 -2220 2 1 {name=l542 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -2230 1 1 {name=l543 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -2230 3 0 {name=l544 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -1980 0 0 {name=l545 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -2100 0 0 {name=x137}
C {devices/lab_wire.sym} 3200 -2220 2 1 {name=l546 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -2230 1 1 {name=l547 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -2230 3 0 {name=l548 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -1980 0 0 {name=l549 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -2100 0 0 {name=x138}
C {devices/lab_wire.sym} 3460 -2220 2 1 {name=l550 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -2230 1 1 {name=l551 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -2230 3 0 {name=l552 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -1980 0 0 {name=l553 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -2100 0 0 {name=x139}
C {devices/lab_wire.sym} 3720 -2220 2 1 {name=l554 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -2230 1 1 {name=l555 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -2230 3 0 {name=l556 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -1980 0 0 {name=l557 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -2100 0 0 {name=x140}
C {devices/lab_wire.sym} 3980 -2220 2 1 {name=l558 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -2230 1 1 {name=l559 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -2230 3 0 {name=l560 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -1980 0 0 {name=l561 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -2100 0 0 {name=x141}
C {devices/lab_wire.sym} 4240 -2220 2 1 {name=l562 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -2230 1 1 {name=l563 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -2230 3 0 {name=l564 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -1980 0 0 {name=l565 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -2100 0 0 {name=x142}
C {devices/lab_wire.sym} 4500 -2220 2 1 {name=l566 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -2230 1 1 {name=l567 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -2230 3 0 {name=l568 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -1980 0 0 {name=l569 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -2100 0 0 {name=x143}
C {devices/lab_wire.sym} 4760 -2220 2 1 {name=l570 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -2230 1 1 {name=l571 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -2230 3 0 {name=l572 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -1980 0 0 {name=l573 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -2100 0 0 {name=x144}
C {devices/lab_wire.sym} 5020 -2220 2 1 {name=l574 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -2230 1 1 {name=l575 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -2230 3 0 {name=l576 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -1980 0 0 {name=l577 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -2100 0 0 {name=x145}
C {devices/lab_wire.sym} 5280 -2220 2 1 {name=l578 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -2230 1 1 {name=l579 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -2230 3 0 {name=l580 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -1980 0 0 {name=l581 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -2100 0 0 {name=x146}
C {devices/lab_wire.sym} 5540 -2220 2 1 {name=l582 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -2230 1 1 {name=l583 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -2230 3 0 {name=l584 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -1980 0 0 {name=l585 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -2100 0 0 {name=x147}
C {devices/lab_wire.sym} 5800 -2220 2 1 {name=l586 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -2230 1 1 {name=l587 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -2230 3 0 {name=l588 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -1980 0 0 {name=l589 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -2100 0 0 {name=x148}
C {devices/lab_wire.sym} 6060 -2220 2 1 {name=l590 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -2230 1 1 {name=l591 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -2230 3 0 {name=l592 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -1980 0 0 {name=l593 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -2100 0 0 {name=x149}
C {devices/lab_wire.sym} 6320 -2220 2 1 {name=l594 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -2230 1 1 {name=l595 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -2230 3 0 {name=l596 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -1980 0 0 {name=l597 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -2100 0 0 {name=x150}
C {devices/lab_wire.sym} 6580 -2220 2 1 {name=l598 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -2230 1 1 {name=l599 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -2230 3 0 {name=l600 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -1980 0 0 {name=l601 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -2100 0 0 {name=x151}
C {devices/lab_wire.sym} 6840 -2220 2 1 {name=l602 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -2230 1 1 {name=l603 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -2230 3 0 {name=l604 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -1980 0 0 {name=l605 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -2100 0 0 {name=x152}
C {devices/lab_wire.sym} 7100 -2220 2 1 {name=l606 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -2230 1 1 {name=l607 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -2230 3 0 {name=l608 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -1980 0 0 {name=l609 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -2100 0 0 {name=x153}
C {devices/lab_wire.sym} 7360 -2220 2 1 {name=l610 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -2230 1 1 {name=l611 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -2230 3 0 {name=l612 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -1980 0 0 {name=l613 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -2100 0 0 {name=x154}
C {devices/lab_wire.sym} 7620 -2220 2 1 {name=l614 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -2230 1 1 {name=l615 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -2230 3 0 {name=l616 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -1980 0 0 {name=l617 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -2100 0 0 {name=x155}
C {devices/lab_wire.sym} 7880 -2220 2 1 {name=l618 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -2230 1 1 {name=l619 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -2230 3 0 {name=l620 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -1980 0 0 {name=l621 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -2100 0 0 {name=x156}
C {devices/lab_wire.sym} 8140 -2220 2 1 {name=l622 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -2230 1 1 {name=l623 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -2230 3 0 {name=l624 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -1980 0 0 {name=l625 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -2100 0 0 {name=x157}
C {devices/lab_wire.sym} 8400 -2220 2 1 {name=l626 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -2230 1 1 {name=l627 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -2230 3 0 {name=l628 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -1980 0 0 {name=l629 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -2100 0 0 {name=x158}
C {devices/lab_wire.sym} 8660 -2220 2 1 {name=l630 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -2230 1 1 {name=l631 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -2230 3 0 {name=l632 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -1980 0 0 {name=l633 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -2100 0 0 {name=x159}
C {devices/lab_wire.sym} 8920 -2220 2 1 {name=l634 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -2230 1 1 {name=l635 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -2230 3 0 {name=l636 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -1980 0 0 {name=l637 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -2100 0 0 {name=x160}
C {devices/lab_wire.sym} 9180 -2220 2 1 {name=l638 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -2230 1 1 {name=l639 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -2230 3 0 {name=l640 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -1980 0 0 {name=l641 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -2360 0 0 {name=x161}
C {devices/lab_wire.sym} 1120 -2480 2 1 {name=l642 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -2490 1 1 {name=l643 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -2490 3 0 {name=l644 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -2240 0 0 {name=l645 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -2360 0 0 {name=x162}
C {devices/lab_wire.sym} 1380 -2480 2 1 {name=l646 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -2490 1 1 {name=l647 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -2490 3 0 {name=l648 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -2240 0 0 {name=l649 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -2360 0 0 {name=x163}
C {devices/lab_wire.sym} 1640 -2480 2 1 {name=l650 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -2490 1 1 {name=l651 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -2490 3 0 {name=l652 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -2240 0 0 {name=l653 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -2360 0 0 {name=x164}
C {devices/lab_wire.sym} 1900 -2480 2 1 {name=l654 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -2490 1 1 {name=l655 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -2490 3 0 {name=l656 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -2240 0 0 {name=l657 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -2360 0 0 {name=x165}
C {devices/lab_wire.sym} 2160 -2480 2 1 {name=l658 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -2490 1 1 {name=l659 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -2490 3 0 {name=l660 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -2240 0 0 {name=l661 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -2360 0 0 {name=x166}
C {devices/lab_wire.sym} 2420 -2480 2 1 {name=l662 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -2490 1 1 {name=l663 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -2490 3 0 {name=l664 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -2240 0 0 {name=l665 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -2360 0 0 {name=x167}
C {devices/lab_wire.sym} 2680 -2480 2 1 {name=l666 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -2490 1 1 {name=l667 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -2490 3 0 {name=l668 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -2240 0 0 {name=l669 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -2360 0 0 {name=x168}
C {devices/lab_wire.sym} 2940 -2480 2 1 {name=l670 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -2490 1 1 {name=l671 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -2490 3 0 {name=l672 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -2240 0 0 {name=l673 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -2360 0 0 {name=x169}
C {devices/lab_wire.sym} 3200 -2480 2 1 {name=l674 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -2490 1 1 {name=l675 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -2490 3 0 {name=l676 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -2240 0 0 {name=l677 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -2360 0 0 {name=x170}
C {devices/lab_wire.sym} 3460 -2480 2 1 {name=l678 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -2490 1 1 {name=l679 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -2490 3 0 {name=l680 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -2240 0 0 {name=l681 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -2360 0 0 {name=x171}
C {devices/lab_wire.sym} 3720 -2480 2 1 {name=l682 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -2490 1 1 {name=l683 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -2490 3 0 {name=l684 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -2240 0 0 {name=l685 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -2360 0 0 {name=x172}
C {devices/lab_wire.sym} 3980 -2480 2 1 {name=l686 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -2490 1 1 {name=l687 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -2490 3 0 {name=l688 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -2240 0 0 {name=l689 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -2360 0 0 {name=x173}
C {devices/lab_wire.sym} 4240 -2480 2 1 {name=l690 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -2490 1 1 {name=l691 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -2490 3 0 {name=l692 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -2240 0 0 {name=l693 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -2360 0 0 {name=x174}
C {devices/lab_wire.sym} 4500 -2480 2 1 {name=l694 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -2490 1 1 {name=l695 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -2490 3 0 {name=l696 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -2240 0 0 {name=l697 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -2360 0 0 {name=x175}
C {devices/lab_wire.sym} 4760 -2480 2 1 {name=l698 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -2490 1 1 {name=l699 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -2490 3 0 {name=l700 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -2240 0 0 {name=l701 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -2360 0 0 {name=x176}
C {devices/lab_wire.sym} 5020 -2480 2 1 {name=l702 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -2490 1 1 {name=l703 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -2490 3 0 {name=l704 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -2240 0 0 {name=l705 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -2360 0 0 {name=x177}
C {devices/lab_wire.sym} 5280 -2480 2 1 {name=l706 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -2490 1 1 {name=l707 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -2490 3 0 {name=l708 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -2240 0 0 {name=l709 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -2360 0 0 {name=x178}
C {devices/lab_wire.sym} 5540 -2480 2 1 {name=l710 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -2490 1 1 {name=l711 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -2490 3 0 {name=l712 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -2240 0 0 {name=l713 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -2360 0 0 {name=x179}
C {devices/lab_wire.sym} 5800 -2480 2 1 {name=l714 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -2490 1 1 {name=l715 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -2490 3 0 {name=l716 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -2240 0 0 {name=l717 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -2360 0 0 {name=x180}
C {devices/lab_wire.sym} 6060 -2480 2 1 {name=l718 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -2490 1 1 {name=l719 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -2490 3 0 {name=l720 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -2240 0 0 {name=l721 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -2360 0 0 {name=x181}
C {devices/lab_wire.sym} 6320 -2480 2 1 {name=l722 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -2490 1 1 {name=l723 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -2490 3 0 {name=l724 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -2240 0 0 {name=l725 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -2360 0 0 {name=x182}
C {devices/lab_wire.sym} 6580 -2480 2 1 {name=l726 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -2490 1 1 {name=l727 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -2490 3 0 {name=l728 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -2240 0 0 {name=l729 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -2360 0 0 {name=x183}
C {devices/lab_wire.sym} 6840 -2480 2 1 {name=l730 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -2490 1 1 {name=l731 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -2490 3 0 {name=l732 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -2240 0 0 {name=l733 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -2360 0 0 {name=x184}
C {devices/lab_wire.sym} 7100 -2480 2 1 {name=l734 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -2490 1 1 {name=l735 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -2490 3 0 {name=l736 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -2240 0 0 {name=l737 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -2360 0 0 {name=x185}
C {devices/lab_wire.sym} 7360 -2480 2 1 {name=l738 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -2490 1 1 {name=l739 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -2490 3 0 {name=l740 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -2240 0 0 {name=l741 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -2360 0 0 {name=x186}
C {devices/lab_wire.sym} 7620 -2480 2 1 {name=l742 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -2490 1 1 {name=l743 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -2490 3 0 {name=l744 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -2240 0 0 {name=l745 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -2360 0 0 {name=x187}
C {devices/lab_wire.sym} 7880 -2480 2 1 {name=l746 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -2490 1 1 {name=l747 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -2490 3 0 {name=l748 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -2240 0 0 {name=l749 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -2360 0 0 {name=x188}
C {devices/lab_wire.sym} 8140 -2480 2 1 {name=l750 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -2490 1 1 {name=l751 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -2490 3 0 {name=l752 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -2240 0 0 {name=l753 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -2360 0 0 {name=x189}
C {devices/lab_wire.sym} 8400 -2480 2 1 {name=l754 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -2490 1 1 {name=l755 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -2490 3 0 {name=l756 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -2240 0 0 {name=l757 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -2360 0 0 {name=x190}
C {devices/lab_wire.sym} 8660 -2480 2 1 {name=l758 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -2490 1 1 {name=l759 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -2490 3 0 {name=l760 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -2240 0 0 {name=l761 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -2360 0 0 {name=x191}
C {devices/lab_wire.sym} 8920 -2480 2 1 {name=l762 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -2490 1 1 {name=l763 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -2490 3 0 {name=l764 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -2240 0 0 {name=l765 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -2360 0 0 {name=x192}
C {devices/lab_wire.sym} 9180 -2480 2 1 {name=l766 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -2490 1 1 {name=l767 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -2490 3 0 {name=l768 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -2240 0 0 {name=l769 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -2620 0 0 {name=x193}
C {devices/lab_wire.sym} 1120 -2740 2 1 {name=l770 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -2750 1 1 {name=l771 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -2750 3 0 {name=l772 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -2500 0 0 {name=l773 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -2620 0 0 {name=x194}
C {devices/lab_wire.sym} 1380 -2740 2 1 {name=l774 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -2750 1 1 {name=l775 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -2750 3 0 {name=l776 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -2500 0 0 {name=l777 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -2620 0 0 {name=x195}
C {devices/lab_wire.sym} 1640 -2740 2 1 {name=l778 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -2750 1 1 {name=l779 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -2750 3 0 {name=l780 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -2500 0 0 {name=l781 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -2620 0 0 {name=x196}
C {devices/lab_wire.sym} 1900 -2740 2 1 {name=l782 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -2750 1 1 {name=l783 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -2750 3 0 {name=l784 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -2500 0 0 {name=l785 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -2620 0 0 {name=x197}
C {devices/lab_wire.sym} 2160 -2740 2 1 {name=l786 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -2750 1 1 {name=l787 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -2750 3 0 {name=l788 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -2500 0 0 {name=l789 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -2620 0 0 {name=x198}
C {devices/lab_wire.sym} 2420 -2740 2 1 {name=l790 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -2750 1 1 {name=l791 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -2750 3 0 {name=l792 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -2500 0 0 {name=l793 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -2620 0 0 {name=x199}
C {devices/lab_wire.sym} 2680 -2740 2 1 {name=l794 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -2750 1 1 {name=l795 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -2750 3 0 {name=l796 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -2500 0 0 {name=l797 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -2620 0 0 {name=x200}
C {devices/lab_wire.sym} 2940 -2740 2 1 {name=l798 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -2750 1 1 {name=l799 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -2750 3 0 {name=l800 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -2500 0 0 {name=l801 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -2620 0 0 {name=x201}
C {devices/lab_wire.sym} 3200 -2740 2 1 {name=l802 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -2750 1 1 {name=l803 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -2750 3 0 {name=l804 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -2500 0 0 {name=l805 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -2620 0 0 {name=x202}
C {devices/lab_wire.sym} 3460 -2740 2 1 {name=l806 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -2750 1 1 {name=l807 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -2750 3 0 {name=l808 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -2500 0 0 {name=l809 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -2620 0 0 {name=x203}
C {devices/lab_wire.sym} 3720 -2740 2 1 {name=l810 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -2750 1 1 {name=l811 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -2750 3 0 {name=l812 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -2500 0 0 {name=l813 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -2620 0 0 {name=x204}
C {devices/lab_wire.sym} 3980 -2740 2 1 {name=l814 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -2750 1 1 {name=l815 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -2750 3 0 {name=l816 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -2500 0 0 {name=l817 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -2620 0 0 {name=x205}
C {devices/lab_wire.sym} 4240 -2740 2 1 {name=l818 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -2750 1 1 {name=l819 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -2750 3 0 {name=l820 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -2500 0 0 {name=l821 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -2620 0 0 {name=x206}
C {devices/lab_wire.sym} 4500 -2740 2 1 {name=l822 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -2750 1 1 {name=l823 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -2750 3 0 {name=l824 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -2500 0 0 {name=l825 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -2620 0 0 {name=x207}
C {devices/lab_wire.sym} 4760 -2740 2 1 {name=l826 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -2750 1 1 {name=l827 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -2750 3 0 {name=l828 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -2500 0 0 {name=l829 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -2620 0 0 {name=x208}
C {devices/lab_wire.sym} 5020 -2740 2 1 {name=l830 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -2750 1 1 {name=l831 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -2750 3 0 {name=l832 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -2500 0 0 {name=l833 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -2620 0 0 {name=x209}
C {devices/lab_wire.sym} 5280 -2740 2 1 {name=l834 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -2750 1 1 {name=l835 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -2750 3 0 {name=l836 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -2500 0 0 {name=l837 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -2620 0 0 {name=x210}
C {devices/lab_wire.sym} 5540 -2740 2 1 {name=l838 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -2750 1 1 {name=l839 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -2750 3 0 {name=l840 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -2500 0 0 {name=l841 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -2620 0 0 {name=x211}
C {devices/lab_wire.sym} 5800 -2740 2 1 {name=l842 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -2750 1 1 {name=l843 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -2750 3 0 {name=l844 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -2500 0 0 {name=l845 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -2620 0 0 {name=x212}
C {devices/lab_wire.sym} 6060 -2740 2 1 {name=l846 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -2750 1 1 {name=l847 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -2750 3 0 {name=l848 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -2500 0 0 {name=l849 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -2620 0 0 {name=x213}
C {devices/lab_wire.sym} 6320 -2740 2 1 {name=l850 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -2750 1 1 {name=l851 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -2750 3 0 {name=l852 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -2500 0 0 {name=l853 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -2620 0 0 {name=x214}
C {devices/lab_wire.sym} 6580 -2740 2 1 {name=l854 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -2750 1 1 {name=l855 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -2750 3 0 {name=l856 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -2500 0 0 {name=l857 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -2620 0 0 {name=x215}
C {devices/lab_wire.sym} 6840 -2740 2 1 {name=l858 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -2750 1 1 {name=l859 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -2750 3 0 {name=l860 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -2500 0 0 {name=l861 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -2620 0 0 {name=x216}
C {devices/lab_wire.sym} 7100 -2740 2 1 {name=l862 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -2750 1 1 {name=l863 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -2750 3 0 {name=l864 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -2500 0 0 {name=l865 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -2620 0 0 {name=x217}
C {devices/lab_wire.sym} 7360 -2740 2 1 {name=l866 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -2750 1 1 {name=l867 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -2750 3 0 {name=l868 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -2500 0 0 {name=l869 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -2620 0 0 {name=x218}
C {devices/lab_wire.sym} 7620 -2740 2 1 {name=l870 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -2750 1 1 {name=l871 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -2750 3 0 {name=l872 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -2500 0 0 {name=l873 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -2620 0 0 {name=x219}
C {devices/lab_wire.sym} 7880 -2740 2 1 {name=l874 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -2750 1 1 {name=l875 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -2750 3 0 {name=l876 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -2500 0 0 {name=l877 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -2620 0 0 {name=x220}
C {devices/lab_wire.sym} 8140 -2740 2 1 {name=l878 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -2750 1 1 {name=l879 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -2750 3 0 {name=l880 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -2500 0 0 {name=l881 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -2620 0 0 {name=x221}
C {devices/lab_wire.sym} 8400 -2740 2 1 {name=l882 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -2750 1 1 {name=l883 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -2750 3 0 {name=l884 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -2500 0 0 {name=l885 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -2620 0 0 {name=x222}
C {devices/lab_wire.sym} 8660 -2740 2 1 {name=l886 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -2750 1 1 {name=l887 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -2750 3 0 {name=l888 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -2500 0 0 {name=l889 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -2620 0 0 {name=x223}
C {devices/lab_wire.sym} 8920 -2740 2 1 {name=l890 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -2750 1 1 {name=l891 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -2750 3 0 {name=l892 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -2500 0 0 {name=l893 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -2620 0 0 {name=x224}
C {devices/lab_wire.sym} 9180 -2740 2 1 {name=l894 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -2750 1 1 {name=l895 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -2750 3 0 {name=l896 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -2500 0 0 {name=l897 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -2880 0 0 {name=x225}
C {devices/lab_wire.sym} 1120 -3000 2 1 {name=l898 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -3010 1 1 {name=l899 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -3010 3 0 {name=l900 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -2760 0 0 {name=l901 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -2880 0 0 {name=x226}
C {devices/lab_wire.sym} 1380 -3000 2 1 {name=l902 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -3010 1 1 {name=l903 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -3010 3 0 {name=l904 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -2760 0 0 {name=l905 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -2880 0 0 {name=x227}
C {devices/lab_wire.sym} 1640 -3000 2 1 {name=l906 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -3010 1 1 {name=l907 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -3010 3 0 {name=l908 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -2760 0 0 {name=l909 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -2880 0 0 {name=x228}
C {devices/lab_wire.sym} 1900 -3000 2 1 {name=l910 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -3010 1 1 {name=l911 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -3010 3 0 {name=l912 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -2760 0 0 {name=l913 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -2880 0 0 {name=x229}
C {devices/lab_wire.sym} 2160 -3000 2 1 {name=l914 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -3010 1 1 {name=l915 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -3010 3 0 {name=l916 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -2760 0 0 {name=l917 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -2880 0 0 {name=x230}
C {devices/lab_wire.sym} 2420 -3000 2 1 {name=l918 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -3010 1 1 {name=l919 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -3010 3 0 {name=l920 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -2760 0 0 {name=l921 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -2880 0 0 {name=x231}
C {devices/lab_wire.sym} 2680 -3000 2 1 {name=l922 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -3010 1 1 {name=l923 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -3010 3 0 {name=l924 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -2760 0 0 {name=l925 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -2880 0 0 {name=x232}
C {devices/lab_wire.sym} 2940 -3000 2 1 {name=l926 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -3010 1 1 {name=l927 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -3010 3 0 {name=l928 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -2760 0 0 {name=l929 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -2880 0 0 {name=x233}
C {devices/lab_wire.sym} 3200 -3000 2 1 {name=l930 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -3010 1 1 {name=l931 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -3010 3 0 {name=l932 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -2760 0 0 {name=l933 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -2880 0 0 {name=x234}
C {devices/lab_wire.sym} 3460 -3000 2 1 {name=l934 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -3010 1 1 {name=l935 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -3010 3 0 {name=l936 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -2760 0 0 {name=l937 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -2880 0 0 {name=x235}
C {devices/lab_wire.sym} 3720 -3000 2 1 {name=l938 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -3010 1 1 {name=l939 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -3010 3 0 {name=l940 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -2760 0 0 {name=l941 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -2880 0 0 {name=x236}
C {devices/lab_wire.sym} 3980 -3000 2 1 {name=l942 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -3010 1 1 {name=l943 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -3010 3 0 {name=l944 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -2760 0 0 {name=l945 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -2880 0 0 {name=x237}
C {devices/lab_wire.sym} 4240 -3000 2 1 {name=l946 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -3010 1 1 {name=l947 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -3010 3 0 {name=l948 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -2760 0 0 {name=l949 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -2880 0 0 {name=x238}
C {devices/lab_wire.sym} 4500 -3000 2 1 {name=l950 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -3010 1 1 {name=l951 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -3010 3 0 {name=l952 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -2760 0 0 {name=l953 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -2880 0 0 {name=x239}
C {devices/lab_wire.sym} 4760 -3000 2 1 {name=l954 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -3010 1 1 {name=l955 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -3010 3 0 {name=l956 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -2760 0 0 {name=l957 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -2880 0 0 {name=x240}
C {devices/lab_wire.sym} 5020 -3000 2 1 {name=l958 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -3010 1 1 {name=l959 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -3010 3 0 {name=l960 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -2760 0 0 {name=l961 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -2880 0 0 {name=x241}
C {devices/lab_wire.sym} 5280 -3000 2 1 {name=l962 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -3010 1 1 {name=l963 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -3010 3 0 {name=l964 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -2760 0 0 {name=l965 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -2880 0 0 {name=x242}
C {devices/lab_wire.sym} 5540 -3000 2 1 {name=l966 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -3010 1 1 {name=l967 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -3010 3 0 {name=l968 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -2760 0 0 {name=l969 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -2880 0 0 {name=x243}
C {devices/lab_wire.sym} 5800 -3000 2 1 {name=l970 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -3010 1 1 {name=l971 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -3010 3 0 {name=l972 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -2760 0 0 {name=l973 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -2880 0 0 {name=x244}
C {devices/lab_wire.sym} 6060 -3000 2 1 {name=l974 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -3010 1 1 {name=l975 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -3010 3 0 {name=l976 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -2760 0 0 {name=l977 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -2880 0 0 {name=x245}
C {devices/lab_wire.sym} 6320 -3000 2 1 {name=l978 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -3010 1 1 {name=l979 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -3010 3 0 {name=l980 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -2760 0 0 {name=l981 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -2880 0 0 {name=x246}
C {devices/lab_wire.sym} 6580 -3000 2 1 {name=l982 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -3010 1 1 {name=l983 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -3010 3 0 {name=l984 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -2760 0 0 {name=l985 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -2880 0 0 {name=x247}
C {devices/lab_wire.sym} 6840 -3000 2 1 {name=l986 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -3010 1 1 {name=l987 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -3010 3 0 {name=l988 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -2760 0 0 {name=l989 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -2880 0 0 {name=x248}
C {devices/lab_wire.sym} 7100 -3000 2 1 {name=l990 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -3010 1 1 {name=l991 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -3010 3 0 {name=l992 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -2760 0 0 {name=l993 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -2880 0 0 {name=x249}
C {devices/lab_wire.sym} 7360 -3000 2 1 {name=l994 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -3010 1 1 {name=l995 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -3010 3 0 {name=l996 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -2760 0 0 {name=l997 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -2880 0 0 {name=x250}
C {devices/lab_wire.sym} 7620 -3000 2 1 {name=l998 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -3010 1 1 {name=l999 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -3010 3 0 {name=l1000 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -2760 0 0 {name=l1001 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -2880 0 0 {name=x251}
C {devices/lab_wire.sym} 7880 -3000 2 1 {name=l1002 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -3010 1 1 {name=l1003 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -3010 3 0 {name=l1004 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -2760 0 0 {name=l1005 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -2880 0 0 {name=x252}
C {devices/lab_wire.sym} 8140 -3000 2 1 {name=l1006 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -3010 1 1 {name=l1007 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -3010 3 0 {name=l1008 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -2760 0 0 {name=l1009 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -2880 0 0 {name=x253}
C {devices/lab_wire.sym} 8400 -3000 2 1 {name=l1010 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -3010 1 1 {name=l1011 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -3010 3 0 {name=l1012 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -2760 0 0 {name=l1013 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -2880 0 0 {name=x254}
C {devices/lab_wire.sym} 8660 -3000 2 1 {name=l1014 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -3010 1 1 {name=l1015 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -3010 3 0 {name=l1016 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -2760 0 0 {name=l1017 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -2880 0 0 {name=x255}
C {devices/lab_wire.sym} 8920 -3000 2 1 {name=l1018 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -3010 1 1 {name=l1019 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -3010 3 0 {name=l1020 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -2760 0 0 {name=l1021 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -2880 0 0 {name=x256}
C {devices/lab_wire.sym} 9180 -3000 2 1 {name=l1022 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -3010 1 1 {name=l1023 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -3010 3 0 {name=l1024 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -2760 0 0 {name=l1025 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -3140 0 0 {name=x257}
C {devices/lab_wire.sym} 1120 -3260 2 1 {name=l1026 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -3270 1 1 {name=l1027 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -3270 3 0 {name=l1028 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -3020 0 0 {name=l1029 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -3140 0 0 {name=x258}
C {devices/lab_wire.sym} 1380 -3260 2 1 {name=l1030 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -3270 1 1 {name=l1031 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -3270 3 0 {name=l1032 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -3020 0 0 {name=l1033 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -3140 0 0 {name=x259}
C {devices/lab_wire.sym} 1640 -3260 2 1 {name=l1034 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -3270 1 1 {name=l1035 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -3270 3 0 {name=l1036 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -3020 0 0 {name=l1037 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -3140 0 0 {name=x260}
C {devices/lab_wire.sym} 1900 -3260 2 1 {name=l1038 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -3270 1 1 {name=l1039 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -3270 3 0 {name=l1040 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -3020 0 0 {name=l1041 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -3140 0 0 {name=x261}
C {devices/lab_wire.sym} 2160 -3260 2 1 {name=l1042 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -3270 1 1 {name=l1043 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -3270 3 0 {name=l1044 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -3020 0 0 {name=l1045 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -3140 0 0 {name=x262}
C {devices/lab_wire.sym} 2420 -3260 2 1 {name=l1046 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -3270 1 1 {name=l1047 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -3270 3 0 {name=l1048 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -3020 0 0 {name=l1049 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -3140 0 0 {name=x263}
C {devices/lab_wire.sym} 2680 -3260 2 1 {name=l1050 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -3270 1 1 {name=l1051 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -3270 3 0 {name=l1052 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -3020 0 0 {name=l1053 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -3140 0 0 {name=x264}
C {devices/lab_wire.sym} 2940 -3260 2 1 {name=l1054 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -3270 1 1 {name=l1055 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -3270 3 0 {name=l1056 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -3020 0 0 {name=l1057 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -3140 0 0 {name=x265}
C {devices/lab_wire.sym} 3200 -3260 2 1 {name=l1058 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -3270 1 1 {name=l1059 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -3270 3 0 {name=l1060 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -3020 0 0 {name=l1061 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -3140 0 0 {name=x266}
C {devices/lab_wire.sym} 3460 -3260 2 1 {name=l1062 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -3270 1 1 {name=l1063 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -3270 3 0 {name=l1064 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -3020 0 0 {name=l1065 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -3140 0 0 {name=x267}
C {devices/lab_wire.sym} 3720 -3260 2 1 {name=l1066 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -3270 1 1 {name=l1067 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -3270 3 0 {name=l1068 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -3020 0 0 {name=l1069 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -3140 0 0 {name=x268}
C {devices/lab_wire.sym} 3980 -3260 2 1 {name=l1070 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -3270 1 1 {name=l1071 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -3270 3 0 {name=l1072 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -3020 0 0 {name=l1073 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -3140 0 0 {name=x269}
C {devices/lab_wire.sym} 4240 -3260 2 1 {name=l1074 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -3270 1 1 {name=l1075 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -3270 3 0 {name=l1076 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -3020 0 0 {name=l1077 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -3140 0 0 {name=x270}
C {devices/lab_wire.sym} 4500 -3260 2 1 {name=l1078 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -3270 1 1 {name=l1079 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -3270 3 0 {name=l1080 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -3020 0 0 {name=l1081 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -3140 0 0 {name=x271}
C {devices/lab_wire.sym} 4760 -3260 2 1 {name=l1082 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -3270 1 1 {name=l1083 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -3270 3 0 {name=l1084 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -3020 0 0 {name=l1085 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -3140 0 0 {name=x272}
C {devices/lab_wire.sym} 5020 -3260 2 1 {name=l1086 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -3270 1 1 {name=l1087 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -3270 3 0 {name=l1088 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -3020 0 0 {name=l1089 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -3140 0 0 {name=x273}
C {devices/lab_wire.sym} 5280 -3260 2 1 {name=l1090 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -3270 1 1 {name=l1091 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -3270 3 0 {name=l1092 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -3020 0 0 {name=l1093 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -3140 0 0 {name=x274}
C {devices/lab_wire.sym} 5540 -3260 2 1 {name=l1094 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -3270 1 1 {name=l1095 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -3270 3 0 {name=l1096 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -3020 0 0 {name=l1097 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -3140 0 0 {name=x275}
C {devices/lab_wire.sym} 5800 -3260 2 1 {name=l1098 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -3270 1 1 {name=l1099 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -3270 3 0 {name=l1100 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -3020 0 0 {name=l1101 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -3140 0 0 {name=x276}
C {devices/lab_wire.sym} 6060 -3260 2 1 {name=l1102 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -3270 1 1 {name=l1103 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -3270 3 0 {name=l1104 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -3020 0 0 {name=l1105 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -3140 0 0 {name=x277}
C {devices/lab_wire.sym} 6320 -3260 2 1 {name=l1106 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -3270 1 1 {name=l1107 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -3270 3 0 {name=l1108 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -3020 0 0 {name=l1109 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -3140 0 0 {name=x278}
C {devices/lab_wire.sym} 6580 -3260 2 1 {name=l1110 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -3270 1 1 {name=l1111 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -3270 3 0 {name=l1112 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -3020 0 0 {name=l1113 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -3140 0 0 {name=x279}
C {devices/lab_wire.sym} 6840 -3260 2 1 {name=l1114 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -3270 1 1 {name=l1115 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -3270 3 0 {name=l1116 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -3020 0 0 {name=l1117 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -3140 0 0 {name=x280}
C {devices/lab_wire.sym} 7100 -3260 2 1 {name=l1118 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -3270 1 1 {name=l1119 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -3270 3 0 {name=l1120 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -3020 0 0 {name=l1121 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -3140 0 0 {name=x281}
C {devices/lab_wire.sym} 7360 -3260 2 1 {name=l1122 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -3270 1 1 {name=l1123 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -3270 3 0 {name=l1124 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -3020 0 0 {name=l1125 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -3140 0 0 {name=x282}
C {devices/lab_wire.sym} 7620 -3260 2 1 {name=l1126 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -3270 1 1 {name=l1127 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -3270 3 0 {name=l1128 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -3020 0 0 {name=l1129 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -3140 0 0 {name=x283}
C {devices/lab_wire.sym} 7880 -3260 2 1 {name=l1130 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -3270 1 1 {name=l1131 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -3270 3 0 {name=l1132 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -3020 0 0 {name=l1133 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -3140 0 0 {name=x284}
C {devices/lab_wire.sym} 8140 -3260 2 1 {name=l1134 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -3270 1 1 {name=l1135 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -3270 3 0 {name=l1136 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -3020 0 0 {name=l1137 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -3140 0 0 {name=x285}
C {devices/lab_wire.sym} 8400 -3260 2 1 {name=l1138 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -3270 1 1 {name=l1139 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -3270 3 0 {name=l1140 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -3020 0 0 {name=l1141 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -3140 0 0 {name=x286}
C {devices/lab_wire.sym} 8660 -3260 2 1 {name=l1142 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -3270 1 1 {name=l1143 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -3270 3 0 {name=l1144 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -3020 0 0 {name=l1145 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -3140 0 0 {name=x287}
C {devices/lab_wire.sym} 8920 -3260 2 1 {name=l1146 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -3270 1 1 {name=l1147 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -3270 3 0 {name=l1148 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -3020 0 0 {name=l1149 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -3140 0 0 {name=x288}
C {devices/lab_wire.sym} 9180 -3260 2 1 {name=l1150 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -3270 1 1 {name=l1151 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -3270 3 0 {name=l1152 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -3020 0 0 {name=l1153 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -3400 0 0 {name=x289}
C {devices/lab_wire.sym} 1120 -3520 2 1 {name=l1154 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -3530 1 1 {name=l1155 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -3530 3 0 {name=l1156 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -3280 0 0 {name=l1157 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -3400 0 0 {name=x290}
C {devices/lab_wire.sym} 1380 -3520 2 1 {name=l1158 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -3530 1 1 {name=l1159 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -3530 3 0 {name=l1160 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -3280 0 0 {name=l1161 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -3400 0 0 {name=x291}
C {devices/lab_wire.sym} 1640 -3520 2 1 {name=l1162 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -3530 1 1 {name=l1163 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -3530 3 0 {name=l1164 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -3280 0 0 {name=l1165 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -3400 0 0 {name=x292}
C {devices/lab_wire.sym} 1900 -3520 2 1 {name=l1166 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -3530 1 1 {name=l1167 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -3530 3 0 {name=l1168 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -3280 0 0 {name=l1169 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -3400 0 0 {name=x293}
C {devices/lab_wire.sym} 2160 -3520 2 1 {name=l1170 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -3530 1 1 {name=l1171 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -3530 3 0 {name=l1172 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -3280 0 0 {name=l1173 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -3400 0 0 {name=x294}
C {devices/lab_wire.sym} 2420 -3520 2 1 {name=l1174 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -3530 1 1 {name=l1175 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -3530 3 0 {name=l1176 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -3280 0 0 {name=l1177 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -3400 0 0 {name=x295}
C {devices/lab_wire.sym} 2680 -3520 2 1 {name=l1178 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -3530 1 1 {name=l1179 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -3530 3 0 {name=l1180 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -3280 0 0 {name=l1181 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -3400 0 0 {name=x296}
C {devices/lab_wire.sym} 2940 -3520 2 1 {name=l1182 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -3530 1 1 {name=l1183 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -3530 3 0 {name=l1184 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -3280 0 0 {name=l1185 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -3400 0 0 {name=x297}
C {devices/lab_wire.sym} 3200 -3520 2 1 {name=l1186 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -3530 1 1 {name=l1187 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -3530 3 0 {name=l1188 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -3280 0 0 {name=l1189 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -3400 0 0 {name=x298}
C {devices/lab_wire.sym} 3460 -3520 2 1 {name=l1190 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -3530 1 1 {name=l1191 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -3530 3 0 {name=l1192 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -3280 0 0 {name=l1193 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -3400 0 0 {name=x299}
C {devices/lab_wire.sym} 3720 -3520 2 1 {name=l1194 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -3530 1 1 {name=l1195 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -3530 3 0 {name=l1196 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -3280 0 0 {name=l1197 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -3400 0 0 {name=x300}
C {devices/lab_wire.sym} 3980 -3520 2 1 {name=l1198 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -3530 1 1 {name=l1199 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -3530 3 0 {name=l1200 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -3280 0 0 {name=l1201 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -3400 0 0 {name=x301}
C {devices/lab_wire.sym} 4240 -3520 2 1 {name=l1202 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -3530 1 1 {name=l1203 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -3530 3 0 {name=l1204 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -3280 0 0 {name=l1205 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -3400 0 0 {name=x302}
C {devices/lab_wire.sym} 4500 -3520 2 1 {name=l1206 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -3530 1 1 {name=l1207 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -3530 3 0 {name=l1208 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -3280 0 0 {name=l1209 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -3400 0 0 {name=x303}
C {devices/lab_wire.sym} 4760 -3520 2 1 {name=l1210 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -3530 1 1 {name=l1211 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -3530 3 0 {name=l1212 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -3280 0 0 {name=l1213 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -3400 0 0 {name=x304}
C {devices/lab_wire.sym} 5020 -3520 2 1 {name=l1214 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -3530 1 1 {name=l1215 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -3530 3 0 {name=l1216 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -3280 0 0 {name=l1217 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -3400 0 0 {name=x305}
C {devices/lab_wire.sym} 5280 -3520 2 1 {name=l1218 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -3530 1 1 {name=l1219 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -3530 3 0 {name=l1220 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -3280 0 0 {name=l1221 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -3400 0 0 {name=x306}
C {devices/lab_wire.sym} 5540 -3520 2 1 {name=l1222 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -3530 1 1 {name=l1223 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -3530 3 0 {name=l1224 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -3280 0 0 {name=l1225 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -3400 0 0 {name=x307}
C {devices/lab_wire.sym} 5800 -3520 2 1 {name=l1226 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -3530 1 1 {name=l1227 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -3530 3 0 {name=l1228 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -3280 0 0 {name=l1229 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -3400 0 0 {name=x308}
C {devices/lab_wire.sym} 6060 -3520 2 1 {name=l1230 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -3530 1 1 {name=l1231 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -3530 3 0 {name=l1232 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -3280 0 0 {name=l1233 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -3400 0 0 {name=x309}
C {devices/lab_wire.sym} 6320 -3520 2 1 {name=l1234 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -3530 1 1 {name=l1235 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -3530 3 0 {name=l1236 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -3280 0 0 {name=l1237 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -3400 0 0 {name=x310}
C {devices/lab_wire.sym} 6580 -3520 2 1 {name=l1238 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -3530 1 1 {name=l1239 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -3530 3 0 {name=l1240 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -3280 0 0 {name=l1241 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -3400 0 0 {name=x311}
C {devices/lab_wire.sym} 6840 -3520 2 1 {name=l1242 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -3530 1 1 {name=l1243 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -3530 3 0 {name=l1244 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -3280 0 0 {name=l1245 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -3400 0 0 {name=x312}
C {devices/lab_wire.sym} 7100 -3520 2 1 {name=l1246 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -3530 1 1 {name=l1247 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -3530 3 0 {name=l1248 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -3280 0 0 {name=l1249 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -3400 0 0 {name=x313}
C {devices/lab_wire.sym} 7360 -3520 2 1 {name=l1250 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -3530 1 1 {name=l1251 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -3530 3 0 {name=l1252 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -3280 0 0 {name=l1253 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -3400 0 0 {name=x314}
C {devices/lab_wire.sym} 7620 -3520 2 1 {name=l1254 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -3530 1 1 {name=l1255 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -3530 3 0 {name=l1256 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -3280 0 0 {name=l1257 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -3400 0 0 {name=x315}
C {devices/lab_wire.sym} 7880 -3520 2 1 {name=l1258 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -3530 1 1 {name=l1259 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -3530 3 0 {name=l1260 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -3280 0 0 {name=l1261 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -3400 0 0 {name=x316}
C {devices/lab_wire.sym} 8140 -3520 2 1 {name=l1262 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -3530 1 1 {name=l1263 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -3530 3 0 {name=l1264 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -3280 0 0 {name=l1265 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -3400 0 0 {name=x317}
C {devices/lab_wire.sym} 8400 -3520 2 1 {name=l1266 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -3530 1 1 {name=l1267 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -3530 3 0 {name=l1268 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -3280 0 0 {name=l1269 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -3400 0 0 {name=x318}
C {devices/lab_wire.sym} 8660 -3520 2 1 {name=l1270 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -3530 1 1 {name=l1271 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -3530 3 0 {name=l1272 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -3280 0 0 {name=l1273 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -3400 0 0 {name=x319}
C {devices/lab_wire.sym} 8920 -3520 2 1 {name=l1274 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -3530 1 1 {name=l1275 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -3530 3 0 {name=l1276 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -3280 0 0 {name=l1277 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -3400 0 0 {name=x320}
C {devices/lab_wire.sym} 9180 -3520 2 1 {name=l1278 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -3530 1 1 {name=l1279 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -3530 3 0 {name=l1280 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -3280 0 0 {name=l1281 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -3660 0 0 {name=x321}
C {devices/lab_wire.sym} 1120 -3780 2 1 {name=l1282 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -3790 1 1 {name=l1283 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -3790 3 0 {name=l1284 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -3540 0 0 {name=l1285 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -3660 0 0 {name=x322}
C {devices/lab_wire.sym} 1380 -3780 2 1 {name=l1286 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -3790 1 1 {name=l1287 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -3790 3 0 {name=l1288 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -3540 0 0 {name=l1289 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -3660 0 0 {name=x323}
C {devices/lab_wire.sym} 1640 -3780 2 1 {name=l1290 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -3790 1 1 {name=l1291 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -3790 3 0 {name=l1292 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -3540 0 0 {name=l1293 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -3660 0 0 {name=x324}
C {devices/lab_wire.sym} 1900 -3780 2 1 {name=l1294 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -3790 1 1 {name=l1295 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -3790 3 0 {name=l1296 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -3540 0 0 {name=l1297 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -3660 0 0 {name=x325}
C {devices/lab_wire.sym} 2160 -3780 2 1 {name=l1298 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -3790 1 1 {name=l1299 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -3790 3 0 {name=l1300 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -3540 0 0 {name=l1301 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -3660 0 0 {name=x326}
C {devices/lab_wire.sym} 2420 -3780 2 1 {name=l1302 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -3790 1 1 {name=l1303 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -3790 3 0 {name=l1304 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -3540 0 0 {name=l1305 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -3660 0 0 {name=x327}
C {devices/lab_wire.sym} 2680 -3780 2 1 {name=l1306 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -3790 1 1 {name=l1307 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -3790 3 0 {name=l1308 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -3540 0 0 {name=l1309 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -3660 0 0 {name=x328}
C {devices/lab_wire.sym} 2940 -3780 2 1 {name=l1310 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -3790 1 1 {name=l1311 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -3790 3 0 {name=l1312 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -3540 0 0 {name=l1313 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -3660 0 0 {name=x329}
C {devices/lab_wire.sym} 3200 -3780 2 1 {name=l1314 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -3790 1 1 {name=l1315 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -3790 3 0 {name=l1316 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -3540 0 0 {name=l1317 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -3660 0 0 {name=x330}
C {devices/lab_wire.sym} 3460 -3780 2 1 {name=l1318 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -3790 1 1 {name=l1319 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -3790 3 0 {name=l1320 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -3540 0 0 {name=l1321 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -3660 0 0 {name=x331}
C {devices/lab_wire.sym} 3720 -3780 2 1 {name=l1322 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -3790 1 1 {name=l1323 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -3790 3 0 {name=l1324 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -3540 0 0 {name=l1325 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -3660 0 0 {name=x332}
C {devices/lab_wire.sym} 3980 -3780 2 1 {name=l1326 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -3790 1 1 {name=l1327 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -3790 3 0 {name=l1328 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -3540 0 0 {name=l1329 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -3660 0 0 {name=x333}
C {devices/lab_wire.sym} 4240 -3780 2 1 {name=l1330 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -3790 1 1 {name=l1331 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -3790 3 0 {name=l1332 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -3540 0 0 {name=l1333 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -3660 0 0 {name=x334}
C {devices/lab_wire.sym} 4500 -3780 2 1 {name=l1334 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -3790 1 1 {name=l1335 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -3790 3 0 {name=l1336 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -3540 0 0 {name=l1337 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -3660 0 0 {name=x335}
C {devices/lab_wire.sym} 4760 -3780 2 1 {name=l1338 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -3790 1 1 {name=l1339 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -3790 3 0 {name=l1340 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -3540 0 0 {name=l1341 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -3660 0 0 {name=x336}
C {devices/lab_wire.sym} 5020 -3780 2 1 {name=l1342 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -3790 1 1 {name=l1343 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -3790 3 0 {name=l1344 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -3540 0 0 {name=l1345 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -3660 0 0 {name=x337}
C {devices/lab_wire.sym} 5280 -3780 2 1 {name=l1346 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -3790 1 1 {name=l1347 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -3790 3 0 {name=l1348 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -3540 0 0 {name=l1349 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -3660 0 0 {name=x338}
C {devices/lab_wire.sym} 5540 -3780 2 1 {name=l1350 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -3790 1 1 {name=l1351 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -3790 3 0 {name=l1352 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -3540 0 0 {name=l1353 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -3660 0 0 {name=x339}
C {devices/lab_wire.sym} 5800 -3780 2 1 {name=l1354 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -3790 1 1 {name=l1355 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -3790 3 0 {name=l1356 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -3540 0 0 {name=l1357 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -3660 0 0 {name=x340}
C {devices/lab_wire.sym} 6060 -3780 2 1 {name=l1358 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -3790 1 1 {name=l1359 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -3790 3 0 {name=l1360 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -3540 0 0 {name=l1361 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -3660 0 0 {name=x341}
C {devices/lab_wire.sym} 6320 -3780 2 1 {name=l1362 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -3790 1 1 {name=l1363 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -3790 3 0 {name=l1364 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -3540 0 0 {name=l1365 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -3660 0 0 {name=x342}
C {devices/lab_wire.sym} 6580 -3780 2 1 {name=l1366 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -3790 1 1 {name=l1367 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -3790 3 0 {name=l1368 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -3540 0 0 {name=l1369 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -3660 0 0 {name=x343}
C {devices/lab_wire.sym} 6840 -3780 2 1 {name=l1370 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -3790 1 1 {name=l1371 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -3790 3 0 {name=l1372 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -3540 0 0 {name=l1373 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -3660 0 0 {name=x344}
C {devices/lab_wire.sym} 7100 -3780 2 1 {name=l1374 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -3790 1 1 {name=l1375 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -3790 3 0 {name=l1376 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -3540 0 0 {name=l1377 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -3660 0 0 {name=x345}
C {devices/lab_wire.sym} 7360 -3780 2 1 {name=l1378 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -3790 1 1 {name=l1379 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -3790 3 0 {name=l1380 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -3540 0 0 {name=l1381 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -3660 0 0 {name=x346}
C {devices/lab_wire.sym} 7620 -3780 2 1 {name=l1382 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -3790 1 1 {name=l1383 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -3790 3 0 {name=l1384 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -3540 0 0 {name=l1385 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -3660 0 0 {name=x347}
C {devices/lab_wire.sym} 7880 -3780 2 1 {name=l1386 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -3790 1 1 {name=l1387 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -3790 3 0 {name=l1388 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -3540 0 0 {name=l1389 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -3660 0 0 {name=x348}
C {devices/lab_wire.sym} 8140 -3780 2 1 {name=l1390 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -3790 1 1 {name=l1391 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -3790 3 0 {name=l1392 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -3540 0 0 {name=l1393 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -3660 0 0 {name=x349}
C {devices/lab_wire.sym} 8400 -3780 2 1 {name=l1394 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -3790 1 1 {name=l1395 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -3790 3 0 {name=l1396 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -3540 0 0 {name=l1397 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -3660 0 0 {name=x350}
C {devices/lab_wire.sym} 8660 -3780 2 1 {name=l1398 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -3790 1 1 {name=l1399 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -3790 3 0 {name=l1400 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -3540 0 0 {name=l1401 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -3660 0 0 {name=x351}
C {devices/lab_wire.sym} 8920 -3780 2 1 {name=l1402 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -3790 1 1 {name=l1403 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -3790 3 0 {name=l1404 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -3540 0 0 {name=l1405 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -3660 0 0 {name=x352}
C {devices/lab_wire.sym} 9180 -3780 2 1 {name=l1406 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -3790 1 1 {name=l1407 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -3790 3 0 {name=l1408 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -3540 0 0 {name=l1409 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -3920 0 0 {name=x353}
C {devices/lab_wire.sym} 1120 -4040 2 1 {name=l1410 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -4050 1 1 {name=l1411 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -4050 3 0 {name=l1412 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -3800 0 0 {name=l1413 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -3920 0 0 {name=x354}
C {devices/lab_wire.sym} 1380 -4040 2 1 {name=l1414 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -4050 1 1 {name=l1415 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -4050 3 0 {name=l1416 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -3800 0 0 {name=l1417 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -3920 0 0 {name=x355}
C {devices/lab_wire.sym} 1640 -4040 2 1 {name=l1418 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -4050 1 1 {name=l1419 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -4050 3 0 {name=l1420 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -3800 0 0 {name=l1421 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -3920 0 0 {name=x356}
C {devices/lab_wire.sym} 1900 -4040 2 1 {name=l1422 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -4050 1 1 {name=l1423 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -4050 3 0 {name=l1424 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -3800 0 0 {name=l1425 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -3920 0 0 {name=x357}
C {devices/lab_wire.sym} 2160 -4040 2 1 {name=l1426 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -4050 1 1 {name=l1427 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -4050 3 0 {name=l1428 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -3800 0 0 {name=l1429 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -3920 0 0 {name=x358}
C {devices/lab_wire.sym} 2420 -4040 2 1 {name=l1430 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -4050 1 1 {name=l1431 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -4050 3 0 {name=l1432 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -3800 0 0 {name=l1433 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -3920 0 0 {name=x359}
C {devices/lab_wire.sym} 2680 -4040 2 1 {name=l1434 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -4050 1 1 {name=l1435 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -4050 3 0 {name=l1436 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -3800 0 0 {name=l1437 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -3920 0 0 {name=x360}
C {devices/lab_wire.sym} 2940 -4040 2 1 {name=l1438 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -4050 1 1 {name=l1439 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -4050 3 0 {name=l1440 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -3800 0 0 {name=l1441 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -3920 0 0 {name=x361}
C {devices/lab_wire.sym} 3200 -4040 2 1 {name=l1442 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -4050 1 1 {name=l1443 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -4050 3 0 {name=l1444 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -3800 0 0 {name=l1445 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -3920 0 0 {name=x362}
C {devices/lab_wire.sym} 3460 -4040 2 1 {name=l1446 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -4050 1 1 {name=l1447 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -4050 3 0 {name=l1448 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -3800 0 0 {name=l1449 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -3920 0 0 {name=x363}
C {devices/lab_wire.sym} 3720 -4040 2 1 {name=l1450 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -4050 1 1 {name=l1451 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -4050 3 0 {name=l1452 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -3800 0 0 {name=l1453 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -3920 0 0 {name=x364}
C {devices/lab_wire.sym} 3980 -4040 2 1 {name=l1454 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -4050 1 1 {name=l1455 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -4050 3 0 {name=l1456 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -3800 0 0 {name=l1457 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -3920 0 0 {name=x365}
C {devices/lab_wire.sym} 4240 -4040 2 1 {name=l1458 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -4050 1 1 {name=l1459 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -4050 3 0 {name=l1460 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -3800 0 0 {name=l1461 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -3920 0 0 {name=x366}
C {devices/lab_wire.sym} 4500 -4040 2 1 {name=l1462 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -4050 1 1 {name=l1463 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -4050 3 0 {name=l1464 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -3800 0 0 {name=l1465 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -3920 0 0 {name=x367}
C {devices/lab_wire.sym} 4760 -4040 2 1 {name=l1466 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -4050 1 1 {name=l1467 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -4050 3 0 {name=l1468 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -3800 0 0 {name=l1469 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -3920 0 0 {name=x368}
C {devices/lab_wire.sym} 5020 -4040 2 1 {name=l1470 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -4050 1 1 {name=l1471 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -4050 3 0 {name=l1472 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -3800 0 0 {name=l1473 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -3920 0 0 {name=x369}
C {devices/lab_wire.sym} 5280 -4040 2 1 {name=l1474 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -4050 1 1 {name=l1475 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -4050 3 0 {name=l1476 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -3800 0 0 {name=l1477 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -3920 0 0 {name=x370}
C {devices/lab_wire.sym} 5540 -4040 2 1 {name=l1478 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -4050 1 1 {name=l1479 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -4050 3 0 {name=l1480 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -3800 0 0 {name=l1481 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -3920 0 0 {name=x371}
C {devices/lab_wire.sym} 5800 -4040 2 1 {name=l1482 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -4050 1 1 {name=l1483 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -4050 3 0 {name=l1484 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -3800 0 0 {name=l1485 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -3920 0 0 {name=x372}
C {devices/lab_wire.sym} 6060 -4040 2 1 {name=l1486 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -4050 1 1 {name=l1487 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -4050 3 0 {name=l1488 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -3800 0 0 {name=l1489 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -3920 0 0 {name=x373}
C {devices/lab_wire.sym} 6320 -4040 2 1 {name=l1490 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -4050 1 1 {name=l1491 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -4050 3 0 {name=l1492 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -3800 0 0 {name=l1493 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -3920 0 0 {name=x374}
C {devices/lab_wire.sym} 6580 -4040 2 1 {name=l1494 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -4050 1 1 {name=l1495 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -4050 3 0 {name=l1496 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -3800 0 0 {name=l1497 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -3920 0 0 {name=x375}
C {devices/lab_wire.sym} 6840 -4040 2 1 {name=l1498 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -4050 1 1 {name=l1499 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -4050 3 0 {name=l1500 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -3800 0 0 {name=l1501 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -3920 0 0 {name=x376}
C {devices/lab_wire.sym} 7100 -4040 2 1 {name=l1502 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -4050 1 1 {name=l1503 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -4050 3 0 {name=l1504 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -3800 0 0 {name=l1505 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -3920 0 0 {name=x377}
C {devices/lab_wire.sym} 7360 -4040 2 1 {name=l1506 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -4050 1 1 {name=l1507 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -4050 3 0 {name=l1508 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -3800 0 0 {name=l1509 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -3920 0 0 {name=x378}
C {devices/lab_wire.sym} 7620 -4040 2 1 {name=l1510 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -4050 1 1 {name=l1511 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -4050 3 0 {name=l1512 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -3800 0 0 {name=l1513 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -3920 0 0 {name=x379}
C {devices/lab_wire.sym} 7880 -4040 2 1 {name=l1514 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -4050 1 1 {name=l1515 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -4050 3 0 {name=l1516 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -3800 0 0 {name=l1517 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -3920 0 0 {name=x380}
C {devices/lab_wire.sym} 8140 -4040 2 1 {name=l1518 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -4050 1 1 {name=l1519 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -4050 3 0 {name=l1520 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -3800 0 0 {name=l1521 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -3920 0 0 {name=x381}
C {devices/lab_wire.sym} 8400 -4040 2 1 {name=l1522 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -4050 1 1 {name=l1523 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -4050 3 0 {name=l1524 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -3800 0 0 {name=l1525 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -3920 0 0 {name=x382}
C {devices/lab_wire.sym} 8660 -4040 2 1 {name=l1526 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -4050 1 1 {name=l1527 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -4050 3 0 {name=l1528 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -3800 0 0 {name=l1529 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -3920 0 0 {name=x383}
C {devices/lab_wire.sym} 8920 -4040 2 1 {name=l1530 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -4050 1 1 {name=l1531 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -4050 3 0 {name=l1532 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -3800 0 0 {name=l1533 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -3920 0 0 {name=x384}
C {devices/lab_wire.sym} 9180 -4040 2 1 {name=l1534 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -4050 1 1 {name=l1535 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -4050 3 0 {name=l1536 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -3800 0 0 {name=l1537 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -4180 0 0 {name=x385}
C {devices/lab_wire.sym} 1120 -4300 2 1 {name=l1538 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -4310 1 1 {name=l1539 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -4310 3 0 {name=l1540 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -4060 0 0 {name=l1541 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -4180 0 0 {name=x386}
C {devices/lab_wire.sym} 1380 -4300 2 1 {name=l1542 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -4310 1 1 {name=l1543 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -4310 3 0 {name=l1544 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -4060 0 0 {name=l1545 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -4180 0 0 {name=x387}
C {devices/lab_wire.sym} 1640 -4300 2 1 {name=l1546 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -4310 1 1 {name=l1547 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -4310 3 0 {name=l1548 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -4060 0 0 {name=l1549 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -4180 0 0 {name=x388}
C {devices/lab_wire.sym} 1900 -4300 2 1 {name=l1550 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -4310 1 1 {name=l1551 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -4310 3 0 {name=l1552 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -4060 0 0 {name=l1553 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -4180 0 0 {name=x389}
C {devices/lab_wire.sym} 2160 -4300 2 1 {name=l1554 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -4310 1 1 {name=l1555 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -4310 3 0 {name=l1556 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -4060 0 0 {name=l1557 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -4180 0 0 {name=x390}
C {devices/lab_wire.sym} 2420 -4300 2 1 {name=l1558 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -4310 1 1 {name=l1559 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -4310 3 0 {name=l1560 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -4060 0 0 {name=l1561 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -4180 0 0 {name=x391}
C {devices/lab_wire.sym} 2680 -4300 2 1 {name=l1562 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -4310 1 1 {name=l1563 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -4310 3 0 {name=l1564 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -4060 0 0 {name=l1565 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -4180 0 0 {name=x392}
C {devices/lab_wire.sym} 2940 -4300 2 1 {name=l1566 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -4310 1 1 {name=l1567 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -4310 3 0 {name=l1568 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -4060 0 0 {name=l1569 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -4180 0 0 {name=x393}
C {devices/lab_wire.sym} 3200 -4300 2 1 {name=l1570 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -4310 1 1 {name=l1571 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -4310 3 0 {name=l1572 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -4060 0 0 {name=l1573 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -4180 0 0 {name=x394}
C {devices/lab_wire.sym} 3460 -4300 2 1 {name=l1574 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -4310 1 1 {name=l1575 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -4310 3 0 {name=l1576 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -4060 0 0 {name=l1577 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -4180 0 0 {name=x395}
C {devices/lab_wire.sym} 3720 -4300 2 1 {name=l1578 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -4310 1 1 {name=l1579 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -4310 3 0 {name=l1580 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -4060 0 0 {name=l1581 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -4180 0 0 {name=x396}
C {devices/lab_wire.sym} 3980 -4300 2 1 {name=l1582 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -4310 1 1 {name=l1583 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -4310 3 0 {name=l1584 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -4060 0 0 {name=l1585 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -4180 0 0 {name=x397}
C {devices/lab_wire.sym} 4240 -4300 2 1 {name=l1586 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -4310 1 1 {name=l1587 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -4310 3 0 {name=l1588 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -4060 0 0 {name=l1589 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -4180 0 0 {name=x398}
C {devices/lab_wire.sym} 4500 -4300 2 1 {name=l1590 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -4310 1 1 {name=l1591 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -4310 3 0 {name=l1592 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -4060 0 0 {name=l1593 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -4180 0 0 {name=x399}
C {devices/lab_wire.sym} 4760 -4300 2 1 {name=l1594 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -4310 1 1 {name=l1595 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -4310 3 0 {name=l1596 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -4060 0 0 {name=l1597 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -4180 0 0 {name=x400}
C {devices/lab_wire.sym} 5020 -4300 2 1 {name=l1598 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -4310 1 1 {name=l1599 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -4310 3 0 {name=l1600 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -4060 0 0 {name=l1601 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -4180 0 0 {name=x401}
C {devices/lab_wire.sym} 5280 -4300 2 1 {name=l1602 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -4310 1 1 {name=l1603 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -4310 3 0 {name=l1604 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -4060 0 0 {name=l1605 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -4180 0 0 {name=x402}
C {devices/lab_wire.sym} 5540 -4300 2 1 {name=l1606 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -4310 1 1 {name=l1607 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -4310 3 0 {name=l1608 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -4060 0 0 {name=l1609 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -4180 0 0 {name=x403}
C {devices/lab_wire.sym} 5800 -4300 2 1 {name=l1610 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -4310 1 1 {name=l1611 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -4310 3 0 {name=l1612 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -4060 0 0 {name=l1613 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -4180 0 0 {name=x404}
C {devices/lab_wire.sym} 6060 -4300 2 1 {name=l1614 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -4310 1 1 {name=l1615 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -4310 3 0 {name=l1616 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -4060 0 0 {name=l1617 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -4180 0 0 {name=x405}
C {devices/lab_wire.sym} 6320 -4300 2 1 {name=l1618 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -4310 1 1 {name=l1619 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -4310 3 0 {name=l1620 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -4060 0 0 {name=l1621 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -4180 0 0 {name=x406}
C {devices/lab_wire.sym} 6580 -4300 2 1 {name=l1622 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -4310 1 1 {name=l1623 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -4310 3 0 {name=l1624 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -4060 0 0 {name=l1625 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -4180 0 0 {name=x407}
C {devices/lab_wire.sym} 6840 -4300 2 1 {name=l1626 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -4310 1 1 {name=l1627 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -4310 3 0 {name=l1628 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -4060 0 0 {name=l1629 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -4180 0 0 {name=x408}
C {devices/lab_wire.sym} 7100 -4300 2 1 {name=l1630 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -4310 1 1 {name=l1631 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -4310 3 0 {name=l1632 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -4060 0 0 {name=l1633 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -4180 0 0 {name=x409}
C {devices/lab_wire.sym} 7360 -4300 2 1 {name=l1634 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -4310 1 1 {name=l1635 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -4310 3 0 {name=l1636 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -4060 0 0 {name=l1637 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -4180 0 0 {name=x410}
C {devices/lab_wire.sym} 7620 -4300 2 1 {name=l1638 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -4310 1 1 {name=l1639 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -4310 3 0 {name=l1640 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -4060 0 0 {name=l1641 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -4180 0 0 {name=x411}
C {devices/lab_wire.sym} 7880 -4300 2 1 {name=l1642 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -4310 1 1 {name=l1643 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -4310 3 0 {name=l1644 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -4060 0 0 {name=l1645 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -4180 0 0 {name=x412}
C {devices/lab_wire.sym} 8140 -4300 2 1 {name=l1646 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -4310 1 1 {name=l1647 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -4310 3 0 {name=l1648 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -4060 0 0 {name=l1649 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -4180 0 0 {name=x413}
C {devices/lab_wire.sym} 8400 -4300 2 1 {name=l1650 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -4310 1 1 {name=l1651 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -4310 3 0 {name=l1652 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -4060 0 0 {name=l1653 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -4180 0 0 {name=x414}
C {devices/lab_wire.sym} 8660 -4300 2 1 {name=l1654 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -4310 1 1 {name=l1655 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -4310 3 0 {name=l1656 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -4060 0 0 {name=l1657 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -4180 0 0 {name=x415}
C {devices/lab_wire.sym} 8920 -4300 2 1 {name=l1658 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -4310 1 1 {name=l1659 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -4310 3 0 {name=l1660 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -4060 0 0 {name=l1661 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -4180 0 0 {name=x416}
C {devices/lab_wire.sym} 9180 -4300 2 1 {name=l1662 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -4310 1 1 {name=l1663 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -4310 3 0 {name=l1664 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -4060 0 0 {name=l1665 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -4440 0 0 {name=x417}
C {devices/lab_wire.sym} 1120 -4560 2 1 {name=l1666 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -4570 1 1 {name=l1667 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -4570 3 0 {name=l1668 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -4320 0 0 {name=l1669 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -4440 0 0 {name=x418}
C {devices/lab_wire.sym} 1380 -4560 2 1 {name=l1670 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -4570 1 1 {name=l1671 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -4570 3 0 {name=l1672 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -4320 0 0 {name=l1673 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -4440 0 0 {name=x419}
C {devices/lab_wire.sym} 1640 -4560 2 1 {name=l1674 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -4570 1 1 {name=l1675 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -4570 3 0 {name=l1676 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -4320 0 0 {name=l1677 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -4440 0 0 {name=x420}
C {devices/lab_wire.sym} 1900 -4560 2 1 {name=l1678 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -4570 1 1 {name=l1679 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -4570 3 0 {name=l1680 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -4320 0 0 {name=l1681 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -4440 0 0 {name=x421}
C {devices/lab_wire.sym} 2160 -4560 2 1 {name=l1682 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -4570 1 1 {name=l1683 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -4570 3 0 {name=l1684 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -4320 0 0 {name=l1685 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -4440 0 0 {name=x422}
C {devices/lab_wire.sym} 2420 -4560 2 1 {name=l1686 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -4570 1 1 {name=l1687 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -4570 3 0 {name=l1688 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -4320 0 0 {name=l1689 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -4440 0 0 {name=x423}
C {devices/lab_wire.sym} 2680 -4560 2 1 {name=l1690 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -4570 1 1 {name=l1691 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -4570 3 0 {name=l1692 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -4320 0 0 {name=l1693 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -4440 0 0 {name=x424}
C {devices/lab_wire.sym} 2940 -4560 2 1 {name=l1694 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -4570 1 1 {name=l1695 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -4570 3 0 {name=l1696 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -4320 0 0 {name=l1697 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -4440 0 0 {name=x425}
C {devices/lab_wire.sym} 3200 -4560 2 1 {name=l1698 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -4570 1 1 {name=l1699 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -4570 3 0 {name=l1700 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -4320 0 0 {name=l1701 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -4440 0 0 {name=x426}
C {devices/lab_wire.sym} 3460 -4560 2 1 {name=l1702 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -4570 1 1 {name=l1703 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -4570 3 0 {name=l1704 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -4320 0 0 {name=l1705 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -4440 0 0 {name=x427}
C {devices/lab_wire.sym} 3720 -4560 2 1 {name=l1706 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -4570 1 1 {name=l1707 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -4570 3 0 {name=l1708 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -4320 0 0 {name=l1709 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -4440 0 0 {name=x428}
C {devices/lab_wire.sym} 3980 -4560 2 1 {name=l1710 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -4570 1 1 {name=l1711 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -4570 3 0 {name=l1712 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -4320 0 0 {name=l1713 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -4440 0 0 {name=x429}
C {devices/lab_wire.sym} 4240 -4560 2 1 {name=l1714 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -4570 1 1 {name=l1715 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -4570 3 0 {name=l1716 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -4320 0 0 {name=l1717 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -4440 0 0 {name=x430}
C {devices/lab_wire.sym} 4500 -4560 2 1 {name=l1718 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -4570 1 1 {name=l1719 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -4570 3 0 {name=l1720 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -4320 0 0 {name=l1721 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -4440 0 0 {name=x431}
C {devices/lab_wire.sym} 4760 -4560 2 1 {name=l1722 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -4570 1 1 {name=l1723 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -4570 3 0 {name=l1724 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -4320 0 0 {name=l1725 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -4440 0 0 {name=x432}
C {devices/lab_wire.sym} 5020 -4560 2 1 {name=l1726 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -4570 1 1 {name=l1727 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -4570 3 0 {name=l1728 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -4320 0 0 {name=l1729 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -4440 0 0 {name=x433}
C {devices/lab_wire.sym} 5280 -4560 2 1 {name=l1730 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -4570 1 1 {name=l1731 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -4570 3 0 {name=l1732 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -4320 0 0 {name=l1733 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -4440 0 0 {name=x434}
C {devices/lab_wire.sym} 5540 -4560 2 1 {name=l1734 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -4570 1 1 {name=l1735 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -4570 3 0 {name=l1736 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -4320 0 0 {name=l1737 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -4440 0 0 {name=x435}
C {devices/lab_wire.sym} 5800 -4560 2 1 {name=l1738 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -4570 1 1 {name=l1739 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -4570 3 0 {name=l1740 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -4320 0 0 {name=l1741 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -4440 0 0 {name=x436}
C {devices/lab_wire.sym} 6060 -4560 2 1 {name=l1742 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -4570 1 1 {name=l1743 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -4570 3 0 {name=l1744 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -4320 0 0 {name=l1745 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -4440 0 0 {name=x437}
C {devices/lab_wire.sym} 6320 -4560 2 1 {name=l1746 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -4570 1 1 {name=l1747 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -4570 3 0 {name=l1748 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -4320 0 0 {name=l1749 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -4440 0 0 {name=x438}
C {devices/lab_wire.sym} 6580 -4560 2 1 {name=l1750 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -4570 1 1 {name=l1751 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -4570 3 0 {name=l1752 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -4320 0 0 {name=l1753 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -4440 0 0 {name=x439}
C {devices/lab_wire.sym} 6840 -4560 2 1 {name=l1754 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -4570 1 1 {name=l1755 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -4570 3 0 {name=l1756 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -4320 0 0 {name=l1757 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -4440 0 0 {name=x440}
C {devices/lab_wire.sym} 7100 -4560 2 1 {name=l1758 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -4570 1 1 {name=l1759 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -4570 3 0 {name=l1760 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -4320 0 0 {name=l1761 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -4440 0 0 {name=x441}
C {devices/lab_wire.sym} 7360 -4560 2 1 {name=l1762 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -4570 1 1 {name=l1763 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -4570 3 0 {name=l1764 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -4320 0 0 {name=l1765 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -4440 0 0 {name=x442}
C {devices/lab_wire.sym} 7620 -4560 2 1 {name=l1766 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -4570 1 1 {name=l1767 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -4570 3 0 {name=l1768 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -4320 0 0 {name=l1769 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -4440 0 0 {name=x443}
C {devices/lab_wire.sym} 7880 -4560 2 1 {name=l1770 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -4570 1 1 {name=l1771 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -4570 3 0 {name=l1772 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -4320 0 0 {name=l1773 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -4440 0 0 {name=x444}
C {devices/lab_wire.sym} 8140 -4560 2 1 {name=l1774 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -4570 1 1 {name=l1775 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -4570 3 0 {name=l1776 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -4320 0 0 {name=l1777 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -4440 0 0 {name=x445}
C {devices/lab_wire.sym} 8400 -4560 2 1 {name=l1778 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -4570 1 1 {name=l1779 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -4570 3 0 {name=l1780 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -4320 0 0 {name=l1781 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -4440 0 0 {name=x446}
C {devices/lab_wire.sym} 8660 -4560 2 1 {name=l1782 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -4570 1 1 {name=l1783 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -4570 3 0 {name=l1784 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -4320 0 0 {name=l1785 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -4440 0 0 {name=x447}
C {devices/lab_wire.sym} 8920 -4560 2 1 {name=l1786 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -4570 1 1 {name=l1787 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -4570 3 0 {name=l1788 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -4320 0 0 {name=l1789 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -4440 0 0 {name=x448}
C {devices/lab_wire.sym} 9180 -4560 2 1 {name=l1790 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -4570 1 1 {name=l1791 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -4570 3 0 {name=l1792 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -4320 0 0 {name=l1793 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -4700 0 0 {name=x449}
C {devices/lab_wire.sym} 1120 -4820 2 1 {name=l1794 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -4830 1 1 {name=l1795 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -4830 3 0 {name=l1796 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -4580 0 0 {name=l1797 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -4700 0 0 {name=x450}
C {devices/lab_wire.sym} 1380 -4820 2 1 {name=l1798 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -4830 1 1 {name=l1799 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -4830 3 0 {name=l1800 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -4580 0 0 {name=l1801 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -4700 0 0 {name=x451}
C {devices/lab_wire.sym} 1640 -4820 2 1 {name=l1802 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -4830 1 1 {name=l1803 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -4830 3 0 {name=l1804 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -4580 0 0 {name=l1805 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -4700 0 0 {name=x452}
C {devices/lab_wire.sym} 1900 -4820 2 1 {name=l1806 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -4830 1 1 {name=l1807 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -4830 3 0 {name=l1808 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -4580 0 0 {name=l1809 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -4700 0 0 {name=x453}
C {devices/lab_wire.sym} 2160 -4820 2 1 {name=l1810 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -4830 1 1 {name=l1811 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -4830 3 0 {name=l1812 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -4580 0 0 {name=l1813 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -4700 0 0 {name=x454}
C {devices/lab_wire.sym} 2420 -4820 2 1 {name=l1814 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -4830 1 1 {name=l1815 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -4830 3 0 {name=l1816 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -4580 0 0 {name=l1817 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -4700 0 0 {name=x455}
C {devices/lab_wire.sym} 2680 -4820 2 1 {name=l1818 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -4830 1 1 {name=l1819 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -4830 3 0 {name=l1820 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -4580 0 0 {name=l1821 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -4700 0 0 {name=x456}
C {devices/lab_wire.sym} 2940 -4820 2 1 {name=l1822 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -4830 1 1 {name=l1823 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -4830 3 0 {name=l1824 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -4580 0 0 {name=l1825 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -4700 0 0 {name=x457}
C {devices/lab_wire.sym} 3200 -4820 2 1 {name=l1826 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -4830 1 1 {name=l1827 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -4830 3 0 {name=l1828 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -4580 0 0 {name=l1829 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -4700 0 0 {name=x458}
C {devices/lab_wire.sym} 3460 -4820 2 1 {name=l1830 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -4830 1 1 {name=l1831 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -4830 3 0 {name=l1832 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -4580 0 0 {name=l1833 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -4700 0 0 {name=x459}
C {devices/lab_wire.sym} 3720 -4820 2 1 {name=l1834 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -4830 1 1 {name=l1835 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -4830 3 0 {name=l1836 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -4580 0 0 {name=l1837 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -4700 0 0 {name=x460}
C {devices/lab_wire.sym} 3980 -4820 2 1 {name=l1838 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -4830 1 1 {name=l1839 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -4830 3 0 {name=l1840 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -4580 0 0 {name=l1841 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -4700 0 0 {name=x461}
C {devices/lab_wire.sym} 4240 -4820 2 1 {name=l1842 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -4830 1 1 {name=l1843 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -4830 3 0 {name=l1844 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -4580 0 0 {name=l1845 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -4700 0 0 {name=x462}
C {devices/lab_wire.sym} 4500 -4820 2 1 {name=l1846 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -4830 1 1 {name=l1847 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -4830 3 0 {name=l1848 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -4580 0 0 {name=l1849 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -4700 0 0 {name=x463}
C {devices/lab_wire.sym} 4760 -4820 2 1 {name=l1850 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -4830 1 1 {name=l1851 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -4830 3 0 {name=l1852 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -4580 0 0 {name=l1853 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -4700 0 0 {name=x464}
C {devices/lab_wire.sym} 5020 -4820 2 1 {name=l1854 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -4830 1 1 {name=l1855 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -4830 3 0 {name=l1856 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -4580 0 0 {name=l1857 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -4700 0 0 {name=x465}
C {devices/lab_wire.sym} 5280 -4820 2 1 {name=l1858 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -4830 1 1 {name=l1859 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -4830 3 0 {name=l1860 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -4580 0 0 {name=l1861 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -4700 0 0 {name=x466}
C {devices/lab_wire.sym} 5540 -4820 2 1 {name=l1862 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -4830 1 1 {name=l1863 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -4830 3 0 {name=l1864 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -4580 0 0 {name=l1865 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -4700 0 0 {name=x467}
C {devices/lab_wire.sym} 5800 -4820 2 1 {name=l1866 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -4830 1 1 {name=l1867 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -4830 3 0 {name=l1868 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -4580 0 0 {name=l1869 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -4700 0 0 {name=x468}
C {devices/lab_wire.sym} 6060 -4820 2 1 {name=l1870 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -4830 1 1 {name=l1871 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -4830 3 0 {name=l1872 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -4580 0 0 {name=l1873 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -4700 0 0 {name=x469}
C {devices/lab_wire.sym} 6320 -4820 2 1 {name=l1874 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -4830 1 1 {name=l1875 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -4830 3 0 {name=l1876 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -4580 0 0 {name=l1877 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -4700 0 0 {name=x470}
C {devices/lab_wire.sym} 6580 -4820 2 1 {name=l1878 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -4830 1 1 {name=l1879 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -4830 3 0 {name=l1880 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -4580 0 0 {name=l1881 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -4700 0 0 {name=x471}
C {devices/lab_wire.sym} 6840 -4820 2 1 {name=l1882 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -4830 1 1 {name=l1883 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -4830 3 0 {name=l1884 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -4580 0 0 {name=l1885 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -4700 0 0 {name=x472}
C {devices/lab_wire.sym} 7100 -4820 2 1 {name=l1886 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -4830 1 1 {name=l1887 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -4830 3 0 {name=l1888 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -4580 0 0 {name=l1889 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -4700 0 0 {name=x473}
C {devices/lab_wire.sym} 7360 -4820 2 1 {name=l1890 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -4830 1 1 {name=l1891 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -4830 3 0 {name=l1892 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -4580 0 0 {name=l1893 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -4700 0 0 {name=x474}
C {devices/lab_wire.sym} 7620 -4820 2 1 {name=l1894 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -4830 1 1 {name=l1895 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -4830 3 0 {name=l1896 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -4580 0 0 {name=l1897 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -4700 0 0 {name=x475}
C {devices/lab_wire.sym} 7880 -4820 2 1 {name=l1898 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -4830 1 1 {name=l1899 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -4830 3 0 {name=l1900 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -4580 0 0 {name=l1901 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -4700 0 0 {name=x476}
C {devices/lab_wire.sym} 8140 -4820 2 1 {name=l1902 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -4830 1 1 {name=l1903 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -4830 3 0 {name=l1904 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -4580 0 0 {name=l1905 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -4700 0 0 {name=x477}
C {devices/lab_wire.sym} 8400 -4820 2 1 {name=l1906 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -4830 1 1 {name=l1907 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -4830 3 0 {name=l1908 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -4580 0 0 {name=l1909 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -4700 0 0 {name=x478}
C {devices/lab_wire.sym} 8660 -4820 2 1 {name=l1910 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -4830 1 1 {name=l1911 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -4830 3 0 {name=l1912 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -4580 0 0 {name=l1913 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -4700 0 0 {name=x479}
C {devices/lab_wire.sym} 8920 -4820 2 1 {name=l1914 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -4830 1 1 {name=l1915 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -4830 3 0 {name=l1916 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -4580 0 0 {name=l1917 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -4700 0 0 {name=x480}
C {devices/lab_wire.sym} 9180 -4820 2 1 {name=l1918 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -4830 1 1 {name=l1919 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -4830 3 0 {name=l1920 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -4580 0 0 {name=l1921 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -4960 0 0 {name=x481}
C {devices/lab_wire.sym} 1120 -5080 2 1 {name=l1922 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -5090 1 1 {name=l1923 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -5090 3 0 {name=l1924 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -4840 0 0 {name=l1925 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -4960 0 0 {name=x482}
C {devices/lab_wire.sym} 1380 -5080 2 1 {name=l1926 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -5090 1 1 {name=l1927 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -5090 3 0 {name=l1928 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -4840 0 0 {name=l1929 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -4960 0 0 {name=x483}
C {devices/lab_wire.sym} 1640 -5080 2 1 {name=l1930 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -5090 1 1 {name=l1931 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -5090 3 0 {name=l1932 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -4840 0 0 {name=l1933 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -4960 0 0 {name=x484}
C {devices/lab_wire.sym} 1900 -5080 2 1 {name=l1934 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -5090 1 1 {name=l1935 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -5090 3 0 {name=l1936 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -4840 0 0 {name=l1937 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -4960 0 0 {name=x485}
C {devices/lab_wire.sym} 2160 -5080 2 1 {name=l1938 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -5090 1 1 {name=l1939 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -5090 3 0 {name=l1940 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -4840 0 0 {name=l1941 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -4960 0 0 {name=x486}
C {devices/lab_wire.sym} 2420 -5080 2 1 {name=l1942 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -5090 1 1 {name=l1943 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -5090 3 0 {name=l1944 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -4840 0 0 {name=l1945 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -4960 0 0 {name=x487}
C {devices/lab_wire.sym} 2680 -5080 2 1 {name=l1946 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -5090 1 1 {name=l1947 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -5090 3 0 {name=l1948 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -4840 0 0 {name=l1949 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -4960 0 0 {name=x488}
C {devices/lab_wire.sym} 2940 -5080 2 1 {name=l1950 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -5090 1 1 {name=l1951 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -5090 3 0 {name=l1952 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -4840 0 0 {name=l1953 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -4960 0 0 {name=x489}
C {devices/lab_wire.sym} 3200 -5080 2 1 {name=l1954 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -5090 1 1 {name=l1955 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -5090 3 0 {name=l1956 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -4840 0 0 {name=l1957 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -4960 0 0 {name=x490}
C {devices/lab_wire.sym} 3460 -5080 2 1 {name=l1958 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -5090 1 1 {name=l1959 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -5090 3 0 {name=l1960 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -4840 0 0 {name=l1961 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -4960 0 0 {name=x491}
C {devices/lab_wire.sym} 3720 -5080 2 1 {name=l1962 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -5090 1 1 {name=l1963 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -5090 3 0 {name=l1964 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -4840 0 0 {name=l1965 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -4960 0 0 {name=x492}
C {devices/lab_wire.sym} 3980 -5080 2 1 {name=l1966 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -5090 1 1 {name=l1967 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -5090 3 0 {name=l1968 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -4840 0 0 {name=l1969 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -4960 0 0 {name=x493}
C {devices/lab_wire.sym} 4240 -5080 2 1 {name=l1970 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -5090 1 1 {name=l1971 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -5090 3 0 {name=l1972 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -4840 0 0 {name=l1973 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -4960 0 0 {name=x494}
C {devices/lab_wire.sym} 4500 -5080 2 1 {name=l1974 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -5090 1 1 {name=l1975 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -5090 3 0 {name=l1976 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -4840 0 0 {name=l1977 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -4960 0 0 {name=x495}
C {devices/lab_wire.sym} 4760 -5080 2 1 {name=l1978 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -5090 1 1 {name=l1979 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -5090 3 0 {name=l1980 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -4840 0 0 {name=l1981 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -4960 0 0 {name=x496}
C {devices/lab_wire.sym} 5020 -5080 2 1 {name=l1982 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -5090 1 1 {name=l1983 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -5090 3 0 {name=l1984 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -4840 0 0 {name=l1985 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -4960 0 0 {name=x497}
C {devices/lab_wire.sym} 5280 -5080 2 1 {name=l1986 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -5090 1 1 {name=l1987 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -5090 3 0 {name=l1988 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -4840 0 0 {name=l1989 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -4960 0 0 {name=x498}
C {devices/lab_wire.sym} 5540 -5080 2 1 {name=l1990 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -5090 1 1 {name=l1991 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -5090 3 0 {name=l1992 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -4840 0 0 {name=l1993 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -4960 0 0 {name=x499}
C {devices/lab_wire.sym} 5800 -5080 2 1 {name=l1994 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -5090 1 1 {name=l1995 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -5090 3 0 {name=l1996 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -4840 0 0 {name=l1997 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -4960 0 0 {name=x500}
C {devices/lab_wire.sym} 6060 -5080 2 1 {name=l1998 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -5090 1 1 {name=l1999 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -5090 3 0 {name=l2000 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -4840 0 0 {name=l2001 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -4960 0 0 {name=x501}
C {devices/lab_wire.sym} 6320 -5080 2 1 {name=l2002 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -5090 1 1 {name=l2003 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -5090 3 0 {name=l2004 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -4840 0 0 {name=l2005 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -4960 0 0 {name=x502}
C {devices/lab_wire.sym} 6580 -5080 2 1 {name=l2006 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -5090 1 1 {name=l2007 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -5090 3 0 {name=l2008 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -4840 0 0 {name=l2009 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -4960 0 0 {name=x503}
C {devices/lab_wire.sym} 6840 -5080 2 1 {name=l2010 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -5090 1 1 {name=l2011 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -5090 3 0 {name=l2012 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -4840 0 0 {name=l2013 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -4960 0 0 {name=x504}
C {devices/lab_wire.sym} 7100 -5080 2 1 {name=l2014 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -5090 1 1 {name=l2015 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -5090 3 0 {name=l2016 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -4840 0 0 {name=l2017 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -4960 0 0 {name=x505}
C {devices/lab_wire.sym} 7360 -5080 2 1 {name=l2018 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -5090 1 1 {name=l2019 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -5090 3 0 {name=l2020 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -4840 0 0 {name=l2021 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -4960 0 0 {name=x506}
C {devices/lab_wire.sym} 7620 -5080 2 1 {name=l2022 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -5090 1 1 {name=l2023 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -5090 3 0 {name=l2024 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -4840 0 0 {name=l2025 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -4960 0 0 {name=x507}
C {devices/lab_wire.sym} 7880 -5080 2 1 {name=l2026 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -5090 1 1 {name=l2027 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -5090 3 0 {name=l2028 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -4840 0 0 {name=l2029 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -4960 0 0 {name=x508}
C {devices/lab_wire.sym} 8140 -5080 2 1 {name=l2030 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -5090 1 1 {name=l2031 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -5090 3 0 {name=l2032 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -4840 0 0 {name=l2033 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -4960 0 0 {name=x509}
C {devices/lab_wire.sym} 8400 -5080 2 1 {name=l2034 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -5090 1 1 {name=l2035 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -5090 3 0 {name=l2036 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -4840 0 0 {name=l2037 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -4960 0 0 {name=x510}
C {devices/lab_wire.sym} 8660 -5080 2 1 {name=l2038 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -5090 1 1 {name=l2039 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -5090 3 0 {name=l2040 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -4840 0 0 {name=l2041 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -4960 0 0 {name=x511}
C {devices/lab_wire.sym} 8920 -5080 2 1 {name=l2042 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -5090 1 1 {name=l2043 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -5090 3 0 {name=l2044 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -4840 0 0 {name=l2045 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -4960 0 0 {name=x512}
C {devices/lab_wire.sym} 9180 -5080 2 1 {name=l2046 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -5090 1 1 {name=l2047 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -5090 3 0 {name=l2048 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -4840 0 0 {name=l2049 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -5220 0 0 {name=x513}
C {devices/lab_wire.sym} 1120 -5340 2 1 {name=l2050 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -5350 1 1 {name=l2051 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -5350 3 0 {name=l2052 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -5100 0 0 {name=l2053 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -5220 0 0 {name=x514}
C {devices/lab_wire.sym} 1380 -5340 2 1 {name=l2054 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -5350 1 1 {name=l2055 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -5350 3 0 {name=l2056 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -5100 0 0 {name=l2057 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -5220 0 0 {name=x515}
C {devices/lab_wire.sym} 1640 -5340 2 1 {name=l2058 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -5350 1 1 {name=l2059 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -5350 3 0 {name=l2060 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -5100 0 0 {name=l2061 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -5220 0 0 {name=x516}
C {devices/lab_wire.sym} 1900 -5340 2 1 {name=l2062 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -5350 1 1 {name=l2063 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -5350 3 0 {name=l2064 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -5100 0 0 {name=l2065 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -5220 0 0 {name=x517}
C {devices/lab_wire.sym} 2160 -5340 2 1 {name=l2066 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -5350 1 1 {name=l2067 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -5350 3 0 {name=l2068 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -5100 0 0 {name=l2069 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -5220 0 0 {name=x518}
C {devices/lab_wire.sym} 2420 -5340 2 1 {name=l2070 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -5350 1 1 {name=l2071 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -5350 3 0 {name=l2072 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -5100 0 0 {name=l2073 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -5220 0 0 {name=x519}
C {devices/lab_wire.sym} 2680 -5340 2 1 {name=l2074 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -5350 1 1 {name=l2075 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -5350 3 0 {name=l2076 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -5100 0 0 {name=l2077 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -5220 0 0 {name=x520}
C {devices/lab_wire.sym} 2940 -5340 2 1 {name=l2078 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -5350 1 1 {name=l2079 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -5350 3 0 {name=l2080 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -5100 0 0 {name=l2081 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -5220 0 0 {name=x521}
C {devices/lab_wire.sym} 3200 -5340 2 1 {name=l2082 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -5350 1 1 {name=l2083 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -5350 3 0 {name=l2084 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -5100 0 0 {name=l2085 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -5220 0 0 {name=x522}
C {devices/lab_wire.sym} 3460 -5340 2 1 {name=l2086 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -5350 1 1 {name=l2087 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -5350 3 0 {name=l2088 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -5100 0 0 {name=l2089 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -5220 0 0 {name=x523}
C {devices/lab_wire.sym} 3720 -5340 2 1 {name=l2090 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -5350 1 1 {name=l2091 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -5350 3 0 {name=l2092 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -5100 0 0 {name=l2093 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -5220 0 0 {name=x524}
C {devices/lab_wire.sym} 3980 -5340 2 1 {name=l2094 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -5350 1 1 {name=l2095 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -5350 3 0 {name=l2096 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -5100 0 0 {name=l2097 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -5220 0 0 {name=x525}
C {devices/lab_wire.sym} 4240 -5340 2 1 {name=l2098 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -5350 1 1 {name=l2099 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -5350 3 0 {name=l2100 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -5100 0 0 {name=l2101 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -5220 0 0 {name=x526}
C {devices/lab_wire.sym} 4500 -5340 2 1 {name=l2102 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -5350 1 1 {name=l2103 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -5350 3 0 {name=l2104 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -5100 0 0 {name=l2105 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -5220 0 0 {name=x527}
C {devices/lab_wire.sym} 4760 -5340 2 1 {name=l2106 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -5350 1 1 {name=l2107 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -5350 3 0 {name=l2108 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -5100 0 0 {name=l2109 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -5220 0 0 {name=x528}
C {devices/lab_wire.sym} 5020 -5340 2 1 {name=l2110 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -5350 1 1 {name=l2111 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -5350 3 0 {name=l2112 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -5100 0 0 {name=l2113 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -5220 0 0 {name=x529}
C {devices/lab_wire.sym} 5280 -5340 2 1 {name=l2114 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -5350 1 1 {name=l2115 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -5350 3 0 {name=l2116 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -5100 0 0 {name=l2117 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -5220 0 0 {name=x530}
C {devices/lab_wire.sym} 5540 -5340 2 1 {name=l2118 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -5350 1 1 {name=l2119 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -5350 3 0 {name=l2120 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -5100 0 0 {name=l2121 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -5220 0 0 {name=x531}
C {devices/lab_wire.sym} 5800 -5340 2 1 {name=l2122 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -5350 1 1 {name=l2123 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -5350 3 0 {name=l2124 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -5100 0 0 {name=l2125 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -5220 0 0 {name=x532}
C {devices/lab_wire.sym} 6060 -5340 2 1 {name=l2126 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -5350 1 1 {name=l2127 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -5350 3 0 {name=l2128 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -5100 0 0 {name=l2129 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -5220 0 0 {name=x533}
C {devices/lab_wire.sym} 6320 -5340 2 1 {name=l2130 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -5350 1 1 {name=l2131 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -5350 3 0 {name=l2132 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -5100 0 0 {name=l2133 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -5220 0 0 {name=x534}
C {devices/lab_wire.sym} 6580 -5340 2 1 {name=l2134 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -5350 1 1 {name=l2135 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -5350 3 0 {name=l2136 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -5100 0 0 {name=l2137 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -5220 0 0 {name=x535}
C {devices/lab_wire.sym} 6840 -5340 2 1 {name=l2138 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -5350 1 1 {name=l2139 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -5350 3 0 {name=l2140 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -5100 0 0 {name=l2141 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -5220 0 0 {name=x536}
C {devices/lab_wire.sym} 7100 -5340 2 1 {name=l2142 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -5350 1 1 {name=l2143 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -5350 3 0 {name=l2144 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -5100 0 0 {name=l2145 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -5220 0 0 {name=x537}
C {devices/lab_wire.sym} 7360 -5340 2 1 {name=l2146 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -5350 1 1 {name=l2147 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -5350 3 0 {name=l2148 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -5100 0 0 {name=l2149 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -5220 0 0 {name=x538}
C {devices/lab_wire.sym} 7620 -5340 2 1 {name=l2150 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -5350 1 1 {name=l2151 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -5350 3 0 {name=l2152 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -5100 0 0 {name=l2153 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -5220 0 0 {name=x539}
C {devices/lab_wire.sym} 7880 -5340 2 1 {name=l2154 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -5350 1 1 {name=l2155 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -5350 3 0 {name=l2156 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -5100 0 0 {name=l2157 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -5220 0 0 {name=x540}
C {devices/lab_wire.sym} 8140 -5340 2 1 {name=l2158 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -5350 1 1 {name=l2159 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -5350 3 0 {name=l2160 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -5100 0 0 {name=l2161 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -5220 0 0 {name=x541}
C {devices/lab_wire.sym} 8400 -5340 2 1 {name=l2162 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -5350 1 1 {name=l2163 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -5350 3 0 {name=l2164 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -5100 0 0 {name=l2165 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -5220 0 0 {name=x542}
C {devices/lab_wire.sym} 8660 -5340 2 1 {name=l2166 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -5350 1 1 {name=l2167 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -5350 3 0 {name=l2168 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -5100 0 0 {name=l2169 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -5220 0 0 {name=x543}
C {devices/lab_wire.sym} 8920 -5340 2 1 {name=l2170 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -5350 1 1 {name=l2171 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -5350 3 0 {name=l2172 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -5100 0 0 {name=l2173 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -5220 0 0 {name=x544}
C {devices/lab_wire.sym} 9180 -5340 2 1 {name=l2174 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -5350 1 1 {name=l2175 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -5350 3 0 {name=l2176 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -5100 0 0 {name=l2177 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -5480 0 0 {name=x545}
C {devices/lab_wire.sym} 1120 -5600 2 1 {name=l2178 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -5610 1 1 {name=l2179 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -5610 3 0 {name=l2180 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -5360 0 0 {name=l2181 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -5480 0 0 {name=x546}
C {devices/lab_wire.sym} 1380 -5600 2 1 {name=l2182 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -5610 1 1 {name=l2183 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -5610 3 0 {name=l2184 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -5360 0 0 {name=l2185 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -5480 0 0 {name=x547}
C {devices/lab_wire.sym} 1640 -5600 2 1 {name=l2186 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -5610 1 1 {name=l2187 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -5610 3 0 {name=l2188 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -5360 0 0 {name=l2189 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -5480 0 0 {name=x548}
C {devices/lab_wire.sym} 1900 -5600 2 1 {name=l2190 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -5610 1 1 {name=l2191 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -5610 3 0 {name=l2192 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -5360 0 0 {name=l2193 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -5480 0 0 {name=x549}
C {devices/lab_wire.sym} 2160 -5600 2 1 {name=l2194 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -5610 1 1 {name=l2195 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -5610 3 0 {name=l2196 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -5360 0 0 {name=l2197 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -5480 0 0 {name=x550}
C {devices/lab_wire.sym} 2420 -5600 2 1 {name=l2198 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -5610 1 1 {name=l2199 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -5610 3 0 {name=l2200 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -5360 0 0 {name=l2201 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -5480 0 0 {name=x551}
C {devices/lab_wire.sym} 2680 -5600 2 1 {name=l2202 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -5610 1 1 {name=l2203 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -5610 3 0 {name=l2204 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -5360 0 0 {name=l2205 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -5480 0 0 {name=x552}
C {devices/lab_wire.sym} 2940 -5600 2 1 {name=l2206 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -5610 1 1 {name=l2207 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -5610 3 0 {name=l2208 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -5360 0 0 {name=l2209 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -5480 0 0 {name=x553}
C {devices/lab_wire.sym} 3200 -5600 2 1 {name=l2210 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -5610 1 1 {name=l2211 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -5610 3 0 {name=l2212 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -5360 0 0 {name=l2213 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -5480 0 0 {name=x554}
C {devices/lab_wire.sym} 3460 -5600 2 1 {name=l2214 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -5610 1 1 {name=l2215 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -5610 3 0 {name=l2216 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -5360 0 0 {name=l2217 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -5480 0 0 {name=x555}
C {devices/lab_wire.sym} 3720 -5600 2 1 {name=l2218 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -5610 1 1 {name=l2219 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -5610 3 0 {name=l2220 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -5360 0 0 {name=l2221 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -5480 0 0 {name=x556}
C {devices/lab_wire.sym} 3980 -5600 2 1 {name=l2222 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -5610 1 1 {name=l2223 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -5610 3 0 {name=l2224 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -5360 0 0 {name=l2225 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -5480 0 0 {name=x557}
C {devices/lab_wire.sym} 4240 -5600 2 1 {name=l2226 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -5610 1 1 {name=l2227 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -5610 3 0 {name=l2228 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -5360 0 0 {name=l2229 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -5480 0 0 {name=x558}
C {devices/lab_wire.sym} 4500 -5600 2 1 {name=l2230 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -5610 1 1 {name=l2231 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -5610 3 0 {name=l2232 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -5360 0 0 {name=l2233 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -5480 0 0 {name=x559}
C {devices/lab_wire.sym} 4760 -5600 2 1 {name=l2234 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -5610 1 1 {name=l2235 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -5610 3 0 {name=l2236 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -5360 0 0 {name=l2237 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -5480 0 0 {name=x560}
C {devices/lab_wire.sym} 5020 -5600 2 1 {name=l2238 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -5610 1 1 {name=l2239 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -5610 3 0 {name=l2240 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -5360 0 0 {name=l2241 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -5480 0 0 {name=x561}
C {devices/lab_wire.sym} 5280 -5600 2 1 {name=l2242 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -5610 1 1 {name=l2243 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -5610 3 0 {name=l2244 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -5360 0 0 {name=l2245 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -5480 0 0 {name=x562}
C {devices/lab_wire.sym} 5540 -5600 2 1 {name=l2246 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -5610 1 1 {name=l2247 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -5610 3 0 {name=l2248 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -5360 0 0 {name=l2249 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -5480 0 0 {name=x563}
C {devices/lab_wire.sym} 5800 -5600 2 1 {name=l2250 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -5610 1 1 {name=l2251 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -5610 3 0 {name=l2252 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -5360 0 0 {name=l2253 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -5480 0 0 {name=x564}
C {devices/lab_wire.sym} 6060 -5600 2 1 {name=l2254 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -5610 1 1 {name=l2255 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -5610 3 0 {name=l2256 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -5360 0 0 {name=l2257 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -5480 0 0 {name=x565}
C {devices/lab_wire.sym} 6320 -5600 2 1 {name=l2258 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -5610 1 1 {name=l2259 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -5610 3 0 {name=l2260 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -5360 0 0 {name=l2261 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -5480 0 0 {name=x566}
C {devices/lab_wire.sym} 6580 -5600 2 1 {name=l2262 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -5610 1 1 {name=l2263 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -5610 3 0 {name=l2264 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -5360 0 0 {name=l2265 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -5480 0 0 {name=x567}
C {devices/lab_wire.sym} 6840 -5600 2 1 {name=l2266 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -5610 1 1 {name=l2267 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -5610 3 0 {name=l2268 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -5360 0 0 {name=l2269 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -5480 0 0 {name=x568}
C {devices/lab_wire.sym} 7100 -5600 2 1 {name=l2270 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -5610 1 1 {name=l2271 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -5610 3 0 {name=l2272 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -5360 0 0 {name=l2273 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -5480 0 0 {name=x569}
C {devices/lab_wire.sym} 7360 -5600 2 1 {name=l2274 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -5610 1 1 {name=l2275 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -5610 3 0 {name=l2276 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -5360 0 0 {name=l2277 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -5480 0 0 {name=x570}
C {devices/lab_wire.sym} 7620 -5600 2 1 {name=l2278 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -5610 1 1 {name=l2279 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -5610 3 0 {name=l2280 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -5360 0 0 {name=l2281 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -5480 0 0 {name=x571}
C {devices/lab_wire.sym} 7880 -5600 2 1 {name=l2282 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -5610 1 1 {name=l2283 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -5610 3 0 {name=l2284 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -5360 0 0 {name=l2285 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -5480 0 0 {name=x572}
C {devices/lab_wire.sym} 8140 -5600 2 1 {name=l2286 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -5610 1 1 {name=l2287 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -5610 3 0 {name=l2288 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -5360 0 0 {name=l2289 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -5480 0 0 {name=x573}
C {devices/lab_wire.sym} 8400 -5600 2 1 {name=l2290 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -5610 1 1 {name=l2291 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -5610 3 0 {name=l2292 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -5360 0 0 {name=l2293 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -5480 0 0 {name=x574}
C {devices/lab_wire.sym} 8660 -5600 2 1 {name=l2294 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -5610 1 1 {name=l2295 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -5610 3 0 {name=l2296 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -5360 0 0 {name=l2297 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -5480 0 0 {name=x575}
C {devices/lab_wire.sym} 8920 -5600 2 1 {name=l2298 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -5610 1 1 {name=l2299 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -5610 3 0 {name=l2300 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -5360 0 0 {name=l2301 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -5480 0 0 {name=x576}
C {devices/lab_wire.sym} 9180 -5600 2 1 {name=l2302 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -5610 1 1 {name=l2303 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -5610 3 0 {name=l2304 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -5360 0 0 {name=l2305 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -5740 0 0 {name=x577}
C {devices/lab_wire.sym} 1120 -5860 2 1 {name=l2306 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -5870 1 1 {name=l2307 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -5870 3 0 {name=l2308 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -5620 0 0 {name=l2309 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -5740 0 0 {name=x578}
C {devices/lab_wire.sym} 1380 -5860 2 1 {name=l2310 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -5870 1 1 {name=l2311 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -5870 3 0 {name=l2312 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -5620 0 0 {name=l2313 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -5740 0 0 {name=x579}
C {devices/lab_wire.sym} 1640 -5860 2 1 {name=l2314 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -5870 1 1 {name=l2315 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -5870 3 0 {name=l2316 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -5620 0 0 {name=l2317 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -5740 0 0 {name=x580}
C {devices/lab_wire.sym} 1900 -5860 2 1 {name=l2318 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -5870 1 1 {name=l2319 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -5870 3 0 {name=l2320 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -5620 0 0 {name=l2321 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -5740 0 0 {name=x581}
C {devices/lab_wire.sym} 2160 -5860 2 1 {name=l2322 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -5870 1 1 {name=l2323 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -5870 3 0 {name=l2324 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -5620 0 0 {name=l2325 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -5740 0 0 {name=x582}
C {devices/lab_wire.sym} 2420 -5860 2 1 {name=l2326 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -5870 1 1 {name=l2327 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -5870 3 0 {name=l2328 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -5620 0 0 {name=l2329 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -5740 0 0 {name=x583}
C {devices/lab_wire.sym} 2680 -5860 2 1 {name=l2330 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -5870 1 1 {name=l2331 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -5870 3 0 {name=l2332 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -5620 0 0 {name=l2333 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -5740 0 0 {name=x584}
C {devices/lab_wire.sym} 2940 -5860 2 1 {name=l2334 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -5870 1 1 {name=l2335 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -5870 3 0 {name=l2336 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -5620 0 0 {name=l2337 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -5740 0 0 {name=x585}
C {devices/lab_wire.sym} 3200 -5860 2 1 {name=l2338 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -5870 1 1 {name=l2339 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -5870 3 0 {name=l2340 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -5620 0 0 {name=l2341 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -5740 0 0 {name=x586}
C {devices/lab_wire.sym} 3460 -5860 2 1 {name=l2342 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -5870 1 1 {name=l2343 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -5870 3 0 {name=l2344 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -5620 0 0 {name=l2345 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -5740 0 0 {name=x587}
C {devices/lab_wire.sym} 3720 -5860 2 1 {name=l2346 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -5870 1 1 {name=l2347 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -5870 3 0 {name=l2348 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -5620 0 0 {name=l2349 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -5740 0 0 {name=x588}
C {devices/lab_wire.sym} 3980 -5860 2 1 {name=l2350 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -5870 1 1 {name=l2351 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -5870 3 0 {name=l2352 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -5620 0 0 {name=l2353 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -5740 0 0 {name=x589}
C {devices/lab_wire.sym} 4240 -5860 2 1 {name=l2354 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -5870 1 1 {name=l2355 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -5870 3 0 {name=l2356 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -5620 0 0 {name=l2357 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -5740 0 0 {name=x590}
C {devices/lab_wire.sym} 4500 -5860 2 1 {name=l2358 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -5870 1 1 {name=l2359 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -5870 3 0 {name=l2360 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -5620 0 0 {name=l2361 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -5740 0 0 {name=x591}
C {devices/lab_wire.sym} 4760 -5860 2 1 {name=l2362 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -5870 1 1 {name=l2363 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -5870 3 0 {name=l2364 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -5620 0 0 {name=l2365 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -5740 0 0 {name=x592}
C {devices/lab_wire.sym} 5020 -5860 2 1 {name=l2366 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -5870 1 1 {name=l2367 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -5870 3 0 {name=l2368 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -5620 0 0 {name=l2369 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -5740 0 0 {name=x593}
C {devices/lab_wire.sym} 5280 -5860 2 1 {name=l2370 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -5870 1 1 {name=l2371 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -5870 3 0 {name=l2372 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -5620 0 0 {name=l2373 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -5740 0 0 {name=x594}
C {devices/lab_wire.sym} 5540 -5860 2 1 {name=l2374 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -5870 1 1 {name=l2375 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -5870 3 0 {name=l2376 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -5620 0 0 {name=l2377 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -5740 0 0 {name=x595}
C {devices/lab_wire.sym} 5800 -5860 2 1 {name=l2378 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -5870 1 1 {name=l2379 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -5870 3 0 {name=l2380 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -5620 0 0 {name=l2381 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -5740 0 0 {name=x596}
C {devices/lab_wire.sym} 6060 -5860 2 1 {name=l2382 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -5870 1 1 {name=l2383 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -5870 3 0 {name=l2384 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -5620 0 0 {name=l2385 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -5740 0 0 {name=x597}
C {devices/lab_wire.sym} 6320 -5860 2 1 {name=l2386 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -5870 1 1 {name=l2387 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -5870 3 0 {name=l2388 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -5620 0 0 {name=l2389 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -5740 0 0 {name=x598}
C {devices/lab_wire.sym} 6580 -5860 2 1 {name=l2390 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -5870 1 1 {name=l2391 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -5870 3 0 {name=l2392 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -5620 0 0 {name=l2393 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -5740 0 0 {name=x599}
C {devices/lab_wire.sym} 6840 -5860 2 1 {name=l2394 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -5870 1 1 {name=l2395 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -5870 3 0 {name=l2396 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -5620 0 0 {name=l2397 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -5740 0 0 {name=x600}
C {devices/lab_wire.sym} 7100 -5860 2 1 {name=l2398 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -5870 1 1 {name=l2399 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -5870 3 0 {name=l2400 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -5620 0 0 {name=l2401 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -5740 0 0 {name=x601}
C {devices/lab_wire.sym} 7360 -5860 2 1 {name=l2402 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -5870 1 1 {name=l2403 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -5870 3 0 {name=l2404 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -5620 0 0 {name=l2405 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -5740 0 0 {name=x602}
C {devices/lab_wire.sym} 7620 -5860 2 1 {name=l2406 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -5870 1 1 {name=l2407 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -5870 3 0 {name=l2408 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -5620 0 0 {name=l2409 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -5740 0 0 {name=x603}
C {devices/lab_wire.sym} 7880 -5860 2 1 {name=l2410 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -5870 1 1 {name=l2411 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -5870 3 0 {name=l2412 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -5620 0 0 {name=l2413 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -5740 0 0 {name=x604}
C {devices/lab_wire.sym} 8140 -5860 2 1 {name=l2414 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -5870 1 1 {name=l2415 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -5870 3 0 {name=l2416 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -5620 0 0 {name=l2417 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -5740 0 0 {name=x605}
C {devices/lab_wire.sym} 8400 -5860 2 1 {name=l2418 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -5870 1 1 {name=l2419 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -5870 3 0 {name=l2420 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -5620 0 0 {name=l2421 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -5740 0 0 {name=x606}
C {devices/lab_wire.sym} 8660 -5860 2 1 {name=l2422 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -5870 1 1 {name=l2423 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -5870 3 0 {name=l2424 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -5620 0 0 {name=l2425 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -5740 0 0 {name=x607}
C {devices/lab_wire.sym} 8920 -5860 2 1 {name=l2426 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -5870 1 1 {name=l2427 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -5870 3 0 {name=l2428 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -5620 0 0 {name=l2429 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -5740 0 0 {name=x608}
C {devices/lab_wire.sym} 9180 -5860 2 1 {name=l2430 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -5870 1 1 {name=l2431 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -5870 3 0 {name=l2432 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -5620 0 0 {name=l2433 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -6000 0 0 {name=x609}
C {devices/lab_wire.sym} 1120 -6120 2 1 {name=l2434 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -6130 1 1 {name=l2435 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -6130 3 0 {name=l2436 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -5880 0 0 {name=l2437 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -6000 0 0 {name=x610}
C {devices/lab_wire.sym} 1380 -6120 2 1 {name=l2438 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -6130 1 1 {name=l2439 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -6130 3 0 {name=l2440 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -5880 0 0 {name=l2441 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -6000 0 0 {name=x611}
C {devices/lab_wire.sym} 1640 -6120 2 1 {name=l2442 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -6130 1 1 {name=l2443 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -6130 3 0 {name=l2444 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -5880 0 0 {name=l2445 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -6000 0 0 {name=x612}
C {devices/lab_wire.sym} 1900 -6120 2 1 {name=l2446 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -6130 1 1 {name=l2447 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -6130 3 0 {name=l2448 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -5880 0 0 {name=l2449 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -6000 0 0 {name=x613}
C {devices/lab_wire.sym} 2160 -6120 2 1 {name=l2450 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -6130 1 1 {name=l2451 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -6130 3 0 {name=l2452 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -5880 0 0 {name=l2453 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -6000 0 0 {name=x614}
C {devices/lab_wire.sym} 2420 -6120 2 1 {name=l2454 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -6130 1 1 {name=l2455 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -6130 3 0 {name=l2456 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -5880 0 0 {name=l2457 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -6000 0 0 {name=x615}
C {devices/lab_wire.sym} 2680 -6120 2 1 {name=l2458 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -6130 1 1 {name=l2459 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -6130 3 0 {name=l2460 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -5880 0 0 {name=l2461 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -6000 0 0 {name=x616}
C {devices/lab_wire.sym} 2940 -6120 2 1 {name=l2462 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -6130 1 1 {name=l2463 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -6130 3 0 {name=l2464 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -5880 0 0 {name=l2465 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -6000 0 0 {name=x617}
C {devices/lab_wire.sym} 3200 -6120 2 1 {name=l2466 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -6130 1 1 {name=l2467 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -6130 3 0 {name=l2468 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -5880 0 0 {name=l2469 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -6000 0 0 {name=x618}
C {devices/lab_wire.sym} 3460 -6120 2 1 {name=l2470 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -6130 1 1 {name=l2471 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -6130 3 0 {name=l2472 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -5880 0 0 {name=l2473 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -6000 0 0 {name=x619}
C {devices/lab_wire.sym} 3720 -6120 2 1 {name=l2474 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -6130 1 1 {name=l2475 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -6130 3 0 {name=l2476 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -5880 0 0 {name=l2477 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -6000 0 0 {name=x620}
C {devices/lab_wire.sym} 3980 -6120 2 1 {name=l2478 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -6130 1 1 {name=l2479 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -6130 3 0 {name=l2480 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -5880 0 0 {name=l2481 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -6000 0 0 {name=x621}
C {devices/lab_wire.sym} 4240 -6120 2 1 {name=l2482 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -6130 1 1 {name=l2483 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -6130 3 0 {name=l2484 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -5880 0 0 {name=l2485 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -6000 0 0 {name=x622}
C {devices/lab_wire.sym} 4500 -6120 2 1 {name=l2486 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -6130 1 1 {name=l2487 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -6130 3 0 {name=l2488 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -5880 0 0 {name=l2489 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -6000 0 0 {name=x623}
C {devices/lab_wire.sym} 4760 -6120 2 1 {name=l2490 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -6130 1 1 {name=l2491 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -6130 3 0 {name=l2492 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -5880 0 0 {name=l2493 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -6000 0 0 {name=x624}
C {devices/lab_wire.sym} 5020 -6120 2 1 {name=l2494 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -6130 1 1 {name=l2495 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -6130 3 0 {name=l2496 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -5880 0 0 {name=l2497 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -6000 0 0 {name=x625}
C {devices/lab_wire.sym} 5280 -6120 2 1 {name=l2498 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -6130 1 1 {name=l2499 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -6130 3 0 {name=l2500 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -5880 0 0 {name=l2501 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -6000 0 0 {name=x626}
C {devices/lab_wire.sym} 5540 -6120 2 1 {name=l2502 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -6130 1 1 {name=l2503 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -6130 3 0 {name=l2504 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -5880 0 0 {name=l2505 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -6000 0 0 {name=x627}
C {devices/lab_wire.sym} 5800 -6120 2 1 {name=l2506 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -6130 1 1 {name=l2507 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -6130 3 0 {name=l2508 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -5880 0 0 {name=l2509 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -6000 0 0 {name=x628}
C {devices/lab_wire.sym} 6060 -6120 2 1 {name=l2510 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -6130 1 1 {name=l2511 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -6130 3 0 {name=l2512 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -5880 0 0 {name=l2513 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -6000 0 0 {name=x629}
C {devices/lab_wire.sym} 6320 -6120 2 1 {name=l2514 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -6130 1 1 {name=l2515 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -6130 3 0 {name=l2516 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -5880 0 0 {name=l2517 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -6000 0 0 {name=x630}
C {devices/lab_wire.sym} 6580 -6120 2 1 {name=l2518 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -6130 1 1 {name=l2519 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -6130 3 0 {name=l2520 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -5880 0 0 {name=l2521 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -6000 0 0 {name=x631}
C {devices/lab_wire.sym} 6840 -6120 2 1 {name=l2522 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -6130 1 1 {name=l2523 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -6130 3 0 {name=l2524 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -5880 0 0 {name=l2525 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -6000 0 0 {name=x632}
C {devices/lab_wire.sym} 7100 -6120 2 1 {name=l2526 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -6130 1 1 {name=l2527 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -6130 3 0 {name=l2528 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -5880 0 0 {name=l2529 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -6000 0 0 {name=x633}
C {devices/lab_wire.sym} 7360 -6120 2 1 {name=l2530 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -6130 1 1 {name=l2531 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -6130 3 0 {name=l2532 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -5880 0 0 {name=l2533 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -6000 0 0 {name=x634}
C {devices/lab_wire.sym} 7620 -6120 2 1 {name=l2534 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -6130 1 1 {name=l2535 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -6130 3 0 {name=l2536 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -5880 0 0 {name=l2537 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -6000 0 0 {name=x635}
C {devices/lab_wire.sym} 7880 -6120 2 1 {name=l2538 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -6130 1 1 {name=l2539 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -6130 3 0 {name=l2540 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -5880 0 0 {name=l2541 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -6000 0 0 {name=x636}
C {devices/lab_wire.sym} 8140 -6120 2 1 {name=l2542 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -6130 1 1 {name=l2543 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -6130 3 0 {name=l2544 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -5880 0 0 {name=l2545 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -6000 0 0 {name=x637}
C {devices/lab_wire.sym} 8400 -6120 2 1 {name=l2546 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -6130 1 1 {name=l2547 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -6130 3 0 {name=l2548 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -5880 0 0 {name=l2549 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -6000 0 0 {name=x638}
C {devices/lab_wire.sym} 8660 -6120 2 1 {name=l2550 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -6130 1 1 {name=l2551 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -6130 3 0 {name=l2552 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -5880 0 0 {name=l2553 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -6000 0 0 {name=x639}
C {devices/lab_wire.sym} 8920 -6120 2 1 {name=l2554 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -6130 1 1 {name=l2555 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -6130 3 0 {name=l2556 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -5880 0 0 {name=l2557 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -6000 0 0 {name=x640}
C {devices/lab_wire.sym} 9180 -6120 2 1 {name=l2558 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -6130 1 1 {name=l2559 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -6130 3 0 {name=l2560 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -5880 0 0 {name=l2561 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -6260 0 0 {name=x641}
C {devices/lab_wire.sym} 1120 -6380 2 1 {name=l2562 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -6390 1 1 {name=l2563 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -6390 3 0 {name=l2564 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -6140 0 0 {name=l2565 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -6260 0 0 {name=x642}
C {devices/lab_wire.sym} 1380 -6380 2 1 {name=l2566 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -6390 1 1 {name=l2567 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -6390 3 0 {name=l2568 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -6140 0 0 {name=l2569 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -6260 0 0 {name=x643}
C {devices/lab_wire.sym} 1640 -6380 2 1 {name=l2570 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -6390 1 1 {name=l2571 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -6390 3 0 {name=l2572 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -6140 0 0 {name=l2573 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -6260 0 0 {name=x644}
C {devices/lab_wire.sym} 1900 -6380 2 1 {name=l2574 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -6390 1 1 {name=l2575 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -6390 3 0 {name=l2576 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -6140 0 0 {name=l2577 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -6260 0 0 {name=x645}
C {devices/lab_wire.sym} 2160 -6380 2 1 {name=l2578 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -6390 1 1 {name=l2579 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -6390 3 0 {name=l2580 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -6140 0 0 {name=l2581 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -6260 0 0 {name=x646}
C {devices/lab_wire.sym} 2420 -6380 2 1 {name=l2582 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -6390 1 1 {name=l2583 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -6390 3 0 {name=l2584 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -6140 0 0 {name=l2585 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -6260 0 0 {name=x647}
C {devices/lab_wire.sym} 2680 -6380 2 1 {name=l2586 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -6390 1 1 {name=l2587 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -6390 3 0 {name=l2588 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -6140 0 0 {name=l2589 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -6260 0 0 {name=x648}
C {devices/lab_wire.sym} 2940 -6380 2 1 {name=l2590 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -6390 1 1 {name=l2591 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -6390 3 0 {name=l2592 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -6140 0 0 {name=l2593 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -6260 0 0 {name=x649}
C {devices/lab_wire.sym} 3200 -6380 2 1 {name=l2594 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -6390 1 1 {name=l2595 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -6390 3 0 {name=l2596 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -6140 0 0 {name=l2597 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -6260 0 0 {name=x650}
C {devices/lab_wire.sym} 3460 -6380 2 1 {name=l2598 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -6390 1 1 {name=l2599 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -6390 3 0 {name=l2600 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -6140 0 0 {name=l2601 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -6260 0 0 {name=x651}
C {devices/lab_wire.sym} 3720 -6380 2 1 {name=l2602 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -6390 1 1 {name=l2603 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -6390 3 0 {name=l2604 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -6140 0 0 {name=l2605 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -6260 0 0 {name=x652}
C {devices/lab_wire.sym} 3980 -6380 2 1 {name=l2606 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -6390 1 1 {name=l2607 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -6390 3 0 {name=l2608 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -6140 0 0 {name=l2609 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -6260 0 0 {name=x653}
C {devices/lab_wire.sym} 4240 -6380 2 1 {name=l2610 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -6390 1 1 {name=l2611 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -6390 3 0 {name=l2612 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -6140 0 0 {name=l2613 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -6260 0 0 {name=x654}
C {devices/lab_wire.sym} 4500 -6380 2 1 {name=l2614 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -6390 1 1 {name=l2615 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -6390 3 0 {name=l2616 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -6140 0 0 {name=l2617 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -6260 0 0 {name=x655}
C {devices/lab_wire.sym} 4760 -6380 2 1 {name=l2618 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -6390 1 1 {name=l2619 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -6390 3 0 {name=l2620 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -6140 0 0 {name=l2621 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -6260 0 0 {name=x656}
C {devices/lab_wire.sym} 5020 -6380 2 1 {name=l2622 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -6390 1 1 {name=l2623 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -6390 3 0 {name=l2624 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -6140 0 0 {name=l2625 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -6260 0 0 {name=x657}
C {devices/lab_wire.sym} 5280 -6380 2 1 {name=l2626 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -6390 1 1 {name=l2627 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -6390 3 0 {name=l2628 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -6140 0 0 {name=l2629 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -6260 0 0 {name=x658}
C {devices/lab_wire.sym} 5540 -6380 2 1 {name=l2630 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -6390 1 1 {name=l2631 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -6390 3 0 {name=l2632 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -6140 0 0 {name=l2633 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -6260 0 0 {name=x659}
C {devices/lab_wire.sym} 5800 -6380 2 1 {name=l2634 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -6390 1 1 {name=l2635 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -6390 3 0 {name=l2636 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -6140 0 0 {name=l2637 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -6260 0 0 {name=x660}
C {devices/lab_wire.sym} 6060 -6380 2 1 {name=l2638 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -6390 1 1 {name=l2639 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -6390 3 0 {name=l2640 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -6140 0 0 {name=l2641 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -6260 0 0 {name=x661}
C {devices/lab_wire.sym} 6320 -6380 2 1 {name=l2642 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -6390 1 1 {name=l2643 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -6390 3 0 {name=l2644 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -6140 0 0 {name=l2645 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -6260 0 0 {name=x662}
C {devices/lab_wire.sym} 6580 -6380 2 1 {name=l2646 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -6390 1 1 {name=l2647 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -6390 3 0 {name=l2648 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -6140 0 0 {name=l2649 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -6260 0 0 {name=x663}
C {devices/lab_wire.sym} 6840 -6380 2 1 {name=l2650 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -6390 1 1 {name=l2651 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -6390 3 0 {name=l2652 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -6140 0 0 {name=l2653 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -6260 0 0 {name=x664}
C {devices/lab_wire.sym} 7100 -6380 2 1 {name=l2654 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -6390 1 1 {name=l2655 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -6390 3 0 {name=l2656 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -6140 0 0 {name=l2657 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -6260 0 0 {name=x665}
C {devices/lab_wire.sym} 7360 -6380 2 1 {name=l2658 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -6390 1 1 {name=l2659 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -6390 3 0 {name=l2660 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -6140 0 0 {name=l2661 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -6260 0 0 {name=x666}
C {devices/lab_wire.sym} 7620 -6380 2 1 {name=l2662 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -6390 1 1 {name=l2663 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -6390 3 0 {name=l2664 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -6140 0 0 {name=l2665 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -6260 0 0 {name=x667}
C {devices/lab_wire.sym} 7880 -6380 2 1 {name=l2666 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -6390 1 1 {name=l2667 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -6390 3 0 {name=l2668 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -6140 0 0 {name=l2669 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -6260 0 0 {name=x668}
C {devices/lab_wire.sym} 8140 -6380 2 1 {name=l2670 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -6390 1 1 {name=l2671 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -6390 3 0 {name=l2672 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -6140 0 0 {name=l2673 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -6260 0 0 {name=x669}
C {devices/lab_wire.sym} 8400 -6380 2 1 {name=l2674 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -6390 1 1 {name=l2675 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -6390 3 0 {name=l2676 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -6140 0 0 {name=l2677 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -6260 0 0 {name=x670}
C {devices/lab_wire.sym} 8660 -6380 2 1 {name=l2678 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -6390 1 1 {name=l2679 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -6390 3 0 {name=l2680 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -6140 0 0 {name=l2681 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -6260 0 0 {name=x671}
C {devices/lab_wire.sym} 8920 -6380 2 1 {name=l2682 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -6390 1 1 {name=l2683 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -6390 3 0 {name=l2684 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -6140 0 0 {name=l2685 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 9250 -6260 0 0 {name=x672}
C {devices/lab_wire.sym} 9180 -6380 2 1 {name=l2686 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -6390 1 1 {name=l2687 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -6390 3 0 {name=l2688 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -6140 0 0 {name=l2689 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1190 -6520 0 0 {name=x673}
C {devices/lab_wire.sym} 1120 -6640 2 1 {name=l2690 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -6650 1 1 {name=l2691 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -6650 3 0 {name=l2692 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -6400 0 0 {name=l2693 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1450 -6520 0 0 {name=x674}
C {devices/lab_wire.sym} 1380 -6640 2 1 {name=l2694 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -6650 1 1 {name=l2695 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -6650 3 0 {name=l2696 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -6400 0 0 {name=l2697 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1710 -6520 0 0 {name=x675}
C {devices/lab_wire.sym} 1640 -6640 2 1 {name=l2698 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -6650 1 1 {name=l2699 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -6650 3 0 {name=l2700 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -6400 0 0 {name=l2701 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 1970 -6520 0 0 {name=x676}
C {devices/lab_wire.sym} 1900 -6640 2 1 {name=l2702 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -6650 1 1 {name=l2703 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -6650 3 0 {name=l2704 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -6400 0 0 {name=l2705 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2230 -6520 0 0 {name=x677}
C {devices/lab_wire.sym} 2160 -6640 2 1 {name=l2706 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -6650 1 1 {name=l2707 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -6650 3 0 {name=l2708 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -6400 0 0 {name=l2709 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2490 -6520 0 0 {name=x678}
C {devices/lab_wire.sym} 2420 -6640 2 1 {name=l2710 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -6650 1 1 {name=l2711 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -6650 3 0 {name=l2712 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -6400 0 0 {name=l2713 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 2750 -6520 0 0 {name=x679}
C {devices/lab_wire.sym} 2680 -6640 2 1 {name=l2714 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -6650 1 1 {name=l2715 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -6650 3 0 {name=l2716 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -6400 0 0 {name=l2717 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3010 -6520 0 0 {name=x680}
C {devices/lab_wire.sym} 2940 -6640 2 1 {name=l2718 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -6650 1 1 {name=l2719 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -6650 3 0 {name=l2720 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -6400 0 0 {name=l2721 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3270 -6520 0 0 {name=x681}
C {devices/lab_wire.sym} 3200 -6640 2 1 {name=l2722 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -6650 1 1 {name=l2723 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -6650 3 0 {name=l2724 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -6400 0 0 {name=l2725 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3530 -6520 0 0 {name=x682}
C {devices/lab_wire.sym} 3460 -6640 2 1 {name=l2726 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -6650 1 1 {name=l2727 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -6650 3 0 {name=l2728 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -6400 0 0 {name=l2729 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 3790 -6520 0 0 {name=x683}
C {devices/lab_wire.sym} 3720 -6640 2 1 {name=l2730 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -6650 1 1 {name=l2731 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -6650 3 0 {name=l2732 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -6400 0 0 {name=l2733 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4050 -6520 0 0 {name=x684}
C {devices/lab_wire.sym} 3980 -6640 2 1 {name=l2734 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -6650 1 1 {name=l2735 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -6650 3 0 {name=l2736 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -6400 0 0 {name=l2737 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4310 -6520 0 0 {name=x685}
C {devices/lab_wire.sym} 4240 -6640 2 1 {name=l2738 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -6650 1 1 {name=l2739 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -6650 3 0 {name=l2740 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -6400 0 0 {name=l2741 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4570 -6520 0 0 {name=x686}
C {devices/lab_wire.sym} 4500 -6640 2 1 {name=l2742 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -6650 1 1 {name=l2743 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -6650 3 0 {name=l2744 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -6400 0 0 {name=l2745 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 4830 -6520 0 0 {name=x687}
C {devices/lab_wire.sym} 4760 -6640 2 1 {name=l2746 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -6650 1 1 {name=l2747 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -6650 3 0 {name=l2748 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -6400 0 0 {name=l2749 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5090 -6520 0 0 {name=x688}
C {devices/lab_wire.sym} 5020 -6640 2 1 {name=l2750 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -6650 1 1 {name=l2751 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -6650 3 0 {name=l2752 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -6400 0 0 {name=l2753 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5350 -6520 0 0 {name=x689}
C {devices/lab_wire.sym} 5280 -6640 2 1 {name=l2754 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -6650 1 1 {name=l2755 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -6650 3 0 {name=l2756 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -6400 0 0 {name=l2757 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5610 -6520 0 0 {name=x690}
C {devices/lab_wire.sym} 5540 -6640 2 1 {name=l2758 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -6650 1 1 {name=l2759 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -6650 3 0 {name=l2760 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -6400 0 0 {name=l2761 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 5870 -6520 0 0 {name=x691}
C {devices/lab_wire.sym} 5800 -6640 2 1 {name=l2762 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -6650 1 1 {name=l2763 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -6650 3 0 {name=l2764 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -6400 0 0 {name=l2765 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6130 -6520 0 0 {name=x692}
C {devices/lab_wire.sym} 6060 -6640 2 1 {name=l2766 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -6650 1 1 {name=l2767 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -6650 3 0 {name=l2768 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -6400 0 0 {name=l2769 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6390 -6520 0 0 {name=x693}
C {devices/lab_wire.sym} 6320 -6640 2 1 {name=l2770 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -6650 1 1 {name=l2771 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -6650 3 0 {name=l2772 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -6400 0 0 {name=l2773 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6650 -6520 0 0 {name=x694}
C {devices/lab_wire.sym} 6580 -6640 2 1 {name=l2774 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -6650 1 1 {name=l2775 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -6650 3 0 {name=l2776 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -6400 0 0 {name=l2777 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 6910 -6520 0 0 {name=x695}
C {devices/lab_wire.sym} 6840 -6640 2 1 {name=l2778 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -6650 1 1 {name=l2779 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -6650 3 0 {name=l2780 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -6400 0 0 {name=l2781 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7170 -6520 0 0 {name=x696}
C {devices/lab_wire.sym} 7100 -6640 2 1 {name=l2782 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -6650 1 1 {name=l2783 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -6650 3 0 {name=l2784 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -6400 0 0 {name=l2785 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7430 -6520 0 0 {name=x697}
C {devices/lab_wire.sym} 7360 -6640 2 1 {name=l2786 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -6650 1 1 {name=l2787 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -6650 3 0 {name=l2788 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -6400 0 0 {name=l2789 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7690 -6520 0 0 {name=x698}
C {devices/lab_wire.sym} 7620 -6640 2 1 {name=l2790 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -6650 1 1 {name=l2791 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -6650 3 0 {name=l2792 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -6400 0 0 {name=l2793 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 7950 -6520 0 0 {name=x699}
C {devices/lab_wire.sym} 7880 -6640 2 1 {name=l2794 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -6650 1 1 {name=l2795 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -6650 3 0 {name=l2796 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -6400 0 0 {name=l2797 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8210 -6520 0 0 {name=x700}
C {devices/lab_wire.sym} 8140 -6640 2 1 {name=l2798 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -6650 1 1 {name=l2799 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -6650 3 0 {name=l2800 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -6400 0 0 {name=l2801 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8470 -6520 0 0 {name=x701}
C {devices/lab_wire.sym} 8400 -6640 2 1 {name=l2802 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -6650 1 1 {name=l2803 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -6650 3 0 {name=l2804 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -6400 0 0 {name=l2805 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8730 -6520 0 0 {name=x702}
C {devices/lab_wire.sym} 8660 -6640 2 1 {name=l2806 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -6650 1 1 {name=l2807 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -6650 3 0 {name=l2808 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -6400 0 0 {name=l2809 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap_150n/adc_array_cap.sym} 8990 -6520 0 0 {name=x703}
C {devices/lab_wire.sym} 8920 -6640 2 1 {name=l2810 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -6650 1 1 {name=l2811 sig_type=std_logic lab=vcom}
