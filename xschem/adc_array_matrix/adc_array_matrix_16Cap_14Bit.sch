N 1300 -3930 1320 -3930 {
lab=colon_n[11]}
N 1300 -3950 1320 -3950 {
lab=col_n[11]}
N 1120 -3810 1120 -3800 {
lab=VSS}
N 1120 -4040 1120 -4030 {
lab=VDD}
N 1460 -3810 1470 -3820 {
lab=row_n[1]}
N 1470 -4020 1470 -3820 {
lab=row_n[1]}
N 1460 -4030 1470 -4020 {
lab=row_n[1]}
N 1460 -3810 1460 -3790 {
lab=row_n[1]}
N 1460 -4050 1460 -4030 {
lab=row_n[1]}
N 1340 -3950 1350 -3960 {
lab=col_n[11]}
N 1350 -3960 1550 -3960 {
lab=col_n[11]}
N 1550 -3960 1560 -3950 {
lab=col_n[11]}
N 1340 -3930 1350 -3940 {
lab=colon_n[11]}
N 1350 -3940 1550 -3940 {
lab=colon_n[11]}
N 1550 -3940 1560 -3930 {
lab=colon_n[11]}
N 1340 -3910 1350 -3920 {
lab=#net23}
N 1350 -3920 1550 -3920 {
lab=#net23}
N 1550 -3920 1560 -3910 {
lab=#net23}
N 1340 -3890 1350 -3900 {
lab=#net24}
N 1350 -3900 1550 -3900 {
lab=#net24}
N 1550 -3900 1560 -3890 {
lab=#net24}
N 1400 -4050 1400 -4030 {
lab=vcom}
N 1440 -4050 1440 -4030 {
lab=ctop}
N 1320 -3950 1340 -3950 {
lab=col_n[11]}
N 1320 -3930 1340 -3930 {
lab=colon_n[11]}
N 1320 -3910 1340 -3910 {
lab=#net23}
N 1320 -3890 1340 -3890 {
lab=#net24}
N 1560 -3890 1580 -3890 {
lab=#net24}
N 1560 -3910 1580 -3910 {
lab=#net23}
N 1560 -3930 1580 -3930 {
lab=colon_n[11]}
N 1560 -3950 1580 -3950 {
lab=col_n[11]}
N 1380 -3810 1380 -3800 {
lab=VSS}
N 1380 -4040 1380 -4030 {
lab=VDD}
N 1720 -3810 1730 -3820 {
lab=row_n[2]}
N 1730 -4020 1730 -3820 {
lab=row_n[2]}
N 1720 -4030 1730 -4020 {
lab=row_n[2]}
N 1720 -3810 1720 -3790 {
lab=row_n[2]}
N 1720 -4050 1720 -4030 {
lab=row_n[2]}
N 1600 -3950 1610 -3960 {
lab=col_n[11]}
N 1610 -3960 1810 -3960 {
lab=col_n[11]}
N 1810 -3960 1820 -3950 {
lab=col_n[11]}
N 1600 -3930 1610 -3940 {
lab=colon_n[11]}
N 1610 -3940 1810 -3940 {
lab=colon_n[11]}
N 1810 -3940 1820 -3930 {
lab=colon_n[11]}
N 1600 -3910 1610 -3920 {
lab=#net23}
N 1610 -3920 1810 -3920 {
lab=#net23}
N 1810 -3920 1820 -3910 {
lab=#net23}
N 1600 -3890 1610 -3900 {
lab=#net24}
N 1610 -3900 1810 -3900 {
lab=#net24}
N 1810 -3900 1820 -3890 {
lab=#net24}
N 1660 -4050 1660 -4030 {
lab=vcom}
N 1700 -4050 1700 -4030 {
lab=ctop}
N 1580 -3950 1600 -3950 {
lab=col_n[11]}
N 1580 -3930 1600 -3930 {
lab=colon_n[11]}
N 1580 -3910 1600 -3910 {
lab=#net23}
N 1580 -3890 1600 -3890 {
lab=#net24}
N 1820 -3890 1840 -3890 {
lab=#net24}
N 1820 -3910 1840 -3910 {
lab=#net23}
N 1820 -3930 1840 -3930 {
lab=colon_n[11]}
N 1820 -3950 1840 -3950 {
lab=col_n[11]}
N 1640 -3810 1640 -3800 {
lab=VSS}
N 1640 -4040 1640 -4030 {
lab=VDD}
N 1980 -3810 1990 -3820 {
lab=row_n[3]}
N 1990 -4020 1990 -3820 {
lab=row_n[3]}
N 1980 -4030 1990 -4020 {
lab=row_n[3]}
N 1980 -3810 1980 -3790 {
lab=row_n[3]}
N 1980 -4050 1980 -4030 {
lab=row_n[3]}
N 1860 -3950 1870 -3960 {
lab=col_n[11]}
N 1870 -3960 2070 -3960 {
lab=col_n[11]}
N 2070 -3960 2080 -3950 {
lab=col_n[11]}
N 1860 -3930 1870 -3940 {
lab=colon_n[11]}
N 1870 -3940 2070 -3940 {
lab=colon_n[11]}
N 2070 -3940 2080 -3930 {
lab=colon_n[11]}
N 1860 -3910 1870 -3920 {
lab=#net23}
N 1870 -3920 2070 -3920 {
lab=#net23}
N 2070 -3920 2080 -3910 {
lab=#net23}
N 1860 -3890 1870 -3900 {
lab=#net24}
N 1870 -3900 2070 -3900 {
lab=#net24}
N 2070 -3900 2080 -3890 {
lab=#net24}
N 1920 -4050 1920 -4030 {
lab=vcom}
N 1960 -4050 1960 -4030 {
lab=ctop}
N 1840 -3950 1860 -3950 {
lab=col_n[11]}
N 1840 -3930 1860 -3930 {
lab=colon_n[11]}
N 1840 -3910 1860 -3910 {
lab=#net23}
N 1840 -3890 1860 -3890 {
lab=#net24}
N 2080 -3890 2100 -3890 {
lab=#net24}
N 2080 -3910 2100 -3910 {
lab=#net23}
N 2080 -3930 2100 -3930 {
lab=colon_n[11]}
N 2080 -3950 2100 -3950 {
lab=col_n[11]}
N 1900 -3810 1900 -3800 {
lab=VSS}
N 1900 -4040 1900 -4030 {
lab=VDD}
N 2240 -3810 2250 -3820 {
lab=row_n[4]}
N 2250 -4020 2250 -3820 {
lab=row_n[4]}
N 2240 -4030 2250 -4020 {
lab=row_n[4]}
N 2240 -3810 2240 -3790 {
lab=row_n[4]}
N 2240 -4050 2240 -4030 {
lab=row_n[4]}
N 2120 -3950 2130 -3960 {
lab=col_n[11]}
N 2130 -3960 2330 -3960 {
lab=col_n[11]}
N 2330 -3960 2340 -3950 {
lab=col_n[11]}
N 2120 -3930 2130 -3940 {
lab=colon_n[11]}
N 2130 -3940 2330 -3940 {
lab=colon_n[11]}
N 2330 -3940 2340 -3930 {
lab=colon_n[11]}
N 2120 -3910 2130 -3920 {
lab=#net23}
N 2130 -3920 2330 -3920 {
lab=#net23}
N 2330 -3920 2340 -3910 {
lab=#net23}
N 2120 -3890 2130 -3900 {
lab=#net24}
N 2130 -3900 2330 -3900 {
lab=#net24}
N 2330 -3900 2340 -3890 {
lab=#net24}
N 2180 -4050 2180 -4030 {
lab=vcom}
N 2220 -4050 2220 -4030 {
lab=ctop}
N 2100 -3950 2120 -3950 {
lab=col_n[11]}
N 2100 -3930 2120 -3930 {
lab=colon_n[11]}
N 2100 -3910 2120 -3910 {
lab=#net23}
N 2100 -3890 2120 -3890 {
lab=#net24}
N 2340 -3890 2360 -3890 {
lab=#net24}
N 2340 -3910 2360 -3910 {
lab=#net23}
N 2340 -3930 2360 -3930 {
lab=colon_n[11]}
N 2340 -3950 2360 -3950 {
lab=col_n[11]}
N 2160 -3810 2160 -3800 {
lab=VSS}
N 2160 -4040 2160 -4030 {
lab=VDD}
N 2500 -3810 2510 -3820 {
lab=row_n[5]}
N 2510 -4020 2510 -3820 {
lab=row_n[5]}
N 2500 -4030 2510 -4020 {
lab=row_n[5]}
N 2500 -3810 2500 -3790 {
lab=row_n[5]}
N 2500 -4050 2500 -4030 {
lab=row_n[5]}
N 2380 -3950 2390 -3960 {
lab=col_n[11]}
N 2390 -3960 2590 -3960 {
lab=col_n[11]}
N 2590 -3960 2600 -3950 {
lab=col_n[11]}
N 2380 -3930 2390 -3940 {
lab=colon_n[11]}
N 2390 -3940 2590 -3940 {
lab=colon_n[11]}
N 2590 -3940 2600 -3930 {
lab=colon_n[11]}
N 2380 -3910 2390 -3920 {
lab=#net23}
N 2390 -3920 2590 -3920 {
lab=#net23}
N 2590 -3920 2600 -3910 {
lab=#net23}
N 2380 -3890 2390 -3900 {
lab=#net24}
N 2390 -3900 2590 -3900 {
lab=#net24}
N 2590 -3900 2600 -3890 {
lab=#net24}
N 2440 -4050 2440 -4030 {
lab=vcom}
N 2480 -4050 2480 -4030 {
lab=ctop}
N 2360 -3950 2380 -3950 {
lab=col_n[11]}
N 2360 -3930 2380 -3930 {
lab=colon_n[11]}
N 2360 -3910 2380 -3910 {
lab=#net23}
N 2360 -3890 2380 -3890 {
lab=#net24}
N 2600 -3890 2620 -3890 {
lab=#net24}
N 2600 -3910 2620 -3910 {
lab=#net23}
N 2600 -3930 2620 -3930 {
lab=colon_n[11]}
N 2600 -3950 2620 -3950 {
lab=col_n[11]}
N 2420 -3810 2420 -3800 {
lab=VSS}
N 2420 -4040 2420 -4030 {
lab=VDD}
N 2760 -3810 2770 -3820 {
lab=row_n[6]}
N 2770 -4020 2770 -3820 {
lab=row_n[6]}
N 2760 -4030 2770 -4020 {
lab=row_n[6]}
N 2760 -3810 2760 -3790 {
lab=row_n[6]}
N 2760 -4050 2760 -4030 {
lab=row_n[6]}
N 2640 -3950 2650 -3960 {
lab=col_n[11]}
N 2650 -3960 2850 -3960 {
lab=col_n[11]}
N 2850 -3960 2860 -3950 {
lab=col_n[11]}
N 2640 -3930 2650 -3940 {
lab=colon_n[11]}
N 2650 -3940 2850 -3940 {
lab=colon_n[11]}
N 2850 -3940 2860 -3930 {
lab=colon_n[11]}
N 2640 -3910 2650 -3920 {
lab=#net23}
N 2650 -3920 2850 -3920 {
lab=#net23}
N 2850 -3920 2860 -3910 {
lab=#net23}
N 2640 -3890 2650 -3900 {
lab=#net24}
N 2650 -3900 2850 -3900 {
lab=#net24}
N 2850 -3900 2860 -3890 {
lab=#net24}
N 2700 -4050 2700 -4030 {
lab=vcom}
N 2740 -4050 2740 -4030 {
lab=ctop}
N 2620 -3950 2640 -3950 {
lab=col_n[11]}
N 2620 -3930 2640 -3930 {
lab=colon_n[11]}
N 2620 -3910 2640 -3910 {
lab=#net23}
N 2620 -3890 2640 -3890 {
lab=#net24}
N 2860 -3890 2880 -3890 {
lab=#net24}
N 2860 -3910 2880 -3910 {
lab=#net23}
N 2860 -3930 2880 -3930 {
lab=colon_n[11]}
N 2860 -3950 2880 -3950 {
lab=col_n[11]}
N 2680 -3810 2680 -3800 {
lab=VSS}
N 2680 -4040 2680 -4030 {
lab=VDD}
N 3020 -3810 3030 -3820 {
lab=row_n[7]}
N 3030 -4020 3030 -3820 {
lab=row_n[7]}
N 3020 -4030 3030 -4020 {
lab=row_n[7]}
N 3020 -3810 3020 -3790 {
lab=row_n[7]}
N 3020 -4050 3020 -4030 {
lab=row_n[7]}
N 2900 -3950 2910 -3960 {
lab=col_n[11]}
N 2910 -3960 3110 -3960 {
lab=col_n[11]}
N 3110 -3960 3120 -3950 {
lab=col_n[11]}
N 2900 -3930 2910 -3940 {
lab=colon_n[11]}
N 2910 -3940 3110 -3940 {
lab=colon_n[11]}
N 3110 -3940 3120 -3930 {
lab=colon_n[11]}
N 2900 -3910 2910 -3920 {
lab=#net23}
N 2910 -3920 3110 -3920 {
lab=#net23}
N 3110 -3920 3120 -3910 {
lab=#net23}
N 2900 -3890 2910 -3900 {
lab=#net24}
N 2910 -3900 3110 -3900 {
lab=#net24}
N 3110 -3900 3120 -3890 {
lab=#net24}
N 2960 -4050 2960 -4030 {
lab=vcom}
N 3000 -4050 3000 -4030 {
lab=ctop}
N 2880 -3950 2900 -3950 {
lab=col_n[11]}
N 2880 -3930 2900 -3930 {
lab=colon_n[11]}
N 2880 -3910 2900 -3910 {
lab=#net23}
N 2880 -3890 2900 -3890 {
lab=#net24}
N 3120 -3890 3140 -3890 {
lab=#net24}
N 3120 -3910 3140 -3910 {
lab=#net23}
N 3120 -3930 3140 -3930 {
lab=colon_n[11]}
N 3120 -3950 3140 -3950 {
lab=col_n[11]}
N 2940 -3810 2940 -3800 {
lab=VSS}
N 2940 -4040 2940 -4030 {
lab=VDD}
N 3280 -3810 3290 -3820 {
lab=row_n[8]}
N 3290 -4020 3290 -3820 {
lab=row_n[8]}
N 3280 -4030 3290 -4020 {
lab=row_n[8]}
N 3280 -3810 3280 -3790 {
lab=row_n[8]}
N 3280 -4050 3280 -4030 {
lab=row_n[8]}
N 3160 -3950 3170 -3960 {
lab=col_n[11]}
N 3170 -3960 3370 -3960 {
lab=col_n[11]}
N 3370 -3960 3380 -3950 {
lab=col_n[11]}
N 3160 -3930 3170 -3940 {
lab=colon_n[11]}
N 3170 -3940 3370 -3940 {
lab=colon_n[11]}
N 3370 -3940 3380 -3930 {
lab=colon_n[11]}
N 3160 -3910 3170 -3920 {
lab=#net23}
N 3170 -3920 3370 -3920 {
lab=#net23}
N 3370 -3920 3380 -3910 {
lab=#net23}
N 3160 -3890 3170 -3900 {
lab=#net24}
N 3170 -3900 3370 -3900 {
lab=#net24}
N 3370 -3900 3380 -3890 {
lab=#net24}
N 3220 -4050 3220 -4030 {
lab=vcom}
N 3260 -4050 3260 -4030 {
lab=ctop}
N 3140 -3950 3160 -3950 {
lab=col_n[11]}
N 3140 -3930 3160 -3930 {
lab=colon_n[11]}
N 3140 -3910 3160 -3910 {
lab=#net23}
N 3140 -3890 3160 -3890 {
lab=#net24}
N 3380 -3890 3400 -3890 {
lab=#net24}
N 3380 -3910 3400 -3910 {
lab=#net23}
N 3380 -3930 3400 -3930 {
lab=colon_n[11]}
N 3380 -3950 3400 -3950 {
lab=col_n[11]}
N 3200 -3810 3200 -3800 {
lab=VSS}
N 3200 -4040 3200 -4030 {
lab=VDD}
N 3540 -3810 3550 -3820 {
lab=row_n[9]}
N 3550 -4020 3550 -3820 {
lab=row_n[9]}
N 3540 -4030 3550 -4020 {
lab=row_n[9]}
N 3540 -3810 3540 -3790 {
lab=row_n[9]}
N 3540 -4050 3540 -4030 {
lab=row_n[9]}
N 3420 -3950 3430 -3960 {
lab=col_n[11]}
N 3430 -3960 3630 -3960 {
lab=col_n[11]}
N 3630 -3960 3640 -3950 {
lab=col_n[11]}
N 3420 -3930 3430 -3940 {
lab=colon_n[11]}
N 3430 -3940 3630 -3940 {
lab=colon_n[11]}
N 3630 -3940 3640 -3930 {
lab=colon_n[11]}
N 3420 -3910 3430 -3920 {
lab=#net23}
N 3430 -3920 3630 -3920 {
lab=#net23}
N 3630 -3920 3640 -3910 {
lab=#net23}
N 3420 -3890 3430 -3900 {
lab=#net24}
N 3430 -3900 3630 -3900 {
lab=#net24}
N 3630 -3900 3640 -3890 {
lab=#net24}
N 3480 -4050 3480 -4030 {
lab=vcom}
N 3520 -4050 3520 -4030 {
lab=ctop}
N 3400 -3950 3420 -3950 {
lab=col_n[11]}
N 3400 -3930 3420 -3930 {
lab=colon_n[11]}
N 3400 -3910 3420 -3910 {
lab=#net23}
N 3400 -3890 3420 -3890 {
lab=#net24}
N 3640 -3890 3660 -3890 {
lab=#net24}
N 3640 -3910 3660 -3910 {
lab=#net23}
N 3640 -3930 3660 -3930 {
lab=colon_n[11]}
N 3640 -3950 3660 -3950 {
lab=col_n[11]}
N 3460 -3810 3460 -3800 {
lab=VSS}
N 3460 -4040 3460 -4030 {
lab=VDD}
N 3800 -3810 3810 -3820 {
lab=row_n[10]}
N 3810 -4020 3810 -3820 {
lab=row_n[10]}
N 3800 -4030 3810 -4020 {
lab=row_n[10]}
N 3800 -3810 3800 -3790 {
lab=row_n[10]}
N 3800 -4050 3800 -4030 {
lab=row_n[10]}
N 3680 -3950 3690 -3960 {
lab=col_n[11]}
N 3690 -3960 3890 -3960 {
lab=col_n[11]}
N 3890 -3960 3900 -3950 {
lab=col_n[11]}
N 3680 -3930 3690 -3940 {
lab=colon_n[11]}
N 3690 -3940 3890 -3940 {
lab=colon_n[11]}
N 3890 -3940 3900 -3930 {
lab=colon_n[11]}
N 3680 -3910 3690 -3920 {
lab=#net23}
N 3690 -3920 3890 -3920 {
lab=#net23}
N 3890 -3920 3900 -3910 {
lab=#net23}
N 3680 -3890 3690 -3900 {
lab=#net24}
N 3690 -3900 3890 -3900 {
lab=#net24}
N 3890 -3900 3900 -3890 {
lab=#net24}
N 3740 -4050 3740 -4030 {
lab=vcom}
N 3780 -4050 3780 -4030 {
lab=ctop}
N 3660 -3950 3680 -3950 {
lab=col_n[11]}
N 3660 -3930 3680 -3930 {
lab=colon_n[11]}
N 3660 -3910 3680 -3910 {
lab=#net23}
N 3660 -3890 3680 -3890 {
lab=#net24}
N 3900 -3890 3920 -3890 {
lab=#net24}
N 3900 -3910 3920 -3910 {
lab=#net23}
N 3900 -3930 3920 -3930 {
lab=colon_n[11]}
N 3900 -3950 3920 -3950 {
lab=col_n[11]}
N 3720 -3810 3720 -3800 {
lab=VSS}
N 3720 -4040 3720 -4030 {
lab=VDD}
N 4060 -3810 4070 -3820 {
lab=row_n[11]}
N 4070 -4020 4070 -3820 {
lab=row_n[11]}
N 4060 -4030 4070 -4020 {
lab=row_n[11]}
N 4060 -3810 4060 -3790 {
lab=row_n[11]}
N 4060 -4050 4060 -4030 {
lab=row_n[11]}
N 3940 -3950 3950 -3960 {
lab=col_n[11]}
N 3950 -3960 4150 -3960 {
lab=col_n[11]}
N 4150 -3960 4160 -3950 {
lab=col_n[11]}
N 3940 -3930 3950 -3940 {
lab=colon_n[11]}
N 3950 -3940 4150 -3940 {
lab=colon_n[11]}
N 4150 -3940 4160 -3930 {
lab=colon_n[11]}
N 3940 -3910 3950 -3920 {
lab=#net23}
N 3950 -3920 4150 -3920 {
lab=#net23}
N 4150 -3920 4160 -3910 {
lab=#net23}
N 3940 -3890 3950 -3900 {
lab=#net24}
N 3950 -3900 4150 -3900 {
lab=#net24}
N 4150 -3900 4160 -3890 {
lab=#net24}
N 4000 -4050 4000 -4030 {
lab=vcom}
N 4040 -4050 4040 -4030 {
lab=ctop}
N 3920 -3950 3940 -3950 {
lab=col_n[11]}
N 3920 -3930 3940 -3930 {
lab=colon_n[11]}
N 3920 -3910 3940 -3910 {
lab=#net23}
N 3920 -3890 3940 -3890 {
lab=#net24}
N 4160 -3890 4180 -3890 {
lab=#net24}
N 4160 -3910 4180 -3910 {
lab=#net23}
N 4160 -3930 4180 -3930 {
lab=colon_n[11]}
N 4160 -3950 4180 -3950 {
lab=col_n[11]}
N 3980 -3810 3980 -3800 {
lab=VSS}
N 3980 -4040 3980 -4030 {
lab=VDD}
N 4320 -3810 4330 -3820 {
lab=row_n[12]}
N 4330 -4020 4330 -3820 {
lab=row_n[12]}
N 4320 -4030 4330 -4020 {
lab=row_n[12]}
N 4320 -3810 4320 -3790 {
lab=row_n[12]}
N 4320 -4050 4320 -4030 {
lab=row_n[12]}
N 4200 -3950 4210 -3960 {
lab=col_n[11]}
N 4210 -3960 4410 -3960 {
lab=col_n[11]}
N 4410 -3960 4420 -3950 {
lab=col_n[11]}
N 4200 -3930 4210 -3940 {
lab=colon_n[11]}
N 4210 -3940 4410 -3940 {
lab=colon_n[11]}
N 4410 -3940 4420 -3930 {
lab=colon_n[11]}
N 4200 -3910 4210 -3920 {
lab=#net23}
N 4210 -3920 4410 -3920 {
lab=#net23}
N 4410 -3920 4420 -3910 {
lab=#net23}
N 4200 -3890 4210 -3900 {
lab=#net24}
N 4210 -3900 4410 -3900 {
lab=#net24}
N 4410 -3900 4420 -3890 {
lab=#net24}
N 4260 -4050 4260 -4030 {
lab=vcom}
N 4300 -4050 4300 -4030 {
lab=ctop}
N 4180 -3950 4200 -3950 {
lab=col_n[11]}
N 4180 -3930 4200 -3930 {
lab=colon_n[11]}
N 4180 -3910 4200 -3910 {
lab=#net23}
N 4180 -3890 4200 -3890 {
lab=#net24}
N 4420 -3890 4440 -3890 {
lab=#net24}
N 4420 -3910 4440 -3910 {
lab=#net23}
N 4420 -3930 4440 -3930 {
lab=colon_n[11]}
N 4420 -3950 4440 -3950 {
lab=col_n[11]}
N 4240 -3810 4240 -3800 {
lab=VSS}
N 4240 -4040 4240 -4030 {
lab=VDD}
N 4580 -3810 4590 -3820 {
lab=row_n[13]}
N 4590 -4020 4590 -3820 {
lab=row_n[13]}
N 4580 -4030 4590 -4020 {
lab=row_n[13]}
N 4580 -3810 4580 -3790 {
lab=row_n[13]}
N 4580 -4050 4580 -4030 {
lab=row_n[13]}
N 4460 -3950 4470 -3960 {
lab=col_n[11]}
N 4470 -3960 4670 -3960 {
lab=col_n[11]}
N 4670 -3960 4680 -3950 {
lab=col_n[11]}
N 4460 -3930 4470 -3940 {
lab=colon_n[11]}
N 4470 -3940 4670 -3940 {
lab=colon_n[11]}
N 4670 -3940 4680 -3930 {
lab=colon_n[11]}
N 4460 -3910 4470 -3920 {
lab=#net23}
N 4470 -3920 4670 -3920 {
lab=#net23}
N 4670 -3920 4680 -3910 {
lab=#net23}
N 4460 -3890 4470 -3900 {
lab=#net24}
N 4470 -3900 4670 -3900 {
lab=#net24}
N 4670 -3900 4680 -3890 {
lab=#net24}
N 4520 -4050 4520 -4030 {
lab=vcom}
N 4560 -4050 4560 -4030 {
lab=ctop}
N 4440 -3950 4460 -3950 {
lab=col_n[11]}
N 4440 -3930 4460 -3930 {
lab=colon_n[11]}
N 4440 -3910 4460 -3910 {
lab=#net23}
N 4440 -3890 4460 -3890 {
lab=#net24}
N 4680 -3890 4700 -3890 {
lab=#net24}
N 4680 -3910 4700 -3910 {
lab=#net23}
N 4680 -3930 4700 -3930 {
lab=colon_n[11]}
N 4680 -3950 4700 -3950 {
lab=col_n[11]}
N 4500 -3810 4500 -3800 {
lab=VSS}
N 4500 -4040 4500 -4030 {
lab=VDD}
N 4840 -3810 4850 -3820 {
lab=row_n[14]}
N 4850 -4020 4850 -3820 {
lab=row_n[14]}
N 4840 -4030 4850 -4020 {
lab=row_n[14]}
N 4840 -3810 4840 -3790 {
lab=row_n[14]}
N 4840 -4050 4840 -4030 {
lab=row_n[14]}
N 4720 -3950 4730 -3960 {
lab=col_n[11]}
N 4730 -3960 4930 -3960 {
lab=col_n[11]}
N 4930 -3960 4940 -3950 {
lab=col_n[11]}
N 4720 -3930 4730 -3940 {
lab=colon_n[11]}
N 4730 -3940 4930 -3940 {
lab=colon_n[11]}
N 4930 -3940 4940 -3930 {
lab=colon_n[11]}
N 4720 -3910 4730 -3920 {
lab=#net23}
N 4730 -3920 4930 -3920 {
lab=#net23}
N 4930 -3920 4940 -3910 {
lab=#net23}
N 4720 -3890 4730 -3900 {
lab=#net24}
N 4730 -3900 4930 -3900 {
lab=#net24}
N 4930 -3900 4940 -3890 {
lab=#net24}
N 4780 -4050 4780 -4030 {
lab=vcom}
N 4820 -4050 4820 -4030 {
lab=ctop}
N 4700 -3950 4720 -3950 {
lab=col_n[11]}
N 4700 -3930 4720 -3930 {
lab=colon_n[11]}
N 4700 -3910 4720 -3910 {
lab=#net23}
N 4700 -3890 4720 -3890 {
lab=#net24}
N 4940 -3890 4960 -3890 {
lab=#net24}
N 4940 -3910 4960 -3910 {
lab=#net23}
N 4940 -3930 4960 -3930 {
lab=colon_n[11]}
N 4940 -3950 4960 -3950 {
lab=col_n[11]}
N 4760 -3810 4760 -3800 {
lab=VSS}
N 4760 -4040 4760 -4030 {
lab=VDD}
N 5100 -3810 5110 -3820 {
lab=row_n[15]}
N 5110 -4020 5110 -3820 {
lab=row_n[15]}
N 5100 -4030 5110 -4020 {
lab=row_n[15]}
N 5100 -3810 5100 -3790 {
lab=row_n[15]}
N 5100 -4050 5100 -4030 {
lab=row_n[15]}
N 4980 -3950 4990 -3960 {
lab=col_n[11]}
N 4990 -3960 5190 -3960 {
lab=col_n[11]}
N 5190 -3960 5200 -3950 {
lab=col_n[11]}
N 4980 -3930 4990 -3940 {
lab=colon_n[11]}
N 4990 -3940 5190 -3940 {
lab=colon_n[11]}
N 5190 -3940 5200 -3930 {
lab=colon_n[11]}
N 4980 -3910 4990 -3920 {
lab=#net23}
N 4990 -3920 5190 -3920 {
lab=#net23}
N 5190 -3920 5200 -3910 {
lab=#net23}
N 4980 -3890 4990 -3900 {
lab=#net24}
N 4990 -3900 5190 -3900 {
lab=#net24}
N 5190 -3900 5200 -3890 {
lab=#net24}
N 5040 -4050 5040 -4030 {
lab=vcom}
N 5080 -4050 5080 -4030 {
lab=ctop}
N 4960 -3950 4980 -3950 {
lab=col_n[11]}
N 4960 -3930 4980 -3930 {
lab=colon_n[11]}
N 4960 -3910 4980 -3910 {
lab=#net23}
N 4960 -3890 4980 -3890 {
lab=#net24}
N 5200 -3890 5220 -3890 {
lab=#net24}
N 5200 -3910 5220 -3910 {
lab=#net23}
N 5200 -3930 5220 -3930 {
lab=colon_n[11]}
N 5200 -3950 5220 -3950 {
lab=col_n[11]}
N 5020 -3810 5020 -3800 {
lab=VSS}
N 5020 -4040 5020 -4030 {
lab=VDD}
N 5360 -3810 5370 -3820 {
lab=row_n[16]}
N 5370 -4020 5370 -3820 {
lab=row_n[16]}
N 5360 -4030 5370 -4020 {
lab=row_n[16]}
N 5360 -3810 5360 -3790 {
lab=row_n[16]}
N 5360 -4050 5360 -4030 {
lab=row_n[16]}
N 5240 -3950 5250 -3960 {
lab=col_n[11]}
N 5250 -3960 5450 -3960 {
lab=col_n[11]}
N 5450 -3960 5460 -3950 {
lab=col_n[11]}
N 5240 -3930 5250 -3940 {
lab=colon_n[11]}
N 5250 -3940 5450 -3940 {
lab=colon_n[11]}
N 5450 -3940 5460 -3930 {
lab=colon_n[11]}
N 5240 -3910 5250 -3920 {
lab=#net23}
N 5250 -3920 5450 -3920 {
lab=#net23}
N 5450 -3920 5460 -3910 {
lab=#net23}
N 5240 -3890 5250 -3900 {
lab=#net24}
N 5250 -3900 5450 -3900 {
lab=#net24}
N 5450 -3900 5460 -3890 {
lab=#net24}
N 5300 -4050 5300 -4030 {
lab=vcom}
N 5340 -4050 5340 -4030 {
lab=ctop}
N 5220 -3950 5240 -3950 {
lab=col_n[11]}
N 5220 -3930 5240 -3930 {
lab=colon_n[11]}
N 5220 -3910 5240 -3910 {
lab=#net23}
N 5220 -3890 5240 -3890 {
lab=#net24}
N 5460 -3890 5480 -3890 {
lab=#net24}
N 5460 -3910 5480 -3910 {
lab=#net23}
N 5460 -3930 5480 -3930 {
lab=colon_n[11]}
N 5460 -3950 5480 -3950 {
lab=col_n[11]}
N 5280 -3810 5280 -3800 {
lab=VSS}
N 5280 -4040 5280 -4030 {
lab=VDD}
N 5620 -3810 5630 -3820 {
lab=row_n[17]}
N 5630 -4020 5630 -3820 {
lab=row_n[17]}
N 5620 -4030 5630 -4020 {
lab=row_n[17]}
N 5620 -3810 5620 -3790 {
lab=row_n[17]}
N 5620 -4050 5620 -4030 {
lab=row_n[17]}
N 5500 -3950 5510 -3960 {
lab=col_n[11]}
N 5510 -3960 5710 -3960 {
lab=col_n[11]}
N 5710 -3960 5720 -3950 {
lab=col_n[11]}
N 5500 -3930 5510 -3940 {
lab=colon_n[11]}
N 5510 -3940 5710 -3940 {
lab=colon_n[11]}
N 5710 -3940 5720 -3930 {
lab=colon_n[11]}
N 5500 -3910 5510 -3920 {
lab=#net23}
N 5510 -3920 5710 -3920 {
lab=#net23}
N 5710 -3920 5720 -3910 {
lab=#net23}
N 5500 -3890 5510 -3900 {
lab=#net24}
N 5510 -3900 5710 -3900 {
lab=#net24}
N 5710 -3900 5720 -3890 {
lab=#net24}
N 5560 -4050 5560 -4030 {
lab=vcom}
N 5600 -4050 5600 -4030 {
lab=ctop}
N 5480 -3950 5500 -3950 {
lab=col_n[11]}
N 5480 -3930 5500 -3930 {
lab=colon_n[11]}
N 5480 -3910 5500 -3910 {
lab=#net23}
N 5480 -3890 5500 -3890 {
lab=#net24}
N 5720 -3890 5740 -3890 {
lab=#net24}
N 5720 -3910 5740 -3910 {
lab=#net23}
N 5720 -3930 5740 -3930 {
lab=colon_n[11]}
N 5720 -3950 5740 -3950 {
lab=col_n[11]}
N 5540 -3810 5540 -3800 {
lab=VSS}
N 5540 -4040 5540 -4030 {
lab=VDD}
N 5880 -3810 5890 -3820 {
lab=row_n[18]}
N 5890 -4020 5890 -3820 {
lab=row_n[18]}
N 5880 -4030 5890 -4020 {
lab=row_n[18]}
N 5880 -3810 5880 -3790 {
lab=row_n[18]}
N 5880 -4050 5880 -4030 {
lab=row_n[18]}
N 5760 -3950 5770 -3960 {
lab=col_n[11]}
N 5770 -3960 5970 -3960 {
lab=col_n[11]}
N 5970 -3960 5980 -3950 {
lab=col_n[11]}
N 5760 -3930 5770 -3940 {
lab=colon_n[11]}
N 5770 -3940 5970 -3940 {
lab=colon_n[11]}
N 5970 -3940 5980 -3930 {
lab=colon_n[11]}
N 5760 -3910 5770 -3920 {
lab=#net23}
N 5770 -3920 5970 -3920 {
lab=#net23}
N 5970 -3920 5980 -3910 {
lab=#net23}
N 5760 -3890 5770 -3900 {
lab=#net24}
N 5770 -3900 5970 -3900 {
lab=#net24}
N 5970 -3900 5980 -3890 {
lab=#net24}
N 5820 -4050 5820 -4030 {
lab=vcom}
N 5860 -4050 5860 -4030 {
lab=ctop}
N 5740 -3950 5760 -3950 {
lab=col_n[11]}
N 5740 -3930 5760 -3930 {
lab=colon_n[11]}
N 5740 -3910 5760 -3910 {
lab=#net23}
N 5740 -3890 5760 -3890 {
lab=#net24}
N 5980 -3890 6000 -3890 {
lab=#net24}
N 5980 -3910 6000 -3910 {
lab=#net23}
N 5980 -3930 6000 -3930 {
lab=colon_n[11]}
N 5980 -3950 6000 -3950 {
lab=col_n[11]}
N 5800 -3810 5800 -3800 {
lab=VSS}
N 5800 -4040 5800 -4030 {
lab=VDD}
N 6140 -3810 6150 -3820 {
lab=row_n[19]}
N 6150 -4020 6150 -3820 {
lab=row_n[19]}
N 6140 -4030 6150 -4020 {
lab=row_n[19]}
N 6140 -3810 6140 -3790 {
lab=row_n[19]}
N 6140 -4050 6140 -4030 {
lab=row_n[19]}
N 6020 -3950 6030 -3960 {
lab=col_n[11]}
N 6030 -3960 6230 -3960 {
lab=col_n[11]}
N 6230 -3960 6240 -3950 {
lab=col_n[11]}
N 6020 -3930 6030 -3940 {
lab=colon_n[11]}
N 6030 -3940 6230 -3940 {
lab=colon_n[11]}
N 6230 -3940 6240 -3930 {
lab=colon_n[11]}
N 6020 -3910 6030 -3920 {
lab=#net23}
N 6030 -3920 6230 -3920 {
lab=#net23}
N 6230 -3920 6240 -3910 {
lab=#net23}
N 6020 -3890 6030 -3900 {
lab=#net24}
N 6030 -3900 6230 -3900 {
lab=#net24}
N 6230 -3900 6240 -3890 {
lab=#net24}
N 6080 -4050 6080 -4030 {
lab=vcom}
N 6120 -4050 6120 -4030 {
lab=ctop}
N 6000 -3950 6020 -3950 {
lab=col_n[11]}
N 6000 -3930 6020 -3930 {
lab=colon_n[11]}
N 6000 -3910 6020 -3910 {
lab=#net23}
N 6000 -3890 6020 -3890 {
lab=#net24}
N 6240 -3890 6260 -3890 {
lab=#net24}
N 6240 -3910 6260 -3910 {
lab=#net23}
N 6240 -3930 6260 -3930 {
lab=colon_n[11]}
N 6240 -3950 6260 -3950 {
lab=col_n[11]}
N 6060 -3810 6060 -3800 {
lab=VSS}
N 6060 -4040 6060 -4030 {
lab=VDD}
N 6400 -3810 6410 -3820 {
lab=row_n[20]}
N 6410 -4020 6410 -3820 {
lab=row_n[20]}
N 6400 -4030 6410 -4020 {
lab=row_n[20]}
N 6400 -3810 6400 -3790 {
lab=row_n[20]}
N 6400 -4050 6400 -4030 {
lab=row_n[20]}
N 6280 -3950 6290 -3960 {
lab=col_n[11]}
N 6290 -3960 6490 -3960 {
lab=col_n[11]}
N 6490 -3960 6500 -3950 {
lab=col_n[11]}
N 6280 -3930 6290 -3940 {
lab=colon_n[11]}
N 6290 -3940 6490 -3940 {
lab=colon_n[11]}
N 6490 -3940 6500 -3930 {
lab=colon_n[11]}
N 6280 -3910 6290 -3920 {
lab=#net23}
N 6290 -3920 6490 -3920 {
lab=#net23}
N 6490 -3920 6500 -3910 {
lab=#net23}
N 6280 -3890 6290 -3900 {
lab=#net24}
N 6290 -3900 6490 -3900 {
lab=#net24}
N 6490 -3900 6500 -3890 {
lab=#net24}
N 6340 -4050 6340 -4030 {
lab=vcom}
N 6380 -4050 6380 -4030 {
lab=ctop}
N 6260 -3950 6280 -3950 {
lab=col_n[11]}
N 6260 -3930 6280 -3930 {
lab=colon_n[11]}
N 6260 -3910 6280 -3910 {
lab=#net23}
N 6260 -3890 6280 -3890 {
lab=#net24}
N 6500 -3890 6520 -3890 {
lab=#net24}
N 6500 -3910 6520 -3910 {
lab=#net23}
N 6500 -3930 6520 -3930 {
lab=colon_n[11]}
N 6500 -3950 6520 -3950 {
lab=col_n[11]}
N 6320 -3810 6320 -3800 {
lab=VSS}
N 6320 -4040 6320 -4030 {
lab=VDD}
N 6660 -3810 6670 -3820 {
lab=row_n[21]}
N 6670 -4020 6670 -3820 {
lab=row_n[21]}
N 6660 -4030 6670 -4020 {
lab=row_n[21]}
N 6660 -3810 6660 -3790 {
lab=row_n[21]}
N 6660 -4050 6660 -4030 {
lab=row_n[21]}
N 6540 -3950 6550 -3960 {
lab=col_n[11]}
N 6550 -3960 6750 -3960 {
lab=col_n[11]}
N 6750 -3960 6760 -3950 {
lab=col_n[11]}
N 6540 -3930 6550 -3940 {
lab=colon_n[11]}
N 6550 -3940 6750 -3940 {
lab=colon_n[11]}
N 6750 -3940 6760 -3930 {
lab=colon_n[11]}
N 6540 -3910 6550 -3920 {
lab=#net23}
N 6550 -3920 6750 -3920 {
lab=#net23}
N 6750 -3920 6760 -3910 {
lab=#net23}
N 6540 -3890 6550 -3900 {
lab=#net24}
N 6550 -3900 6750 -3900 {
lab=#net24}
N 6750 -3900 6760 -3890 {
lab=#net24}
N 6600 -4050 6600 -4030 {
lab=vcom}
N 6640 -4050 6640 -4030 {
lab=ctop}
N 6520 -3950 6540 -3950 {
lab=col_n[11]}
N 6520 -3930 6540 -3930 {
lab=colon_n[11]}
N 6520 -3910 6540 -3910 {
lab=#net23}
N 6520 -3890 6540 -3890 {
lab=#net24}
N 6760 -3890 6780 -3890 {
lab=#net24}
N 6760 -3910 6780 -3910 {
lab=#net23}
N 6760 -3930 6780 -3930 {
lab=colon_n[11]}
N 6760 -3950 6780 -3950 {
lab=col_n[11]}
N 6580 -3810 6580 -3800 {
lab=VSS}
N 6580 -4040 6580 -4030 {
lab=VDD}
N 6920 -3810 6930 -3820 {
lab=row_n[22]}
N 6930 -4020 6930 -3820 {
lab=row_n[22]}
N 6920 -4030 6930 -4020 {
lab=row_n[22]}
N 6920 -3810 6920 -3790 {
lab=row_n[22]}
N 6920 -4050 6920 -4030 {
lab=row_n[22]}
N 6800 -3950 6810 -3960 {
lab=col_n[11]}
N 6810 -3960 7010 -3960 {
lab=col_n[11]}
N 7010 -3960 7020 -3950 {
lab=col_n[11]}
N 6800 -3930 6810 -3940 {
lab=colon_n[11]}
N 6810 -3940 7010 -3940 {
lab=colon_n[11]}
N 7010 -3940 7020 -3930 {
lab=colon_n[11]}
N 6800 -3910 6810 -3920 {
lab=#net23}
N 6810 -3920 7010 -3920 {
lab=#net23}
N 7010 -3920 7020 -3910 {
lab=#net23}
N 6800 -3890 6810 -3900 {
lab=#net24}
N 6810 -3900 7010 -3900 {
lab=#net24}
N 7010 -3900 7020 -3890 {
lab=#net24}
N 6860 -4050 6860 -4030 {
lab=vcom}
N 6900 -4050 6900 -4030 {
lab=ctop}
N 6780 -3950 6800 -3950 {
lab=col_n[11]}
N 6780 -3930 6800 -3930 {
lab=colon_n[11]}
N 6780 -3910 6800 -3910 {
lab=#net23}
N 6780 -3890 6800 -3890 {
lab=#net24}
N 7020 -3890 7040 -3890 {
lab=#net24}
N 7020 -3910 7040 -3910 {
lab=#net23}
N 7020 -3930 7040 -3930 {
lab=colon_n[11]}
N 7020 -3950 7040 -3950 {
lab=col_n[11]}
N 6840 -3810 6840 -3800 {
lab=VSS}
N 6840 -4040 6840 -4030 {
lab=VDD}
N 7180 -3810 7190 -3820 {
lab=row_n[23]}
N 7190 -4020 7190 -3820 {
lab=row_n[23]}
N 7180 -4030 7190 -4020 {
lab=row_n[23]}
N 7180 -3810 7180 -3790 {
lab=row_n[23]}
N 7180 -4050 7180 -4030 {
lab=row_n[23]}
N 7060 -3950 7070 -3960 {
lab=col_n[11]}
N 7070 -3960 7270 -3960 {
lab=col_n[11]}
N 7270 -3960 7280 -3950 {
lab=col_n[11]}
N 7060 -3930 7070 -3940 {
lab=colon_n[11]}
N 7070 -3940 7270 -3940 {
lab=colon_n[11]}
N 7270 -3940 7280 -3930 {
lab=colon_n[11]}
N 7060 -3910 7070 -3920 {
lab=#net23}
N 7070 -3920 7270 -3920 {
lab=#net23}
N 7270 -3920 7280 -3910 {
lab=#net23}
N 7060 -3890 7070 -3900 {
lab=#net24}
N 7070 -3900 7270 -3900 {
lab=#net24}
N 7270 -3900 7280 -3890 {
lab=#net24}
N 7120 -4050 7120 -4030 {
lab=vcom}
N 7160 -4050 7160 -4030 {
lab=ctop}
N 7040 -3950 7060 -3950 {
lab=col_n[11]}
N 7040 -3930 7060 -3930 {
lab=colon_n[11]}
N 7040 -3910 7060 -3910 {
lab=#net23}
N 7040 -3890 7060 -3890 {
lab=#net24}
N 7280 -3890 7300 -3890 {
lab=#net24}
N 7280 -3910 7300 -3910 {
lab=#net23}
N 7280 -3930 7300 -3930 {
lab=colon_n[11]}
N 7280 -3950 7300 -3950 {
lab=col_n[11]}
N 7100 -3810 7100 -3800 {
lab=VSS}
N 7100 -4040 7100 -4030 {
lab=VDD}
N 7440 -3810 7450 -3820 {
lab=row_n[24]}
N 7450 -4020 7450 -3820 {
lab=row_n[24]}
N 7440 -4030 7450 -4020 {
lab=row_n[24]}
N 7440 -3810 7440 -3790 {
lab=row_n[24]}
N 7440 -4050 7440 -4030 {
lab=row_n[24]}
N 7320 -3950 7330 -3960 {
lab=col_n[11]}
N 7330 -3960 7530 -3960 {
lab=col_n[11]}
N 7530 -3960 7540 -3950 {
lab=col_n[11]}
N 7320 -3930 7330 -3940 {
lab=colon_n[11]}
N 7330 -3940 7530 -3940 {
lab=colon_n[11]}
N 7530 -3940 7540 -3930 {
lab=colon_n[11]}
N 7320 -3910 7330 -3920 {
lab=#net23}
N 7330 -3920 7530 -3920 {
lab=#net23}
N 7530 -3920 7540 -3910 {
lab=#net23}
N 7320 -3890 7330 -3900 {
lab=#net24}
N 7330 -3900 7530 -3900 {
lab=#net24}
N 7530 -3900 7540 -3890 {
lab=#net24}
N 7380 -4050 7380 -4030 {
lab=vcom}
N 7420 -4050 7420 -4030 {
lab=ctop}
N 7300 -3950 7320 -3950 {
lab=col_n[11]}
N 7300 -3930 7320 -3930 {
lab=colon_n[11]}
N 7300 -3910 7320 -3910 {
lab=#net23}
N 7300 -3890 7320 -3890 {
lab=#net24}
N 7540 -3890 7560 -3890 {
lab=#net24}
N 7540 -3910 7560 -3910 {
lab=#net23}
N 7540 -3930 7560 -3930 {
lab=colon_n[11]}
N 7540 -3950 7560 -3950 {
lab=col_n[11]}
N 7360 -3810 7360 -3800 {
lab=VSS}
N 7360 -4040 7360 -4030 {
lab=VDD}
N 7700 -3810 7710 -3820 {
lab=row_n[25]}
N 7710 -4020 7710 -3820 {
lab=row_n[25]}
N 7700 -4030 7710 -4020 {
lab=row_n[25]}
N 7700 -3810 7700 -3790 {
lab=row_n[25]}
N 7700 -4050 7700 -4030 {
lab=row_n[25]}
N 7580 -3950 7590 -3960 {
lab=col_n[11]}
N 7590 -3960 7790 -3960 {
lab=col_n[11]}
N 7790 -3960 7800 -3950 {
lab=col_n[11]}
N 7580 -3930 7590 -3940 {
lab=colon_n[11]}
N 7590 -3940 7790 -3940 {
lab=colon_n[11]}
N 7790 -3940 7800 -3930 {
lab=colon_n[11]}
N 7580 -3910 7590 -3920 {
lab=#net23}
N 7590 -3920 7790 -3920 {
lab=#net23}
N 7790 -3920 7800 -3910 {
lab=#net23}
N 7580 -3890 7590 -3900 {
lab=#net24}
N 7590 -3900 7790 -3900 {
lab=#net24}
N 7790 -3900 7800 -3890 {
lab=#net24}
N 7640 -4050 7640 -4030 {
lab=vcom}
N 7680 -4050 7680 -4030 {
lab=ctop}
N 7560 -3950 7580 -3950 {
lab=col_n[11]}
N 7560 -3930 7580 -3930 {
lab=colon_n[11]}
N 7560 -3910 7580 -3910 {
lab=#net23}
N 7560 -3890 7580 -3890 {
lab=#net24}
N 7800 -3890 7820 -3890 {
lab=#net24}
N 7800 -3910 7820 -3910 {
lab=#net23}
N 7800 -3930 7820 -3930 {
lab=colon_n[11]}
N 7800 -3950 7820 -3950 {
lab=col_n[11]}
N 7620 -3810 7620 -3800 {
lab=VSS}
N 7620 -4040 7620 -4030 {
lab=VDD}
N 7960 -3810 7970 -3820 {
lab=row_n[26]}
N 7970 -4020 7970 -3820 {
lab=row_n[26]}
N 7960 -4030 7970 -4020 {
lab=row_n[26]}
N 7960 -3810 7960 -3790 {
lab=row_n[26]}
N 7960 -4050 7960 -4030 {
lab=row_n[26]}
N 7840 -3950 7850 -3960 {
lab=col_n[11]}
N 7850 -3960 8050 -3960 {
lab=col_n[11]}
N 8050 -3960 8060 -3950 {
lab=col_n[11]}
N 7840 -3930 7850 -3940 {
lab=colon_n[11]}
N 7850 -3940 8050 -3940 {
lab=colon_n[11]}
N 8050 -3940 8060 -3930 {
lab=colon_n[11]}
N 7840 -3910 7850 -3920 {
lab=#net23}
N 7850 -3920 8050 -3920 {
lab=#net23}
N 8050 -3920 8060 -3910 {
lab=#net23}
N 7840 -3890 7850 -3900 {
lab=#net24}
N 7850 -3900 8050 -3900 {
lab=#net24}
N 8050 -3900 8060 -3890 {
lab=#net24}
N 7900 -4050 7900 -4030 {
lab=vcom}
N 7940 -4050 7940 -4030 {
lab=ctop}
N 7820 -3950 7840 -3950 {
lab=col_n[11]}
N 7820 -3930 7840 -3930 {
lab=colon_n[11]}
N 7820 -3910 7840 -3910 {
lab=#net23}
N 7820 -3890 7840 -3890 {
lab=#net24}
N 8060 -3890 8080 -3890 {
lab=#net24}
N 8060 -3910 8080 -3910 {
lab=#net23}
N 8060 -3930 8080 -3930 {
lab=colon_n[11]}
N 8060 -3950 8080 -3950 {
lab=col_n[11]}
N 7880 -3810 7880 -3800 {
lab=VSS}
N 7880 -4040 7880 -4030 {
lab=VDD}
N 8220 -3810 8230 -3820 {
lab=row_n[27]}
N 8230 -4020 8230 -3820 {
lab=row_n[27]}
N 8220 -4030 8230 -4020 {
lab=row_n[27]}
N 8220 -3810 8220 -3790 {
lab=row_n[27]}
N 8220 -4050 8220 -4030 {
lab=row_n[27]}
N 8100 -3950 8110 -3960 {
lab=col_n[11]}
N 8110 -3960 8310 -3960 {
lab=col_n[11]}
N 8310 -3960 8320 -3950 {
lab=col_n[11]}
N 8100 -3930 8110 -3940 {
lab=colon_n[11]}
N 8110 -3940 8310 -3940 {
lab=colon_n[11]}
N 8310 -3940 8320 -3930 {
lab=colon_n[11]}
N 8100 -3910 8110 -3920 {
lab=#net23}
N 8110 -3920 8310 -3920 {
lab=#net23}
N 8310 -3920 8320 -3910 {
lab=#net23}
N 8100 -3890 8110 -3900 {
lab=#net24}
N 8110 -3900 8310 -3900 {
lab=#net24}
N 8310 -3900 8320 -3890 {
lab=#net24}
N 8160 -4050 8160 -4030 {
lab=vcom}
N 8200 -4050 8200 -4030 {
lab=ctop}
N 8080 -3950 8100 -3950 {
lab=col_n[11]}
N 8080 -3930 8100 -3930 {
lab=colon_n[11]}
N 8080 -3910 8100 -3910 {
lab=#net23}
N 8080 -3890 8100 -3890 {
lab=#net24}
N 8320 -3890 8340 -3890 {
lab=#net24}
N 8320 -3910 8340 -3910 {
lab=#net23}
N 8320 -3930 8340 -3930 {
lab=colon_n[11]}
N 8320 -3950 8340 -3950 {
lab=col_n[11]}
N 8140 -3810 8140 -3800 {
lab=VSS}
N 8140 -4040 8140 -4030 {
lab=VDD}
N 8480 -3810 8490 -3820 {
lab=row_n[28]}
N 8490 -4020 8490 -3820 {
lab=row_n[28]}
N 8480 -4030 8490 -4020 {
lab=row_n[28]}
N 8480 -3810 8480 -3790 {
lab=row_n[28]}
N 8480 -4050 8480 -4030 {
lab=row_n[28]}
N 8360 -3950 8370 -3960 {
lab=col_n[11]}
N 8370 -3960 8570 -3960 {
lab=col_n[11]}
N 8570 -3960 8580 -3950 {
lab=col_n[11]}
N 8360 -3930 8370 -3940 {
lab=colon_n[11]}
N 8370 -3940 8570 -3940 {
lab=colon_n[11]}
N 8570 -3940 8580 -3930 {
lab=colon_n[11]}
N 8360 -3910 8370 -3920 {
lab=#net23}
N 8370 -3920 8570 -3920 {
lab=#net23}
N 8570 -3920 8580 -3910 {
lab=#net23}
N 8360 -3890 8370 -3900 {
lab=#net24}
N 8370 -3900 8570 -3900 {
lab=#net24}
N 8570 -3900 8580 -3890 {
lab=#net24}
N 8420 -4050 8420 -4030 {
lab=vcom}
N 8460 -4050 8460 -4030 {
lab=ctop}
N 8340 -3950 8360 -3950 {
lab=col_n[11]}
N 8340 -3930 8360 -3930 {
lab=colon_n[11]}
N 8340 -3910 8360 -3910 {
lab=#net23}
N 8340 -3890 8360 -3890 {
lab=#net24}
N 8580 -3890 8600 -3890 {
lab=#net24}
N 8580 -3910 8600 -3910 {
lab=#net23}
N 8580 -3930 8600 -3930 {
lab=colon_n[11]}
N 8580 -3950 8600 -3950 {
lab=col_n[11]}
N 8400 -3810 8400 -3800 {
lab=VSS}
N 8400 -4040 8400 -4030 {
lab=VDD}
N 8740 -3810 8750 -3820 {
lab=row_n[29]}
N 8750 -4020 8750 -3820 {
lab=row_n[29]}
N 8740 -4030 8750 -4020 {
lab=row_n[29]}
N 8740 -3810 8740 -3790 {
lab=row_n[29]}
N 8740 -4050 8740 -4030 {
lab=row_n[29]}
N 8620 -3950 8630 -3960 {
lab=col_n[11]}
N 8630 -3960 8830 -3960 {
lab=col_n[11]}
N 8830 -3960 8840 -3950 {
lab=col_n[11]}
N 8620 -3930 8630 -3940 {
lab=colon_n[11]}
N 8630 -3940 8830 -3940 {
lab=colon_n[11]}
N 8830 -3940 8840 -3930 {
lab=colon_n[11]}
N 8620 -3910 8630 -3920 {
lab=#net23}
N 8630 -3920 8830 -3920 {
lab=#net23}
N 8830 -3920 8840 -3910 {
lab=#net23}
N 8620 -3890 8630 -3900 {
lab=#net24}
N 8630 -3900 8830 -3900 {
lab=#net24}
N 8830 -3900 8840 -3890 {
lab=#net24}
N 8680 -4050 8680 -4030 {
lab=vcom}
N 8720 -4050 8720 -4030 {
lab=ctop}
N 8600 -3950 8620 -3950 {
lab=col_n[11]}
N 8600 -3930 8620 -3930 {
lab=colon_n[11]}
N 8600 -3910 8620 -3910 {
lab=#net23}
N 8600 -3890 8620 -3890 {
lab=#net24}
N 8840 -3890 8860 -3890 {
lab=#net24}
N 8840 -3910 8860 -3910 {
lab=#net23}
N 8840 -3930 8860 -3930 {
lab=colon_n[11]}
N 8840 -3950 8860 -3950 {
lab=col_n[11]}
N 8660 -3810 8660 -3800 {
lab=VSS}
N 8660 -4040 8660 -4030 {
lab=VDD}
N 9000 -3810 9010 -3820 {
lab=row_n[30]}
N 9010 -4020 9010 -3820 {
lab=row_n[30]}
N 9000 -4030 9010 -4020 {
lab=row_n[30]}
N 9000 -3810 9000 -3790 {
lab=row_n[30]}
N 9000 -4050 9000 -4030 {
lab=row_n[30]}
N 8880 -3950 8890 -3960 {
lab=col_n[11]}
N 8890 -3960 9090 -3960 {
lab=col_n[11]}
N 9090 -3960 9100 -3950 {
lab=col_n[11]}
N 8880 -3930 8890 -3940 {
lab=colon_n[11]}
N 8890 -3940 9090 -3940 {
lab=colon_n[11]}
N 9090 -3940 9100 -3930 {
lab=colon_n[11]}
N 8880 -3910 8890 -3920 {
lab=#net23}
N 8890 -3920 9090 -3920 {
lab=#net23}
N 9090 -3920 9100 -3910 {
lab=#net23}
N 8880 -3890 8890 -3900 {
lab=#net24}
N 8890 -3900 9090 -3900 {
lab=#net24}
N 9090 -3900 9100 -3890 {
lab=#net24}
N 8940 -4050 8940 -4030 {
lab=vcom}
N 8980 -4050 8980 -4030 {
lab=ctop}
N 8860 -3950 8880 -3950 {
lab=col_n[11]}
N 8860 -3930 8880 -3930 {
lab=colon_n[11]}
N 8860 -3910 8880 -3910 {
lab=#net23}
N 8860 -3890 8880 -3890 {
lab=#net24}
N 9100 -3890 9120 -3890 {
lab=#net24}
N 9100 -3910 9120 -3910 {
lab=#net23}
N 9100 -3930 9120 -3930 {
lab=colon_n[11]}
N 9100 -3950 9120 -3950 {
lab=col_n[11]}
N 8920 -3810 8920 -3800 {
lab=VSS}
N 8920 -4040 8920 -4030 {
lab=VDD}
N 9260 -3810 9270 -3820 {
lab=row_n[31]}
N 9270 -4020 9270 -3820 {
lab=row_n[31]}
N 9260 -4030 9270 -4020 {
lab=row_n[31]}
N 9260 -3810 9260 -3790 {
lab=row_n[31]}
N 9260 -4050 9260 -4030 {
lab=row_n[31]}
N 9140 -3950 9150 -3960 {
lab=col_n[11]}
N 9150 -3960 9350 -3960 {
lab=col_n[11]}
N 9350 -3960 9360 -3950 {
lab=col_n[11]}
N 9140 -3930 9150 -3940 {
lab=colon_n[11]}
N 9150 -3940 9350 -3940 {
lab=colon_n[11]}
N 9350 -3940 9360 -3930 {
lab=colon_n[11]}
N 9140 -3910 9150 -3920 {
lab=#net23}
N 9150 -3920 9350 -3920 {
lab=#net23}
N 9350 -3920 9360 -3910 {
lab=#net23}
N 9140 -3890 9150 -3900 {
lab=#net24}
N 9150 -3900 9350 -3900 {
lab=#net24}
N 9350 -3900 9360 -3890 {
lab=#net24}
N 9200 -4050 9200 -4030 {
lab=vcom}
N 9240 -4050 9240 -4030 {
lab=ctop}
N 9120 -3950 9140 -3950 {
lab=col_n[11]}
N 9120 -3930 9140 -3930 {
lab=colon_n[11]}
N 9120 -3910 9140 -3910 {
lab=#net23}
N 9120 -3890 9140 -3890 {
lab=#net24}
N 9360 -3890 9380 -3890 {
lab=#net24}
N 9360 -3910 9380 -3910 {
lab=#net23}
N 9360 -3930 9380 -3930 {
lab=colon_n[11]}
N 9360 -3950 9380 -3950 {
lab=col_n[11]}
N 9180 -3810 9180 -3800 {
lab=VSS}
N 9180 -4040 9180 -4030 {
lab=VDD}
N 1200 -4070 1210 -4080 {
lab=row_n[0]}
N 1210 -4280 1210 -4080 {
lab=row_n[0]}
N 1200 -4290 1210 -4280 {
lab=row_n[0]}
N 1200 -4070 1200 -4050 {
lab=row_n[0]}
N 1200 -4310 1200 -4290 {
lab=row_n[0]}
N 1080 -4210 1090 -4220 {
lab=col_n[12]}
N 1090 -4220 1290 -4220 {
lab=col_n[12]}
N 1290 -4220 1300 -4210 {
lab=col_n[12]}
N 1080 -4190 1090 -4200 {
lab=colon_n[12]}
N 1090 -4200 1290 -4200 {
lab=colon_n[12]}
N 1290 -4200 1300 -4190 {
lab=colon_n[12]}
N 1080 -4170 1090 -4180 {
lab=#net25}
N 1090 -4180 1290 -4180 {
lab=#net25}
N 1290 -4180 1300 -4170 {
lab=#net25}
N 1080 -4150 1090 -4160 {
lab=#net26}
N 1090 -4160 1290 -4160 {
lab=#net26}
N 1290 -4160 1300 -4150 {
lab=#net26}
N 1140 -4310 1140 -4290 {
lab=vcom}
N 1180 -4310 1180 -4290 {
lab=ctop}
N 1060 -4210 1080 -4210 {
lab=col_n[12]}
N 1060 -4190 1080 -4190 {
lab=colon_n[12]}
N 1060 -4170 1080 -4170 {
lab=#net25}
N 1060 -4150 1080 -4150 {
lab=#net26}
N 1300 -4150 1320 -4150 {
lab=#net26}
N 1300 -4170 1320 -4170 {
lab=#net25}
N 1300 -4190 1320 -4190 {
lab=colon_n[12]}
N 1300 -4210 1320 -4210 {
lab=col_n[12]}
N 1120 -4070 1120 -4060 {
lab=VSS}
N 1120 -4300 1120 -4290 {
lab=VDD}
N 1460 -4070 1470 -4080 {
lab=row_n[1]}
N 1470 -4280 1470 -4080 {
lab=row_n[1]}
N 1460 -4290 1470 -4280 {
lab=row_n[1]}
N 1460 -4070 1460 -4050 {
lab=row_n[1]}
N 1460 -4310 1460 -4290 {
lab=row_n[1]}
N 1340 -4210 1350 -4220 {
lab=col_n[12]}
N 1350 -4220 1550 -4220 {
lab=col_n[12]}
N 1550 -4220 1560 -4210 {
lab=col_n[12]}
N 1340 -4190 1350 -4200 {
lab=colon_n[12]}
N 1350 -4200 1550 -4200 {
lab=colon_n[12]}
N 1550 -4200 1560 -4190 {
lab=colon_n[12]}
N 1340 -4170 1350 -4180 {
lab=#net25}
N 1350 -4180 1550 -4180 {
lab=#net25}
N 1550 -4180 1560 -4170 {
lab=#net25}
N 1340 -4150 1350 -4160 {
lab=#net26}
N 1350 -4160 1550 -4160 {
lab=#net26}
N 1550 -4160 1560 -4150 {
lab=#net26}
N 1400 -4310 1400 -4290 {
lab=vcom}
N 1440 -4310 1440 -4290 {
lab=ctop}
N 1320 -4210 1340 -4210 {
lab=col_n[12]}
N 1320 -4190 1340 -4190 {
lab=colon_n[12]}
N 1320 -4170 1340 -4170 {
lab=#net25}
N 1320 -4150 1340 -4150 {
lab=#net26}
N 1560 -4150 1580 -4150 {
lab=#net26}
N 1560 -4170 1580 -4170 {
lab=#net25}
N 1560 -4190 1580 -4190 {
lab=colon_n[12]}
N 1560 -4210 1580 -4210 {
lab=col_n[12]}
N 1380 -4070 1380 -4060 {
lab=VSS}
N 1380 -4300 1380 -4290 {
lab=VDD}
N 1720 -4070 1730 -4080 {
lab=row_n[2]}
N 1730 -4280 1730 -4080 {
lab=row_n[2]}
N 1720 -4290 1730 -4280 {
lab=row_n[2]}
N 1720 -4070 1720 -4050 {
lab=row_n[2]}
N 1720 -4310 1720 -4290 {
lab=row_n[2]}
N 1600 -4210 1610 -4220 {
lab=col_n[12]}
N 1610 -4220 1810 -4220 {
lab=col_n[12]}
N 1810 -4220 1820 -4210 {
lab=col_n[12]}
N 1600 -4190 1610 -4200 {
lab=colon_n[12]}
N 1610 -4200 1810 -4200 {
lab=colon_n[12]}
N 1810 -4200 1820 -4190 {
lab=colon_n[12]}
N 1600 -4170 1610 -4180 {
lab=#net25}
N 1610 -4180 1810 -4180 {
lab=#net25}
N 1810 -4180 1820 -4170 {
lab=#net25}
N 1600 -4150 1610 -4160 {
lab=#net26}
N 1610 -4160 1810 -4160 {
lab=#net26}
N 1810 -4160 1820 -4150 {
lab=#net26}
N 1660 -4310 1660 -4290 {
lab=vcom}
N 1700 -4310 1700 -4290 {
lab=ctop}
N 1580 -4210 1600 -4210 {
lab=col_n[12]}
N 1580 -4190 1600 -4190 {
lab=colon_n[12]}
N 1580 -4170 1600 -4170 {
lab=#net25}
N 1580 -4150 1600 -4150 {
lab=#net26}
N 1820 -4150 1840 -4150 {
lab=#net26}
N 1820 -4170 1840 -4170 {
lab=#net25}
N 1820 -4190 1840 -4190 {
lab=colon_n[12]}
N 1820 -4210 1840 -4210 {
lab=col_n[12]}
N 1640 -4070 1640 -4060 {
lab=VSS}
N 1640 -4300 1640 -4290 {
lab=VDD}
N 1980 -4070 1990 -4080 {
lab=row_n[3]}
N 1990 -4280 1990 -4080 {
lab=row_n[3]}
N 1980 -4290 1990 -4280 {
lab=row_n[3]}
N 1980 -4070 1980 -4050 {
lab=row_n[3]}
N 1980 -4310 1980 -4290 {
lab=row_n[3]}
N 1860 -4210 1870 -4220 {
lab=col_n[12]}
N 1870 -4220 2070 -4220 {
lab=col_n[12]}
N 2070 -4220 2080 -4210 {
lab=col_n[12]}
N 1860 -4190 1870 -4200 {
lab=colon_n[12]}
N 1870 -4200 2070 -4200 {
lab=colon_n[12]}
N 2070 -4200 2080 -4190 {
lab=colon_n[12]}
N 1860 -4170 1870 -4180 {
lab=#net25}
N 1870 -4180 2070 -4180 {
lab=#net25}
N 2070 -4180 2080 -4170 {
lab=#net25}
N 1860 -4150 1870 -4160 {
lab=#net26}
N 1870 -4160 2070 -4160 {
lab=#net26}
N 2070 -4160 2080 -4150 {
lab=#net26}
N 1920 -4310 1920 -4290 {
lab=vcom}
N 1960 -4310 1960 -4290 {
lab=ctop}
N 1840 -4210 1860 -4210 {
lab=col_n[12]}
N 1840 -4190 1860 -4190 {
lab=colon_n[12]}
N 1840 -4170 1860 -4170 {
lab=#net25}
N 1840 -4150 1860 -4150 {
lab=#net26}
N 2080 -4150 2100 -4150 {
lab=#net26}
N 2080 -4170 2100 -4170 {
lab=#net25}
N 2080 -4190 2100 -4190 {
lab=colon_n[12]}
N 2080 -4210 2100 -4210 {
lab=col_n[12]}
N 1900 -4070 1900 -4060 {
lab=VSS}
N 1900 -4300 1900 -4290 {
lab=VDD}
N 2240 -4070 2250 -4080 {
lab=row_n[4]}
N 2250 -4280 2250 -4080 {
lab=row_n[4]}
N 2240 -4290 2250 -4280 {
lab=row_n[4]}
N 2240 -4070 2240 -4050 {
lab=row_n[4]}
N 2240 -4310 2240 -4290 {
lab=row_n[4]}
N 2120 -4210 2130 -4220 {
lab=col_n[12]}
N 2130 -4220 2330 -4220 {
lab=col_n[12]}
N 2330 -4220 2340 -4210 {
lab=col_n[12]}
N 2120 -4190 2130 -4200 {
lab=colon_n[12]}
N 2130 -4200 2330 -4200 {
lab=colon_n[12]}
N 2330 -4200 2340 -4190 {
lab=colon_n[12]}
N 2120 -4170 2130 -4180 {
lab=#net25}
N 2130 -4180 2330 -4180 {
lab=#net25}
N 2330 -4180 2340 -4170 {
lab=#net25}
N 2120 -4150 2130 -4160 {
lab=#net26}
N 2130 -4160 2330 -4160 {
lab=#net26}
N 2330 -4160 2340 -4150 {
lab=#net26}
N 2180 -4310 2180 -4290 {
lab=vcom}
N 2220 -4310 2220 -4290 {
lab=ctop}
N 2100 -4210 2120 -4210 {
lab=col_n[12]}
N 2100 -4190 2120 -4190 {
lab=colon_n[12]}
N 2100 -4170 2120 -4170 {
lab=#net25}
N 2100 -4150 2120 -4150 {
lab=#net26}
N 2340 -4150 2360 -4150 {
lab=#net26}
N 2340 -4170 2360 -4170 {
lab=#net25}
N 2340 -4190 2360 -4190 {
lab=colon_n[12]}
N 2340 -4210 2360 -4210 {
lab=col_n[12]}
N 2160 -4070 2160 -4060 {
lab=VSS}
N 2160 -4300 2160 -4290 {
lab=VDD}
N 2500 -4070 2510 -4080 {
lab=row_n[5]}
N 2510 -4280 2510 -4080 {
lab=row_n[5]}
N 2500 -4290 2510 -4280 {
lab=row_n[5]}
N 2500 -4070 2500 -4050 {
lab=row_n[5]}
N 2500 -4310 2500 -4290 {
lab=row_n[5]}
N 2380 -4210 2390 -4220 {
lab=col_n[12]}
N 2390 -4220 2590 -4220 {
lab=col_n[12]}
N 2590 -4220 2600 -4210 {
lab=col_n[12]}
N 2380 -4190 2390 -4200 {
lab=colon_n[12]}
N 2390 -4200 2590 -4200 {
lab=colon_n[12]}
N 2590 -4200 2600 -4190 {
lab=colon_n[12]}
N 2380 -4170 2390 -4180 {
lab=#net25}
N 2390 -4180 2590 -4180 {
lab=#net25}
N 2590 -4180 2600 -4170 {
lab=#net25}
N 2380 -4150 2390 -4160 {
lab=#net26}
N 2390 -4160 2590 -4160 {
lab=#net26}
N 2590 -4160 2600 -4150 {
lab=#net26}
N 2440 -4310 2440 -4290 {
lab=vcom}
N 2480 -4310 2480 -4290 {
lab=ctop}
N 2360 -4210 2380 -4210 {
lab=col_n[12]}
N 2360 -4190 2380 -4190 {
lab=colon_n[12]}
N 2360 -4170 2380 -4170 {
lab=#net25}
N 2360 -4150 2380 -4150 {
lab=#net26}
N 2600 -4150 2620 -4150 {
lab=#net26}
N 2600 -4170 2620 -4170 {
lab=#net25}
N 2600 -4190 2620 -4190 {
lab=colon_n[12]}
N 2600 -4210 2620 -4210 {
lab=col_n[12]}
N 2420 -4070 2420 -4060 {
lab=VSS}
N 2420 -4300 2420 -4290 {
lab=VDD}
N 2760 -4070 2770 -4080 {
lab=row_n[6]}
N 2770 -4280 2770 -4080 {
lab=row_n[6]}
N 2760 -4290 2770 -4280 {
lab=row_n[6]}
N 2760 -4070 2760 -4050 {
lab=row_n[6]}
N 2760 -4310 2760 -4290 {
lab=row_n[6]}
N 2640 -4210 2650 -4220 {
lab=col_n[12]}
N 2650 -4220 2850 -4220 {
lab=col_n[12]}
N 2850 -4220 2860 -4210 {
lab=col_n[12]}
N 2640 -4190 2650 -4200 {
lab=colon_n[12]}
N 2650 -4200 2850 -4200 {
lab=colon_n[12]}
N 2850 -4200 2860 -4190 {
lab=colon_n[12]}
N 2640 -4170 2650 -4180 {
lab=#net25}
N 2650 -4180 2850 -4180 {
lab=#net25}
N 2850 -4180 2860 -4170 {
lab=#net25}
N 2640 -4150 2650 -4160 {
lab=#net26}
N 2650 -4160 2850 -4160 {
lab=#net26}
N 2850 -4160 2860 -4150 {
lab=#net26}
N 2700 -4310 2700 -4290 {
lab=vcom}
N 2740 -4310 2740 -4290 {
lab=ctop}
N 2620 -4210 2640 -4210 {
lab=col_n[12]}
N 2620 -4190 2640 -4190 {
lab=colon_n[12]}
N 2620 -4170 2640 -4170 {
lab=#net25}
N 2620 -4150 2640 -4150 {
lab=#net26}
N 2860 -4150 2880 -4150 {
lab=#net26}
N 2860 -4170 2880 -4170 {
lab=#net25}
N 2860 -4190 2880 -4190 {
lab=colon_n[12]}
N 2860 -4210 2880 -4210 {
lab=col_n[12]}
N 2680 -4070 2680 -4060 {
lab=VSS}
N 2680 -4300 2680 -4290 {
lab=VDD}
N 3020 -4070 3030 -4080 {
lab=row_n[7]}
N 3030 -4280 3030 -4080 {
lab=row_n[7]}
N 3020 -4290 3030 -4280 {
lab=row_n[7]}
N 3020 -4070 3020 -4050 {
lab=row_n[7]}
N 3020 -4310 3020 -4290 {
lab=row_n[7]}
N 2900 -4210 2910 -4220 {
lab=col_n[12]}
N 2910 -4220 3110 -4220 {
lab=col_n[12]}
N 3110 -4220 3120 -4210 {
lab=col_n[12]}
N 2900 -4190 2910 -4200 {
lab=colon_n[12]}
N 2910 -4200 3110 -4200 {
lab=colon_n[12]}
N 3110 -4200 3120 -4190 {
lab=colon_n[12]}
N 2900 -4170 2910 -4180 {
lab=#net25}
N 2910 -4180 3110 -4180 {
lab=#net25}
N 3110 -4180 3120 -4170 {
lab=#net25}
N 2900 -4150 2910 -4160 {
lab=#net26}
N 2910 -4160 3110 -4160 {
lab=#net26}
N 3110 -4160 3120 -4150 {
lab=#net26}
N 2960 -4310 2960 -4290 {
lab=vcom}
N 3000 -4310 3000 -4290 {
lab=ctop}
N 2880 -4210 2900 -4210 {
lab=col_n[12]}
N 2880 -4190 2900 -4190 {
lab=colon_n[12]}
N 2880 -4170 2900 -4170 {
lab=#net25}
N 2880 -4150 2900 -4150 {
lab=#net26}
N 3120 -4150 3140 -4150 {
lab=#net26}
N 3120 -4170 3140 -4170 {
lab=#net25}
N 3120 -4190 3140 -4190 {
lab=colon_n[12]}
N 3120 -4210 3140 -4210 {
lab=col_n[12]}
N 2940 -4070 2940 -4060 {
lab=VSS}
N 2940 -4300 2940 -4290 {
lab=VDD}
N 3280 -4070 3290 -4080 {
lab=row_n[8]}
N 3290 -4280 3290 -4080 {
lab=row_n[8]}
N 3280 -4290 3290 -4280 {
lab=row_n[8]}
N 3280 -4070 3280 -4050 {
lab=row_n[8]}
N 3280 -4310 3280 -4290 {
lab=row_n[8]}
N 3160 -4210 3170 -4220 {
lab=col_n[12]}
N 3170 -4220 3370 -4220 {
lab=col_n[12]}
N 3370 -4220 3380 -4210 {
lab=col_n[12]}
N 3160 -4190 3170 -4200 {
lab=colon_n[12]}
N 3170 -4200 3370 -4200 {
lab=colon_n[12]}
N 3370 -4200 3380 -4190 {
lab=colon_n[12]}
N 3160 -4170 3170 -4180 {
lab=#net25}
N 3170 -4180 3370 -4180 {
lab=#net25}
N 3370 -4180 3380 -4170 {
lab=#net25}
N 3160 -4150 3170 -4160 {
lab=#net26}
N 3170 -4160 3370 -4160 {
lab=#net26}
N 3370 -4160 3380 -4150 {
lab=#net26}
N 3220 -4310 3220 -4290 {
lab=vcom}
N 3260 -4310 3260 -4290 {
lab=ctop}
N 3140 -4210 3160 -4210 {
lab=col_n[12]}
N 3140 -4190 3160 -4190 {
lab=colon_n[12]}
N 3140 -4170 3160 -4170 {
lab=#net25}
N 3140 -4150 3160 -4150 {
lab=#net26}
N 3380 -4150 3400 -4150 {
lab=#net26}
N 3380 -4170 3400 -4170 {
lab=#net25}
N 3380 -4190 3400 -4190 {
lab=colon_n[12]}
N 3380 -4210 3400 -4210 {
lab=col_n[12]}
N 3200 -4070 3200 -4060 {
lab=VSS}
N 3200 -4300 3200 -4290 {
lab=VDD}
N 3540 -4070 3550 -4080 {
lab=row_n[9]}
N 3550 -4280 3550 -4080 {
lab=row_n[9]}
N 3540 -4290 3550 -4280 {
lab=row_n[9]}
N 3540 -4070 3540 -4050 {
lab=row_n[9]}
N 3540 -4310 3540 -4290 {
lab=row_n[9]}
N 3420 -4210 3430 -4220 {
lab=col_n[12]}
N 3430 -4220 3630 -4220 {
lab=col_n[12]}
N 3630 -4220 3640 -4210 {
lab=col_n[12]}
N 3420 -4190 3430 -4200 {
lab=colon_n[12]}
N 3430 -4200 3630 -4200 {
lab=colon_n[12]}
N 3630 -4200 3640 -4190 {
lab=colon_n[12]}
N 3420 -4170 3430 -4180 {
lab=#net25}
N 3430 -4180 3630 -4180 {
lab=#net25}
N 3630 -4180 3640 -4170 {
lab=#net25}
N 3420 -4150 3430 -4160 {
lab=#net26}
N 3430 -4160 3630 -4160 {
lab=#net26}
N 3630 -4160 3640 -4150 {
lab=#net26}
N 3480 -4310 3480 -4290 {
lab=vcom}
N 3520 -4310 3520 -4290 {
lab=ctop}
N 3400 -4210 3420 -4210 {
lab=col_n[12]}
N 3400 -4190 3420 -4190 {
lab=colon_n[12]}
N 3400 -4170 3420 -4170 {
lab=#net25}
N 3400 -4150 3420 -4150 {
lab=#net26}
N 3640 -4150 3660 -4150 {
lab=#net26}
N 3640 -4170 3660 -4170 {
lab=#net25}
N 3640 -4190 3660 -4190 {
lab=colon_n[12]}
N 3640 -4210 3660 -4210 {
lab=col_n[12]}
N 3460 -4070 3460 -4060 {
lab=VSS}
N 3460 -4300 3460 -4290 {
lab=VDD}
N 3800 -4070 3810 -4080 {
lab=row_n[10]}
N 3810 -4280 3810 -4080 {
lab=row_n[10]}
N 3800 -4290 3810 -4280 {
lab=row_n[10]}
N 3800 -4070 3800 -4050 {
lab=row_n[10]}
N 3800 -4310 3800 -4290 {
lab=row_n[10]}
N 3680 -4210 3690 -4220 {
lab=col_n[12]}
N 3690 -4220 3890 -4220 {
lab=col_n[12]}
N 3890 -4220 3900 -4210 {
lab=col_n[12]}
N 3680 -4190 3690 -4200 {
lab=colon_n[12]}
N 3690 -4200 3890 -4200 {
lab=colon_n[12]}
N 3890 -4200 3900 -4190 {
lab=colon_n[12]}
N 3680 -4170 3690 -4180 {
lab=#net25}
N 3690 -4180 3890 -4180 {
lab=#net25}
N 3890 -4180 3900 -4170 {
lab=#net25}
N 3680 -4150 3690 -4160 {
lab=#net26}
N 3690 -4160 3890 -4160 {
lab=#net26}
N 3890 -4160 3900 -4150 {
lab=#net26}
N 3740 -4310 3740 -4290 {
lab=vcom}
N 3780 -4310 3780 -4290 {
lab=ctop}
N 3660 -4210 3680 -4210 {
lab=col_n[12]}
N 3660 -4190 3680 -4190 {
lab=colon_n[12]}
N 3660 -4170 3680 -4170 {
lab=#net25}
N 3660 -4150 3680 -4150 {
lab=#net26}
N 3900 -4150 3920 -4150 {
lab=#net26}
N 3900 -4170 3920 -4170 {
lab=#net25}
N 3900 -4190 3920 -4190 {
lab=colon_n[12]}
N 3900 -4210 3920 -4210 {
lab=col_n[12]}
N 3720 -4070 3720 -4060 {
lab=VSS}
N 3720 -4300 3720 -4290 {
lab=VDD}
N 4060 -4070 4070 -4080 {
lab=row_n[11]}
N 4070 -4280 4070 -4080 {
lab=row_n[11]}
N 4060 -4290 4070 -4280 {
lab=row_n[11]}
N 4060 -4070 4060 -4050 {
lab=row_n[11]}
N 4060 -4310 4060 -4290 {
lab=row_n[11]}
N 3940 -4210 3950 -4220 {
lab=col_n[12]}
N 3950 -4220 4150 -4220 {
lab=col_n[12]}
N 4150 -4220 4160 -4210 {
lab=col_n[12]}
N 3940 -4190 3950 -4200 {
lab=colon_n[12]}
N 3950 -4200 4150 -4200 {
lab=colon_n[12]}
N 4150 -4200 4160 -4190 {
lab=colon_n[12]}
N 3940 -4170 3950 -4180 {
lab=#net25}
N 3950 -4180 4150 -4180 {
lab=#net25}
N 4150 -4180 4160 -4170 {
lab=#net25}
N 3940 -4150 3950 -4160 {
lab=#net26}
N 3950 -4160 4150 -4160 {
lab=#net26}
N 4150 -4160 4160 -4150 {
lab=#net26}
N 4000 -4310 4000 -4290 {
lab=vcom}
N 4040 -4310 4040 -4290 {
lab=ctop}
N 3920 -4210 3940 -4210 {
lab=col_n[12]}
N 3920 -4190 3940 -4190 {
lab=colon_n[12]}
N 3920 -4170 3940 -4170 {
lab=#net25}
N 3920 -4150 3940 -4150 {
lab=#net26}
N 4160 -4150 4180 -4150 {
lab=#net26}
N 4160 -4170 4180 -4170 {
lab=#net25}
N 4160 -4190 4180 -4190 {
lab=colon_n[12]}
N 4160 -4210 4180 -4210 {
lab=col_n[12]}
N 3980 -4070 3980 -4060 {
lab=VSS}
N 3980 -4300 3980 -4290 {
lab=VDD}
N 4320 -4070 4330 -4080 {
lab=row_n[12]}
N 4330 -4280 4330 -4080 {
lab=row_n[12]}
N 4320 -4290 4330 -4280 {
lab=row_n[12]}
N 4320 -4070 4320 -4050 {
lab=row_n[12]}
N 4320 -4310 4320 -4290 {
lab=row_n[12]}
N 4200 -4210 4210 -4220 {
lab=col_n[12]}
N 4210 -4220 4410 -4220 {
lab=col_n[12]}
N 4410 -4220 4420 -4210 {
lab=col_n[12]}
N 4200 -4190 4210 -4200 {
lab=colon_n[12]}
N 4210 -4200 4410 -4200 {
lab=colon_n[12]}
N 4410 -4200 4420 -4190 {
lab=colon_n[12]}
N 4200 -4170 4210 -4180 {
lab=#net25}
N 4210 -4180 4410 -4180 {
lab=#net25}
N 4410 -4180 4420 -4170 {
lab=#net25}
N 4200 -4150 4210 -4160 {
lab=#net26}
N 4210 -4160 4410 -4160 {
lab=#net26}
N 4410 -4160 4420 -4150 {
lab=#net26}
N 4260 -4310 4260 -4290 {
lab=vcom}
N 4300 -4310 4300 -4290 {
lab=ctop}
N 4180 -4210 4200 -4210 {
lab=col_n[12]}
N 4180 -4190 4200 -4190 {
lab=colon_n[12]}
N 4180 -4170 4200 -4170 {
lab=#net25}
N 4180 -4150 4200 -4150 {
lab=#net26}
N 4420 -4150 4440 -4150 {
lab=#net26}
N 4420 -4170 4440 -4170 {
lab=#net25}
N 4420 -4190 4440 -4190 {
lab=colon_n[12]}
N 4420 -4210 4440 -4210 {
lab=col_n[12]}
N 4240 -4070 4240 -4060 {
lab=VSS}
N 4240 -4300 4240 -4290 {
lab=VDD}
N 4580 -4070 4590 -4080 {
lab=row_n[13]}
N 4590 -4280 4590 -4080 {
lab=row_n[13]}
N 4580 -4290 4590 -4280 {
lab=row_n[13]}
N 4580 -4070 4580 -4050 {
lab=row_n[13]}
N 4580 -4310 4580 -4290 {
lab=row_n[13]}
N 4460 -4210 4470 -4220 {
lab=col_n[12]}
N 4470 -4220 4670 -4220 {
lab=col_n[12]}
N 4670 -4220 4680 -4210 {
lab=col_n[12]}
N 4460 -4190 4470 -4200 {
lab=colon_n[12]}
N 4470 -4200 4670 -4200 {
lab=colon_n[12]}
N 4670 -4200 4680 -4190 {
lab=colon_n[12]}
N 4460 -4170 4470 -4180 {
lab=#net25}
N 4470 -4180 4670 -4180 {
lab=#net25}
N 4670 -4180 4680 -4170 {
lab=#net25}
N 4460 -4150 4470 -4160 {
lab=#net26}
N 4470 -4160 4670 -4160 {
lab=#net26}
N 4670 -4160 4680 -4150 {
lab=#net26}
N 4520 -4310 4520 -4290 {
lab=vcom}
N 4560 -4310 4560 -4290 {
lab=ctop}
N 4440 -4210 4460 -4210 {
lab=col_n[12]}
N 4440 -4190 4460 -4190 {
lab=colon_n[12]}
N 4440 -4170 4460 -4170 {
lab=#net25}
N 4440 -4150 4460 -4150 {
lab=#net26}
N 4680 -4150 4700 -4150 {
lab=#net26}
N 4680 -4170 4700 -4170 {
lab=#net25}
N 4680 -4190 4700 -4190 {
lab=colon_n[12]}
N 4680 -4210 4700 -4210 {
lab=col_n[12]}
N 4500 -4070 4500 -4060 {
lab=VSS}
N 4500 -4300 4500 -4290 {
lab=VDD}
N 4840 -4070 4850 -4080 {
lab=row_n[14]}
N 4850 -4280 4850 -4080 {
lab=row_n[14]}
N 4840 -4290 4850 -4280 {
lab=row_n[14]}
N 4840 -4070 4840 -4050 {
lab=row_n[14]}
N 4840 -4310 4840 -4290 {
lab=row_n[14]}
N 4720 -4210 4730 -4220 {
lab=col_n[12]}
N 4730 -4220 4930 -4220 {
lab=col_n[12]}
N 4930 -4220 4940 -4210 {
lab=col_n[12]}
N 4720 -4190 4730 -4200 {
lab=colon_n[12]}
N 4730 -4200 4930 -4200 {
lab=colon_n[12]}
N 4930 -4200 4940 -4190 {
lab=colon_n[12]}
N 4720 -4170 4730 -4180 {
lab=#net25}
N 4730 -4180 4930 -4180 {
lab=#net25}
N 4930 -4180 4940 -4170 {
lab=#net25}
N 4720 -4150 4730 -4160 {
lab=#net26}
N 4730 -4160 4930 -4160 {
lab=#net26}
N 4930 -4160 4940 -4150 {
lab=#net26}
N 4780 -4310 4780 -4290 {
lab=vcom}
N 4820 -4310 4820 -4290 {
lab=ctop}
N 4700 -4210 4720 -4210 {
lab=col_n[12]}
N 4700 -4190 4720 -4190 {
lab=colon_n[12]}
N 4700 -4170 4720 -4170 {
lab=#net25}
N 4700 -4150 4720 -4150 {
lab=#net26}
N 4940 -4150 4960 -4150 {
lab=#net26}
N 4940 -4170 4960 -4170 {
lab=#net25}
N 4940 -4190 4960 -4190 {
lab=colon_n[12]}
N 4940 -4210 4960 -4210 {
lab=col_n[12]}
N 4760 -4070 4760 -4060 {
lab=VSS}
N 4760 -4300 4760 -4290 {
lab=VDD}
N 5100 -4070 5110 -4080 {
lab=row_n[15]}
N 5110 -4280 5110 -4080 {
lab=row_n[15]}
N 5100 -4290 5110 -4280 {
lab=row_n[15]}
N 5100 -4070 5100 -4050 {
lab=row_n[15]}
N 5100 -4310 5100 -4290 {
lab=row_n[15]}
N 4980 -4210 4990 -4220 {
lab=col_n[12]}
N 4990 -4220 5190 -4220 {
lab=col_n[12]}
N 5190 -4220 5200 -4210 {
lab=col_n[12]}
N 4980 -4190 4990 -4200 {
lab=colon_n[12]}
N 4990 -4200 5190 -4200 {
lab=colon_n[12]}
N 5190 -4200 5200 -4190 {
lab=colon_n[12]}
N 4980 -4170 4990 -4180 {
lab=#net25}
N 4990 -4180 5190 -4180 {
lab=#net25}
N 5190 -4180 5200 -4170 {
lab=#net25}
N 4980 -4150 4990 -4160 {
lab=#net26}
N 4990 -4160 5190 -4160 {
lab=#net26}
N 5190 -4160 5200 -4150 {
lab=#net26}
N 5040 -4310 5040 -4290 {
lab=vcom}
N 5080 -4310 5080 -4290 {
lab=ctop}
N 4960 -4210 4980 -4210 {
lab=col_n[12]}
N 4960 -4190 4980 -4190 {
lab=colon_n[12]}
N 4960 -4170 4980 -4170 {
lab=#net25}
N 4960 -4150 4980 -4150 {
lab=#net26}
N 5200 -4150 5220 -4150 {
lab=#net26}
N 5200 -4170 5220 -4170 {
lab=#net25}
N 5200 -4190 5220 -4190 {
lab=colon_n[12]}
N 5200 -4210 5220 -4210 {
lab=col_n[12]}
N 5020 -4070 5020 -4060 {
lab=VSS}
N 5020 -4300 5020 -4290 {
lab=VDD}
N 5360 -4070 5370 -4080 {
lab=row_n[16]}
N 5370 -4280 5370 -4080 {
lab=row_n[16]}
N 5360 -4290 5370 -4280 {
lab=row_n[16]}
N 5360 -4070 5360 -4050 {
lab=row_n[16]}
N 5360 -4310 5360 -4290 {
lab=row_n[16]}
N 5240 -4210 5250 -4220 {
lab=col_n[12]}
N 5250 -4220 5450 -4220 {
lab=col_n[12]}
N 5450 -4220 5460 -4210 {
lab=col_n[12]}
N 5240 -4190 5250 -4200 {
lab=colon_n[12]}
N 5250 -4200 5450 -4200 {
lab=colon_n[12]}
N 5450 -4200 5460 -4190 {
lab=colon_n[12]}
N 5240 -4170 5250 -4180 {
lab=#net25}
N 5250 -4180 5450 -4180 {
lab=#net25}
N 5450 -4180 5460 -4170 {
lab=#net25}
N 5240 -4150 5250 -4160 {
lab=#net26}
N 5250 -4160 5450 -4160 {
lab=#net26}
N 5450 -4160 5460 -4150 {
lab=#net26}
N 5300 -4310 5300 -4290 {
lab=vcom}
N 5340 -4310 5340 -4290 {
lab=ctop}
N 5220 -4210 5240 -4210 {
lab=col_n[12]}
N 5220 -4190 5240 -4190 {
lab=colon_n[12]}
N 5220 -4170 5240 -4170 {
lab=#net25}
N 5220 -4150 5240 -4150 {
lab=#net26}
N 5460 -4150 5480 -4150 {
lab=#net26}
N 5460 -4170 5480 -4170 {
lab=#net25}
N 5460 -4190 5480 -4190 {
lab=colon_n[12]}
N 5460 -4210 5480 -4210 {
lab=col_n[12]}
N 5280 -4070 5280 -4060 {
lab=VSS}
N 5280 -4300 5280 -4290 {
lab=VDD}
N 5620 -4070 5630 -4080 {
lab=row_n[17]}
N 5630 -4280 5630 -4080 {
lab=row_n[17]}
N 5620 -4290 5630 -4280 {
lab=row_n[17]}
N 5620 -4070 5620 -4050 {
lab=row_n[17]}
N 5620 -4310 5620 -4290 {
lab=row_n[17]}
N 5500 -4210 5510 -4220 {
lab=col_n[12]}
N 5510 -4220 5710 -4220 {
lab=col_n[12]}
N 5710 -4220 5720 -4210 {
lab=col_n[12]}
N 5500 -4190 5510 -4200 {
lab=colon_n[12]}
N 5510 -4200 5710 -4200 {
lab=colon_n[12]}
N 5710 -4200 5720 -4190 {
lab=colon_n[12]}
N 5500 -4170 5510 -4180 {
lab=#net25}
N 5510 -4180 5710 -4180 {
lab=#net25}
N 5710 -4180 5720 -4170 {
lab=#net25}
N 5500 -4150 5510 -4160 {
lab=#net26}
N 5510 -4160 5710 -4160 {
lab=#net26}
N 5710 -4160 5720 -4150 {
lab=#net26}
N 5560 -4310 5560 -4290 {
lab=vcom}
N 5600 -4310 5600 -4290 {
lab=ctop}
N 5480 -4210 5500 -4210 {
lab=col_n[12]}
N 5480 -4190 5500 -4190 {
lab=colon_n[12]}
N 5480 -4170 5500 -4170 {
lab=#net25}
N 5480 -4150 5500 -4150 {
lab=#net26}
N 5720 -4150 5740 -4150 {
lab=#net26}
N 5720 -4170 5740 -4170 {
lab=#net25}
N 5720 -4190 5740 -4190 {
lab=colon_n[12]}
N 5720 -4210 5740 -4210 {
lab=col_n[12]}
N 5540 -4070 5540 -4060 {
lab=VSS}
N 5540 -4300 5540 -4290 {
lab=VDD}
N 5880 -4070 5890 -4080 {
lab=row_n[18]}
N 5890 -4280 5890 -4080 {
lab=row_n[18]}
N 5880 -4290 5890 -4280 {
lab=row_n[18]}
N 5880 -4070 5880 -4050 {
lab=row_n[18]}
N 5880 -4310 5880 -4290 {
lab=row_n[18]}
N 5760 -4210 5770 -4220 {
lab=col_n[12]}
N 5770 -4220 5970 -4220 {
lab=col_n[12]}
N 5970 -4220 5980 -4210 {
lab=col_n[12]}
N 5760 -4190 5770 -4200 {
lab=colon_n[12]}
N 5770 -4200 5970 -4200 {
lab=colon_n[12]}
N 5970 -4200 5980 -4190 {
lab=colon_n[12]}
N 5760 -4170 5770 -4180 {
lab=#net25}
N 5770 -4180 5970 -4180 {
lab=#net25}
N 5970 -4180 5980 -4170 {
lab=#net25}
N 5760 -4150 5770 -4160 {
lab=#net26}
N 5770 -4160 5970 -4160 {
lab=#net26}
N 5970 -4160 5980 -4150 {
lab=#net26}
N 5820 -4310 5820 -4290 {
lab=vcom}
N 5860 -4310 5860 -4290 {
lab=ctop}
N 5740 -4210 5760 -4210 {
lab=col_n[12]}
N 5740 -4190 5760 -4190 {
lab=colon_n[12]}
N 5740 -4170 5760 -4170 {
lab=#net25}
N 5740 -4150 5760 -4150 {
lab=#net26}
N 5980 -4150 6000 -4150 {
lab=#net26}
N 5980 -4170 6000 -4170 {
lab=#net25}
N 5980 -4190 6000 -4190 {
lab=colon_n[12]}
N 5980 -4210 6000 -4210 {
lab=col_n[12]}
N 5800 -4070 5800 -4060 {
lab=VSS}
N 5800 -4300 5800 -4290 {
lab=VDD}
N 6140 -4070 6150 -4080 {
lab=row_n[19]}
N 6150 -4280 6150 -4080 {
lab=row_n[19]}
N 6140 -4290 6150 -4280 {
lab=row_n[19]}
N 6140 -4070 6140 -4050 {
lab=row_n[19]}
N 6140 -4310 6140 -4290 {
lab=row_n[19]}
N 6020 -4210 6030 -4220 {
lab=col_n[12]}
N 6030 -4220 6230 -4220 {
lab=col_n[12]}
N 6230 -4220 6240 -4210 {
lab=col_n[12]}
N 6020 -4190 6030 -4200 {
lab=colon_n[12]}
N 6030 -4200 6230 -4200 {
lab=colon_n[12]}
N 6230 -4200 6240 -4190 {
lab=colon_n[12]}
N 6020 -4170 6030 -4180 {
lab=#net25}
N 6030 -4180 6230 -4180 {
lab=#net25}
N 6230 -4180 6240 -4170 {
lab=#net25}
N 6020 -4150 6030 -4160 {
lab=#net26}
N 6030 -4160 6230 -4160 {
lab=#net26}
N 6230 -4160 6240 -4150 {
lab=#net26}
N 6080 -4310 6080 -4290 {
lab=vcom}
N 6120 -4310 6120 -4290 {
lab=ctop}
N 6000 -4210 6020 -4210 {
lab=col_n[12]}
N 6000 -4190 6020 -4190 {
lab=colon_n[12]}
N 6000 -4170 6020 -4170 {
lab=#net25}
N 6000 -4150 6020 -4150 {
lab=#net26}
N 6240 -4150 6260 -4150 {
lab=#net26}
N 6240 -4170 6260 -4170 {
lab=#net25}
N 6240 -4190 6260 -4190 {
lab=colon_n[12]}
N 6240 -4210 6260 -4210 {
lab=col_n[12]}
N 6060 -4070 6060 -4060 {
lab=VSS}
N 6060 -4300 6060 -4290 {
lab=VDD}
N 6400 -4070 6410 -4080 {
lab=row_n[20]}
N 6410 -4280 6410 -4080 {
lab=row_n[20]}
N 6400 -4290 6410 -4280 {
lab=row_n[20]}
N 6400 -4070 6400 -4050 {
lab=row_n[20]}
N 6400 -4310 6400 -4290 {
lab=row_n[20]}
N 6280 -4210 6290 -4220 {
lab=col_n[12]}
N 6290 -4220 6490 -4220 {
lab=col_n[12]}
N 6490 -4220 6500 -4210 {
lab=col_n[12]}
N 6280 -4190 6290 -4200 {
lab=colon_n[12]}
N 6290 -4200 6490 -4200 {
lab=colon_n[12]}
N 6490 -4200 6500 -4190 {
lab=colon_n[12]}
N 6280 -4170 6290 -4180 {
lab=#net25}
N 6290 -4180 6490 -4180 {
lab=#net25}
N 6490 -4180 6500 -4170 {
lab=#net25}
N 6280 -4150 6290 -4160 {
lab=#net26}
N 6290 -4160 6490 -4160 {
lab=#net26}
N 6490 -4160 6500 -4150 {
lab=#net26}
N 6340 -4310 6340 -4290 {
lab=vcom}
N 6380 -4310 6380 -4290 {
lab=ctop}
N 6260 -4210 6280 -4210 {
lab=col_n[12]}
N 6260 -4190 6280 -4190 {
lab=colon_n[12]}
N 6260 -4170 6280 -4170 {
lab=#net25}
N 6260 -4150 6280 -4150 {
lab=#net26}
N 6500 -4150 6520 -4150 {
lab=#net26}
N 6500 -4170 6520 -4170 {
lab=#net25}
N 6500 -4190 6520 -4190 {
lab=colon_n[12]}
N 6500 -4210 6520 -4210 {
lab=col_n[12]}
N 6320 -4070 6320 -4060 {
lab=VSS}
N 6320 -4300 6320 -4290 {
lab=VDD}
N 6660 -4070 6670 -4080 {
lab=row_n[21]}
N 6670 -4280 6670 -4080 {
lab=row_n[21]}
N 6660 -4290 6670 -4280 {
lab=row_n[21]}
N 6660 -4070 6660 -4050 {
lab=row_n[21]}
N 6660 -4310 6660 -4290 {
lab=row_n[21]}
N 6540 -4210 6550 -4220 {
lab=col_n[12]}
N 6550 -4220 6750 -4220 {
lab=col_n[12]}
N 6750 -4220 6760 -4210 {
lab=col_n[12]}
N 6540 -4190 6550 -4200 {
lab=colon_n[12]}
N 6550 -4200 6750 -4200 {
lab=colon_n[12]}
N 6750 -4200 6760 -4190 {
lab=colon_n[12]}
N 6540 -4170 6550 -4180 {
lab=#net25}
N 6550 -4180 6750 -4180 {
lab=#net25}
N 6750 -4180 6760 -4170 {
lab=#net25}
N 6540 -4150 6550 -4160 {
lab=#net26}
N 6550 -4160 6750 -4160 {
lab=#net26}
N 6750 -4160 6760 -4150 {
lab=#net26}
N 6600 -4310 6600 -4290 {
lab=vcom}
N 6640 -4310 6640 -4290 {
lab=ctop}
N 6520 -4210 6540 -4210 {
lab=col_n[12]}
N 6520 -4190 6540 -4190 {
lab=colon_n[12]}
N 6520 -4170 6540 -4170 {
lab=#net25}
N 6520 -4150 6540 -4150 {
lab=#net26}
N 6760 -4150 6780 -4150 {
lab=#net26}
N 6760 -4170 6780 -4170 {
lab=#net25}
N 6760 -4190 6780 -4190 {
lab=colon_n[12]}
N 6760 -4210 6780 -4210 {
lab=col_n[12]}
N 6580 -4070 6580 -4060 {
lab=VSS}
N 6580 -4300 6580 -4290 {
lab=VDD}
N 6920 -4070 6930 -4080 {
lab=row_n[22]}
N 6930 -4280 6930 -4080 {
lab=row_n[22]}
N 6920 -4290 6930 -4280 {
lab=row_n[22]}
N 6920 -4070 6920 -4050 {
lab=row_n[22]}
N 6920 -4310 6920 -4290 {
lab=row_n[22]}
N 6800 -4210 6810 -4220 {
lab=col_n[12]}
N 6810 -4220 7010 -4220 {
lab=col_n[12]}
N 7010 -4220 7020 -4210 {
lab=col_n[12]}
N 6800 -4190 6810 -4200 {
lab=colon_n[12]}
N 6810 -4200 7010 -4200 {
lab=colon_n[12]}
N 7010 -4200 7020 -4190 {
lab=colon_n[12]}
N 6800 -4170 6810 -4180 {
lab=#net25}
N 6810 -4180 7010 -4180 {
lab=#net25}
N 7010 -4180 7020 -4170 {
lab=#net25}
N 6800 -4150 6810 -4160 {
lab=#net26}
N 6810 -4160 7010 -4160 {
lab=#net26}
N 7010 -4160 7020 -4150 {
lab=#net26}
N 6860 -4310 6860 -4290 {
lab=vcom}
N 6900 -4310 6900 -4290 {
lab=ctop}
N 6780 -4210 6800 -4210 {
lab=col_n[12]}
N 6780 -4190 6800 -4190 {
lab=colon_n[12]}
N 6780 -4170 6800 -4170 {
lab=#net25}
N 6780 -4150 6800 -4150 {
lab=#net26}
N 7020 -4150 7040 -4150 {
lab=#net26}
N 7020 -4170 7040 -4170 {
lab=#net25}
N 7020 -4190 7040 -4190 {
lab=colon_n[12]}
N 7020 -4210 7040 -4210 {
lab=col_n[12]}
N 6840 -4070 6840 -4060 {
lab=VSS}
N 6840 -4300 6840 -4290 {
lab=VDD}
N 7180 -4070 7190 -4080 {
lab=row_n[23]}
N 7190 -4280 7190 -4080 {
lab=row_n[23]}
N 7180 -4290 7190 -4280 {
lab=row_n[23]}
N 7180 -4070 7180 -4050 {
lab=row_n[23]}
N 7180 -4310 7180 -4290 {
lab=row_n[23]}
N 7060 -4210 7070 -4220 {
lab=col_n[12]}
N 7070 -4220 7270 -4220 {
lab=col_n[12]}
N 7270 -4220 7280 -4210 {
lab=col_n[12]}
N 7060 -4190 7070 -4200 {
lab=colon_n[12]}
N 7070 -4200 7270 -4200 {
lab=colon_n[12]}
N 7270 -4200 7280 -4190 {
lab=colon_n[12]}
N 7060 -4170 7070 -4180 {
lab=#net25}
N 7070 -4180 7270 -4180 {
lab=#net25}
N 7270 -4180 7280 -4170 {
lab=#net25}
N 7060 -4150 7070 -4160 {
lab=#net26}
N 7070 -4160 7270 -4160 {
lab=#net26}
N 7270 -4160 7280 -4150 {
lab=#net26}
N 7120 -4310 7120 -4290 {
lab=vcom}
N 7160 -4310 7160 -4290 {
lab=ctop}
N 7040 -4210 7060 -4210 {
lab=col_n[12]}
N 7040 -4190 7060 -4190 {
lab=colon_n[12]}
N 7040 -4170 7060 -4170 {
lab=#net25}
N 7040 -4150 7060 -4150 {
lab=#net26}
N 7280 -4150 7300 -4150 {
lab=#net26}
N 7280 -4170 7300 -4170 {
lab=#net25}
N 7280 -4190 7300 -4190 {
lab=colon_n[12]}
N 7280 -4210 7300 -4210 {
lab=col_n[12]}
N 7100 -4070 7100 -4060 {
lab=VSS}
N 7100 -4300 7100 -4290 {
lab=VDD}
N 7440 -4070 7450 -4080 {
lab=row_n[24]}
N 7450 -4280 7450 -4080 {
lab=row_n[24]}
N 7440 -4290 7450 -4280 {
lab=row_n[24]}
N 7440 -4070 7440 -4050 {
lab=row_n[24]}
N 7440 -4310 7440 -4290 {
lab=row_n[24]}
N 7320 -4210 7330 -4220 {
lab=col_n[12]}
N 7330 -4220 7530 -4220 {
lab=col_n[12]}
N 7530 -4220 7540 -4210 {
lab=col_n[12]}
N 7320 -4190 7330 -4200 {
lab=colon_n[12]}
N 7330 -4200 7530 -4200 {
lab=colon_n[12]}
N 7530 -4200 7540 -4190 {
lab=colon_n[12]}
N 7320 -4170 7330 -4180 {
lab=#net25}
N 7330 -4180 7530 -4180 {
lab=#net25}
N 7530 -4180 7540 -4170 {
lab=#net25}
N 7320 -4150 7330 -4160 {
lab=#net26}
N 7330 -4160 7530 -4160 {
lab=#net26}
N 7530 -4160 7540 -4150 {
lab=#net26}
N 7380 -4310 7380 -4290 {
lab=vcom}
N 7420 -4310 7420 -4290 {
lab=ctop}
N 7300 -4210 7320 -4210 {
lab=col_n[12]}
N 7300 -4190 7320 -4190 {
lab=colon_n[12]}
N 7300 -4170 7320 -4170 {
lab=#net25}
N 7300 -4150 7320 -4150 {
lab=#net26}
N 7540 -4150 7560 -4150 {
lab=#net26}
N 7540 -4170 7560 -4170 {
lab=#net25}
N 7540 -4190 7560 -4190 {
lab=colon_n[12]}
N 7540 -4210 7560 -4210 {
lab=col_n[12]}
N 7360 -4070 7360 -4060 {
lab=VSS}
N 7360 -4300 7360 -4290 {
lab=VDD}
N 7700 -4070 7710 -4080 {
lab=row_n[25]}
N 7710 -4280 7710 -4080 {
lab=row_n[25]}
N 7700 -4290 7710 -4280 {
lab=row_n[25]}
N 7700 -4070 7700 -4050 {
lab=row_n[25]}
N 7700 -4310 7700 -4290 {
lab=row_n[25]}
N 7580 -4210 7590 -4220 {
lab=col_n[12]}
N 7590 -4220 7790 -4220 {
lab=col_n[12]}
N 7790 -4220 7800 -4210 {
lab=col_n[12]}
N 7580 -4190 7590 -4200 {
lab=colon_n[12]}
N 7590 -4200 7790 -4200 {
lab=colon_n[12]}
N 7790 -4200 7800 -4190 {
lab=colon_n[12]}
N 7580 -4170 7590 -4180 {
lab=#net25}
N 7590 -4180 7790 -4180 {
lab=#net25}
N 7790 -4180 7800 -4170 {
lab=#net25}
N 7580 -4150 7590 -4160 {
lab=#net26}
N 7590 -4160 7790 -4160 {
lab=#net26}
N 7790 -4160 7800 -4150 {
lab=#net26}
N 7640 -4310 7640 -4290 {
lab=vcom}
N 7680 -4310 7680 -4290 {
lab=ctop}
N 7560 -4210 7580 -4210 {
lab=col_n[12]}
N 7560 -4190 7580 -4190 {
lab=colon_n[12]}
N 7560 -4170 7580 -4170 {
lab=#net25}
N 7560 -4150 7580 -4150 {
lab=#net26}
N 7800 -4150 7820 -4150 {
lab=#net26}
N 7800 -4170 7820 -4170 {
lab=#net25}
N 7800 -4190 7820 -4190 {
lab=colon_n[12]}
N 7800 -4210 7820 -4210 {
lab=col_n[12]}
N 7620 -4070 7620 -4060 {
lab=VSS}
N 7620 -4300 7620 -4290 {
lab=VDD}
N 7960 -4070 7970 -4080 {
lab=row_n[26]}
N 7970 -4280 7970 -4080 {
lab=row_n[26]}
N 7960 -4290 7970 -4280 {
lab=row_n[26]}
N 7960 -4070 7960 -4050 {
lab=row_n[26]}
N 7960 -4310 7960 -4290 {
lab=row_n[26]}
N 7840 -4210 7850 -4220 {
lab=col_n[12]}
N 7850 -4220 8050 -4220 {
lab=col_n[12]}
N 8050 -4220 8060 -4210 {
lab=col_n[12]}
N 7840 -4190 7850 -4200 {
lab=colon_n[12]}
N 7850 -4200 8050 -4200 {
lab=colon_n[12]}
N 8050 -4200 8060 -4190 {
lab=colon_n[12]}
N 7840 -4170 7850 -4180 {
lab=#net25}
N 7850 -4180 8050 -4180 {
lab=#net25}
N 8050 -4180 8060 -4170 {
lab=#net25}
N 7840 -4150 7850 -4160 {
lab=#net26}
N 7850 -4160 8050 -4160 {
lab=#net26}
N 8050 -4160 8060 -4150 {
lab=#net26}
N 7900 -4310 7900 -4290 {
lab=vcom}
N 7940 -4310 7940 -4290 {
lab=ctop}
N 7820 -4210 7840 -4210 {
lab=col_n[12]}
N 7820 -4190 7840 -4190 {
lab=colon_n[12]}
N 7820 -4170 7840 -4170 {
lab=#net25}
N 7820 -4150 7840 -4150 {
lab=#net26}
N 8060 -4150 8080 -4150 {
lab=#net26}
N 8060 -4170 8080 -4170 {
lab=#net25}
N 8060 -4190 8080 -4190 {
lab=colon_n[12]}
N 8060 -4210 8080 -4210 {
lab=col_n[12]}
N 7880 -4070 7880 -4060 {
lab=VSS}
N 7880 -4300 7880 -4290 {
lab=VDD}
N 8220 -4070 8230 -4080 {
lab=row_n[27]}
N 8230 -4280 8230 -4080 {
lab=row_n[27]}
N 8220 -4290 8230 -4280 {
lab=row_n[27]}
N 8220 -4070 8220 -4050 {
lab=row_n[27]}
N 8220 -4310 8220 -4290 {
lab=row_n[27]}
N 8100 -4210 8110 -4220 {
lab=col_n[12]}
N 8110 -4220 8310 -4220 {
lab=col_n[12]}
N 8310 -4220 8320 -4210 {
lab=col_n[12]}
N 8100 -4190 8110 -4200 {
lab=colon_n[12]}
N 8110 -4200 8310 -4200 {
lab=colon_n[12]}
N 8310 -4200 8320 -4190 {
lab=colon_n[12]}
N 8100 -4170 8110 -4180 {
lab=#net25}
N 8110 -4180 8310 -4180 {
lab=#net25}
N 8310 -4180 8320 -4170 {
lab=#net25}
N 8100 -4150 8110 -4160 {
lab=#net26}
N 8110 -4160 8310 -4160 {
lab=#net26}
N 8310 -4160 8320 -4150 {
lab=#net26}
N 8160 -4310 8160 -4290 {
lab=vcom}
N 8200 -4310 8200 -4290 {
lab=ctop}
N 8080 -4210 8100 -4210 {
lab=col_n[12]}
N 8080 -4190 8100 -4190 {
lab=colon_n[12]}
N 8080 -4170 8100 -4170 {
lab=#net25}
N 8080 -4150 8100 -4150 {
lab=#net26}
N 8320 -4150 8340 -4150 {
lab=#net26}
N 8320 -4170 8340 -4170 {
lab=#net25}
N 8320 -4190 8340 -4190 {
lab=colon_n[12]}
N 8320 -4210 8340 -4210 {
lab=col_n[12]}
N 8140 -4070 8140 -4060 {
lab=VSS}
N 8140 -4300 8140 -4290 {
lab=VDD}
N 8480 -4070 8490 -4080 {
lab=row_n[28]}
N 8490 -4280 8490 -4080 {
lab=row_n[28]}
N 8480 -4290 8490 -4280 {
lab=row_n[28]}
N 8480 -4070 8480 -4050 {
lab=row_n[28]}
N 8480 -4310 8480 -4290 {
lab=row_n[28]}
N 8360 -4210 8370 -4220 {
lab=col_n[12]}
N 8370 -4220 8570 -4220 {
lab=col_n[12]}
N 8570 -4220 8580 -4210 {
lab=col_n[12]}
N 8360 -4190 8370 -4200 {
lab=colon_n[12]}
N 8370 -4200 8570 -4200 {
lab=colon_n[12]}
N 8570 -4200 8580 -4190 {
lab=colon_n[12]}
N 8360 -4170 8370 -4180 {
lab=#net25}
N 8370 -4180 8570 -4180 {
lab=#net25}
N 8570 -4180 8580 -4170 {
lab=#net25}
N 8360 -4150 8370 -4160 {
lab=#net26}
N 8370 -4160 8570 -4160 {
lab=#net26}
N 8570 -4160 8580 -4150 {
lab=#net26}
N 8420 -4310 8420 -4290 {
lab=vcom}
N 8460 -4310 8460 -4290 {
lab=ctop}
N 8340 -4210 8360 -4210 {
lab=col_n[12]}
N 8340 -4190 8360 -4190 {
lab=colon_n[12]}
N 8340 -4170 8360 -4170 {
lab=#net25}
N 8340 -4150 8360 -4150 {
lab=#net26}
N 8580 -4150 8600 -4150 {
lab=#net26}
N 8580 -4170 8600 -4170 {
lab=#net25}
N 8580 -4190 8600 -4190 {
lab=colon_n[12]}
N 8580 -4210 8600 -4210 {
lab=col_n[12]}
N 8400 -4070 8400 -4060 {
lab=VSS}
N 8400 -4300 8400 -4290 {
lab=VDD}
N 8740 -4070 8750 -4080 {
lab=row_n[29]}
N 8750 -4280 8750 -4080 {
lab=row_n[29]}
N 8740 -4290 8750 -4280 {
lab=row_n[29]}
N 8740 -4070 8740 -4050 {
lab=row_n[29]}
N 8740 -4310 8740 -4290 {
lab=row_n[29]}
N 8620 -4210 8630 -4220 {
lab=col_n[12]}
N 8630 -4220 8830 -4220 {
lab=col_n[12]}
N 8830 -4220 8840 -4210 {
lab=col_n[12]}
N 8620 -4190 8630 -4200 {
lab=colon_n[12]}
N 8630 -4200 8830 -4200 {
lab=colon_n[12]}
N 8830 -4200 8840 -4190 {
lab=colon_n[12]}
N 8620 -4170 8630 -4180 {
lab=#net25}
N 8630 -4180 8830 -4180 {
lab=#net25}
N 8830 -4180 8840 -4170 {
lab=#net25}
N 8620 -4150 8630 -4160 {
lab=#net26}
N 8630 -4160 8830 -4160 {
lab=#net26}
N 8830 -4160 8840 -4150 {
lab=#net26}
N 8680 -4310 8680 -4290 {
lab=vcom}
N 8720 -4310 8720 -4290 {
lab=ctop}
N 8600 -4210 8620 -4210 {
lab=col_n[12]}
N 8600 -4190 8620 -4190 {
lab=colon_n[12]}
N 8600 -4170 8620 -4170 {
lab=#net25}
N 8600 -4150 8620 -4150 {
lab=#net26}
N 8840 -4150 8860 -4150 {
lab=#net26}
N 8840 -4170 8860 -4170 {
lab=#net25}
N 8840 -4190 8860 -4190 {
lab=colon_n[12]}
N 8840 -4210 8860 -4210 {
lab=col_n[12]}
N 8660 -4070 8660 -4060 {
lab=VSS}
N 8660 -4300 8660 -4290 {
lab=VDD}
N 9000 -4070 9010 -4080 {
lab=row_n[30]}
N 9010 -4280 9010 -4080 {
lab=row_n[30]}
N 9000 -4290 9010 -4280 {
lab=row_n[30]}
N 9000 -4070 9000 -4050 {
lab=row_n[30]}
N 9000 -4310 9000 -4290 {
lab=row_n[30]}
N 8880 -4210 8890 -4220 {
lab=col_n[12]}
N 8890 -4220 9090 -4220 {
lab=col_n[12]}
N 9090 -4220 9100 -4210 {
lab=col_n[12]}
N 8880 -4190 8890 -4200 {
lab=colon_n[12]}
N 8890 -4200 9090 -4200 {
lab=colon_n[12]}
N 9090 -4200 9100 -4190 {
lab=colon_n[12]}
N 8880 -4170 8890 -4180 {
lab=#net25}
N 8890 -4180 9090 -4180 {
lab=#net25}
N 9090 -4180 9100 -4170 {
lab=#net25}
N 8880 -4150 8890 -4160 {
lab=#net26}
N 8890 -4160 9090 -4160 {
lab=#net26}
N 9090 -4160 9100 -4150 {
lab=#net26}
N 8940 -4310 8940 -4290 {
lab=vcom}
N 8980 -4310 8980 -4290 {
lab=ctop}
N 8860 -4210 8880 -4210 {
lab=col_n[12]}
N 8860 -4190 8880 -4190 {
lab=colon_n[12]}
N 8860 -4170 8880 -4170 {
lab=#net25}
N 8860 -4150 8880 -4150 {
lab=#net26}
N 9100 -4150 9120 -4150 {
lab=#net26}
N 9100 -4170 9120 -4170 {
lab=#net25}
N 9100 -4190 9120 -4190 {
lab=colon_n[12]}
N 9100 -4210 9120 -4210 {
lab=col_n[12]}
N 8920 -4070 8920 -4060 {
lab=VSS}
N 8920 -4300 8920 -4290 {
lab=VDD}
N 9260 -4070 9270 -4080 {
lab=row_n[31]}
N 9270 -4280 9270 -4080 {
lab=row_n[31]}
N 9260 -4290 9270 -4280 {
lab=row_n[31]}
N 9260 -4070 9260 -4050 {
lab=row_n[31]}
N 9260 -4310 9260 -4290 {
lab=row_n[31]}
N 9140 -4210 9150 -4220 {
lab=col_n[12]}
N 9150 -4220 9350 -4220 {
lab=col_n[12]}
N 9350 -4220 9360 -4210 {
lab=col_n[12]}
N 9140 -4190 9150 -4200 {
lab=colon_n[12]}
N 9150 -4200 9350 -4200 {
lab=colon_n[12]}
N 9350 -4200 9360 -4190 {
lab=colon_n[12]}
N 9140 -4170 9150 -4180 {
lab=#net25}
N 9150 -4180 9350 -4180 {
lab=#net25}
N 9350 -4180 9360 -4170 {
lab=#net25}
N 9140 -4150 9150 -4160 {
lab=#net26}
N 9150 -4160 9350 -4160 {
lab=#net26}
N 9350 -4160 9360 -4150 {
lab=#net26}
N 9200 -4310 9200 -4290 {
lab=vcom}
N 9240 -4310 9240 -4290 {
lab=ctop}
N 9120 -4210 9140 -4210 {
lab=col_n[12]}
N 9120 -4190 9140 -4190 {
lab=colon_n[12]}
N 9120 -4170 9140 -4170 {
lab=#net25}
N 9120 -4150 9140 -4150 {
lab=#net26}
N 9360 -4150 9380 -4150 {
lab=#net26}
N 9360 -4170 9380 -4170 {
lab=#net25}
N 9360 -4190 9380 -4190 {
lab=colon_n[12]}
N 9360 -4210 9380 -4210 {
lab=col_n[12]}
N 9180 -4070 9180 -4060 {
lab=VSS}
N 9180 -4300 9180 -4290 {
lab=VDD}
N 1200 -4330 1210 -4340 {
lab=row_n[0]}
N 1210 -4540 1210 -4340 {
lab=row_n[0]}
N 1200 -4550 1210 -4540 {
lab=row_n[0]}
N 1200 -4330 1200 -4310 {
lab=row_n[0]}
N 1200 -4570 1200 -4550 {
lab=row_n[0]}
N 1080 -4470 1090 -4480 {
lab=col_n[13]}
N 1090 -4480 1290 -4480 {
lab=col_n[13]}
N 1290 -4480 1300 -4470 {
lab=col_n[13]}
N 1080 -4450 1090 -4460 {
lab=colon_n[13]}
N 1090 -4460 1290 -4460 {
lab=colon_n[13]}
N 1290 -4460 1300 -4450 {
lab=colon_n[13]}
N 1080 -4430 1090 -4440 {
lab=#net27}
N 1090 -4440 1290 -4440 {
lab=#net27}
N 1290 -4440 1300 -4430 {
lab=#net27}
N 1080 -4410 1090 -4420 {
lab=#net28}
N 1090 -4420 1290 -4420 {
lab=#net28}
N 1290 -4420 1300 -4410 {
lab=#net28}
N 1140 -4570 1140 -4550 {
lab=vcom}
N 1180 -4570 1180 -4550 {
lab=ctop}
N 1060 -4470 1080 -4470 {
lab=col_n[13]}
N 1060 -4450 1080 -4450 {
lab=colon_n[13]}
N 1060 -4430 1080 -4430 {
lab=#net27}
N 1060 -4410 1080 -4410 {
lab=#net28}
N 1300 -4410 1320 -4410 {
lab=#net28}
N 1300 -4430 1320 -4430 {
lab=#net27}
N 1300 -4450 1320 -4450 {
lab=colon_n[13]}
N 1300 -4470 1320 -4470 {
lab=col_n[13]}
N 1120 -4330 1120 -4320 {
lab=VSS}
N 1120 -4560 1120 -4550 {
lab=VDD}
N 1460 -4330 1470 -4340 {
lab=row_n[1]}
N 1470 -4540 1470 -4340 {
lab=row_n[1]}
N 1460 -4550 1470 -4540 {
lab=row_n[1]}
N 1460 -4330 1460 -4310 {
lab=row_n[1]}
N 1460 -4570 1460 -4550 {
lab=row_n[1]}
N 1340 -4470 1350 -4480 {
lab=col_n[13]}
N 1350 -4480 1550 -4480 {
lab=col_n[13]}
N 1550 -4480 1560 -4470 {
lab=col_n[13]}
N 1340 -4450 1350 -4460 {
lab=colon_n[13]}
N 1350 -4460 1550 -4460 {
lab=colon_n[13]}
N 1550 -4460 1560 -4450 {
lab=colon_n[13]}
N 1340 -4430 1350 -4440 {
lab=#net27}
N 1350 -4440 1550 -4440 {
lab=#net27}
N 1550 -4440 1560 -4430 {
lab=#net27}
N 1340 -4410 1350 -4420 {
lab=#net28}
N 1350 -4420 1550 -4420 {
lab=#net28}
N 1550 -4420 1560 -4410 {
lab=#net28}
N 1400 -4570 1400 -4550 {
lab=vcom}
N 1440 -4570 1440 -4550 {
lab=ctop}
N 1320 -4470 1340 -4470 {
lab=col_n[13]}
N 1320 -4450 1340 -4450 {
lab=colon_n[13]}
N 1320 -4430 1340 -4430 {
lab=#net27}
N 1320 -4410 1340 -4410 {
lab=#net28}
N 1560 -4410 1580 -4410 {
lab=#net28}
N 1560 -4430 1580 -4430 {
lab=#net27}
N 1560 -4450 1580 -4450 {
lab=colon_n[13]}
N 1560 -4470 1580 -4470 {
lab=col_n[13]}
N 1380 -4330 1380 -4320 {
lab=VSS}
N 1380 -4560 1380 -4550 {
lab=VDD}
N 1720 -4330 1730 -4340 {
lab=row_n[2]}
N 1730 -4540 1730 -4340 {
lab=row_n[2]}
N 1720 -4550 1730 -4540 {
lab=row_n[2]}
N 1720 -4330 1720 -4310 {
lab=row_n[2]}
N 1720 -4570 1720 -4550 {
lab=row_n[2]}
N 1600 -4470 1610 -4480 {
lab=col_n[13]}
N 1610 -4480 1810 -4480 {
lab=col_n[13]}
N 1810 -4480 1820 -4470 {
lab=col_n[13]}
N 1600 -4450 1610 -4460 {
lab=colon_n[13]}
N 1610 -4460 1810 -4460 {
lab=colon_n[13]}
N 1810 -4460 1820 -4450 {
lab=colon_n[13]}
N 1600 -4430 1610 -4440 {
lab=#net27}
N 1610 -4440 1810 -4440 {
lab=#net27}
N 1810 -4440 1820 -4430 {
lab=#net27}
N 1600 -4410 1610 -4420 {
lab=#net28}
N 1610 -4420 1810 -4420 {
lab=#net28}
N 1810 -4420 1820 -4410 {
lab=#net28}
N 1660 -4570 1660 -4550 {
lab=vcom}
N 1700 -4570 1700 -4550 {
lab=ctop}
N 1580 -4470 1600 -4470 {
lab=col_n[13]}
N 1580 -4450 1600 -4450 {
lab=colon_n[13]}
N 1580 -4430 1600 -4430 {
lab=#net27}
N 1580 -4410 1600 -4410 {
lab=#net28}
N 1820 -4410 1840 -4410 {
lab=#net28}
N 1820 -4430 1840 -4430 {
lab=#net27}
N 1820 -4450 1840 -4450 {
lab=colon_n[13]}
N 1820 -4470 1840 -4470 {
lab=col_n[13]}
N 1640 -4330 1640 -4320 {
lab=VSS}
N 1640 -4560 1640 -4550 {
lab=VDD}
N 1980 -4330 1990 -4340 {
lab=row_n[3]}
N 1990 -4540 1990 -4340 {
lab=row_n[3]}
N 1980 -4550 1990 -4540 {
lab=row_n[3]}
N 1980 -4330 1980 -4310 {
lab=row_n[3]}
N 1980 -4570 1980 -4550 {
lab=row_n[3]}
N 1860 -4470 1870 -4480 {
lab=col_n[13]}
N 1870 -4480 2070 -4480 {
lab=col_n[13]}
N 2070 -4480 2080 -4470 {
lab=col_n[13]}
N 1860 -4450 1870 -4460 {
lab=colon_n[13]}
N 1870 -4460 2070 -4460 {
lab=colon_n[13]}
N 2070 -4460 2080 -4450 {
lab=colon_n[13]}
N 1860 -4430 1870 -4440 {
lab=#net27}
N 1870 -4440 2070 -4440 {
lab=#net27}
N 2070 -4440 2080 -4430 {
lab=#net27}
N 1860 -4410 1870 -4420 {
lab=#net28}
N 1870 -4420 2070 -4420 {
lab=#net28}
N 2070 -4420 2080 -4410 {
lab=#net28}
N 1920 -4570 1920 -4550 {
lab=vcom}
N 1960 -4570 1960 -4550 {
lab=ctop}
N 1840 -4470 1860 -4470 {
lab=col_n[13]}
N 1840 -4450 1860 -4450 {
lab=colon_n[13]}
N 1840 -4430 1860 -4430 {
lab=#net27}
N 1840 -4410 1860 -4410 {
lab=#net28}
N 2080 -4410 2100 -4410 {
lab=#net28}
N 2080 -4430 2100 -4430 {
lab=#net27}
N 2080 -4450 2100 -4450 {
lab=colon_n[13]}
N 2080 -4470 2100 -4470 {
lab=col_n[13]}
N 1900 -4330 1900 -4320 {
lab=VSS}
N 1900 -4560 1900 -4550 {
lab=VDD}
N 2240 -4330 2250 -4340 {
lab=row_n[4]}
N 2250 -4540 2250 -4340 {
lab=row_n[4]}
N 2240 -4550 2250 -4540 {
lab=row_n[4]}
N 2240 -4330 2240 -4310 {
lab=row_n[4]}
N 2240 -4570 2240 -4550 {
lab=row_n[4]}
N 2120 -4470 2130 -4480 {
lab=col_n[13]}
N 2130 -4480 2330 -4480 {
lab=col_n[13]}
N 2330 -4480 2340 -4470 {
lab=col_n[13]}
N 2120 -4450 2130 -4460 {
lab=colon_n[13]}
N 2130 -4460 2330 -4460 {
lab=colon_n[13]}
N 2330 -4460 2340 -4450 {
lab=colon_n[13]}
N 2120 -4430 2130 -4440 {
lab=#net27}
N 2130 -4440 2330 -4440 {
lab=#net27}
N 2330 -4440 2340 -4430 {
lab=#net27}
N 2120 -4410 2130 -4420 {
lab=#net28}
N 2130 -4420 2330 -4420 {
lab=#net28}
N 2330 -4420 2340 -4410 {
lab=#net28}
N 2180 -4570 2180 -4550 {
lab=vcom}
N 2220 -4570 2220 -4550 {
lab=ctop}
N 2100 -4470 2120 -4470 {
lab=col_n[13]}
N 2100 -4450 2120 -4450 {
lab=colon_n[13]}
N 2100 -4430 2120 -4430 {
lab=#net27}
N 2100 -4410 2120 -4410 {
lab=#net28}
N 2340 -4410 2360 -4410 {
lab=#net28}
N 2340 -4430 2360 -4430 {
lab=#net27}
N 2340 -4450 2360 -4450 {
lab=colon_n[13]}
N 2340 -4470 2360 -4470 {
lab=col_n[13]}
N 2160 -4330 2160 -4320 {
lab=VSS}
N 2160 -4560 2160 -4550 {
lab=VDD}
N 2500 -4330 2510 -4340 {
lab=row_n[5]}
N 2510 -4540 2510 -4340 {
lab=row_n[5]}
N 2500 -4550 2510 -4540 {
lab=row_n[5]}
N 2500 -4330 2500 -4310 {
lab=row_n[5]}
N 2500 -4570 2500 -4550 {
lab=row_n[5]}
N 2380 -4470 2390 -4480 {
lab=col_n[13]}
N 2390 -4480 2590 -4480 {
lab=col_n[13]}
N 2590 -4480 2600 -4470 {
lab=col_n[13]}
N 2380 -4450 2390 -4460 {
lab=colon_n[13]}
N 2390 -4460 2590 -4460 {
lab=colon_n[13]}
N 2590 -4460 2600 -4450 {
lab=colon_n[13]}
N 2380 -4430 2390 -4440 {
lab=#net27}
N 2390 -4440 2590 -4440 {
lab=#net27}
N 2590 -4440 2600 -4430 {
lab=#net27}
N 2380 -4410 2390 -4420 {
lab=#net28}
N 2390 -4420 2590 -4420 {
lab=#net28}
N 2590 -4420 2600 -4410 {
lab=#net28}
N 2440 -4570 2440 -4550 {
lab=vcom}
N 2480 -4570 2480 -4550 {
lab=ctop}
N 2360 -4470 2380 -4470 {
lab=col_n[13]}
N 2360 -4450 2380 -4450 {
lab=colon_n[13]}
N 2360 -4430 2380 -4430 {
lab=#net27}
N 2360 -4410 2380 -4410 {
lab=#net28}
N 2600 -4410 2620 -4410 {
lab=#net28}
N 2600 -4430 2620 -4430 {
lab=#net27}
N 2600 -4450 2620 -4450 {
lab=colon_n[13]}
N 2600 -4470 2620 -4470 {
lab=col_n[13]}
N 2420 -4330 2420 -4320 {
lab=VSS}
N 2420 -4560 2420 -4550 {
lab=VDD}
N 2760 -4330 2770 -4340 {
lab=row_n[6]}
N 2770 -4540 2770 -4340 {
lab=row_n[6]}
N 2760 -4550 2770 -4540 {
lab=row_n[6]}
N 2760 -4330 2760 -4310 {
lab=row_n[6]}
N 2760 -4570 2760 -4550 {
lab=row_n[6]}
N 2640 -4470 2650 -4480 {
lab=col_n[13]}
N 2650 -4480 2850 -4480 {
lab=col_n[13]}
N 2850 -4480 2860 -4470 {
lab=col_n[13]}
N 2640 -4450 2650 -4460 {
lab=colon_n[13]}
N 2650 -4460 2850 -4460 {
lab=colon_n[13]}
N 2850 -4460 2860 -4450 {
lab=colon_n[13]}
N 2640 -4430 2650 -4440 {
lab=#net27}
N 2650 -4440 2850 -4440 {
lab=#net27}
N 2850 -4440 2860 -4430 {
lab=#net27}
N 2640 -4410 2650 -4420 {
lab=#net28}
N 2650 -4420 2850 -4420 {
lab=#net28}
N 2850 -4420 2860 -4410 {
lab=#net28}
N 2700 -4570 2700 -4550 {
lab=vcom}
N 2740 -4570 2740 -4550 {
lab=ctop}
N 2620 -4470 2640 -4470 {
lab=col_n[13]}
N 2620 -4450 2640 -4450 {
lab=colon_n[13]}
N 2620 -4430 2640 -4430 {
lab=#net27}
N 2620 -4410 2640 -4410 {
lab=#net28}
N 2860 -4410 2880 -4410 {
lab=#net28}
N 2860 -4430 2880 -4430 {
lab=#net27}
N 2860 -4450 2880 -4450 {
lab=colon_n[13]}
N 2860 -4470 2880 -4470 {
lab=col_n[13]}
N 2680 -4330 2680 -4320 {
lab=VSS}
N 2680 -4560 2680 -4550 {
lab=VDD}
N 3020 -4330 3030 -4340 {
lab=row_n[7]}
N 3030 -4540 3030 -4340 {
lab=row_n[7]}
N 3020 -4550 3030 -4540 {
lab=row_n[7]}
N 3020 -4330 3020 -4310 {
lab=row_n[7]}
N 3020 -4570 3020 -4550 {
lab=row_n[7]}
N 2900 -4470 2910 -4480 {
lab=col_n[13]}
N 2910 -4480 3110 -4480 {
lab=col_n[13]}
N 3110 -4480 3120 -4470 {
lab=col_n[13]}
N 2900 -4450 2910 -4460 {
lab=colon_n[13]}
N 2910 -4460 3110 -4460 {
lab=colon_n[13]}
N 3110 -4460 3120 -4450 {
lab=colon_n[13]}
N 2900 -4430 2910 -4440 {
lab=#net27}
N 2910 -4440 3110 -4440 {
lab=#net27}
N 3110 -4440 3120 -4430 {
lab=#net27}
N 2900 -4410 2910 -4420 {
lab=#net28}
N 2910 -4420 3110 -4420 {
lab=#net28}
N 3110 -4420 3120 -4410 {
lab=#net28}
N 2960 -4570 2960 -4550 {
lab=vcom}
N 3000 -4570 3000 -4550 {
lab=ctop}
N 2880 -4470 2900 -4470 {
lab=col_n[13]}
N 2880 -4450 2900 -4450 {
lab=colon_n[13]}
N 2880 -4430 2900 -4430 {
lab=#net27}
N 2880 -4410 2900 -4410 {
lab=#net28}
N 3120 -4410 3140 -4410 {
lab=#net28}
N 3120 -4430 3140 -4430 {
lab=#net27}
N 3120 -4450 3140 -4450 {
lab=colon_n[13]}
N 3120 -4470 3140 -4470 {
lab=col_n[13]}
N 2940 -4330 2940 -4320 {
lab=VSS}
N 2940 -4560 2940 -4550 {
lab=VDD}
N 3280 -4330 3290 -4340 {
lab=row_n[8]}
N 3290 -4540 3290 -4340 {
lab=row_n[8]}
N 3280 -4550 3290 -4540 {
lab=row_n[8]}
N 3280 -4330 3280 -4310 {
lab=row_n[8]}
N 3280 -4570 3280 -4550 {
lab=row_n[8]}
N 3160 -4470 3170 -4480 {
lab=col_n[13]}
N 3170 -4480 3370 -4480 {
lab=col_n[13]}
N 3370 -4480 3380 -4470 {
lab=col_n[13]}
N 3160 -4450 3170 -4460 {
lab=colon_n[13]}
N 3170 -4460 3370 -4460 {
lab=colon_n[13]}
N 3370 -4460 3380 -4450 {
lab=colon_n[13]}
N 3160 -4430 3170 -4440 {
lab=#net27}
N 3170 -4440 3370 -4440 {
lab=#net27}
N 3370 -4440 3380 -4430 {
lab=#net27}
N 3160 -4410 3170 -4420 {
lab=#net28}
N 3170 -4420 3370 -4420 {
lab=#net28}
N 3370 -4420 3380 -4410 {
lab=#net28}
N 3220 -4570 3220 -4550 {
lab=vcom}
N 3260 -4570 3260 -4550 {
lab=ctop}
N 3140 -4470 3160 -4470 {
lab=col_n[13]}
N 3140 -4450 3160 -4450 {
lab=colon_n[13]}
N 3140 -4430 3160 -4430 {
lab=#net27}
N 3140 -4410 3160 -4410 {
lab=#net28}
N 3380 -4410 3400 -4410 {
lab=#net28}
N 3380 -4430 3400 -4430 {
lab=#net27}
N 3380 -4450 3400 -4450 {
lab=colon_n[13]}
N 3380 -4470 3400 -4470 {
lab=col_n[13]}
N 3200 -4330 3200 -4320 {
lab=VSS}
N 3200 -4560 3200 -4550 {
lab=VDD}
N 3540 -4330 3550 -4340 {
lab=row_n[9]}
N 3550 -4540 3550 -4340 {
lab=row_n[9]}
N 3540 -4550 3550 -4540 {
lab=row_n[9]}
N 3540 -4330 3540 -4310 {
lab=row_n[9]}
N 3540 -4570 3540 -4550 {
lab=row_n[9]}
N 3420 -4470 3430 -4480 {
lab=col_n[13]}
N 3430 -4480 3630 -4480 {
lab=col_n[13]}
N 3630 -4480 3640 -4470 {
lab=col_n[13]}
N 3420 -4450 3430 -4460 {
lab=colon_n[13]}
N 3430 -4460 3630 -4460 {
lab=colon_n[13]}
N 3630 -4460 3640 -4450 {
lab=colon_n[13]}
N 3420 -4430 3430 -4440 {
lab=#net27}
N 3430 -4440 3630 -4440 {
lab=#net27}
N 3630 -4440 3640 -4430 {
lab=#net27}
N 3420 -4410 3430 -4420 {
lab=#net28}
N 3430 -4420 3630 -4420 {
lab=#net28}
N 3630 -4420 3640 -4410 {
lab=#net28}
N 3480 -4570 3480 -4550 {
lab=vcom}
N 3520 -4570 3520 -4550 {
lab=ctop}
N 3400 -4470 3420 -4470 {
lab=col_n[13]}
N 3400 -4450 3420 -4450 {
lab=colon_n[13]}
N 3400 -4430 3420 -4430 {
lab=#net27}
N 3400 -4410 3420 -4410 {
lab=#net28}
N 3640 -4410 3660 -4410 {
lab=#net28}
N 3640 -4430 3660 -4430 {
lab=#net27}
N 3640 -4450 3660 -4450 {
lab=colon_n[13]}
N 3640 -4470 3660 -4470 {
lab=col_n[13]}
N 3460 -4330 3460 -4320 {
lab=VSS}
N 3460 -4560 3460 -4550 {
lab=VDD}
N 3800 -4330 3810 -4340 {
lab=row_n[10]}
N 3810 -4540 3810 -4340 {
lab=row_n[10]}
N 3800 -4550 3810 -4540 {
lab=row_n[10]}
N 3800 -4330 3800 -4310 {
lab=row_n[10]}
N 3800 -4570 3800 -4550 {
lab=row_n[10]}
N 3680 -4470 3690 -4480 {
lab=col_n[13]}
N 3690 -4480 3890 -4480 {
lab=col_n[13]}
N 3890 -4480 3900 -4470 {
lab=col_n[13]}
N 3680 -4450 3690 -4460 {
lab=colon_n[13]}
N 3690 -4460 3890 -4460 {
lab=colon_n[13]}
N 3890 -4460 3900 -4450 {
lab=colon_n[13]}
N 3680 -4430 3690 -4440 {
lab=#net27}
N 3690 -4440 3890 -4440 {
lab=#net27}
N 3890 -4440 3900 -4430 {
lab=#net27}
N 3680 -4410 3690 -4420 {
lab=#net28}
N 3690 -4420 3890 -4420 {
lab=#net28}
N 3890 -4420 3900 -4410 {
lab=#net28}
N 3740 -4570 3740 -4550 {
lab=vcom}
N 3780 -4570 3780 -4550 {
lab=ctop}
N 3660 -4470 3680 -4470 {
lab=col_n[13]}
N 3660 -4450 3680 -4450 {
lab=colon_n[13]}
N 3660 -4430 3680 -4430 {
lab=#net27}
N 3660 -4410 3680 -4410 {
lab=#net28}
N 3900 -4410 3920 -4410 {
lab=#net28}
N 3900 -4430 3920 -4430 {
lab=#net27}
N 3900 -4450 3920 -4450 {
lab=colon_n[13]}
N 3900 -4470 3920 -4470 {
lab=col_n[13]}
N 3720 -4330 3720 -4320 {
lab=VSS}
N 3720 -4560 3720 -4550 {
lab=VDD}
N 4060 -4330 4070 -4340 {
lab=row_n[11]}
N 4070 -4540 4070 -4340 {
lab=row_n[11]}
N 4060 -4550 4070 -4540 {
lab=row_n[11]}
N 4060 -4330 4060 -4310 {
lab=row_n[11]}
N 4060 -4570 4060 -4550 {
lab=row_n[11]}
N 3940 -4470 3950 -4480 {
lab=col_n[13]}
N 3950 -4480 4150 -4480 {
lab=col_n[13]}
N 4150 -4480 4160 -4470 {
lab=col_n[13]}
N 3940 -4450 3950 -4460 {
lab=colon_n[13]}
N 3950 -4460 4150 -4460 {
lab=colon_n[13]}
N 4150 -4460 4160 -4450 {
lab=colon_n[13]}
N 3940 -4430 3950 -4440 {
lab=#net27}
N 3950 -4440 4150 -4440 {
lab=#net27}
N 4150 -4440 4160 -4430 {
lab=#net27}
N 3940 -4410 3950 -4420 {
lab=#net28}
N 3950 -4420 4150 -4420 {
lab=#net28}
N 4150 -4420 4160 -4410 {
lab=#net28}
N 4000 -4570 4000 -4550 {
lab=vcom}
N 4040 -4570 4040 -4550 {
lab=ctop}
N 3920 -4470 3940 -4470 {
lab=col_n[13]}
N 3920 -4450 3940 -4450 {
lab=colon_n[13]}
N 3920 -4430 3940 -4430 {
lab=#net27}
N 3920 -4410 3940 -4410 {
lab=#net28}
N 4160 -4410 4180 -4410 {
lab=#net28}
N 4160 -4430 4180 -4430 {
lab=#net27}
N 4160 -4450 4180 -4450 {
lab=colon_n[13]}
N 4160 -4470 4180 -4470 {
lab=col_n[13]}
N 3980 -4330 3980 -4320 {
lab=VSS}
N 3980 -4560 3980 -4550 {
lab=VDD}
N 4320 -4330 4330 -4340 {
lab=row_n[12]}
N 4330 -4540 4330 -4340 {
lab=row_n[12]}
N 4320 -4550 4330 -4540 {
lab=row_n[12]}
N 4320 -4330 4320 -4310 {
lab=row_n[12]}
N 4320 -4570 4320 -4550 {
lab=row_n[12]}
N 4200 -4470 4210 -4480 {
lab=col_n[13]}
N 4210 -4480 4410 -4480 {
lab=col_n[13]}
N 4410 -4480 4420 -4470 {
lab=col_n[13]}
N 4200 -4450 4210 -4460 {
lab=colon_n[13]}
N 4210 -4460 4410 -4460 {
lab=colon_n[13]}
N 4410 -4460 4420 -4450 {
lab=colon_n[13]}
N 4200 -4430 4210 -4440 {
lab=#net27}
N 4210 -4440 4410 -4440 {
lab=#net27}
N 4410 -4440 4420 -4430 {
lab=#net27}
N 4200 -4410 4210 -4420 {
lab=#net28}
N 4210 -4420 4410 -4420 {
lab=#net28}
N 4410 -4420 4420 -4410 {
lab=#net28}
N 4260 -4570 4260 -4550 {
lab=vcom}
N 4300 -4570 4300 -4550 {
lab=ctop}
N 4180 -4470 4200 -4470 {
lab=col_n[13]}
N 4180 -4450 4200 -4450 {
lab=colon_n[13]}
N 4180 -4430 4200 -4430 {
lab=#net27}
N 4180 -4410 4200 -4410 {
lab=#net28}
N 4420 -4410 4440 -4410 {
lab=#net28}
N 4420 -4430 4440 -4430 {
lab=#net27}
N 4420 -4450 4440 -4450 {
lab=colon_n[13]}
N 4420 -4470 4440 -4470 {
lab=col_n[13]}
N 4240 -4330 4240 -4320 {
lab=VSS}
N 4240 -4560 4240 -4550 {
lab=VDD}
N 4580 -4330 4590 -4340 {
lab=row_n[13]}
N 4590 -4540 4590 -4340 {
lab=row_n[13]}
N 4580 -4550 4590 -4540 {
lab=row_n[13]}
N 4580 -4330 4580 -4310 {
lab=row_n[13]}
N 4580 -4570 4580 -4550 {
lab=row_n[13]}
N 4460 -4470 4470 -4480 {
lab=col_n[13]}
N 4470 -4480 4670 -4480 {
lab=col_n[13]}
N 4670 -4480 4680 -4470 {
lab=col_n[13]}
N 4460 -4450 4470 -4460 {
lab=colon_n[13]}
N 4470 -4460 4670 -4460 {
lab=colon_n[13]}
N 4670 -4460 4680 -4450 {
lab=colon_n[13]}
N 4460 -4430 4470 -4440 {
lab=#net27}
N 4470 -4440 4670 -4440 {
lab=#net27}
N 4670 -4440 4680 -4430 {
lab=#net27}
N 4460 -4410 4470 -4420 {
lab=#net28}
N 4470 -4420 4670 -4420 {
lab=#net28}
N 4670 -4420 4680 -4410 {
lab=#net28}
N 4520 -4570 4520 -4550 {
lab=vcom}
N 4560 -4570 4560 -4550 {
lab=ctop}
N 4440 -4470 4460 -4470 {
lab=col_n[13]}
N 4440 -4450 4460 -4450 {
lab=colon_n[13]}
N 4440 -4430 4460 -4430 {
lab=#net27}
N 4440 -4410 4460 -4410 {
lab=#net28}
N 4680 -4410 4700 -4410 {
lab=#net28}
N 4680 -4430 4700 -4430 {
lab=#net27}
N 4680 -4450 4700 -4450 {
lab=colon_n[13]}
N 4680 -4470 4700 -4470 {
lab=col_n[13]}
N 4500 -4330 4500 -4320 {
lab=VSS}
N 4500 -4560 4500 -4550 {
lab=VDD}
N 4840 -4330 4850 -4340 {
lab=row_n[14]}
N 4850 -4540 4850 -4340 {
lab=row_n[14]}
N 4840 -4550 4850 -4540 {
lab=row_n[14]}
N 4840 -4330 4840 -4310 {
lab=row_n[14]}
N 4840 -4570 4840 -4550 {
lab=row_n[14]}
N 4720 -4470 4730 -4480 {
lab=col_n[13]}
N 4730 -4480 4930 -4480 {
lab=col_n[13]}
N 4930 -4480 4940 -4470 {
lab=col_n[13]}
N 4720 -4450 4730 -4460 {
lab=colon_n[13]}
N 4730 -4460 4930 -4460 {
lab=colon_n[13]}
N 4930 -4460 4940 -4450 {
lab=colon_n[13]}
N 4720 -4430 4730 -4440 {
lab=#net27}
N 4730 -4440 4930 -4440 {
lab=#net27}
N 4930 -4440 4940 -4430 {
lab=#net27}
N 4720 -4410 4730 -4420 {
lab=#net28}
N 4730 -4420 4930 -4420 {
lab=#net28}
N 4930 -4420 4940 -4410 {
lab=#net28}
N 4780 -4570 4780 -4550 {
lab=vcom}
N 4820 -4570 4820 -4550 {
lab=ctop}
N 4700 -4470 4720 -4470 {
lab=col_n[13]}
N 4700 -4450 4720 -4450 {
lab=colon_n[13]}
N 4700 -4430 4720 -4430 {
lab=#net27}
N 4700 -4410 4720 -4410 {
lab=#net28}
N 4940 -4410 4960 -4410 {
lab=#net28}
N 4940 -4430 4960 -4430 {
lab=#net27}
N 4940 -4450 4960 -4450 {
lab=colon_n[13]}
N 4940 -4470 4960 -4470 {
lab=col_n[13]}
N 4760 -4330 4760 -4320 {
lab=VSS}
N 4760 -4560 4760 -4550 {
lab=VDD}
N 5100 -4330 5110 -4340 {
lab=row_n[15]}
N 5110 -4540 5110 -4340 {
lab=row_n[15]}
N 5100 -4550 5110 -4540 {
lab=row_n[15]}
N 5100 -4330 5100 -4310 {
lab=row_n[15]}
N 5100 -4570 5100 -4550 {
lab=row_n[15]}
N 4980 -4470 4990 -4480 {
lab=col_n[13]}
N 4990 -4480 5190 -4480 {
lab=col_n[13]}
N 5190 -4480 5200 -4470 {
lab=col_n[13]}
N 4980 -4450 4990 -4460 {
lab=colon_n[13]}
N 4990 -4460 5190 -4460 {
lab=colon_n[13]}
N 5190 -4460 5200 -4450 {
lab=colon_n[13]}
N 4980 -4430 4990 -4440 {
lab=#net27}
N 4990 -4440 5190 -4440 {
lab=#net27}
N 5190 -4440 5200 -4430 {
lab=#net27}
N 4980 -4410 4990 -4420 {
lab=#net28}
N 4990 -4420 5190 -4420 {
lab=#net28}
N 5190 -4420 5200 -4410 {
lab=#net28}
N 5040 -4570 5040 -4550 {
lab=vcom}
N 5080 -4570 5080 -4550 {
lab=ctop}
N 4960 -4470 4980 -4470 {
lab=col_n[13]}
N 4960 -4450 4980 -4450 {
lab=colon_n[13]}
N 4960 -4430 4980 -4430 {
lab=#net27}
N 4960 -4410 4980 -4410 {
lab=#net28}
N 5200 -4410 5220 -4410 {
lab=#net28}
N 5200 -4430 5220 -4430 {
lab=#net27}
N 5200 -4450 5220 -4450 {
lab=colon_n[13]}
N 5200 -4470 5220 -4470 {
lab=col_n[13]}
N 5020 -4330 5020 -4320 {
lab=VSS}
N 5020 -4560 5020 -4550 {
lab=VDD}
N 5360 -4330 5370 -4340 {
lab=row_n[16]}
N 5370 -4540 5370 -4340 {
lab=row_n[16]}
N 5360 -4550 5370 -4540 {
lab=row_n[16]}
N 5360 -4330 5360 -4310 {
lab=row_n[16]}
N 5360 -4570 5360 -4550 {
lab=row_n[16]}
N 5240 -4470 5250 -4480 {
lab=col_n[13]}
N 5250 -4480 5450 -4480 {
lab=col_n[13]}
N 5450 -4480 5460 -4470 {
lab=col_n[13]}
N 5240 -4450 5250 -4460 {
lab=colon_n[13]}
N 5250 -4460 5450 -4460 {
lab=colon_n[13]}
N 5450 -4460 5460 -4450 {
lab=colon_n[13]}
N 5240 -4430 5250 -4440 {
lab=#net27}
N 5250 -4440 5450 -4440 {
lab=#net27}
N 5450 -4440 5460 -4430 {
lab=#net27}
N 5240 -4410 5250 -4420 {
lab=#net28}
N 5250 -4420 5450 -4420 {
lab=#net28}
N 5450 -4420 5460 -4410 {
lab=#net28}
N 5300 -4570 5300 -4550 {
lab=vcom}
N 5340 -4570 5340 -4550 {
lab=ctop}
N 5220 -4470 5240 -4470 {
lab=col_n[13]}
N 5220 -4450 5240 -4450 {
lab=colon_n[13]}
N 5220 -4430 5240 -4430 {
lab=#net27}
N 5220 -4410 5240 -4410 {
lab=#net28}
N 5460 -4410 5480 -4410 {
lab=#net28}
N 5460 -4430 5480 -4430 {
lab=#net27}
N 5460 -4450 5480 -4450 {
lab=colon_n[13]}
N 5460 -4470 5480 -4470 {
lab=col_n[13]}
N 5280 -4330 5280 -4320 {
lab=VSS}
N 5280 -4560 5280 -4550 {
lab=VDD}
N 5620 -4330 5630 -4340 {
lab=row_n[17]}
N 5630 -4540 5630 -4340 {
lab=row_n[17]}
N 5620 -4550 5630 -4540 {
lab=row_n[17]}
N 5620 -4330 5620 -4310 {
lab=row_n[17]}
N 5620 -4570 5620 -4550 {
lab=row_n[17]}
N 5500 -4470 5510 -4480 {
lab=col_n[13]}
N 5510 -4480 5710 -4480 {
lab=col_n[13]}
N 5710 -4480 5720 -4470 {
lab=col_n[13]}
N 5500 -4450 5510 -4460 {
lab=colon_n[13]}
N 5510 -4460 5710 -4460 {
lab=colon_n[13]}
N 5710 -4460 5720 -4450 {
lab=colon_n[13]}
N 5500 -4430 5510 -4440 {
lab=#net27}
N 5510 -4440 5710 -4440 {
lab=#net27}
N 5710 -4440 5720 -4430 {
lab=#net27}
N 5500 -4410 5510 -4420 {
lab=#net28}
N 5510 -4420 5710 -4420 {
lab=#net28}
N 5710 -4420 5720 -4410 {
lab=#net28}
N 5560 -4570 5560 -4550 {
lab=vcom}
N 5600 -4570 5600 -4550 {
lab=ctop}
N 5480 -4470 5500 -4470 {
lab=col_n[13]}
N 5480 -4450 5500 -4450 {
lab=colon_n[13]}
N 5480 -4430 5500 -4430 {
lab=#net27}
N 5480 -4410 5500 -4410 {
lab=#net28}
N 5720 -4410 5740 -4410 {
lab=#net28}
N 5720 -4430 5740 -4430 {
lab=#net27}
N 5720 -4450 5740 -4450 {
lab=colon_n[13]}
N 5720 -4470 5740 -4470 {
lab=col_n[13]}
N 5540 -4330 5540 -4320 {
lab=VSS}
N 5540 -4560 5540 -4550 {
lab=VDD}
N 5880 -4330 5890 -4340 {
lab=row_n[18]}
N 5890 -4540 5890 -4340 {
lab=row_n[18]}
N 5880 -4550 5890 -4540 {
lab=row_n[18]}
N 5880 -4330 5880 -4310 {
lab=row_n[18]}
N 5880 -4570 5880 -4550 {
lab=row_n[18]}
N 5760 -4470 5770 -4480 {
lab=col_n[13]}
N 5770 -4480 5970 -4480 {
lab=col_n[13]}
N 5970 -4480 5980 -4470 {
lab=col_n[13]}
N 5760 -4450 5770 -4460 {
lab=colon_n[13]}
N 5770 -4460 5970 -4460 {
lab=colon_n[13]}
N 5970 -4460 5980 -4450 {
lab=colon_n[13]}
N 5760 -4430 5770 -4440 {
lab=#net27}
N 5770 -4440 5970 -4440 {
lab=#net27}
N 5970 -4440 5980 -4430 {
lab=#net27}
N 5760 -4410 5770 -4420 {
lab=#net28}
N 5770 -4420 5970 -4420 {
lab=#net28}
N 5970 -4420 5980 -4410 {
lab=#net28}
N 5820 -4570 5820 -4550 {
lab=vcom}
N 5860 -4570 5860 -4550 {
lab=ctop}
N 5740 -4470 5760 -4470 {
lab=col_n[13]}
N 5740 -4450 5760 -4450 {
lab=colon_n[13]}
N 5740 -4430 5760 -4430 {
lab=#net27}
N 5740 -4410 5760 -4410 {
lab=#net28}
N 5980 -4410 6000 -4410 {
lab=#net28}
N 5980 -4430 6000 -4430 {
lab=#net27}
N 5980 -4450 6000 -4450 {
lab=colon_n[13]}
N 5980 -4470 6000 -4470 {
lab=col_n[13]}
N 5800 -4330 5800 -4320 {
lab=VSS}
N 5800 -4560 5800 -4550 {
lab=VDD}
N 6140 -4330 6150 -4340 {
lab=row_n[19]}
N 6150 -4540 6150 -4340 {
lab=row_n[19]}
N 6140 -4550 6150 -4540 {
lab=row_n[19]}
N 6140 -4330 6140 -4310 {
lab=row_n[19]}
N 6140 -4570 6140 -4550 {
lab=row_n[19]}
N 6020 -4470 6030 -4480 {
lab=col_n[13]}
N 6030 -4480 6230 -4480 {
lab=col_n[13]}
N 6230 -4480 6240 -4470 {
lab=col_n[13]}
N 6020 -4450 6030 -4460 {
lab=colon_n[13]}
N 6030 -4460 6230 -4460 {
lab=colon_n[13]}
N 6230 -4460 6240 -4450 {
lab=colon_n[13]}
N 6020 -4430 6030 -4440 {
lab=#net27}
N 6030 -4440 6230 -4440 {
lab=#net27}
N 6230 -4440 6240 -4430 {
lab=#net27}
N 6020 -4410 6030 -4420 {
lab=#net28}
N 6030 -4420 6230 -4420 {
lab=#net28}
N 6230 -4420 6240 -4410 {
lab=#net28}
N 6080 -4570 6080 -4550 {
lab=vcom}
N 6120 -4570 6120 -4550 {
lab=ctop}
N 6000 -4470 6020 -4470 {
lab=col_n[13]}
N 6000 -4450 6020 -4450 {
lab=colon_n[13]}
N 6000 -4430 6020 -4430 {
lab=#net27}
N 6000 -4410 6020 -4410 {
lab=#net28}
N 6240 -4410 6260 -4410 {
lab=#net28}
N 6240 -4430 6260 -4430 {
lab=#net27}
N 6240 -4450 6260 -4450 {
lab=colon_n[13]}
N 6240 -4470 6260 -4470 {
lab=col_n[13]}
N 6060 -4330 6060 -4320 {
lab=VSS}
N 6060 -4560 6060 -4550 {
lab=VDD}
N 6400 -4330 6410 -4340 {
lab=row_n[20]}
N 6410 -4540 6410 -4340 {
lab=row_n[20]}
N 6400 -4550 6410 -4540 {
lab=row_n[20]}
N 6400 -4330 6400 -4310 {
lab=row_n[20]}
N 6400 -4570 6400 -4550 {
lab=row_n[20]}
N 6280 -4470 6290 -4480 {
lab=col_n[13]}
N 6290 -4480 6490 -4480 {
lab=col_n[13]}
N 6490 -4480 6500 -4470 {
lab=col_n[13]}
N 6280 -4450 6290 -4460 {
lab=colon_n[13]}
N 6290 -4460 6490 -4460 {
lab=colon_n[13]}
N 6490 -4460 6500 -4450 {
lab=colon_n[13]}
N 6280 -4430 6290 -4440 {
lab=#net27}
N 6290 -4440 6490 -4440 {
lab=#net27}
N 6490 -4440 6500 -4430 {
lab=#net27}
N 6280 -4410 6290 -4420 {
lab=#net28}
N 6290 -4420 6490 -4420 {
lab=#net28}
N 6490 -4420 6500 -4410 {
lab=#net28}
N 6340 -4570 6340 -4550 {
lab=vcom}
N 6380 -4570 6380 -4550 {
lab=ctop}
N 6260 -4470 6280 -4470 {
lab=col_n[13]}
N 6260 -4450 6280 -4450 {
lab=colon_n[13]}
N 6260 -4430 6280 -4430 {
lab=#net27}
N 6260 -4410 6280 -4410 {
lab=#net28}
N 6500 -4410 6520 -4410 {
lab=#net28}
N 6500 -4430 6520 -4430 {
lab=#net27}
N 6500 -4450 6520 -4450 {
lab=colon_n[13]}
N 6500 -4470 6520 -4470 {
lab=col_n[13]}
N 6320 -4330 6320 -4320 {
lab=VSS}
N 6320 -4560 6320 -4550 {
lab=VDD}
N 6660 -4330 6670 -4340 {
lab=row_n[21]}
N 6670 -4540 6670 -4340 {
lab=row_n[21]}
N 6660 -4550 6670 -4540 {
lab=row_n[21]}
N 6660 -4330 6660 -4310 {
lab=row_n[21]}
N 6660 -4570 6660 -4550 {
lab=row_n[21]}
N 6540 -4470 6550 -4480 {
lab=col_n[13]}
N 6550 -4480 6750 -4480 {
lab=col_n[13]}
N 6750 -4480 6760 -4470 {
lab=col_n[13]}
N 6540 -4450 6550 -4460 {
lab=colon_n[13]}
N 6550 -4460 6750 -4460 {
lab=colon_n[13]}
N 6750 -4460 6760 -4450 {
lab=colon_n[13]}
N 6540 -4430 6550 -4440 {
lab=#net27}
N 6550 -4440 6750 -4440 {
lab=#net27}
N 6750 -4440 6760 -4430 {
lab=#net27}
N 6540 -4410 6550 -4420 {
lab=#net28}
N 6550 -4420 6750 -4420 {
lab=#net28}
N 6750 -4420 6760 -4410 {
lab=#net28}
N 6600 -4570 6600 -4550 {
lab=vcom}
N 6640 -4570 6640 -4550 {
lab=ctop}
N 6520 -4470 6540 -4470 {
lab=col_n[13]}
N 6520 -4450 6540 -4450 {
lab=colon_n[13]}
N 6520 -4430 6540 -4430 {
lab=#net27}
N 6520 -4410 6540 -4410 {
lab=#net28}
N 6760 -4410 6780 -4410 {
lab=#net28}
N 6760 -4430 6780 -4430 {
lab=#net27}
N 6760 -4450 6780 -4450 {
lab=colon_n[13]}
N 6760 -4470 6780 -4470 {
lab=col_n[13]}
N 6580 -4330 6580 -4320 {
lab=VSS}
N 6580 -4560 6580 -4550 {
lab=VDD}
N 6920 -4330 6930 -4340 {
lab=row_n[22]}
N 6930 -4540 6930 -4340 {
lab=row_n[22]}
N 6920 -4550 6930 -4540 {
lab=row_n[22]}
N 6920 -4330 6920 -4310 {
lab=row_n[22]}
N 6920 -4570 6920 -4550 {
lab=row_n[22]}
N 6800 -4470 6810 -4480 {
lab=col_n[13]}
N 6810 -4480 7010 -4480 {
lab=col_n[13]}
N 7010 -4480 7020 -4470 {
lab=col_n[13]}
N 6800 -4450 6810 -4460 {
lab=colon_n[13]}
N 6810 -4460 7010 -4460 {
lab=colon_n[13]}
N 7010 -4460 7020 -4450 {
lab=colon_n[13]}
N 6800 -4430 6810 -4440 {
lab=#net27}
N 6810 -4440 7010 -4440 {
lab=#net27}
N 7010 -4440 7020 -4430 {
lab=#net27}
N 6800 -4410 6810 -4420 {
lab=#net28}
N 6810 -4420 7010 -4420 {
lab=#net28}
N 7010 -4420 7020 -4410 {
lab=#net28}
N 6860 -4570 6860 -4550 {
lab=vcom}
N 6900 -4570 6900 -4550 {
lab=ctop}
N 6780 -4470 6800 -4470 {
lab=col_n[13]}
N 6780 -4450 6800 -4450 {
lab=colon_n[13]}
N 6780 -4430 6800 -4430 {
lab=#net27}
N 6780 -4410 6800 -4410 {
lab=#net28}
N 7020 -4410 7040 -4410 {
lab=#net28}
N 7020 -4430 7040 -4430 {
lab=#net27}
N 7020 -4450 7040 -4450 {
lab=colon_n[13]}
N 7020 -4470 7040 -4470 {
lab=col_n[13]}
N 6840 -4330 6840 -4320 {
lab=VSS}
N 6840 -4560 6840 -4550 {
lab=VDD}
N 7180 -4330 7190 -4340 {
lab=row_n[23]}
N 7190 -4540 7190 -4340 {
lab=row_n[23]}
N 7180 -4550 7190 -4540 {
lab=row_n[23]}
N 7180 -4330 7180 -4310 {
lab=row_n[23]}
N 7180 -4570 7180 -4550 {
lab=row_n[23]}
N 7060 -4470 7070 -4480 {
lab=col_n[13]}
N 7070 -4480 7270 -4480 {
lab=col_n[13]}
N 7270 -4480 7280 -4470 {
lab=col_n[13]}
N 7060 -4450 7070 -4460 {
lab=colon_n[13]}
N 7070 -4460 7270 -4460 {
lab=colon_n[13]}
N 7270 -4460 7280 -4450 {
lab=colon_n[13]}
N 7060 -4430 7070 -4440 {
lab=#net27}
N 7070 -4440 7270 -4440 {
lab=#net27}
N 7270 -4440 7280 -4430 {
lab=#net27}
N 7060 -4410 7070 -4420 {
lab=#net28}
N 7070 -4420 7270 -4420 {
lab=#net28}
N 7270 -4420 7280 -4410 {
lab=#net28}
N 7120 -4570 7120 -4550 {
lab=vcom}
N 7160 -4570 7160 -4550 {
lab=ctop}
N 7040 -4470 7060 -4470 {
lab=col_n[13]}
N 7040 -4450 7060 -4450 {
lab=colon_n[13]}
N 7040 -4430 7060 -4430 {
lab=#net27}
N 7040 -4410 7060 -4410 {
lab=#net28}
N 7280 -4410 7300 -4410 {
lab=#net28}
N 7280 -4430 7300 -4430 {
lab=#net27}
N 7280 -4450 7300 -4450 {
lab=colon_n[13]}
N 7280 -4470 7300 -4470 {
lab=col_n[13]}
N 7100 -4330 7100 -4320 {
lab=VSS}
N 7100 -4560 7100 -4550 {
lab=VDD}
N 7440 -4330 7450 -4340 {
lab=row_n[24]}
N 7450 -4540 7450 -4340 {
lab=row_n[24]}
N 7440 -4550 7450 -4540 {
lab=row_n[24]}
N 7440 -4330 7440 -4310 {
lab=row_n[24]}
N 7440 -4570 7440 -4550 {
lab=row_n[24]}
N 7320 -4470 7330 -4480 {
lab=col_n[13]}
N 7330 -4480 7530 -4480 {
lab=col_n[13]}
N 7530 -4480 7540 -4470 {
lab=col_n[13]}
N 7320 -4450 7330 -4460 {
lab=colon_n[13]}
N 7330 -4460 7530 -4460 {
lab=colon_n[13]}
N 7530 -4460 7540 -4450 {
lab=colon_n[13]}
N 7320 -4430 7330 -4440 {
lab=#net27}
N 7330 -4440 7530 -4440 {
lab=#net27}
N 7530 -4440 7540 -4430 {
lab=#net27}
N 7320 -4410 7330 -4420 {
lab=#net28}
N 7330 -4420 7530 -4420 {
lab=#net28}
N 7530 -4420 7540 -4410 {
lab=#net28}
N 7380 -4570 7380 -4550 {
lab=vcom}
N 7420 -4570 7420 -4550 {
lab=ctop}
N 7300 -4470 7320 -4470 {
lab=col_n[13]}
N 7300 -4450 7320 -4450 {
lab=colon_n[13]}
N 7300 -4430 7320 -4430 {
lab=#net27}
N 7300 -4410 7320 -4410 {
lab=#net28}
N 7540 -4410 7560 -4410 {
lab=#net28}
N 7540 -4430 7560 -4430 {
lab=#net27}
N 7540 -4450 7560 -4450 {
lab=colon_n[13]}
N 7540 -4470 7560 -4470 {
lab=col_n[13]}
N 7360 -4330 7360 -4320 {
lab=VSS}
N 7360 -4560 7360 -4550 {
lab=VDD}
N 7700 -4330 7710 -4340 {
lab=row_n[25]}
N 7710 -4540 7710 -4340 {
lab=row_n[25]}
N 7700 -4550 7710 -4540 {
lab=row_n[25]}
N 7700 -4330 7700 -4310 {
lab=row_n[25]}
N 7700 -4570 7700 -4550 {
lab=row_n[25]}
N 7580 -4470 7590 -4480 {
lab=col_n[13]}
N 7590 -4480 7790 -4480 {
lab=col_n[13]}
N 7790 -4480 7800 -4470 {
lab=col_n[13]}
N 7580 -4450 7590 -4460 {
lab=colon_n[13]}
N 7590 -4460 7790 -4460 {
lab=colon_n[13]}
N 7790 -4460 7800 -4450 {
lab=colon_n[13]}
N 7580 -4430 7590 -4440 {
lab=#net27}
N 7590 -4440 7790 -4440 {
lab=#net27}
N 7790 -4440 7800 -4430 {
lab=#net27}
N 7580 -4410 7590 -4420 {
lab=#net28}
N 7590 -4420 7790 -4420 {
lab=#net28}
N 7790 -4420 7800 -4410 {
lab=#net28}
N 7640 -4570 7640 -4550 {
lab=vcom}
N 7680 -4570 7680 -4550 {
lab=ctop}
N 7560 -4470 7580 -4470 {
lab=col_n[13]}
N 7560 -4450 7580 -4450 {
lab=colon_n[13]}
N 7560 -4430 7580 -4430 {
lab=#net27}
N 7560 -4410 7580 -4410 {
lab=#net28}
N 7800 -4410 7820 -4410 {
lab=#net28}
N 7800 -4430 7820 -4430 {
lab=#net27}
N 7800 -4450 7820 -4450 {
lab=colon_n[13]}
N 7800 -4470 7820 -4470 {
lab=col_n[13]}
N 7620 -4330 7620 -4320 {
lab=VSS}
N 7620 -4560 7620 -4550 {
lab=VDD}
N 7960 -4330 7970 -4340 {
lab=row_n[26]}
N 7970 -4540 7970 -4340 {
lab=row_n[26]}
N 7960 -4550 7970 -4540 {
lab=row_n[26]}
N 7960 -4330 7960 -4310 {
lab=row_n[26]}
N 7960 -4570 7960 -4550 {
lab=row_n[26]}
N 7840 -4470 7850 -4480 {
lab=col_n[13]}
N 7850 -4480 8050 -4480 {
lab=col_n[13]}
N 8050 -4480 8060 -4470 {
lab=col_n[13]}
N 7840 -4450 7850 -4460 {
lab=colon_n[13]}
N 7850 -4460 8050 -4460 {
lab=colon_n[13]}
N 8050 -4460 8060 -4450 {
lab=colon_n[13]}
N 7840 -4430 7850 -4440 {
lab=#net27}
N 7850 -4440 8050 -4440 {
lab=#net27}
N 8050 -4440 8060 -4430 {
lab=#net27}
N 7840 -4410 7850 -4420 {
lab=#net28}
N 7850 -4420 8050 -4420 {
lab=#net28}
N 8050 -4420 8060 -4410 {
lab=#net28}
N 7900 -4570 7900 -4550 {
lab=vcom}
N 7940 -4570 7940 -4550 {
lab=ctop}
N 7820 -4470 7840 -4470 {
lab=col_n[13]}
N 7820 -4450 7840 -4450 {
lab=colon_n[13]}
N 7820 -4430 7840 -4430 {
lab=#net27}
N 7820 -4410 7840 -4410 {
lab=#net28}
N 8060 -4410 8080 -4410 {
lab=#net28}
N 8060 -4430 8080 -4430 {
lab=#net27}
N 8060 -4450 8080 -4450 {
lab=colon_n[13]}
N 8060 -4470 8080 -4470 {
lab=col_n[13]}
N 7880 -4330 7880 -4320 {
lab=VSS}
N 7880 -4560 7880 -4550 {
lab=VDD}
N 8220 -4330 8230 -4340 {
lab=row_n[27]}
N 8230 -4540 8230 -4340 {
lab=row_n[27]}
N 8220 -4550 8230 -4540 {
lab=row_n[27]}
N 8220 -4330 8220 -4310 {
lab=row_n[27]}
N 8220 -4570 8220 -4550 {
lab=row_n[27]}
N 8100 -4470 8110 -4480 {
lab=col_n[13]}
N 8110 -4480 8310 -4480 {
lab=col_n[13]}
N 8310 -4480 8320 -4470 {
lab=col_n[13]}
N 8100 -4450 8110 -4460 {
lab=colon_n[13]}
N 8110 -4460 8310 -4460 {
lab=colon_n[13]}
N 8310 -4460 8320 -4450 {
lab=colon_n[13]}
N 8100 -4430 8110 -4440 {
lab=#net27}
N 8110 -4440 8310 -4440 {
lab=#net27}
N 8310 -4440 8320 -4430 {
lab=#net27}
N 8100 -4410 8110 -4420 {
lab=#net28}
N 8110 -4420 8310 -4420 {
lab=#net28}
N 8310 -4420 8320 -4410 {
lab=#net28}
N 8160 -4570 8160 -4550 {
lab=vcom}
N 8200 -4570 8200 -4550 {
lab=ctop}
N 8080 -4470 8100 -4470 {
lab=col_n[13]}
N 8080 -4450 8100 -4450 {
lab=colon_n[13]}
N 8080 -4430 8100 -4430 {
lab=#net27}
N 8080 -4410 8100 -4410 {
lab=#net28}
N 8320 -4410 8340 -4410 {
lab=#net28}
N 8320 -4430 8340 -4430 {
lab=#net27}
N 8320 -4450 8340 -4450 {
lab=colon_n[13]}
N 8320 -4470 8340 -4470 {
lab=col_n[13]}
N 8140 -4330 8140 -4320 {
lab=VSS}
N 8140 -4560 8140 -4550 {
lab=VDD}
N 8480 -4330 8490 -4340 {
lab=row_n[28]}
N 8490 -4540 8490 -4340 {
lab=row_n[28]}
N 8480 -4550 8490 -4540 {
lab=row_n[28]}
N 8480 -4330 8480 -4310 {
lab=row_n[28]}
N 8480 -4570 8480 -4550 {
lab=row_n[28]}
N 8360 -4470 8370 -4480 {
lab=col_n[13]}
N 8370 -4480 8570 -4480 {
lab=col_n[13]}
N 8570 -4480 8580 -4470 {
lab=col_n[13]}
N 8360 -4450 8370 -4460 {
lab=colon_n[13]}
N 8370 -4460 8570 -4460 {
lab=colon_n[13]}
N 8570 -4460 8580 -4450 {
lab=colon_n[13]}
N 8360 -4430 8370 -4440 {
lab=#net27}
N 8370 -4440 8570 -4440 {
lab=#net27}
N 8570 -4440 8580 -4430 {
lab=#net27}
N 8360 -4410 8370 -4420 {
lab=#net28}
N 8370 -4420 8570 -4420 {
lab=#net28}
N 8570 -4420 8580 -4410 {
lab=#net28}
N 8420 -4570 8420 -4550 {
lab=vcom}
N 8460 -4570 8460 -4550 {
lab=ctop}
N 8340 -4470 8360 -4470 {
lab=col_n[13]}
N 8340 -4450 8360 -4450 {
lab=colon_n[13]}
N 8340 -4430 8360 -4430 {
lab=#net27}
N 8340 -4410 8360 -4410 {
lab=#net28}
N 8580 -4410 8600 -4410 {
lab=#net28}
N 8580 -4430 8600 -4430 {
lab=#net27}
N 8580 -4450 8600 -4450 {
lab=colon_n[13]}
N 8580 -4470 8600 -4470 {
lab=col_n[13]}
N 8400 -4330 8400 -4320 {
lab=VSS}
N 8400 -4560 8400 -4550 {
lab=VDD}
N 8740 -4330 8750 -4340 {
lab=row_n[29]}
N 8750 -4540 8750 -4340 {
lab=row_n[29]}
N 8740 -4550 8750 -4540 {
lab=row_n[29]}
N 8740 -4330 8740 -4310 {
lab=row_n[29]}
N 8740 -4570 8740 -4550 {
lab=row_n[29]}
N 8620 -4470 8630 -4480 {
lab=col_n[13]}
N 8630 -4480 8830 -4480 {
lab=col_n[13]}
N 8830 -4480 8840 -4470 {
lab=col_n[13]}
N 8620 -4450 8630 -4460 {
lab=colon_n[13]}
N 8630 -4460 8830 -4460 {
lab=colon_n[13]}
N 8830 -4460 8840 -4450 {
lab=colon_n[13]}
N 8620 -4430 8630 -4440 {
lab=#net27}
N 8630 -4440 8830 -4440 {
lab=#net27}
N 8830 -4440 8840 -4430 {
lab=#net27}
N 8620 -4410 8630 -4420 {
lab=#net28}
N 8630 -4420 8830 -4420 {
lab=#net28}
N 8830 -4420 8840 -4410 {
lab=#net28}
N 8680 -4570 8680 -4550 {
lab=vcom}
N 8720 -4570 8720 -4550 {
lab=ctop}
N 8600 -4470 8620 -4470 {
lab=col_n[13]}
N 8600 -4450 8620 -4450 {
lab=colon_n[13]}
N 8600 -4430 8620 -4430 {
lab=#net27}
N 8600 -4410 8620 -4410 {
lab=#net28}
N 8840 -4410 8860 -4410 {
lab=#net28}
N 8840 -4430 8860 -4430 {
lab=#net27}
N 8840 -4450 8860 -4450 {
lab=colon_n[13]}
N 8840 -4470 8860 -4470 {
lab=col_n[13]}
N 8660 -4330 8660 -4320 {
lab=VSS}
N 8660 -4560 8660 -4550 {
lab=VDD}
N 9000 -4330 9010 -4340 {
lab=row_n[30]}
N 9010 -4540 9010 -4340 {
lab=row_n[30]}
N 9000 -4550 9010 -4540 {
lab=row_n[30]}
N 9000 -4330 9000 -4310 {
lab=row_n[30]}
N 9000 -4570 9000 -4550 {
lab=row_n[30]}
N 8880 -4470 8890 -4480 {
lab=col_n[13]}
N 8890 -4480 9090 -4480 {
lab=col_n[13]}
N 9090 -4480 9100 -4470 {
lab=col_n[13]}
N 8880 -4450 8890 -4460 {
lab=colon_n[13]}
N 8890 -4460 9090 -4460 {
lab=colon_n[13]}
N 9090 -4460 9100 -4450 {
lab=colon_n[13]}
N 8880 -4430 8890 -4440 {
lab=#net27}
N 8890 -4440 9090 -4440 {
lab=#net27}
N 9090 -4440 9100 -4430 {
lab=#net27}
N 8880 -4410 8890 -4420 {
lab=#net28}
N 8890 -4420 9090 -4420 {
lab=#net28}
N 9090 -4420 9100 -4410 {
lab=#net28}
N 8940 -4570 8940 -4550 {
lab=vcom}
N 8980 -4570 8980 -4550 {
lab=ctop}
N 8860 -4470 8880 -4470 {
lab=col_n[13]}
N 8860 -4450 8880 -4450 {
lab=colon_n[13]}
N 8860 -4430 8880 -4430 {
lab=#net27}
N 8860 -4410 8880 -4410 {
lab=#net28}
N 9100 -4410 9120 -4410 {
lab=#net28}
N 9100 -4430 9120 -4430 {
lab=#net27}
N 9100 -4450 9120 -4450 {
lab=colon_n[13]}
N 9100 -4470 9120 -4470 {
lab=col_n[13]}
N 8920 -4330 8920 -4320 {
lab=VSS}
N 8920 -4560 8920 -4550 {
lab=VDD}
N 9260 -4330 9270 -4340 {
lab=row_n[31]}
N 9270 -4540 9270 -4340 {
lab=row_n[31]}
N 9260 -4550 9270 -4540 {
lab=row_n[31]}
N 9260 -4330 9260 -4310 {
lab=row_n[31]}
N 9260 -4570 9260 -4550 {
lab=row_n[31]}
N 9140 -4470 9150 -4480 {
lab=col_n[13]}
N 9150 -4480 9350 -4480 {
lab=col_n[13]}
N 9350 -4480 9360 -4470 {
lab=col_n[13]}
N 9140 -4450 9150 -4460 {
lab=colon_n[13]}
N 9150 -4460 9350 -4460 {
lab=colon_n[13]}
N 9350 -4460 9360 -4450 {
lab=colon_n[13]}
N 9140 -4430 9150 -4440 {
lab=#net27}
N 9150 -4440 9350 -4440 {
lab=#net27}
N 9350 -4440 9360 -4430 {
lab=#net27}
N 9140 -4410 9150 -4420 {
lab=#net28}
N 9150 -4420 9350 -4420 {
lab=#net28}
N 9350 -4420 9360 -4410 {
lab=#net28}
N 9200 -4570 9200 -4550 {
lab=vcom}
N 9240 -4570 9240 -4550 {
lab=ctop}
N 9120 -4470 9140 -4470 {
lab=col_n[13]}
N 9120 -4450 9140 -4450 {
lab=colon_n[13]}
N 9120 -4430 9140 -4430 {
lab=#net27}
N 9120 -4410 9140 -4410 {
lab=#net28}
N 9360 -4410 9380 -4410 {
lab=#net28}
N 9360 -4430 9380 -4430 {
lab=#net27}
N 9360 -4450 9380 -4450 {
lab=colon_n[13]}
N 9360 -4470 9380 -4470 {
lab=col_n[13]}
N 9180 -4330 9180 -4320 {
lab=VSS}
N 9180 -4560 9180 -4550 {
lab=VDD}
N 1200 -4590 1210 -4600 {
lab=row_n[0]}
N 1210 -4800 1210 -4600 {
lab=row_n[0]}
N 1200 -4810 1210 -4800 {
lab=row_n[0]}
N 1200 -4590 1200 -4570 {
lab=row_n[0]}
N 1200 -4830 1200 -4810 {
lab=row_n[0]}
N 1080 -4730 1090 -4740 {
lab=col_n[14]}
N 1090 -4740 1290 -4740 {
lab=col_n[14]}
N 1290 -4740 1300 -4730 {
lab=col_n[14]}
N 1080 -4710 1090 -4720 {
lab=colon_n[14]}
N 1090 -4720 1290 -4720 {
lab=colon_n[14]}
N 1290 -4720 1300 -4710 {
lab=colon_n[14]}
N 1080 -4690 1090 -4700 {
lab=#net29}
N 1090 -4700 1290 -4700 {
lab=#net29}
N 1290 -4700 1300 -4690 {
lab=#net29}
N 1080 -4670 1090 -4680 {
lab=#net30}
N 1090 -4680 1290 -4680 {
lab=#net30}
N 1290 -4680 1300 -4670 {
lab=#net30}
N 1140 -4830 1140 -4810 {
lab=vcom}
N 1180 -4830 1180 -4810 {
lab=ctop}
N 1060 -4730 1080 -4730 {
lab=col_n[14]}
N 1060 -4710 1080 -4710 {
lab=colon_n[14]}
N 1060 -4690 1080 -4690 {
lab=#net29}
N 1060 -4670 1080 -4670 {
lab=#net30}
N 1300 -4670 1320 -4670 {
lab=#net30}
N 1300 -4690 1320 -4690 {
lab=#net29}
N 1300 -4710 1320 -4710 {
lab=colon_n[14]}
N 1300 -4730 1320 -4730 {
lab=col_n[14]}
N 1120 -4590 1120 -4580 {
lab=VSS}
N 1120 -4820 1120 -4810 {
lab=VDD}
N 1460 -4590 1470 -4600 {
lab=row_n[1]}
N 1470 -4800 1470 -4600 {
lab=row_n[1]}
N 1460 -4810 1470 -4800 {
lab=row_n[1]}
N 1460 -4590 1460 -4570 {
lab=row_n[1]}
N 1460 -4830 1460 -4810 {
lab=row_n[1]}
N 1340 -4730 1350 -4740 {
lab=col_n[14]}
N 1350 -4740 1550 -4740 {
lab=col_n[14]}
N 1550 -4740 1560 -4730 {
lab=col_n[14]}
N 1340 -4710 1350 -4720 {
lab=colon_n[14]}
N 1350 -4720 1550 -4720 {
lab=colon_n[14]}
N 1550 -4720 1560 -4710 {
lab=colon_n[14]}
N 1340 -4690 1350 -4700 {
lab=#net29}
N 1350 -4700 1550 -4700 {
lab=#net29}
N 1550 -4700 1560 -4690 {
lab=#net29}
N 1340 -4670 1350 -4680 {
lab=#net30}
N 1350 -4680 1550 -4680 {
lab=#net30}
N 1550 -4680 1560 -4670 {
lab=#net30}
N 1400 -4830 1400 -4810 {
lab=vcom}
N 1440 -4830 1440 -4810 {
lab=ctop}
N 1320 -4730 1340 -4730 {
lab=col_n[14]}
N 1320 -4710 1340 -4710 {
lab=colon_n[14]}
N 1320 -4690 1340 -4690 {
lab=#net29}
N 1320 -4670 1340 -4670 {
lab=#net30}
N 1560 -4670 1580 -4670 {
lab=#net30}
N 1560 -4690 1580 -4690 {
lab=#net29}
N 1560 -4710 1580 -4710 {
lab=colon_n[14]}
N 1560 -4730 1580 -4730 {
lab=col_n[14]}
N 1380 -4590 1380 -4580 {
lab=VSS}
N 1380 -4820 1380 -4810 {
lab=VDD}
N 1720 -4590 1730 -4600 {
lab=row_n[2]}
N 1730 -4800 1730 -4600 {
lab=row_n[2]}
N 1720 -4810 1730 -4800 {
lab=row_n[2]}
N 1720 -4590 1720 -4570 {
lab=row_n[2]}
N 1720 -4830 1720 -4810 {
lab=row_n[2]}
N 1600 -4730 1610 -4740 {
lab=col_n[14]}
N 1610 -4740 1810 -4740 {
lab=col_n[14]}
N 1810 -4740 1820 -4730 {
lab=col_n[14]}
N 1600 -4710 1610 -4720 {
lab=colon_n[14]}
N 1610 -4720 1810 -4720 {
lab=colon_n[14]}
N 1810 -4720 1820 -4710 {
lab=colon_n[14]}
N 1600 -4690 1610 -4700 {
lab=#net29}
N 1610 -4700 1810 -4700 {
lab=#net29}
N 1810 -4700 1820 -4690 {
lab=#net29}
N 1600 -4670 1610 -4680 {
lab=#net30}
N 1610 -4680 1810 -4680 {
lab=#net30}
N 1810 -4680 1820 -4670 {
lab=#net30}
N 1660 -4830 1660 -4810 {
lab=vcom}
N 1700 -4830 1700 -4810 {
lab=ctop}
N 1580 -4730 1600 -4730 {
lab=col_n[14]}
N 1580 -4710 1600 -4710 {
lab=colon_n[14]}
N 1580 -4690 1600 -4690 {
lab=#net29}
N 1580 -4670 1600 -4670 {
lab=#net30}
N 1820 -4670 1840 -4670 {
lab=#net30}
N 1820 -4690 1840 -4690 {
lab=#net29}
N 1820 -4710 1840 -4710 {
lab=colon_n[14]}
N 1820 -4730 1840 -4730 {
lab=col_n[14]}
N 1640 -4590 1640 -4580 {
lab=VSS}
N 1640 -4820 1640 -4810 {
lab=VDD}
N 1980 -4590 1990 -4600 {
lab=row_n[3]}
N 1990 -4800 1990 -4600 {
lab=row_n[3]}
N 1980 -4810 1990 -4800 {
lab=row_n[3]}
N 1980 -4590 1980 -4570 {
lab=row_n[3]}
N 1980 -4830 1980 -4810 {
lab=row_n[3]}
N 1860 -4730 1870 -4740 {
lab=col_n[14]}
N 1870 -4740 2070 -4740 {
lab=col_n[14]}
N 2070 -4740 2080 -4730 {
lab=col_n[14]}
N 1860 -4710 1870 -4720 {
lab=colon_n[14]}
N 1870 -4720 2070 -4720 {
lab=colon_n[14]}
N 2070 -4720 2080 -4710 {
lab=colon_n[14]}
N 1860 -4690 1870 -4700 {
lab=#net29}
N 1870 -4700 2070 -4700 {
lab=#net29}
N 2070 -4700 2080 -4690 {
lab=#net29}
N 1860 -4670 1870 -4680 {
lab=#net30}
N 1870 -4680 2070 -4680 {
lab=#net30}
N 2070 -4680 2080 -4670 {
lab=#net30}
N 1920 -4830 1920 -4810 {
lab=vcom}
N 1960 -4830 1960 -4810 {
lab=ctop}
N 1840 -4730 1860 -4730 {
lab=col_n[14]}
N 1840 -4710 1860 -4710 {
lab=colon_n[14]}
N 1840 -4690 1860 -4690 {
lab=#net29}
N 1840 -4670 1860 -4670 {
lab=#net30}
N 2080 -4670 2100 -4670 {
lab=#net30}
N 2080 -4690 2100 -4690 {
lab=#net29}
N 2080 -4710 2100 -4710 {
lab=colon_n[14]}
N 2080 -4730 2100 -4730 {
lab=col_n[14]}
N 1900 -4590 1900 -4580 {
lab=VSS}
N 1900 -4820 1900 -4810 {
lab=VDD}
N 2240 -4590 2250 -4600 {
lab=row_n[4]}
N 2250 -4800 2250 -4600 {
lab=row_n[4]}
N 2240 -4810 2250 -4800 {
lab=row_n[4]}
N 2240 -4590 2240 -4570 {
lab=row_n[4]}
N 2240 -4830 2240 -4810 {
lab=row_n[4]}
N 2120 -4730 2130 -4740 {
lab=col_n[14]}
N 2130 -4740 2330 -4740 {
lab=col_n[14]}
N 2330 -4740 2340 -4730 {
lab=col_n[14]}
N 2120 -4710 2130 -4720 {
lab=colon_n[14]}
N 2130 -4720 2330 -4720 {
lab=colon_n[14]}
N 2330 -4720 2340 -4710 {
lab=colon_n[14]}
N 2120 -4690 2130 -4700 {
lab=#net29}
N 2130 -4700 2330 -4700 {
lab=#net29}
N 2330 -4700 2340 -4690 {
lab=#net29}
N 2120 -4670 2130 -4680 {
lab=#net30}
N 2130 -4680 2330 -4680 {
lab=#net30}
N 2330 -4680 2340 -4670 {
lab=#net30}
N 2180 -4830 2180 -4810 {
lab=vcom}
N 2220 -4830 2220 -4810 {
lab=ctop}
N 2100 -4730 2120 -4730 {
lab=col_n[14]}
N 2100 -4710 2120 -4710 {
lab=colon_n[14]}
N 2100 -4690 2120 -4690 {
lab=#net29}
N 2100 -4670 2120 -4670 {
lab=#net30}
N 2340 -4670 2360 -4670 {
lab=#net30}
N 2340 -4690 2360 -4690 {
lab=#net29}
N 2340 -4710 2360 -4710 {
lab=colon_n[14]}
N 2340 -4730 2360 -4730 {
lab=col_n[14]}
N 2160 -4590 2160 -4580 {
lab=VSS}
N 2160 -4820 2160 -4810 {
lab=VDD}
N 2500 -4590 2510 -4600 {
lab=row_n[5]}
N 2510 -4800 2510 -4600 {
lab=row_n[5]}
N 2500 -4810 2510 -4800 {
lab=row_n[5]}
N 2500 -4590 2500 -4570 {
lab=row_n[5]}
N 2500 -4830 2500 -4810 {
lab=row_n[5]}
N 2380 -4730 2390 -4740 {
lab=col_n[14]}
N 2390 -4740 2590 -4740 {
lab=col_n[14]}
N 2590 -4740 2600 -4730 {
lab=col_n[14]}
N 2380 -4710 2390 -4720 {
lab=colon_n[14]}
N 2390 -4720 2590 -4720 {
lab=colon_n[14]}
N 2590 -4720 2600 -4710 {
lab=colon_n[14]}
N 2380 -4690 2390 -4700 {
lab=#net29}
N 2390 -4700 2590 -4700 {
lab=#net29}
N 2590 -4700 2600 -4690 {
lab=#net29}
N 2380 -4670 2390 -4680 {
lab=#net30}
N 2390 -4680 2590 -4680 {
lab=#net30}
N 2590 -4680 2600 -4670 {
lab=#net30}
N 2440 -4830 2440 -4810 {
lab=vcom}
N 2480 -4830 2480 -4810 {
lab=ctop}
N 2360 -4730 2380 -4730 {
lab=col_n[14]}
N 2360 -4710 2380 -4710 {
lab=colon_n[14]}
N 2360 -4690 2380 -4690 {
lab=#net29}
N 2360 -4670 2380 -4670 {
lab=#net30}
N 2600 -4670 2620 -4670 {
lab=#net30}
N 2600 -4690 2620 -4690 {
lab=#net29}
N 2600 -4710 2620 -4710 {
lab=colon_n[14]}
N 2600 -4730 2620 -4730 {
lab=col_n[14]}
N 2420 -4590 2420 -4580 {
lab=VSS}
N 2420 -4820 2420 -4810 {
lab=VDD}
N 2760 -4590 2770 -4600 {
lab=row_n[6]}
N 2770 -4800 2770 -4600 {
lab=row_n[6]}
N 2760 -4810 2770 -4800 {
lab=row_n[6]}
N 2760 -4590 2760 -4570 {
lab=row_n[6]}
N 2760 -4830 2760 -4810 {
lab=row_n[6]}
N 2640 -4730 2650 -4740 {
lab=col_n[14]}
N 2650 -4740 2850 -4740 {
lab=col_n[14]}
N 2850 -4740 2860 -4730 {
lab=col_n[14]}
N 2640 -4710 2650 -4720 {
lab=colon_n[14]}
N 2650 -4720 2850 -4720 {
lab=colon_n[14]}
N 2850 -4720 2860 -4710 {
lab=colon_n[14]}
N 2640 -4690 2650 -4700 {
lab=#net29}
N 2650 -4700 2850 -4700 {
lab=#net29}
N 2850 -4700 2860 -4690 {
lab=#net29}
N 2640 -4670 2650 -4680 {
lab=#net30}
N 2650 -4680 2850 -4680 {
lab=#net30}
N 2850 -4680 2860 -4670 {
lab=#net30}
N 2700 -4830 2700 -4810 {
lab=vcom}
N 2740 -4830 2740 -4810 {
lab=ctop}
N 2620 -4730 2640 -4730 {
lab=col_n[14]}
N 2620 -4710 2640 -4710 {
lab=colon_n[14]}
N 2620 -4690 2640 -4690 {
lab=#net29}
N 2620 -4670 2640 -4670 {
lab=#net30}
N 2860 -4670 2880 -4670 {
lab=#net30}
N 2860 -4690 2880 -4690 {
lab=#net29}
N 2860 -4710 2880 -4710 {
lab=colon_n[14]}
N 2860 -4730 2880 -4730 {
lab=col_n[14]}
N 2680 -4590 2680 -4580 {
lab=VSS}
N 2680 -4820 2680 -4810 {
lab=VDD}
N 3020 -4590 3030 -4600 {
lab=row_n[7]}
N 3030 -4800 3030 -4600 {
lab=row_n[7]}
N 3020 -4810 3030 -4800 {
lab=row_n[7]}
N 3020 -4590 3020 -4570 {
lab=row_n[7]}
N 3020 -4830 3020 -4810 {
lab=row_n[7]}
N 2900 -4730 2910 -4740 {
lab=col_n[14]}
N 2910 -4740 3110 -4740 {
lab=col_n[14]}
N 3110 -4740 3120 -4730 {
lab=col_n[14]}
N 2900 -4710 2910 -4720 {
lab=colon_n[14]}
N 2910 -4720 3110 -4720 {
lab=colon_n[14]}
N 3110 -4720 3120 -4710 {
lab=colon_n[14]}
N 2900 -4690 2910 -4700 {
lab=#net29}
N 2910 -4700 3110 -4700 {
lab=#net29}
N 3110 -4700 3120 -4690 {
lab=#net29}
N 2900 -4670 2910 -4680 {
lab=#net30}
N 2910 -4680 3110 -4680 {
lab=#net30}
N 3110 -4680 3120 -4670 {
lab=#net30}
N 2960 -4830 2960 -4810 {
lab=vcom}
N 3000 -4830 3000 -4810 {
lab=ctop}
N 2880 -4730 2900 -4730 {
lab=col_n[14]}
N 2880 -4710 2900 -4710 {
lab=colon_n[14]}
N 2880 -4690 2900 -4690 {
lab=#net29}
N 2880 -4670 2900 -4670 {
lab=#net30}
N 3120 -4670 3140 -4670 {
lab=#net30}
N 3120 -4690 3140 -4690 {
lab=#net29}
N 3120 -4710 3140 -4710 {
lab=colon_n[14]}
N 3120 -4730 3140 -4730 {
lab=col_n[14]}
N 2940 -4590 2940 -4580 {
lab=VSS}
N 2940 -4820 2940 -4810 {
lab=VDD}
N 3280 -4590 3290 -4600 {
lab=row_n[8]}
N 3290 -4800 3290 -4600 {
lab=row_n[8]}
N 3280 -4810 3290 -4800 {
lab=row_n[8]}
N 3280 -4590 3280 -4570 {
lab=row_n[8]}
N 3280 -4830 3280 -4810 {
lab=row_n[8]}
N 3160 -4730 3170 -4740 {
lab=col_n[14]}
N 3170 -4740 3370 -4740 {
lab=col_n[14]}
N 3370 -4740 3380 -4730 {
lab=col_n[14]}
N 3160 -4710 3170 -4720 {
lab=colon_n[14]}
N 3170 -4720 3370 -4720 {
lab=colon_n[14]}
N 3370 -4720 3380 -4710 {
lab=colon_n[14]}
N 3160 -4690 3170 -4700 {
lab=#net29}
N 3170 -4700 3370 -4700 {
lab=#net29}
N 3370 -4700 3380 -4690 {
lab=#net29}
N 3160 -4670 3170 -4680 {
lab=#net30}
N 3170 -4680 3370 -4680 {
lab=#net30}
N 3370 -4680 3380 -4670 {
lab=#net30}
N 3220 -4830 3220 -4810 {
lab=vcom}
N 3260 -4830 3260 -4810 {
lab=ctop}
N 3140 -4730 3160 -4730 {
lab=col_n[14]}
N 3140 -4710 3160 -4710 {
lab=colon_n[14]}
N 3140 -4690 3160 -4690 {
lab=#net29}
N 3140 -4670 3160 -4670 {
lab=#net30}
N 3380 -4670 3400 -4670 {
lab=#net30}
N 3380 -4690 3400 -4690 {
lab=#net29}
N 3380 -4710 3400 -4710 {
lab=colon_n[14]}
N 3380 -4730 3400 -4730 {
lab=col_n[14]}
N 3200 -4590 3200 -4580 {
lab=VSS}
N 3200 -4820 3200 -4810 {
lab=VDD}
N 3540 -4590 3550 -4600 {
lab=row_n[9]}
N 3550 -4800 3550 -4600 {
lab=row_n[9]}
N 3540 -4810 3550 -4800 {
lab=row_n[9]}
N 3540 -4590 3540 -4570 {
lab=row_n[9]}
N 3540 -4830 3540 -4810 {
lab=row_n[9]}
N 3420 -4730 3430 -4740 {
lab=col_n[14]}
N 3430 -4740 3630 -4740 {
lab=col_n[14]}
N 3630 -4740 3640 -4730 {
lab=col_n[14]}
N 3420 -4710 3430 -4720 {
lab=colon_n[14]}
N 3430 -4720 3630 -4720 {
lab=colon_n[14]}
N 3630 -4720 3640 -4710 {
lab=colon_n[14]}
N 3420 -4690 3430 -4700 {
lab=#net29}
N 3430 -4700 3630 -4700 {
lab=#net29}
N 3630 -4700 3640 -4690 {
lab=#net29}
N 3420 -4670 3430 -4680 {
lab=#net30}
N 3430 -4680 3630 -4680 {
lab=#net30}
N 3630 -4680 3640 -4670 {
lab=#net30}
N 3480 -4830 3480 -4810 {
lab=vcom}
N 3520 -4830 3520 -4810 {
lab=ctop}
N 3400 -4730 3420 -4730 {
lab=col_n[14]}
N 3400 -4710 3420 -4710 {
lab=colon_n[14]}
N 3400 -4690 3420 -4690 {
lab=#net29}
N 3400 -4670 3420 -4670 {
lab=#net30}
N 3640 -4670 3660 -4670 {
lab=#net30}
N 3640 -4690 3660 -4690 {
lab=#net29}
N 3640 -4710 3660 -4710 {
lab=colon_n[14]}
N 3640 -4730 3660 -4730 {
lab=col_n[14]}
N 3460 -4590 3460 -4580 {
lab=VSS}
N 3460 -4820 3460 -4810 {
lab=VDD}
N 3800 -4590 3810 -4600 {
lab=row_n[10]}
N 3810 -4800 3810 -4600 {
lab=row_n[10]}
N 3800 -4810 3810 -4800 {
lab=row_n[10]}
N 3800 -4590 3800 -4570 {
lab=row_n[10]}
N 3800 -4830 3800 -4810 {
lab=row_n[10]}
N 3680 -4730 3690 -4740 {
lab=col_n[14]}
N 3690 -4740 3890 -4740 {
lab=col_n[14]}
N 3890 -4740 3900 -4730 {
lab=col_n[14]}
N 3680 -4710 3690 -4720 {
lab=colon_n[14]}
N 3690 -4720 3890 -4720 {
lab=colon_n[14]}
N 3890 -4720 3900 -4710 {
lab=colon_n[14]}
N 3680 -4690 3690 -4700 {
lab=#net29}
N 3690 -4700 3890 -4700 {
lab=#net29}
N 3890 -4700 3900 -4690 {
lab=#net29}
N 3680 -4670 3690 -4680 {
lab=#net30}
N 3690 -4680 3890 -4680 {
lab=#net30}
N 3890 -4680 3900 -4670 {
lab=#net30}
N 3740 -4830 3740 -4810 {
lab=vcom}
N 3780 -4830 3780 -4810 {
lab=ctop}
N 3660 -4730 3680 -4730 {
lab=col_n[14]}
N 3660 -4710 3680 -4710 {
lab=colon_n[14]}
N 3660 -4690 3680 -4690 {
lab=#net29}
N 3660 -4670 3680 -4670 {
lab=#net30}
N 3900 -4670 3920 -4670 {
lab=#net30}
N 3900 -4690 3920 -4690 {
lab=#net29}
N 3900 -4710 3920 -4710 {
lab=colon_n[14]}
N 3900 -4730 3920 -4730 {
lab=col_n[14]}
N 3720 -4590 3720 -4580 {
lab=VSS}
N 3720 -4820 3720 -4810 {
lab=VDD}
N 4060 -4590 4070 -4600 {
lab=row_n[11]}
N 4070 -4800 4070 -4600 {
lab=row_n[11]}
N 4060 -4810 4070 -4800 {
lab=row_n[11]}
N 4060 -4590 4060 -4570 {
lab=row_n[11]}
N 4060 -4830 4060 -4810 {
lab=row_n[11]}
N 3940 -4730 3950 -4740 {
lab=col_n[14]}
N 3950 -4740 4150 -4740 {
lab=col_n[14]}
N 4150 -4740 4160 -4730 {
lab=col_n[14]}
N 3940 -4710 3950 -4720 {
lab=colon_n[14]}
N 3950 -4720 4150 -4720 {
lab=colon_n[14]}
N 4150 -4720 4160 -4710 {
lab=colon_n[14]}
N 3940 -4690 3950 -4700 {
lab=#net29}
N 3950 -4700 4150 -4700 {
lab=#net29}
N 4150 -4700 4160 -4690 {
lab=#net29}
N 3940 -4670 3950 -4680 {
lab=#net30}
N 3950 -4680 4150 -4680 {
lab=#net30}
N 4150 -4680 4160 -4670 {
lab=#net30}
N 4000 -4830 4000 -4810 {
lab=vcom}
N 4040 -4830 4040 -4810 {
lab=ctop}
N 3920 -4730 3940 -4730 {
lab=col_n[14]}
N 3920 -4710 3940 -4710 {
lab=colon_n[14]}
N 3920 -4690 3940 -4690 {
lab=#net29}
N 3920 -4670 3940 -4670 {
lab=#net30}
N 4160 -4670 4180 -4670 {
lab=#net30}
N 4160 -4690 4180 -4690 {
lab=#net29}
N 4160 -4710 4180 -4710 {
lab=colon_n[14]}
N 4160 -4730 4180 -4730 {
lab=col_n[14]}
N 3980 -4590 3980 -4580 {
lab=VSS}
N 3980 -4820 3980 -4810 {
lab=VDD}
N 4320 -4590 4330 -4600 {
lab=row_n[12]}
N 4330 -4800 4330 -4600 {
lab=row_n[12]}
N 4320 -4810 4330 -4800 {
lab=row_n[12]}
N 4320 -4590 4320 -4570 {
lab=row_n[12]}
N 4320 -4830 4320 -4810 {
lab=row_n[12]}
N 4200 -4730 4210 -4740 {
lab=col_n[14]}
N 4210 -4740 4410 -4740 {
lab=col_n[14]}
N 4410 -4740 4420 -4730 {
lab=col_n[14]}
N 4200 -4710 4210 -4720 {
lab=colon_n[14]}
N 4210 -4720 4410 -4720 {
lab=colon_n[14]}
N 4410 -4720 4420 -4710 {
lab=colon_n[14]}
N 4200 -4690 4210 -4700 {
lab=#net29}
N 4210 -4700 4410 -4700 {
lab=#net29}
N 4410 -4700 4420 -4690 {
lab=#net29}
N 4200 -4670 4210 -4680 {
lab=#net30}
N 4210 -4680 4410 -4680 {
lab=#net30}
N 4410 -4680 4420 -4670 {
lab=#net30}
N 4260 -4830 4260 -4810 {
lab=vcom}
N 4300 -4830 4300 -4810 {
lab=ctop}
N 4180 -4730 4200 -4730 {
lab=col_n[14]}
N 4180 -4710 4200 -4710 {
lab=colon_n[14]}
N 4180 -4690 4200 -4690 {
lab=#net29}
N 4180 -4670 4200 -4670 {
lab=#net30}
N 4420 -4670 4440 -4670 {
lab=#net30}
N 4420 -4690 4440 -4690 {
lab=#net29}
N 4420 -4710 4440 -4710 {
lab=colon_n[14]}
N 4420 -4730 4440 -4730 {
lab=col_n[14]}
N 4240 -4590 4240 -4580 {
lab=VSS}
N 4240 -4820 4240 -4810 {
lab=VDD}
N 4580 -4590 4590 -4600 {
lab=row_n[13]}
N 4590 -4800 4590 -4600 {
lab=row_n[13]}
N 4580 -4810 4590 -4800 {
lab=row_n[13]}
N 4580 -4590 4580 -4570 {
lab=row_n[13]}
N 4580 -4830 4580 -4810 {
lab=row_n[13]}
N 4460 -4730 4470 -4740 {
lab=col_n[14]}
N 4470 -4740 4670 -4740 {
lab=col_n[14]}
N 4670 -4740 4680 -4730 {
lab=col_n[14]}
N 4460 -4710 4470 -4720 {
lab=colon_n[14]}
N 4470 -4720 4670 -4720 {
lab=colon_n[14]}
N 4670 -4720 4680 -4710 {
lab=colon_n[14]}
N 4460 -4690 4470 -4700 {
lab=#net29}
N 4470 -4700 4670 -4700 {
lab=#net29}
N 4670 -4700 4680 -4690 {
lab=#net29}
N 4460 -4670 4470 -4680 {
lab=#net30}
N 4470 -4680 4670 -4680 {
lab=#net30}
N 4670 -4680 4680 -4670 {
lab=#net30}
N 4520 -4830 4520 -4810 {
lab=vcom}
N 4560 -4830 4560 -4810 {
lab=ctop}
N 4440 -4730 4460 -4730 {
lab=col_n[14]}
N 4440 -4710 4460 -4710 {
lab=colon_n[14]}
N 4440 -4690 4460 -4690 {
lab=#net29}
N 4440 -4670 4460 -4670 {
lab=#net30}
N 4680 -4670 4700 -4670 {
lab=#net30}
N 4680 -4690 4700 -4690 {
lab=#net29}
N 4680 -4710 4700 -4710 {
lab=colon_n[14]}
N 4680 -4730 4700 -4730 {
lab=col_n[14]}
N 4500 -4590 4500 -4580 {
lab=VSS}
N 4500 -4820 4500 -4810 {
lab=VDD}
N 4840 -4590 4850 -4600 {
lab=row_n[14]}
N 4850 -4800 4850 -4600 {
lab=row_n[14]}
N 4840 -4810 4850 -4800 {
lab=row_n[14]}
N 4840 -4590 4840 -4570 {
lab=row_n[14]}
N 4840 -4830 4840 -4810 {
lab=row_n[14]}
N 4720 -4730 4730 -4740 {
lab=col_n[14]}
N 4730 -4740 4930 -4740 {
lab=col_n[14]}
N 4930 -4740 4940 -4730 {
lab=col_n[14]}
N 4720 -4710 4730 -4720 {
lab=colon_n[14]}
N 4730 -4720 4930 -4720 {
lab=colon_n[14]}
N 4930 -4720 4940 -4710 {
lab=colon_n[14]}
N 4720 -4690 4730 -4700 {
lab=#net29}
N 4730 -4700 4930 -4700 {
lab=#net29}
N 4930 -4700 4940 -4690 {
lab=#net29}
N 4720 -4670 4730 -4680 {
lab=#net30}
N 4730 -4680 4930 -4680 {
lab=#net30}
N 4930 -4680 4940 -4670 {
lab=#net30}
N 4780 -4830 4780 -4810 {
lab=vcom}
N 4820 -4830 4820 -4810 {
lab=ctop}
N 4700 -4730 4720 -4730 {
lab=col_n[14]}
N 4700 -4710 4720 -4710 {
lab=colon_n[14]}
N 4700 -4690 4720 -4690 {
lab=#net29}
N 4700 -4670 4720 -4670 {
lab=#net30}
N 4940 -4670 4960 -4670 {
lab=#net30}
N 4940 -4690 4960 -4690 {
lab=#net29}
N 4940 -4710 4960 -4710 {
lab=colon_n[14]}
N 4940 -4730 4960 -4730 {
lab=col_n[14]}
N 4760 -4590 4760 -4580 {
lab=VSS}
N 4760 -4820 4760 -4810 {
lab=VDD}
N 5100 -4590 5110 -4600 {
lab=row_n[15]}
N 5110 -4800 5110 -4600 {
lab=row_n[15]}
N 5100 -4810 5110 -4800 {
lab=row_n[15]}
N 5100 -4590 5100 -4570 {
lab=row_n[15]}
N 5100 -4830 5100 -4810 {
lab=row_n[15]}
N 4980 -4730 4990 -4740 {
lab=col_n[14]}
N 4990 -4740 5190 -4740 {
lab=col_n[14]}
N 5190 -4740 5200 -4730 {
lab=col_n[14]}
N 4980 -4710 4990 -4720 {
lab=colon_n[14]}
N 4990 -4720 5190 -4720 {
lab=colon_n[14]}
N 5190 -4720 5200 -4710 {
lab=colon_n[14]}
N 4980 -4690 4990 -4700 {
lab=#net29}
N 4990 -4700 5190 -4700 {
lab=#net29}
N 5190 -4700 5200 -4690 {
lab=#net29}
N 4980 -4670 4990 -4680 {
lab=#net30}
N 4990 -4680 5190 -4680 {
lab=#net30}
N 5190 -4680 5200 -4670 {
lab=#net30}
N 5040 -4830 5040 -4810 {
lab=vcom}
N 5080 -4830 5080 -4810 {
lab=ctop}
N 4960 -4730 4980 -4730 {
lab=col_n[14]}
N 4960 -4710 4980 -4710 {
lab=colon_n[14]}
N 4960 -4690 4980 -4690 {
lab=#net29}
N 4960 -4670 4980 -4670 {
lab=#net30}
N 5200 -4670 5220 -4670 {
lab=#net30}
N 5200 -4690 5220 -4690 {
lab=#net29}
N 5200 -4710 5220 -4710 {
lab=colon_n[14]}
N 5200 -4730 5220 -4730 {
lab=col_n[14]}
N 5020 -4590 5020 -4580 {
lab=VSS}
N 5020 -4820 5020 -4810 {
lab=VDD}
N 5360 -4590 5370 -4600 {
lab=row_n[16]}
N 5370 -4800 5370 -4600 {
lab=row_n[16]}
N 5360 -4810 5370 -4800 {
lab=row_n[16]}
N 5360 -4590 5360 -4570 {
lab=row_n[16]}
N 5360 -4830 5360 -4810 {
lab=row_n[16]}
N 5240 -4730 5250 -4740 {
lab=col_n[14]}
N 5250 -4740 5450 -4740 {
lab=col_n[14]}
N 5450 -4740 5460 -4730 {
lab=col_n[14]}
N 5240 -4710 5250 -4720 {
lab=colon_n[14]}
N 5250 -4720 5450 -4720 {
lab=colon_n[14]}
N 5450 -4720 5460 -4710 {
lab=colon_n[14]}
N 5240 -4690 5250 -4700 {
lab=#net29}
N 5250 -4700 5450 -4700 {
lab=#net29}
N 5450 -4700 5460 -4690 {
lab=#net29}
N 5240 -4670 5250 -4680 {
lab=#net30}
N 5250 -4680 5450 -4680 {
lab=#net30}
N 5450 -4680 5460 -4670 {
lab=#net30}
N 5300 -4830 5300 -4810 {
lab=vcom}
N 5340 -4830 5340 -4810 {
lab=ctop}
N 5220 -4730 5240 -4730 {
lab=col_n[14]}
N 5220 -4710 5240 -4710 {
lab=colon_n[14]}
N 5220 -4690 5240 -4690 {
lab=#net29}
N 5220 -4670 5240 -4670 {
lab=#net30}
N 5460 -4670 5480 -4670 {
lab=#net30}
N 5460 -4690 5480 -4690 {
lab=#net29}
N 5460 -4710 5480 -4710 {
lab=colon_n[14]}
N 5460 -4730 5480 -4730 {
lab=col_n[14]}
N 5280 -4590 5280 -4580 {
lab=VSS}
N 5280 -4820 5280 -4810 {
lab=VDD}
N 5620 -4590 5630 -4600 {
lab=row_n[17]}
N 5630 -4800 5630 -4600 {
lab=row_n[17]}
N 5620 -4810 5630 -4800 {
lab=row_n[17]}
N 5620 -4590 5620 -4570 {
lab=row_n[17]}
N 5620 -4830 5620 -4810 {
lab=row_n[17]}
N 5500 -4730 5510 -4740 {
lab=col_n[14]}
N 5510 -4740 5710 -4740 {
lab=col_n[14]}
N 5710 -4740 5720 -4730 {
lab=col_n[14]}
N 5500 -4710 5510 -4720 {
lab=colon_n[14]}
N 5510 -4720 5710 -4720 {
lab=colon_n[14]}
N 5710 -4720 5720 -4710 {
lab=colon_n[14]}
N 5500 -4690 5510 -4700 {
lab=#net29}
N 5510 -4700 5710 -4700 {
lab=#net29}
N 5710 -4700 5720 -4690 {
lab=#net29}
N 5500 -4670 5510 -4680 {
lab=#net30}
N 5510 -4680 5710 -4680 {
lab=#net30}
N 5710 -4680 5720 -4670 {
lab=#net30}
N 5560 -4830 5560 -4810 {
lab=vcom}
N 5600 -4830 5600 -4810 {
lab=ctop}
N 5480 -4730 5500 -4730 {
lab=col_n[14]}
N 5480 -4710 5500 -4710 {
lab=colon_n[14]}
N 5480 -4690 5500 -4690 {
lab=#net29}
N 5480 -4670 5500 -4670 {
lab=#net30}
N 5720 -4670 5740 -4670 {
lab=#net30}
N 5720 -4690 5740 -4690 {
lab=#net29}
N 5720 -4710 5740 -4710 {
lab=colon_n[14]}
N 5720 -4730 5740 -4730 {
lab=col_n[14]}
N 5540 -4590 5540 -4580 {
lab=VSS}
N 5540 -4820 5540 -4810 {
lab=VDD}
N 5880 -4590 5890 -4600 {
lab=row_n[18]}
N 5890 -4800 5890 -4600 {
lab=row_n[18]}
N 5880 -4810 5890 -4800 {
lab=row_n[18]}
N 5880 -4590 5880 -4570 {
lab=row_n[18]}
N 5880 -4830 5880 -4810 {
lab=row_n[18]}
N 5760 -4730 5770 -4740 {
lab=col_n[14]}
N 5770 -4740 5970 -4740 {
lab=col_n[14]}
N 5970 -4740 5980 -4730 {
lab=col_n[14]}
N 5760 -4710 5770 -4720 {
lab=colon_n[14]}
N 5770 -4720 5970 -4720 {
lab=colon_n[14]}
N 5970 -4720 5980 -4710 {
lab=colon_n[14]}
N 5760 -4690 5770 -4700 {
lab=#net29}
N 5770 -4700 5970 -4700 {
lab=#net29}
N 5970 -4700 5980 -4690 {
lab=#net29}
N 5760 -4670 5770 -4680 {
lab=#net30}
N 5770 -4680 5970 -4680 {
lab=#net30}
N 5970 -4680 5980 -4670 {
lab=#net30}
N 5820 -4830 5820 -4810 {
lab=vcom}
N 5860 -4830 5860 -4810 {
lab=ctop}
N 5740 -4730 5760 -4730 {
lab=col_n[14]}
N 5740 -4710 5760 -4710 {
lab=colon_n[14]}
N 5740 -4690 5760 -4690 {
lab=#net29}
N 5740 -4670 5760 -4670 {
lab=#net30}
N 5980 -4670 6000 -4670 {
lab=#net30}
N 5980 -4690 6000 -4690 {
lab=#net29}
N 5980 -4710 6000 -4710 {
lab=colon_n[14]}
N 5980 -4730 6000 -4730 {
lab=col_n[14]}
N 5800 -4590 5800 -4580 {
lab=VSS}
N 5800 -4820 5800 -4810 {
lab=VDD}
N 6140 -4590 6150 -4600 {
lab=row_n[19]}
N 6150 -4800 6150 -4600 {
lab=row_n[19]}
N 6140 -4810 6150 -4800 {
lab=row_n[19]}
N 6140 -4590 6140 -4570 {
lab=row_n[19]}
N 6140 -4830 6140 -4810 {
lab=row_n[19]}
N 6020 -4730 6030 -4740 {
lab=col_n[14]}
N 6030 -4740 6230 -4740 {
lab=col_n[14]}
N 6230 -4740 6240 -4730 {
lab=col_n[14]}
N 6020 -4710 6030 -4720 {
lab=colon_n[14]}
N 6030 -4720 6230 -4720 {
lab=colon_n[14]}
N 6230 -4720 6240 -4710 {
lab=colon_n[14]}
N 6020 -4690 6030 -4700 {
lab=#net29}
N 6030 -4700 6230 -4700 {
lab=#net29}
N 6230 -4700 6240 -4690 {
lab=#net29}
N 6020 -4670 6030 -4680 {
lab=#net30}
N 6030 -4680 6230 -4680 {
lab=#net30}
N 6230 -4680 6240 -4670 {
lab=#net30}
N 6080 -4830 6080 -4810 {
lab=vcom}
N 6120 -4830 6120 -4810 {
lab=ctop}
N 6000 -4730 6020 -4730 {
lab=col_n[14]}
N 6000 -4710 6020 -4710 {
lab=colon_n[14]}
N 6000 -4690 6020 -4690 {
lab=#net29}
N 6000 -4670 6020 -4670 {
lab=#net30}
N 6240 -4670 6260 -4670 {
lab=#net30}
N 6240 -4690 6260 -4690 {
lab=#net29}
N 6240 -4710 6260 -4710 {
lab=colon_n[14]}
N 6240 -4730 6260 -4730 {
lab=col_n[14]}
N 6060 -4590 6060 -4580 {
lab=VSS}
N 6060 -4820 6060 -4810 {
lab=VDD}
N 6400 -4590 6410 -4600 {
lab=row_n[20]}
N 6410 -4800 6410 -4600 {
lab=row_n[20]}
N 6400 -4810 6410 -4800 {
lab=row_n[20]}
N 6400 -4590 6400 -4570 {
lab=row_n[20]}
N 6400 -4830 6400 -4810 {
lab=row_n[20]}
N 6280 -4730 6290 -4740 {
lab=col_n[14]}
N 6290 -4740 6490 -4740 {
lab=col_n[14]}
N 6490 -4740 6500 -4730 {
lab=col_n[14]}
N 6280 -4710 6290 -4720 {
lab=colon_n[14]}
N 6290 -4720 6490 -4720 {
lab=colon_n[14]}
N 6490 -4720 6500 -4710 {
lab=colon_n[14]}
N 6280 -4690 6290 -4700 {
lab=#net29}
N 6290 -4700 6490 -4700 {
lab=#net29}
N 6490 -4700 6500 -4690 {
lab=#net29}
N 6280 -4670 6290 -4680 {
lab=#net30}
N 6290 -4680 6490 -4680 {
lab=#net30}
N 6490 -4680 6500 -4670 {
lab=#net30}
N 6340 -4830 6340 -4810 {
lab=vcom}
N 6380 -4830 6380 -4810 {
lab=ctop}
N 6260 -4730 6280 -4730 {
lab=col_n[14]}
N 6260 -4710 6280 -4710 {
lab=colon_n[14]}
N 6260 -4690 6280 -4690 {
lab=#net29}
N 6260 -4670 6280 -4670 {
lab=#net30}
N 6500 -4670 6520 -4670 {
lab=#net30}
N 6500 -4690 6520 -4690 {
lab=#net29}
N 6500 -4710 6520 -4710 {
lab=colon_n[14]}
N 6500 -4730 6520 -4730 {
lab=col_n[14]}
N 6320 -4590 6320 -4580 {
lab=VSS}
N 6320 -4820 6320 -4810 {
lab=VDD}
N 6660 -4590 6670 -4600 {
lab=row_n[21]}
N 6670 -4800 6670 -4600 {
lab=row_n[21]}
N 6660 -4810 6670 -4800 {
lab=row_n[21]}
N 6660 -4590 6660 -4570 {
lab=row_n[21]}
N 6660 -4830 6660 -4810 {
lab=row_n[21]}
N 6540 -4730 6550 -4740 {
lab=col_n[14]}
N 6550 -4740 6750 -4740 {
lab=col_n[14]}
N 6750 -4740 6760 -4730 {
lab=col_n[14]}
N 6540 -4710 6550 -4720 {
lab=colon_n[14]}
N 6550 -4720 6750 -4720 {
lab=colon_n[14]}
N 6750 -4720 6760 -4710 {
lab=colon_n[14]}
N 6540 -4690 6550 -4700 {
lab=#net29}
N 6550 -4700 6750 -4700 {
lab=#net29}
N 6750 -4700 6760 -4690 {
lab=#net29}
N 6540 -4670 6550 -4680 {
lab=#net30}
N 6550 -4680 6750 -4680 {
lab=#net30}
N 6750 -4680 6760 -4670 {
lab=#net30}
N 6600 -4830 6600 -4810 {
lab=vcom}
N 6640 -4830 6640 -4810 {
lab=ctop}
N 6520 -4730 6540 -4730 {
lab=col_n[14]}
N 6520 -4710 6540 -4710 {
lab=colon_n[14]}
N 6520 -4690 6540 -4690 {
lab=#net29}
N 6520 -4670 6540 -4670 {
lab=#net30}
N 6760 -4670 6780 -4670 {
lab=#net30}
N 6760 -4690 6780 -4690 {
lab=#net29}
N 6760 -4710 6780 -4710 {
lab=colon_n[14]}
N 6760 -4730 6780 -4730 {
lab=col_n[14]}
N 6580 -4590 6580 -4580 {
lab=VSS}
N 6580 -4820 6580 -4810 {
lab=VDD}
N 6920 -4590 6930 -4600 {
lab=row_n[22]}
N 6930 -4800 6930 -4600 {
lab=row_n[22]}
N 6920 -4810 6930 -4800 {
lab=row_n[22]}
N 6920 -4590 6920 -4570 {
lab=row_n[22]}
N 6920 -4830 6920 -4810 {
lab=row_n[22]}
N 6800 -4730 6810 -4740 {
lab=col_n[14]}
N 6810 -4740 7010 -4740 {
lab=col_n[14]}
N 7010 -4740 7020 -4730 {
lab=col_n[14]}
N 6800 -4710 6810 -4720 {
lab=colon_n[14]}
N 6810 -4720 7010 -4720 {
lab=colon_n[14]}
N 7010 -4720 7020 -4710 {
lab=colon_n[14]}
N 6800 -4690 6810 -4700 {
lab=#net29}
N 6810 -4700 7010 -4700 {
lab=#net29}
N 7010 -4700 7020 -4690 {
lab=#net29}
N 6800 -4670 6810 -4680 {
lab=#net30}
N 6810 -4680 7010 -4680 {
lab=#net30}
N 7010 -4680 7020 -4670 {
lab=#net30}
N 6860 -4830 6860 -4810 {
lab=vcom}
N 6900 -4830 6900 -4810 {
lab=ctop}
N 6780 -4730 6800 -4730 {
lab=col_n[14]}
N 6780 -4710 6800 -4710 {
lab=colon_n[14]}
N 6780 -4690 6800 -4690 {
lab=#net29}
N 6780 -4670 6800 -4670 {
lab=#net30}
N 7020 -4670 7040 -4670 {
lab=#net30}
N 7020 -4690 7040 -4690 {
lab=#net29}
N 7020 -4710 7040 -4710 {
lab=colon_n[14]}
N 7020 -4730 7040 -4730 {
lab=col_n[14]}
N 6840 -4590 6840 -4580 {
lab=VSS}
N 6840 -4820 6840 -4810 {
lab=VDD}
N 7180 -4590 7190 -4600 {
lab=row_n[23]}
N 7190 -4800 7190 -4600 {
lab=row_n[23]}
N 7180 -4810 7190 -4800 {
lab=row_n[23]}
N 7180 -4590 7180 -4570 {
lab=row_n[23]}
N 7180 -4830 7180 -4810 {
lab=row_n[23]}
N 7060 -4730 7070 -4740 {
lab=col_n[14]}
N 7070 -4740 7270 -4740 {
lab=col_n[14]}
N 7270 -4740 7280 -4730 {
lab=col_n[14]}
N 7060 -4710 7070 -4720 {
lab=colon_n[14]}
N 7070 -4720 7270 -4720 {
lab=colon_n[14]}
N 7270 -4720 7280 -4710 {
lab=colon_n[14]}
N 7060 -4690 7070 -4700 {
lab=#net29}
N 7070 -4700 7270 -4700 {
lab=#net29}
N 7270 -4700 7280 -4690 {
lab=#net29}
N 7060 -4670 7070 -4680 {
lab=#net30}
N 7070 -4680 7270 -4680 {
lab=#net30}
N 7270 -4680 7280 -4670 {
lab=#net30}
N 7120 -4830 7120 -4810 {
lab=vcom}
N 7160 -4830 7160 -4810 {
lab=ctop}
N 7040 -4730 7060 -4730 {
lab=col_n[14]}
N 7040 -4710 7060 -4710 {
lab=colon_n[14]}
N 7040 -4690 7060 -4690 {
lab=#net29}
N 7040 -4670 7060 -4670 {
lab=#net30}
N 7280 -4670 7300 -4670 {
lab=#net30}
N 7280 -4690 7300 -4690 {
lab=#net29}
N 7280 -4710 7300 -4710 {
lab=colon_n[14]}
N 7280 -4730 7300 -4730 {
lab=col_n[14]}
N 7100 -4590 7100 -4580 {
lab=VSS}
N 7100 -4820 7100 -4810 {
lab=VDD}
N 7440 -4590 7450 -4600 {
lab=row_n[24]}
N 7450 -4800 7450 -4600 {
lab=row_n[24]}
N 7440 -4810 7450 -4800 {
lab=row_n[24]}
N 7440 -4590 7440 -4570 {
lab=row_n[24]}
N 7440 -4830 7440 -4810 {
lab=row_n[24]}
N 7320 -4730 7330 -4740 {
lab=col_n[14]}
N 7330 -4740 7530 -4740 {
lab=col_n[14]}
N 7530 -4740 7540 -4730 {
lab=col_n[14]}
N 7320 -4710 7330 -4720 {
lab=colon_n[14]}
N 7330 -4720 7530 -4720 {
lab=colon_n[14]}
N 7530 -4720 7540 -4710 {
lab=colon_n[14]}
N 7320 -4690 7330 -4700 {
lab=#net29}
N 7330 -4700 7530 -4700 {
lab=#net29}
N 7530 -4700 7540 -4690 {
lab=#net29}
N 7320 -4670 7330 -4680 {
lab=#net30}
N 7330 -4680 7530 -4680 {
lab=#net30}
N 7530 -4680 7540 -4670 {
lab=#net30}
N 7380 -4830 7380 -4810 {
lab=vcom}
N 7420 -4830 7420 -4810 {
lab=ctop}
N 7300 -4730 7320 -4730 {
lab=col_n[14]}
N 7300 -4710 7320 -4710 {
lab=colon_n[14]}
N 7300 -4690 7320 -4690 {
lab=#net29}
N 7300 -4670 7320 -4670 {
lab=#net30}
N 7540 -4670 7560 -4670 {
lab=#net30}
N 7540 -4690 7560 -4690 {
lab=#net29}
N 7540 -4710 7560 -4710 {
lab=colon_n[14]}
N 7540 -4730 7560 -4730 {
lab=col_n[14]}
N 7360 -4590 7360 -4580 {
lab=VSS}
N 7360 -4820 7360 -4810 {
lab=VDD}
N 7700 -4590 7710 -4600 {
lab=row_n[25]}
N 7710 -4800 7710 -4600 {
lab=row_n[25]}
N 7700 -4810 7710 -4800 {
lab=row_n[25]}
N 7700 -4590 7700 -4570 {
lab=row_n[25]}
N 7700 -4830 7700 -4810 {
lab=row_n[25]}
N 7580 -4730 7590 -4740 {
lab=col_n[14]}
N 7590 -4740 7790 -4740 {
lab=col_n[14]}
N 7790 -4740 7800 -4730 {
lab=col_n[14]}
N 7580 -4710 7590 -4720 {
lab=colon_n[14]}
N 7590 -4720 7790 -4720 {
lab=colon_n[14]}
N 7790 -4720 7800 -4710 {
lab=colon_n[14]}
N 7580 -4690 7590 -4700 {
lab=#net29}
N 7590 -4700 7790 -4700 {
lab=#net29}
N 7790 -4700 7800 -4690 {
lab=#net29}
N 7580 -4670 7590 -4680 {
lab=#net30}
N 7590 -4680 7790 -4680 {
lab=#net30}
N 7790 -4680 7800 -4670 {
lab=#net30}
N 7640 -4830 7640 -4810 {
lab=vcom}
N 7680 -4830 7680 -4810 {
lab=ctop}
N 7560 -4730 7580 -4730 {
lab=col_n[14]}
N 7560 -4710 7580 -4710 {
lab=colon_n[14]}
N 7560 -4690 7580 -4690 {
lab=#net29}
N 7560 -4670 7580 -4670 {
lab=#net30}
N 7800 -4670 7820 -4670 {
lab=#net30}
N 7800 -4690 7820 -4690 {
lab=#net29}
N 7800 -4710 7820 -4710 {
lab=colon_n[14]}
N 7800 -4730 7820 -4730 {
lab=col_n[14]}
N 7620 -4590 7620 -4580 {
lab=VSS}
N 7620 -4820 7620 -4810 {
lab=VDD}
N 7960 -4590 7970 -4600 {
lab=row_n[26]}
N 7970 -4800 7970 -4600 {
lab=row_n[26]}
N 7960 -4810 7970 -4800 {
lab=row_n[26]}
N 7960 -4590 7960 -4570 {
lab=row_n[26]}
N 7960 -4830 7960 -4810 {
lab=row_n[26]}
N 7840 -4730 7850 -4740 {
lab=col_n[14]}
N 7850 -4740 8050 -4740 {
lab=col_n[14]}
N 8050 -4740 8060 -4730 {
lab=col_n[14]}
N 7840 -4710 7850 -4720 {
lab=colon_n[14]}
N 7850 -4720 8050 -4720 {
lab=colon_n[14]}
N 8050 -4720 8060 -4710 {
lab=colon_n[14]}
N 7840 -4690 7850 -4700 {
lab=#net29}
N 7850 -4700 8050 -4700 {
lab=#net29}
N 8050 -4700 8060 -4690 {
lab=#net29}
N 7840 -4670 7850 -4680 {
lab=#net30}
N 7850 -4680 8050 -4680 {
lab=#net30}
N 8050 -4680 8060 -4670 {
lab=#net30}
N 7900 -4830 7900 -4810 {
lab=vcom}
N 7940 -4830 7940 -4810 {
lab=ctop}
N 7820 -4730 7840 -4730 {
lab=col_n[14]}
N 7820 -4710 7840 -4710 {
lab=colon_n[14]}
N 7820 -4690 7840 -4690 {
lab=#net29}
N 7820 -4670 7840 -4670 {
lab=#net30}
N 8060 -4670 8080 -4670 {
lab=#net30}
N 8060 -4690 8080 -4690 {
lab=#net29}
N 8060 -4710 8080 -4710 {
lab=colon_n[14]}
N 8060 -4730 8080 -4730 {
lab=col_n[14]}
N 7880 -4590 7880 -4580 {
lab=VSS}
N 7880 -4820 7880 -4810 {
lab=VDD}
N 8220 -4590 8230 -4600 {
lab=row_n[27]}
N 8230 -4800 8230 -4600 {
lab=row_n[27]}
N 8220 -4810 8230 -4800 {
lab=row_n[27]}
N 8220 -4590 8220 -4570 {
lab=row_n[27]}
N 8220 -4830 8220 -4810 {
lab=row_n[27]}
N 8100 -4730 8110 -4740 {
lab=col_n[14]}
N 8110 -4740 8310 -4740 {
lab=col_n[14]}
N 8310 -4740 8320 -4730 {
lab=col_n[14]}
N 8100 -4710 8110 -4720 {
lab=colon_n[14]}
N 8110 -4720 8310 -4720 {
lab=colon_n[14]}
N 8310 -4720 8320 -4710 {
lab=colon_n[14]}
N 8100 -4690 8110 -4700 {
lab=#net29}
N 8110 -4700 8310 -4700 {
lab=#net29}
N 8310 -4700 8320 -4690 {
lab=#net29}
N 8100 -4670 8110 -4680 {
lab=#net30}
N 8110 -4680 8310 -4680 {
lab=#net30}
N 8310 -4680 8320 -4670 {
lab=#net30}
N 8160 -4830 8160 -4810 {
lab=vcom}
N 8200 -4830 8200 -4810 {
lab=ctop}
N 8080 -4730 8100 -4730 {
lab=col_n[14]}
N 8080 -4710 8100 -4710 {
lab=colon_n[14]}
N 8080 -4690 8100 -4690 {
lab=#net29}
N 8080 -4670 8100 -4670 {
lab=#net30}
N 8320 -4670 8340 -4670 {
lab=#net30}
N 8320 -4690 8340 -4690 {
lab=#net29}
N 8320 -4710 8340 -4710 {
lab=colon_n[14]}
N 8320 -4730 8340 -4730 {
lab=col_n[14]}
N 8140 -4590 8140 -4580 {
lab=VSS}
N 8140 -4820 8140 -4810 {
lab=VDD}
N 8480 -4590 8490 -4600 {
lab=row_n[28]}
N 8490 -4800 8490 -4600 {
lab=row_n[28]}
N 8480 -4810 8490 -4800 {
lab=row_n[28]}
N 8480 -4590 8480 -4570 {
lab=row_n[28]}
N 8480 -4830 8480 -4810 {
lab=row_n[28]}
N 8360 -4730 8370 -4740 {
lab=col_n[14]}
N 8370 -4740 8570 -4740 {
lab=col_n[14]}
N 8570 -4740 8580 -4730 {
lab=col_n[14]}
N 8360 -4710 8370 -4720 {
lab=colon_n[14]}
N 8370 -4720 8570 -4720 {
lab=colon_n[14]}
N 8570 -4720 8580 -4710 {
lab=colon_n[14]}
N 8360 -4690 8370 -4700 {
lab=#net29}
N 8370 -4700 8570 -4700 {
lab=#net29}
N 8570 -4700 8580 -4690 {
lab=#net29}
N 8360 -4670 8370 -4680 {
lab=#net30}
N 8370 -4680 8570 -4680 {
lab=#net30}
N 8570 -4680 8580 -4670 {
lab=#net30}
N 8420 -4830 8420 -4810 {
lab=vcom}
N 8460 -4830 8460 -4810 {
lab=ctop}
N 8340 -4730 8360 -4730 {
lab=col_n[14]}
N 8340 -4710 8360 -4710 {
lab=colon_n[14]}
N 8340 -4690 8360 -4690 {
lab=#net29}
N 8340 -4670 8360 -4670 {
lab=#net30}
N 8580 -4670 8600 -4670 {
lab=#net30}
N 8580 -4690 8600 -4690 {
lab=#net29}
N 8580 -4710 8600 -4710 {
lab=colon_n[14]}
N 8580 -4730 8600 -4730 {
lab=col_n[14]}
N 8400 -4590 8400 -4580 {
lab=VSS}
N 8400 -4820 8400 -4810 {
lab=VDD}
N 8740 -4590 8750 -4600 {
lab=row_n[29]}
N 8750 -4800 8750 -4600 {
lab=row_n[29]}
N 8740 -4810 8750 -4800 {
lab=row_n[29]}
N 8740 -4590 8740 -4570 {
lab=row_n[29]}
N 8740 -4830 8740 -4810 {
lab=row_n[29]}
N 8620 -4730 8630 -4740 {
lab=col_n[14]}
N 8630 -4740 8830 -4740 {
lab=col_n[14]}
N 8830 -4740 8840 -4730 {
lab=col_n[14]}
N 8620 -4710 8630 -4720 {
lab=colon_n[14]}
N 8630 -4720 8830 -4720 {
lab=colon_n[14]}
N 8830 -4720 8840 -4710 {
lab=colon_n[14]}
N 8620 -4690 8630 -4700 {
lab=#net29}
N 8630 -4700 8830 -4700 {
lab=#net29}
N 8830 -4700 8840 -4690 {
lab=#net29}
N 8620 -4670 8630 -4680 {
lab=#net30}
N 8630 -4680 8830 -4680 {
lab=#net30}
N 8830 -4680 8840 -4670 {
lab=#net30}
N 8680 -4830 8680 -4810 {
lab=vcom}
N 8720 -4830 8720 -4810 {
lab=ctop}
N 8600 -4730 8620 -4730 {
lab=col_n[14]}
N 8600 -4710 8620 -4710 {
lab=colon_n[14]}
N 8600 -4690 8620 -4690 {
lab=#net29}
N 8600 -4670 8620 -4670 {
lab=#net30}
N 8840 -4670 8860 -4670 {
lab=#net30}
N 8840 -4690 8860 -4690 {
lab=#net29}
N 8840 -4710 8860 -4710 {
lab=colon_n[14]}
N 8840 -4730 8860 -4730 {
lab=col_n[14]}
N 8660 -4590 8660 -4580 {
lab=VSS}
N 8660 -4820 8660 -4810 {
lab=VDD}
N 9000 -4590 9010 -4600 {
lab=row_n[30]}
N 9010 -4800 9010 -4600 {
lab=row_n[30]}
N 9000 -4810 9010 -4800 {
lab=row_n[30]}
N 9000 -4590 9000 -4570 {
lab=row_n[30]}
N 9000 -4830 9000 -4810 {
lab=row_n[30]}
N 8880 -4730 8890 -4740 {
lab=col_n[14]}
N 8890 -4740 9090 -4740 {
lab=col_n[14]}
N 9090 -4740 9100 -4730 {
lab=col_n[14]}
N 8880 -4710 8890 -4720 {
lab=colon_n[14]}
N 8890 -4720 9090 -4720 {
lab=colon_n[14]}
N 9090 -4720 9100 -4710 {
lab=colon_n[14]}
N 8880 -4690 8890 -4700 {
lab=#net29}
N 8890 -4700 9090 -4700 {
lab=#net29}
N 9090 -4700 9100 -4690 {
lab=#net29}
N 8880 -4670 8890 -4680 {
lab=#net30}
N 8890 -4680 9090 -4680 {
lab=#net30}
N 9090 -4680 9100 -4670 {
lab=#net30}
N 8940 -4830 8940 -4810 {
lab=vcom}
N 8980 -4830 8980 -4810 {
lab=ctop}
N 8860 -4730 8880 -4730 {
lab=col_n[14]}
N 8860 -4710 8880 -4710 {
lab=colon_n[14]}
N 8860 -4690 8880 -4690 {
lab=#net29}
N 8860 -4670 8880 -4670 {
lab=#net30}
N 9100 -4670 9120 -4670 {
lab=#net30}
N 9100 -4690 9120 -4690 {
lab=#net29}
N 9100 -4710 9120 -4710 {
lab=colon_n[14]}
N 9100 -4730 9120 -4730 {
lab=col_n[14]}
N 8920 -4590 8920 -4580 {
lab=VSS}
N 8920 -4820 8920 -4810 {
lab=VDD}
N 9260 -4590 9270 -4600 {
lab=row_n[31]}
N 9270 -4800 9270 -4600 {
lab=row_n[31]}
N 9260 -4810 9270 -4800 {
lab=row_n[31]}
N 9260 -4590 9260 -4570 {
lab=row_n[31]}
N 9260 -4830 9260 -4810 {
lab=row_n[31]}
N 9140 -4730 9150 -4740 {
lab=col_n[14]}
N 9150 -4740 9350 -4740 {
lab=col_n[14]}
N 9350 -4740 9360 -4730 {
lab=col_n[14]}
N 9140 -4710 9150 -4720 {
lab=colon_n[14]}
N 9150 -4720 9350 -4720 {
lab=colon_n[14]}
N 9350 -4720 9360 -4710 {
lab=colon_n[14]}
N 9140 -4690 9150 -4700 {
lab=#net29}
N 9150 -4700 9350 -4700 {
lab=#net29}
N 9350 -4700 9360 -4690 {
lab=#net29}
N 9140 -4670 9150 -4680 {
lab=#net30}
N 9150 -4680 9350 -4680 {
lab=#net30}
N 9350 -4680 9360 -4670 {
lab=#net30}
N 9200 -4830 9200 -4810 {
lab=vcom}
N 9240 -4830 9240 -4810 {
lab=ctop}
N 9120 -4730 9140 -4730 {
lab=col_n[14]}
N 9120 -4710 9140 -4710 {
lab=colon_n[14]}
N 9120 -4690 9140 -4690 {
lab=#net29}
N 9120 -4670 9140 -4670 {
lab=#net30}
N 9360 -4670 9380 -4670 {
lab=#net30}
N 9360 -4690 9380 -4690 {
lab=#net29}
N 9360 -4710 9380 -4710 {
lab=colon_n[14]}
N 9360 -4730 9380 -4730 {
lab=col_n[14]}
N 9180 -4590 9180 -4580 {
lab=VSS}
N 9180 -4820 9180 -4810 {
lab=VDD}
N 1200 -4850 1210 -4860 {
lab=row_n[0]}
N 1210 -5060 1210 -4860 {
lab=row_n[0]}
N 1200 -5070 1210 -5060 {
lab=row_n[0]}
N 1200 -4850 1200 -4830 {
lab=row_n[0]}
N 1200 -5090 1200 -5070 {
lab=row_n[0]}
N 1080 -4990 1090 -5000 {
lab=col_n[15]}
N 1090 -5000 1290 -5000 {
lab=col_n[15]}
N 1290 -5000 1300 -4990 {
lab=col_n[15]}
N 1080 -4970 1090 -4980 {
lab=colon_n[15]}
N 1090 -4980 1290 -4980 {
lab=colon_n[15]}
N 1290 -4980 1300 -4970 {
lab=colon_n[15]}
N 1080 -4950 1090 -4960 {
lab=#net31}
N 1090 -4960 1290 -4960 {
lab=#net31}
N 1290 -4960 1300 -4950 {
lab=#net31}
N 1080 -4930 1090 -4940 {
lab=#net32}
N 1090 -4940 1290 -4940 {
lab=#net32}
N 1290 -4940 1300 -4930 {
lab=#net32}
N 1140 -5090 1140 -5070 {
lab=vcom}
N 1180 -5090 1180 -5070 {
lab=ctop}
N 1060 -4990 1080 -4990 {
lab=col_n[15]}
N 1060 -4970 1080 -4970 {
lab=colon_n[15]}
N 1060 -4950 1080 -4950 {
lab=#net31}
N 1060 -4930 1080 -4930 {
lab=#net32}
N 1300 -4930 1320 -4930 {
lab=#net32}
N 1300 -4950 1320 -4950 {
lab=#net31}
N 1300 -4970 1320 -4970 {
lab=colon_n[15]}
N 1300 -4990 1320 -4990 {
lab=col_n[15]}
N 1120 -4850 1120 -4840 {
lab=VSS}
N 1120 -5080 1120 -5070 {
lab=VDD}
N 1460 -4850 1470 -4860 {
lab=row_n[1]}
N 1470 -5060 1470 -4860 {
lab=row_n[1]}
N 1460 -5070 1470 -5060 {
lab=row_n[1]}
N 1460 -4850 1460 -4830 {
lab=row_n[1]}
N 1460 -5090 1460 -5070 {
lab=row_n[1]}
N 1340 -4990 1350 -5000 {
lab=col_n[15]}
N 1350 -5000 1550 -5000 {
lab=col_n[15]}
N 1550 -5000 1560 -4990 {
lab=col_n[15]}
N 1340 -4970 1350 -4980 {
lab=colon_n[15]}
N 1350 -4980 1550 -4980 {
lab=colon_n[15]}
N 1550 -4980 1560 -4970 {
lab=colon_n[15]}
N 1340 -4950 1350 -4960 {
lab=#net31}
N 1350 -4960 1550 -4960 {
lab=#net31}
N 1550 -4960 1560 -4950 {
lab=#net31}
N 1340 -4930 1350 -4940 {
lab=#net32}
N 1350 -4940 1550 -4940 {
lab=#net32}
N 1550 -4940 1560 -4930 {
lab=#net32}
N 1400 -5090 1400 -5070 {
lab=vcom}
N 1440 -5090 1440 -5070 {
lab=ctop}
N 1320 -4990 1340 -4990 {
lab=col_n[15]}
N 1320 -4970 1340 -4970 {
lab=colon_n[15]}
N 1320 -4950 1340 -4950 {
lab=#net31}
N 1320 -4930 1340 -4930 {
lab=#net32}
N 1560 -4930 1580 -4930 {
lab=#net32}
N 1560 -4950 1580 -4950 {
lab=#net31}
N 1560 -4970 1580 -4970 {
lab=colon_n[15]}
N 1560 -4990 1580 -4990 {
lab=col_n[15]}
N 1380 -4850 1380 -4840 {
lab=VSS}
N 1380 -5080 1380 -5070 {
lab=VDD}
N 1720 -4850 1730 -4860 {
lab=row_n[2]}
N 1730 -5060 1730 -4860 {
lab=row_n[2]}
N 1720 -5070 1730 -5060 {
lab=row_n[2]}
N 1720 -4850 1720 -4830 {
lab=row_n[2]}
N 1720 -5090 1720 -5070 {
lab=row_n[2]}
N 1600 -4990 1610 -5000 {
lab=col_n[15]}
N 1610 -5000 1810 -5000 {
lab=col_n[15]}
N 1810 -5000 1820 -4990 {
lab=col_n[15]}
N 1600 -4970 1610 -4980 {
lab=colon_n[15]}
N 1610 -4980 1810 -4980 {
lab=colon_n[15]}
N 1810 -4980 1820 -4970 {
lab=colon_n[15]}
N 1600 -4950 1610 -4960 {
lab=#net31}
N 1610 -4960 1810 -4960 {
lab=#net31}
N 1810 -4960 1820 -4950 {
lab=#net31}
N 1600 -4930 1610 -4940 {
lab=#net32}
N 1610 -4940 1810 -4940 {
lab=#net32}
N 1810 -4940 1820 -4930 {
lab=#net32}
N 1660 -5090 1660 -5070 {
lab=vcom}
N 1700 -5090 1700 -5070 {
lab=ctop}
N 1580 -4990 1600 -4990 {
lab=col_n[15]}
N 1580 -4970 1600 -4970 {
lab=colon_n[15]}
N 1580 -4950 1600 -4950 {
lab=#net31}
N 1580 -4930 1600 -4930 {
lab=#net32}
N 1820 -4930 1840 -4930 {
lab=#net32}
N 1820 -4950 1840 -4950 {
lab=#net31}
N 1820 -4970 1840 -4970 {
lab=colon_n[15]}
N 1820 -4990 1840 -4990 {
lab=col_n[15]}
N 1640 -4850 1640 -4840 {
lab=VSS}
N 1640 -5080 1640 -5070 {
lab=VDD}
N 1980 -4850 1990 -4860 {
lab=row_n[3]}
N 1990 -5060 1990 -4860 {
lab=row_n[3]}
N 1980 -5070 1990 -5060 {
lab=row_n[3]}
N 1980 -4850 1980 -4830 {
lab=row_n[3]}
N 1980 -5090 1980 -5070 {
lab=row_n[3]}
N 1860 -4990 1870 -5000 {
lab=col_n[15]}
N 1870 -5000 2070 -5000 {
lab=col_n[15]}
N 2070 -5000 2080 -4990 {
lab=col_n[15]}
N 1860 -4970 1870 -4980 {
lab=colon_n[15]}
N 1870 -4980 2070 -4980 {
lab=colon_n[15]}
N 2070 -4980 2080 -4970 {
lab=colon_n[15]}
N 1860 -4950 1870 -4960 {
lab=#net31}
N 1870 -4960 2070 -4960 {
lab=#net31}
N 2070 -4960 2080 -4950 {
lab=#net31}
N 1860 -4930 1870 -4940 {
lab=#net32}
N 1870 -4940 2070 -4940 {
lab=#net32}
N 2070 -4940 2080 -4930 {
lab=#net32}
N 1920 -5090 1920 -5070 {
lab=vcom}
N 1960 -5090 1960 -5070 {
lab=ctop}
N 1840 -4990 1860 -4990 {
lab=col_n[15]}
N 1840 -4970 1860 -4970 {
lab=colon_n[15]}
N 1840 -4950 1860 -4950 {
lab=#net31}
N 1840 -4930 1860 -4930 {
lab=#net32}
N 2080 -4930 2100 -4930 {
lab=#net32}
N 2080 -4950 2100 -4950 {
lab=#net31}
N 2080 -4970 2100 -4970 {
lab=colon_n[15]}
N 2080 -4990 2100 -4990 {
lab=col_n[15]}
N 1900 -4850 1900 -4840 {
lab=VSS}
N 1900 -5080 1900 -5070 {
lab=VDD}
N 2240 -4850 2250 -4860 {
lab=row_n[4]}
N 2250 -5060 2250 -4860 {
lab=row_n[4]}
N 2240 -5070 2250 -5060 {
lab=row_n[4]}
N 2240 -4850 2240 -4830 {
lab=row_n[4]}
N 2240 -5090 2240 -5070 {
lab=row_n[4]}
N 2120 -4990 2130 -5000 {
lab=col_n[15]}
N 2130 -5000 2330 -5000 {
lab=col_n[15]}
N 2330 -5000 2340 -4990 {
lab=col_n[15]}
N 2120 -4970 2130 -4980 {
lab=colon_n[15]}
N 2130 -4980 2330 -4980 {
lab=colon_n[15]}
N 2330 -4980 2340 -4970 {
lab=colon_n[15]}
N 2120 -4950 2130 -4960 {
lab=#net31}
N 2130 -4960 2330 -4960 {
lab=#net31}
N 2330 -4960 2340 -4950 {
lab=#net31}
N 2120 -4930 2130 -4940 {
lab=#net32}
N 2130 -4940 2330 -4940 {
lab=#net32}
N 2330 -4940 2340 -4930 {
lab=#net32}
N 2180 -5090 2180 -5070 {
lab=vcom}
N 2220 -5090 2220 -5070 {
lab=ctop}
N 2100 -4990 2120 -4990 {
lab=col_n[15]}
N 2100 -4970 2120 -4970 {
lab=colon_n[15]}
N 2100 -4950 2120 -4950 {
lab=#net31}
N 2100 -4930 2120 -4930 {
lab=#net32}
N 2340 -4930 2360 -4930 {
lab=#net32}
N 2340 -4950 2360 -4950 {
lab=#net31}
N 2340 -4970 2360 -4970 {
lab=colon_n[15]}
N 2340 -4990 2360 -4990 {
lab=col_n[15]}
N 2160 -4850 2160 -4840 {
lab=VSS}
N 2160 -5080 2160 -5070 {
lab=VDD}
N 2500 -4850 2510 -4860 {
lab=row_n[5]}
N 2510 -5060 2510 -4860 {
lab=row_n[5]}
N 2500 -5070 2510 -5060 {
lab=row_n[5]}
N 2500 -4850 2500 -4830 {
lab=row_n[5]}
N 2500 -5090 2500 -5070 {
lab=row_n[5]}
N 2380 -4990 2390 -5000 {
lab=col_n[15]}
N 2390 -5000 2590 -5000 {
lab=col_n[15]}
N 2590 -5000 2600 -4990 {
lab=col_n[15]}
N 2380 -4970 2390 -4980 {
lab=colon_n[15]}
N 2390 -4980 2590 -4980 {
lab=colon_n[15]}
N 2590 -4980 2600 -4970 {
lab=colon_n[15]}
N 2380 -4950 2390 -4960 {
lab=#net31}
N 2390 -4960 2590 -4960 {
lab=#net31}
N 2590 -4960 2600 -4950 {
lab=#net31}
N 2380 -4930 2390 -4940 {
lab=#net32}
N 2390 -4940 2590 -4940 {
lab=#net32}
N 2590 -4940 2600 -4930 {
lab=#net32}
N 2440 -5090 2440 -5070 {
lab=vcom}
N 2480 -5090 2480 -5070 {
lab=ctop}
N 2360 -4990 2380 -4990 {
lab=col_n[15]}
N 2360 -4970 2380 -4970 {
lab=colon_n[15]}
N 2360 -4950 2380 -4950 {
lab=#net31}
N 2360 -4930 2380 -4930 {
lab=#net32}
N 2600 -4930 2620 -4930 {
lab=#net32}
N 2600 -4950 2620 -4950 {
lab=#net31}
N 2600 -4970 2620 -4970 {
lab=colon_n[15]}
N 2600 -4990 2620 -4990 {
lab=col_n[15]}
N 2420 -4850 2420 -4840 {
lab=VSS}
N 2420 -5080 2420 -5070 {
lab=VDD}
N 2760 -4850 2770 -4860 {
lab=row_n[6]}
N 2770 -5060 2770 -4860 {
lab=row_n[6]}
N 2760 -5070 2770 -5060 {
lab=row_n[6]}
N 2760 -4850 2760 -4830 {
lab=row_n[6]}
N 2760 -5090 2760 -5070 {
lab=row_n[6]}
N 2640 -4990 2650 -5000 {
lab=col_n[15]}
N 2650 -5000 2850 -5000 {
lab=col_n[15]}
N 2850 -5000 2860 -4990 {
lab=col_n[15]}
N 2640 -4970 2650 -4980 {
lab=colon_n[15]}
N 2650 -4980 2850 -4980 {
lab=colon_n[15]}
N 2850 -4980 2860 -4970 {
lab=colon_n[15]}
N 2640 -4950 2650 -4960 {
lab=#net31}
N 2650 -4960 2850 -4960 {
lab=#net31}
N 2850 -4960 2860 -4950 {
lab=#net31}
N 2640 -4930 2650 -4940 {
lab=#net32}
N 2650 -4940 2850 -4940 {
lab=#net32}
N 2850 -4940 2860 -4930 {
lab=#net32}
N 2700 -5090 2700 -5070 {
lab=vcom}
N 2740 -5090 2740 -5070 {
lab=ctop}
N 2620 -4990 2640 -4990 {
lab=col_n[15]}
N 2620 -4970 2640 -4970 {
lab=colon_n[15]}
N 2620 -4950 2640 -4950 {
lab=#net31}
N 2620 -4930 2640 -4930 {
lab=#net32}
N 2860 -4930 2880 -4930 {
lab=#net32}
N 2860 -4950 2880 -4950 {
lab=#net31}
N 2860 -4970 2880 -4970 {
lab=colon_n[15]}
N 2860 -4990 2880 -4990 {
lab=col_n[15]}
N 2680 -4850 2680 -4840 {
lab=VSS}
N 2680 -5080 2680 -5070 {
lab=VDD}
N 3020 -4850 3030 -4860 {
lab=row_n[7]}
N 3030 -5060 3030 -4860 {
lab=row_n[7]}
N 3020 -5070 3030 -5060 {
lab=row_n[7]}
N 3020 -4850 3020 -4830 {
lab=row_n[7]}
N 3020 -5090 3020 -5070 {
lab=row_n[7]}
N 2900 -4990 2910 -5000 {
lab=col_n[15]}
N 2910 -5000 3110 -5000 {
lab=col_n[15]}
N 3110 -5000 3120 -4990 {
lab=col_n[15]}
N 2900 -4970 2910 -4980 {
lab=colon_n[15]}
N 2910 -4980 3110 -4980 {
lab=colon_n[15]}
N 3110 -4980 3120 -4970 {
lab=colon_n[15]}
N 2900 -4950 2910 -4960 {
lab=#net31}
N 2910 -4960 3110 -4960 {
lab=#net31}
N 3110 -4960 3120 -4950 {
lab=#net31}
N 2900 -4930 2910 -4940 {
lab=#net32}
N 2910 -4940 3110 -4940 {
lab=#net32}
N 3110 -4940 3120 -4930 {
lab=#net32}
N 2960 -5090 2960 -5070 {
lab=vcom}
N 3000 -5090 3000 -5070 {
lab=ctop}
N 2880 -4990 2900 -4990 {
lab=col_n[15]}
N 2880 -4970 2900 -4970 {
lab=colon_n[15]}
N 2880 -4950 2900 -4950 {
lab=#net31}
N 2880 -4930 2900 -4930 {
lab=#net32}
N 3120 -4930 3140 -4930 {
lab=#net32}
N 3120 -4950 3140 -4950 {
lab=#net31}
N 3120 -4970 3140 -4970 {
lab=colon_n[15]}
N 3120 -4990 3140 -4990 {
lab=col_n[15]}
N 2940 -4850 2940 -4840 {
lab=VSS}
N 2940 -5080 2940 -5070 {
lab=VDD}
N 3280 -4850 3290 -4860 {
lab=row_n[8]}
N 3290 -5060 3290 -4860 {
lab=row_n[8]}
N 3280 -5070 3290 -5060 {
lab=row_n[8]}
N 3280 -4850 3280 -4830 {
lab=row_n[8]}
N 3280 -5090 3280 -5070 {
lab=row_n[8]}
N 3160 -4990 3170 -5000 {
lab=col_n[15]}
N 3170 -5000 3370 -5000 {
lab=col_n[15]}
N 3370 -5000 3380 -4990 {
lab=col_n[15]}
N 3160 -4970 3170 -4980 {
lab=colon_n[15]}
N 3170 -4980 3370 -4980 {
lab=colon_n[15]}
N 3370 -4980 3380 -4970 {
lab=colon_n[15]}
N 3160 -4950 3170 -4960 {
lab=#net31}
N 3170 -4960 3370 -4960 {
lab=#net31}
N 3370 -4960 3380 -4950 {
lab=#net31}
N 3160 -4930 3170 -4940 {
lab=#net32}
N 3170 -4940 3370 -4940 {
lab=#net32}
N 3370 -4940 3380 -4930 {
lab=#net32}
N 3220 -5090 3220 -5070 {
lab=vcom}
N 3260 -5090 3260 -5070 {
lab=ctop}
N 3140 -4990 3160 -4990 {
lab=col_n[15]}
N 3140 -4970 3160 -4970 {
lab=colon_n[15]}
N 3140 -4950 3160 -4950 {
lab=#net31}
N 3140 -4930 3160 -4930 {
lab=#net32}
N 3380 -4930 3400 -4930 {
lab=#net32}
N 3380 -4950 3400 -4950 {
lab=#net31}
N 3380 -4970 3400 -4970 {
lab=colon_n[15]}
N 3380 -4990 3400 -4990 {
lab=col_n[15]}
N 3200 -4850 3200 -4840 {
lab=VSS}
N 3200 -5080 3200 -5070 {
lab=VDD}
N 3540 -4850 3550 -4860 {
lab=row_n[9]}
N 3550 -5060 3550 -4860 {
lab=row_n[9]}
N 3540 -5070 3550 -5060 {
lab=row_n[9]}
N 3540 -4850 3540 -4830 {
lab=row_n[9]}
N 3540 -5090 3540 -5070 {
lab=row_n[9]}
N 3420 -4990 3430 -5000 {
lab=col_n[15]}
N 3430 -5000 3630 -5000 {
lab=col_n[15]}
N 3630 -5000 3640 -4990 {
lab=col_n[15]}
N 3420 -4970 3430 -4980 {
lab=colon_n[15]}
N 3430 -4980 3630 -4980 {
lab=colon_n[15]}
N 3630 -4980 3640 -4970 {
lab=colon_n[15]}
N 3420 -4950 3430 -4960 {
lab=#net31}
N 3430 -4960 3630 -4960 {
lab=#net31}
N 3630 -4960 3640 -4950 {
lab=#net31}
N 3420 -4930 3430 -4940 {
lab=#net32}
N 3430 -4940 3630 -4940 {
lab=#net32}
N 3630 -4940 3640 -4930 {
lab=#net32}
N 3480 -5090 3480 -5070 {
lab=vcom}
N 3520 -5090 3520 -5070 {
lab=ctop}
N 3400 -4990 3420 -4990 {
lab=col_n[15]}
N 3400 -4970 3420 -4970 {
lab=colon_n[15]}
N 3400 -4950 3420 -4950 {
lab=#net31}
N 3400 -4930 3420 -4930 {
lab=#net32}
N 3640 -4930 3660 -4930 {
lab=#net32}
N 3640 -4950 3660 -4950 {
lab=#net31}
N 3640 -4970 3660 -4970 {
lab=colon_n[15]}
N 3640 -4990 3660 -4990 {
lab=col_n[15]}
N 3460 -4850 3460 -4840 {
lab=VSS}
N 3460 -5080 3460 -5070 {
lab=VDD}
N 3800 -4850 3810 -4860 {
lab=row_n[10]}
N 3810 -5060 3810 -4860 {
lab=row_n[10]}
N 3800 -5070 3810 -5060 {
lab=row_n[10]}
N 3800 -4850 3800 -4830 {
lab=row_n[10]}
N 3800 -5090 3800 -5070 {
lab=row_n[10]}
N 3680 -4990 3690 -5000 {
lab=col_n[15]}
N 3690 -5000 3890 -5000 {
lab=col_n[15]}
N 3890 -5000 3900 -4990 {
lab=col_n[15]}
N 3680 -4970 3690 -4980 {
lab=colon_n[15]}
N 3690 -4980 3890 -4980 {
lab=colon_n[15]}
N 3890 -4980 3900 -4970 {
lab=colon_n[15]}
N 3680 -4950 3690 -4960 {
lab=#net31}
N 3690 -4960 3890 -4960 {
lab=#net31}
N 3890 -4960 3900 -4950 {
lab=#net31}
N 3680 -4930 3690 -4940 {
lab=#net32}
N 3690 -4940 3890 -4940 {
lab=#net32}
N 3890 -4940 3900 -4930 {
lab=#net32}
N 3740 -5090 3740 -5070 {
lab=vcom}
N 3780 -5090 3780 -5070 {
lab=ctop}
N 3660 -4990 3680 -4990 {
lab=col_n[15]}
N 3660 -4970 3680 -4970 {
lab=colon_n[15]}
N 3660 -4950 3680 -4950 {
lab=#net31}
N 3660 -4930 3680 -4930 {
lab=#net32}
N 3900 -4930 3920 -4930 {
lab=#net32}
N 3900 -4950 3920 -4950 {
lab=#net31}
N 3900 -4970 3920 -4970 {
lab=colon_n[15]}
N 3900 -4990 3920 -4990 {
lab=col_n[15]}
N 3720 -4850 3720 -4840 {
lab=VSS}
N 3720 -5080 3720 -5070 {
lab=VDD}
N 4060 -4850 4070 -4860 {
lab=row_n[11]}
N 4070 -5060 4070 -4860 {
lab=row_n[11]}
N 4060 -5070 4070 -5060 {
lab=row_n[11]}
N 4060 -4850 4060 -4830 {
lab=row_n[11]}
N 4060 -5090 4060 -5070 {
lab=row_n[11]}
N 3940 -4990 3950 -5000 {
lab=col_n[15]}
N 3950 -5000 4150 -5000 {
lab=col_n[15]}
N 4150 -5000 4160 -4990 {
lab=col_n[15]}
N 3940 -4970 3950 -4980 {
lab=colon_n[15]}
N 3950 -4980 4150 -4980 {
lab=colon_n[15]}
N 4150 -4980 4160 -4970 {
lab=colon_n[15]}
N 3940 -4950 3950 -4960 {
lab=#net31}
N 3950 -4960 4150 -4960 {
lab=#net31}
N 4150 -4960 4160 -4950 {
lab=#net31}
N 3940 -4930 3950 -4940 {
lab=#net32}
N 3950 -4940 4150 -4940 {
lab=#net32}
N 4150 -4940 4160 -4930 {
lab=#net32}
N 4000 -5090 4000 -5070 {
lab=vcom}
N 4040 -5090 4040 -5070 {
lab=ctop}
N 3920 -4990 3940 -4990 {
lab=col_n[15]}
N 3920 -4970 3940 -4970 {
lab=colon_n[15]}
N 3920 -4950 3940 -4950 {
lab=#net31}
N 3920 -4930 3940 -4930 {
lab=#net32}
N 4160 -4930 4180 -4930 {
lab=#net32}
N 4160 -4950 4180 -4950 {
lab=#net31}
N 4160 -4970 4180 -4970 {
lab=colon_n[15]}
N 4160 -4990 4180 -4990 {
lab=col_n[15]}
N 3980 -4850 3980 -4840 {
lab=VSS}
N 3980 -5080 3980 -5070 {
lab=VDD}
N 4320 -4850 4330 -4860 {
lab=row_n[12]}
N 4330 -5060 4330 -4860 {
lab=row_n[12]}
N 4320 -5070 4330 -5060 {
lab=row_n[12]}
N 4320 -4850 4320 -4830 {
lab=row_n[12]}
N 4320 -5090 4320 -5070 {
lab=row_n[12]}
N 4200 -4990 4210 -5000 {
lab=col_n[15]}
N 4210 -5000 4410 -5000 {
lab=col_n[15]}
N 4410 -5000 4420 -4990 {
lab=col_n[15]}
N 4200 -4970 4210 -4980 {
lab=colon_n[15]}
N 4210 -4980 4410 -4980 {
lab=colon_n[15]}
N 4410 -4980 4420 -4970 {
lab=colon_n[15]}
N 4200 -4950 4210 -4960 {
lab=#net31}
N 4210 -4960 4410 -4960 {
lab=#net31}
N 4410 -4960 4420 -4950 {
lab=#net31}
N 4200 -4930 4210 -4940 {
lab=#net32}
N 4210 -4940 4410 -4940 {
lab=#net32}
N 4410 -4940 4420 -4930 {
lab=#net32}
N 4260 -5090 4260 -5070 {
lab=vcom}
N 4300 -5090 4300 -5070 {
lab=ctop}
N 4180 -4990 4200 -4990 {
lab=col_n[15]}
N 4180 -4970 4200 -4970 {
lab=colon_n[15]}
N 4180 -4950 4200 -4950 {
lab=#net31}
N 4180 -4930 4200 -4930 {
lab=#net32}
N 4420 -4930 4440 -4930 {
lab=#net32}
N 4420 -4950 4440 -4950 {
lab=#net31}
N 4420 -4970 4440 -4970 {
lab=colon_n[15]}
N 4420 -4990 4440 -4990 {
lab=col_n[15]}
N 4240 -4850 4240 -4840 {
lab=VSS}
N 4240 -5080 4240 -5070 {
lab=VDD}
N 4580 -4850 4590 -4860 {
lab=row_n[13]}
N 4590 -5060 4590 -4860 {
lab=row_n[13]}
N 4580 -5070 4590 -5060 {
lab=row_n[13]}
N 4580 -4850 4580 -4830 {
lab=row_n[13]}
N 4580 -5090 4580 -5070 {
lab=row_n[13]}
N 4460 -4990 4470 -5000 {
lab=col_n[15]}
N 4470 -5000 4670 -5000 {
lab=col_n[15]}
N 4670 -5000 4680 -4990 {
lab=col_n[15]}
N 4460 -4970 4470 -4980 {
lab=colon_n[15]}
N 4470 -4980 4670 -4980 {
lab=colon_n[15]}
N 4670 -4980 4680 -4970 {
lab=colon_n[15]}
N 4460 -4950 4470 -4960 {
lab=#net31}
N 4470 -4960 4670 -4960 {
lab=#net31}
N 4670 -4960 4680 -4950 {
lab=#net31}
N 4460 -4930 4470 -4940 {
lab=#net32}
N 4470 -4940 4670 -4940 {
lab=#net32}
N 4670 -4940 4680 -4930 {
lab=#net32}
N 4520 -5090 4520 -5070 {
lab=vcom}
N 4560 -5090 4560 -5070 {
lab=ctop}
N 4440 -4990 4460 -4990 {
lab=col_n[15]}
N 4440 -4970 4460 -4970 {
lab=colon_n[15]}
N 4440 -4950 4460 -4950 {
lab=#net31}
N 4440 -4930 4460 -4930 {
lab=#net32}
N 4680 -4930 4700 -4930 {
lab=#net32}
N 4680 -4950 4700 -4950 {
lab=#net31}
N 4680 -4970 4700 -4970 {
lab=colon_n[15]}
N 4680 -4990 4700 -4990 {
lab=col_n[15]}
N 4500 -4850 4500 -4840 {
lab=VSS}
N 4500 -5080 4500 -5070 {
lab=VDD}
N 4840 -4850 4850 -4860 {
lab=row_n[14]}
N 4850 -5060 4850 -4860 {
lab=row_n[14]}
N 4840 -5070 4850 -5060 {
lab=row_n[14]}
N 4840 -4850 4840 -4830 {
lab=row_n[14]}
N 4840 -5090 4840 -5070 {
lab=row_n[14]}
N 4720 -4990 4730 -5000 {
lab=col_n[15]}
N 4730 -5000 4930 -5000 {
lab=col_n[15]}
N 4930 -5000 4940 -4990 {
lab=col_n[15]}
N 4720 -4970 4730 -4980 {
lab=colon_n[15]}
N 4730 -4980 4930 -4980 {
lab=colon_n[15]}
N 4930 -4980 4940 -4970 {
lab=colon_n[15]}
N 4720 -4950 4730 -4960 {
lab=#net31}
N 4730 -4960 4930 -4960 {
lab=#net31}
N 4930 -4960 4940 -4950 {
lab=#net31}
N 4720 -4930 4730 -4940 {
lab=#net32}
N 4730 -4940 4930 -4940 {
lab=#net32}
N 4930 -4940 4940 -4930 {
lab=#net32}
N 4780 -5090 4780 -5070 {
lab=vcom}
N 4820 -5090 4820 -5070 {
lab=ctop}
N 4700 -4990 4720 -4990 {
lab=col_n[15]}
N 4700 -4970 4720 -4970 {
lab=colon_n[15]}
N 4700 -4950 4720 -4950 {
lab=#net31}
N 4700 -4930 4720 -4930 {
lab=#net32}
N 4940 -4930 4960 -4930 {
lab=#net32}
N 4940 -4950 4960 -4950 {
lab=#net31}
N 4940 -4970 4960 -4970 {
lab=colon_n[15]}
N 4940 -4990 4960 -4990 {
lab=col_n[15]}
N 4760 -4850 4760 -4840 {
lab=VSS}
N 4760 -5080 4760 -5070 {
lab=VDD}
N 5100 -4850 5110 -4860 {
lab=row_n[15]}
N 5110 -5060 5110 -4860 {
lab=row_n[15]}
N 5100 -5070 5110 -5060 {
lab=row_n[15]}
N 5100 -4850 5100 -4830 {
lab=row_n[15]}
N 5100 -5090 5100 -5070 {
lab=row_n[15]}
N 4980 -4990 4990 -5000 {
lab=col_n[15]}
N 4990 -5000 5190 -5000 {
lab=col_n[15]}
N 5190 -5000 5200 -4990 {
lab=col_n[15]}
N 4980 -4970 4990 -4980 {
lab=colon_n[15]}
N 4990 -4980 5190 -4980 {
lab=colon_n[15]}
N 5190 -4980 5200 -4970 {
lab=colon_n[15]}
N 4980 -4950 4990 -4960 {
lab=#net31}
N 4990 -4960 5190 -4960 {
lab=#net31}
N 5190 -4960 5200 -4950 {
lab=#net31}
N 4980 -4930 4990 -4940 {
lab=#net32}
N 4990 -4940 5190 -4940 {
lab=#net32}
N 5190 -4940 5200 -4930 {
lab=#net32}
N 5040 -5090 5040 -5070 {
lab=vcom}
N 5080 -5090 5080 -5070 {
lab=ctop}
N 4960 -4990 4980 -4990 {
lab=col_n[15]}
N 4960 -4970 4980 -4970 {
lab=colon_n[15]}
N 4960 -4950 4980 -4950 {
lab=#net31}
N 4960 -4930 4980 -4930 {
lab=#net32}
N 5200 -4930 5220 -4930 {
lab=#net32}
N 5200 -4950 5220 -4950 {
lab=#net31}
N 5200 -4970 5220 -4970 {
lab=colon_n[15]}
N 5200 -4990 5220 -4990 {
lab=col_n[15]}
N 5020 -4850 5020 -4840 {
lab=VSS}
N 5020 -5080 5020 -5070 {
lab=VDD}
N 5360 -4850 5370 -4860 {
lab=row_n[16]}
N 5370 -5060 5370 -4860 {
lab=row_n[16]}
N 5360 -5070 5370 -5060 {
lab=row_n[16]}
N 5360 -4850 5360 -4830 {
lab=row_n[16]}
N 5360 -5090 5360 -5070 {
lab=row_n[16]}
N 5240 -4990 5250 -5000 {
lab=col_n[15]}
N 5250 -5000 5450 -5000 {
lab=col_n[15]}
N 5450 -5000 5460 -4990 {
lab=col_n[15]}
N 5240 -4970 5250 -4980 {
lab=colon_n[15]}
N 5250 -4980 5450 -4980 {
lab=colon_n[15]}
N 5450 -4980 5460 -4970 {
lab=colon_n[15]}
N 5240 -4950 5250 -4960 {
lab=#net31}
N 5250 -4960 5450 -4960 {
lab=#net31}
N 5450 -4960 5460 -4950 {
lab=#net31}
N 5240 -4930 5250 -4940 {
lab=#net32}
N 5250 -4940 5450 -4940 {
lab=#net32}
N 5450 -4940 5460 -4930 {
lab=#net32}
N 5300 -5090 5300 -5070 {
lab=vcom}
N 5340 -5090 5340 -5070 {
lab=ctop}
N 5220 -4990 5240 -4990 {
lab=col_n[15]}
N 5220 -4970 5240 -4970 {
lab=colon_n[15]}
N 5220 -4950 5240 -4950 {
lab=#net31}
N 5220 -4930 5240 -4930 {
lab=#net32}
N 5460 -4930 5480 -4930 {
lab=#net32}
N 5460 -4950 5480 -4950 {
lab=#net31}
N 5460 -4970 5480 -4970 {
lab=colon_n[15]}
N 5460 -4990 5480 -4990 {
lab=col_n[15]}
N 5280 -4850 5280 -4840 {
lab=VSS}
N 5280 -5080 5280 -5070 {
lab=VDD}
N 5620 -4850 5630 -4860 {
lab=row_n[17]}
N 5630 -5060 5630 -4860 {
lab=row_n[17]}
N 5620 -5070 5630 -5060 {
lab=row_n[17]}
N 5620 -4850 5620 -4830 {
lab=row_n[17]}
N 5620 -5090 5620 -5070 {
lab=row_n[17]}
N 5500 -4990 5510 -5000 {
lab=col_n[15]}
N 5510 -5000 5710 -5000 {
lab=col_n[15]}
N 5710 -5000 5720 -4990 {
lab=col_n[15]}
N 5500 -4970 5510 -4980 {
lab=colon_n[15]}
N 5510 -4980 5710 -4980 {
lab=colon_n[15]}
N 5710 -4980 5720 -4970 {
lab=colon_n[15]}
N 5500 -4950 5510 -4960 {
lab=#net31}
N 5510 -4960 5710 -4960 {
lab=#net31}
N 5710 -4960 5720 -4950 {
lab=#net31}
N 5500 -4930 5510 -4940 {
lab=#net32}
N 5510 -4940 5710 -4940 {
lab=#net32}
N 5710 -4940 5720 -4930 {
lab=#net32}
N 5560 -5090 5560 -5070 {
lab=vcom}
N 5600 -5090 5600 -5070 {
lab=ctop}
N 5480 -4990 5500 -4990 {
lab=col_n[15]}
N 5480 -4970 5500 -4970 {
lab=colon_n[15]}
N 5480 -4950 5500 -4950 {
lab=#net31}
N 5480 -4930 5500 -4930 {
lab=#net32}
N 5720 -4930 5740 -4930 {
lab=#net32}
N 5720 -4950 5740 -4950 {
lab=#net31}
N 5720 -4970 5740 -4970 {
lab=colon_n[15]}
N 5720 -4990 5740 -4990 {
lab=col_n[15]}
N 5540 -4850 5540 -4840 {
lab=VSS}
N 5540 -5080 5540 -5070 {
lab=VDD}
N 5880 -4850 5890 -4860 {
lab=row_n[18]}
N 5890 -5060 5890 -4860 {
lab=row_n[18]}
N 5880 -5070 5890 -5060 {
lab=row_n[18]}
N 5880 -4850 5880 -4830 {
lab=row_n[18]}
N 5880 -5090 5880 -5070 {
lab=row_n[18]}
N 5760 -4990 5770 -5000 {
lab=col_n[15]}
N 5770 -5000 5970 -5000 {
lab=col_n[15]}
N 5970 -5000 5980 -4990 {
lab=col_n[15]}
N 5760 -4970 5770 -4980 {
lab=colon_n[15]}
N 5770 -4980 5970 -4980 {
lab=colon_n[15]}
N 5970 -4980 5980 -4970 {
lab=colon_n[15]}
N 5760 -4950 5770 -4960 {
lab=#net31}
N 5770 -4960 5970 -4960 {
lab=#net31}
N 5970 -4960 5980 -4950 {
lab=#net31}
N 5760 -4930 5770 -4940 {
lab=#net32}
N 5770 -4940 5970 -4940 {
lab=#net32}
N 5970 -4940 5980 -4930 {
lab=#net32}
N 5820 -5090 5820 -5070 {
lab=vcom}
N 5860 -5090 5860 -5070 {
lab=ctop}
N 5740 -4990 5760 -4990 {
lab=col_n[15]}
N 5740 -4970 5760 -4970 {
lab=colon_n[15]}
N 5740 -4950 5760 -4950 {
lab=#net31}
N 5740 -4930 5760 -4930 {
lab=#net32}
N 5980 -4930 6000 -4930 {
lab=#net32}
N 5980 -4950 6000 -4950 {
lab=#net31}
N 5980 -4970 6000 -4970 {
lab=colon_n[15]}
N 5980 -4990 6000 -4990 {
lab=col_n[15]}
N 5800 -4850 5800 -4840 {
lab=VSS}
N 5800 -5080 5800 -5070 {
lab=VDD}
N 6140 -4850 6150 -4860 {
lab=row_n[19]}
N 6150 -5060 6150 -4860 {
lab=row_n[19]}
N 6140 -5070 6150 -5060 {
lab=row_n[19]}
N 6140 -4850 6140 -4830 {
lab=row_n[19]}
N 6140 -5090 6140 -5070 {
lab=row_n[19]}
N 6020 -4990 6030 -5000 {
lab=col_n[15]}
N 6030 -5000 6230 -5000 {
lab=col_n[15]}
N 6230 -5000 6240 -4990 {
lab=col_n[15]}
N 6020 -4970 6030 -4980 {
lab=colon_n[15]}
N 6030 -4980 6230 -4980 {
lab=colon_n[15]}
N 6230 -4980 6240 -4970 {
lab=colon_n[15]}
N 6020 -4950 6030 -4960 {
lab=#net31}
N 6030 -4960 6230 -4960 {
lab=#net31}
N 6230 -4960 6240 -4950 {
lab=#net31}
N 6020 -4930 6030 -4940 {
lab=#net32}
N 6030 -4940 6230 -4940 {
lab=#net32}
N 6230 -4940 6240 -4930 {
lab=#net32}
N 6080 -5090 6080 -5070 {
lab=vcom}
N 6120 -5090 6120 -5070 {
lab=ctop}
N 6000 -4990 6020 -4990 {
lab=col_n[15]}
N 6000 -4970 6020 -4970 {
lab=colon_n[15]}
N 6000 -4950 6020 -4950 {
lab=#net31}
N 6000 -4930 6020 -4930 {
lab=#net32}
N 6240 -4930 6260 -4930 {
lab=#net32}
N 6240 -4950 6260 -4950 {
lab=#net31}
N 6240 -4970 6260 -4970 {
lab=colon_n[15]}
N 6240 -4990 6260 -4990 {
lab=col_n[15]}
N 6060 -4850 6060 -4840 {
lab=VSS}
N 6060 -5080 6060 -5070 {
lab=VDD}
N 6400 -4850 6410 -4860 {
lab=row_n[20]}
N 6410 -5060 6410 -4860 {
lab=row_n[20]}
N 6400 -5070 6410 -5060 {
lab=row_n[20]}
N 6400 -4850 6400 -4830 {
lab=row_n[20]}
N 6400 -5090 6400 -5070 {
lab=row_n[20]}
N 6280 -4990 6290 -5000 {
lab=col_n[15]}
N 6290 -5000 6490 -5000 {
lab=col_n[15]}
N 6490 -5000 6500 -4990 {
lab=col_n[15]}
N 6280 -4970 6290 -4980 {
lab=colon_n[15]}
N 6290 -4980 6490 -4980 {
lab=colon_n[15]}
N 6490 -4980 6500 -4970 {
lab=colon_n[15]}
N 6280 -4950 6290 -4960 {
lab=#net31}
N 6290 -4960 6490 -4960 {
lab=#net31}
N 6490 -4960 6500 -4950 {
lab=#net31}
N 6280 -4930 6290 -4940 {
lab=#net32}
N 6290 -4940 6490 -4940 {
lab=#net32}
N 6490 -4940 6500 -4930 {
lab=#net32}
N 6340 -5090 6340 -5070 {
lab=vcom}
N 6380 -5090 6380 -5070 {
lab=ctop}
N 6260 -4990 6280 -4990 {
lab=col_n[15]}
N 6260 -4970 6280 -4970 {
lab=colon_n[15]}
N 6260 -4950 6280 -4950 {
lab=#net31}
N 6260 -4930 6280 -4930 {
lab=#net32}
N 6500 -4930 6520 -4930 {
lab=#net32}
N 6500 -4950 6520 -4950 {
lab=#net31}
N 6500 -4970 6520 -4970 {
lab=colon_n[15]}
N 6500 -4990 6520 -4990 {
lab=col_n[15]}
N 6320 -4850 6320 -4840 {
lab=VSS}
N 6320 -5080 6320 -5070 {
lab=VDD}
N 6660 -4850 6670 -4860 {
lab=row_n[21]}
N 6670 -5060 6670 -4860 {
lab=row_n[21]}
N 6660 -5070 6670 -5060 {
lab=row_n[21]}
N 6660 -4850 6660 -4830 {
lab=row_n[21]}
N 6660 -5090 6660 -5070 {
lab=row_n[21]}
N 6540 -4990 6550 -5000 {
lab=col_n[15]}
N 6550 -5000 6750 -5000 {
lab=col_n[15]}
N 6750 -5000 6760 -4990 {
lab=col_n[15]}
N 6540 -4970 6550 -4980 {
lab=colon_n[15]}
N 6550 -4980 6750 -4980 {
lab=colon_n[15]}
N 6750 -4980 6760 -4970 {
lab=colon_n[15]}
N 6540 -4950 6550 -4960 {
lab=#net31}
N 6550 -4960 6750 -4960 {
lab=#net31}
N 6750 -4960 6760 -4950 {
lab=#net31}
N 6540 -4930 6550 -4940 {
lab=#net32}
N 6550 -4940 6750 -4940 {
lab=#net32}
N 6750 -4940 6760 -4930 {
lab=#net32}
N 6600 -5090 6600 -5070 {
lab=vcom}
N 6640 -5090 6640 -5070 {
lab=ctop}
N 6520 -4990 6540 -4990 {
lab=col_n[15]}
N 6520 -4970 6540 -4970 {
lab=colon_n[15]}
N 6520 -4950 6540 -4950 {
lab=#net31}
N 6520 -4930 6540 -4930 {
lab=#net32}
N 6760 -4930 6780 -4930 {
lab=#net32}
N 6760 -4950 6780 -4950 {
lab=#net31}
N 6760 -4970 6780 -4970 {
lab=colon_n[15]}
N 6760 -4990 6780 -4990 {
lab=col_n[15]}
N 6580 -4850 6580 -4840 {
lab=VSS}
N 6580 -5080 6580 -5070 {
lab=VDD}
N 6920 -4850 6930 -4860 {
lab=row_n[22]}
N 6930 -5060 6930 -4860 {
lab=row_n[22]}
N 6920 -5070 6930 -5060 {
lab=row_n[22]}
N 6920 -4850 6920 -4830 {
lab=row_n[22]}
N 6920 -5090 6920 -5070 {
lab=row_n[22]}
N 6800 -4990 6810 -5000 {
lab=col_n[15]}
N 6810 -5000 7010 -5000 {
lab=col_n[15]}
N 7010 -5000 7020 -4990 {
lab=col_n[15]}
N 6800 -4970 6810 -4980 {
lab=colon_n[15]}
N 6810 -4980 7010 -4980 {
lab=colon_n[15]}
N 7010 -4980 7020 -4970 {
lab=colon_n[15]}
N 6800 -4950 6810 -4960 {
lab=#net31}
N 6810 -4960 7010 -4960 {
lab=#net31}
N 7010 -4960 7020 -4950 {
lab=#net31}
N 6800 -4930 6810 -4940 {
lab=#net32}
N 6810 -4940 7010 -4940 {
lab=#net32}
N 7010 -4940 7020 -4930 {
lab=#net32}
N 6860 -5090 6860 -5070 {
lab=vcom}
N 6900 -5090 6900 -5070 {
lab=ctop}
N 6780 -4990 6800 -4990 {
lab=col_n[15]}
N 6780 -4970 6800 -4970 {
lab=colon_n[15]}
N 6780 -4950 6800 -4950 {
lab=#net31}
N 6780 -4930 6800 -4930 {
lab=#net32}
N 7020 -4930 7040 -4930 {
lab=#net32}
N 7020 -4950 7040 -4950 {
lab=#net31}
N 7020 -4970 7040 -4970 {
lab=colon_n[15]}
N 7020 -4990 7040 -4990 {
lab=col_n[15]}
N 6840 -4850 6840 -4840 {
lab=VSS}
N 6840 -5080 6840 -5070 {
lab=VDD}
N 7180 -4850 7190 -4860 {
lab=row_n[23]}
N 7190 -5060 7190 -4860 {
lab=row_n[23]}
N 7180 -5070 7190 -5060 {
lab=row_n[23]}
N 7180 -4850 7180 -4830 {
lab=row_n[23]}
N 7180 -5090 7180 -5070 {
lab=row_n[23]}
N 7060 -4990 7070 -5000 {
lab=col_n[15]}
N 7070 -5000 7270 -5000 {
lab=col_n[15]}
N 7270 -5000 7280 -4990 {
lab=col_n[15]}
N 7060 -4970 7070 -4980 {
lab=colon_n[15]}
N 7070 -4980 7270 -4980 {
lab=colon_n[15]}
N 7270 -4980 7280 -4970 {
lab=colon_n[15]}
N 7060 -4950 7070 -4960 {
lab=#net31}
N 7070 -4960 7270 -4960 {
lab=#net31}
N 7270 -4960 7280 -4950 {
lab=#net31}
N 7060 -4930 7070 -4940 {
lab=#net32}
N 7070 -4940 7270 -4940 {
lab=#net32}
N 7270 -4940 7280 -4930 {
lab=#net32}
N 7120 -5090 7120 -5070 {
lab=vcom}
N 7160 -5090 7160 -5070 {
lab=ctop}
N 7040 -4990 7060 -4990 {
lab=col_n[15]}
N 7040 -4970 7060 -4970 {
lab=colon_n[15]}
N 7040 -4950 7060 -4950 {
lab=#net31}
N 7040 -4930 7060 -4930 {
lab=#net32}
N 7280 -4930 7300 -4930 {
lab=#net32}
N 7280 -4950 7300 -4950 {
lab=#net31}
N 7280 -4970 7300 -4970 {
lab=colon_n[15]}
N 7280 -4990 7300 -4990 {
lab=col_n[15]}
N 7100 -4850 7100 -4840 {
lab=VSS}
N 7100 -5080 7100 -5070 {
lab=VDD}
N 7440 -4850 7450 -4860 {
lab=row_n[24]}
N 7450 -5060 7450 -4860 {
lab=row_n[24]}
N 7440 -5070 7450 -5060 {
lab=row_n[24]}
N 7440 -4850 7440 -4830 {
lab=row_n[24]}
N 7440 -5090 7440 -5070 {
lab=row_n[24]}
N 7320 -4990 7330 -5000 {
lab=col_n[15]}
N 7330 -5000 7530 -5000 {
lab=col_n[15]}
N 7530 -5000 7540 -4990 {
lab=col_n[15]}
N 7320 -4970 7330 -4980 {
lab=colon_n[15]}
N 7330 -4980 7530 -4980 {
lab=colon_n[15]}
N 7530 -4980 7540 -4970 {
lab=colon_n[15]}
N 7320 -4950 7330 -4960 {
lab=#net31}
N 7330 -4960 7530 -4960 {
lab=#net31}
N 7530 -4960 7540 -4950 {
lab=#net31}
N 7320 -4930 7330 -4940 {
lab=#net32}
N 7330 -4940 7530 -4940 {
lab=#net32}
N 7530 -4940 7540 -4930 {
lab=#net32}
N 7380 -5090 7380 -5070 {
lab=vcom}
N 7420 -5090 7420 -5070 {
lab=ctop}
N 7300 -4990 7320 -4990 {
lab=col_n[15]}
N 7300 -4970 7320 -4970 {
lab=colon_n[15]}
N 7300 -4950 7320 -4950 {
lab=#net31}
N 7300 -4930 7320 -4930 {
lab=#net32}
N 7540 -4930 7560 -4930 {
lab=#net32}
N 7540 -4950 7560 -4950 {
lab=#net31}
N 7540 -4970 7560 -4970 {
lab=colon_n[15]}
N 7540 -4990 7560 -4990 {
lab=col_n[15]}
N 7360 -4850 7360 -4840 {
lab=VSS}
N 7360 -5080 7360 -5070 {
lab=VDD}
N 7700 -4850 7710 -4860 {
lab=row_n[25]}
N 7710 -5060 7710 -4860 {
lab=row_n[25]}
N 7700 -5070 7710 -5060 {
lab=row_n[25]}
N 7700 -4850 7700 -4830 {
lab=row_n[25]}
N 7700 -5090 7700 -5070 {
lab=row_n[25]}
N 7580 -4990 7590 -5000 {
lab=col_n[15]}
N 7590 -5000 7790 -5000 {
lab=col_n[15]}
N 7790 -5000 7800 -4990 {
lab=col_n[15]}
N 7580 -4970 7590 -4980 {
lab=colon_n[15]}
N 7590 -4980 7790 -4980 {
lab=colon_n[15]}
N 7790 -4980 7800 -4970 {
lab=colon_n[15]}
N 7580 -4950 7590 -4960 {
lab=#net31}
N 7590 -4960 7790 -4960 {
lab=#net31}
N 7790 -4960 7800 -4950 {
lab=#net31}
N 7580 -4930 7590 -4940 {
lab=#net32}
N 7590 -4940 7790 -4940 {
lab=#net32}
N 7790 -4940 7800 -4930 {
lab=#net32}
N 7640 -5090 7640 -5070 {
lab=vcom}
N 7680 -5090 7680 -5070 {
lab=ctop}
N 7560 -4990 7580 -4990 {
lab=col_n[15]}
N 7560 -4970 7580 -4970 {
lab=colon_n[15]}
N 7560 -4950 7580 -4950 {
lab=#net31}
N 7560 -4930 7580 -4930 {
lab=#net32}
N 7800 -4930 7820 -4930 {
lab=#net32}
N 7800 -4950 7820 -4950 {
lab=#net31}
N 7800 -4970 7820 -4970 {
lab=colon_n[15]}
N 7800 -4990 7820 -4990 {
lab=col_n[15]}
N 7620 -4850 7620 -4840 {
lab=VSS}
N 7620 -5080 7620 -5070 {
lab=VDD}
N 7960 -4850 7970 -4860 {
lab=row_n[26]}
N 7970 -5060 7970 -4860 {
lab=row_n[26]}
N 7960 -5070 7970 -5060 {
lab=row_n[26]}
N 7960 -4850 7960 -4830 {
lab=row_n[26]}
N 7960 -5090 7960 -5070 {
lab=row_n[26]}
N 7840 -4990 7850 -5000 {
lab=col_n[15]}
N 7850 -5000 8050 -5000 {
lab=col_n[15]}
N 8050 -5000 8060 -4990 {
lab=col_n[15]}
N 7840 -4970 7850 -4980 {
lab=colon_n[15]}
N 7850 -4980 8050 -4980 {
lab=colon_n[15]}
N 8050 -4980 8060 -4970 {
lab=colon_n[15]}
N 7840 -4950 7850 -4960 {
lab=#net31}
N 7850 -4960 8050 -4960 {
lab=#net31}
N 8050 -4960 8060 -4950 {
lab=#net31}
N 7840 -4930 7850 -4940 {
lab=#net32}
N 7850 -4940 8050 -4940 {
lab=#net32}
N 8050 -4940 8060 -4930 {
lab=#net32}
N 7900 -5090 7900 -5070 {
lab=vcom}
N 7940 -5090 7940 -5070 {
lab=ctop}
N 7820 -4990 7840 -4990 {
lab=col_n[15]}
N 7820 -4970 7840 -4970 {
lab=colon_n[15]}
N 7820 -4950 7840 -4950 {
lab=#net31}
N 7820 -4930 7840 -4930 {
lab=#net32}
N 8060 -4930 8080 -4930 {
lab=#net32}
N 8060 -4950 8080 -4950 {
lab=#net31}
N 8060 -4970 8080 -4970 {
lab=colon_n[15]}
N 8060 -4990 8080 -4990 {
lab=col_n[15]}
N 7880 -4850 7880 -4840 {
lab=VSS}
N 7880 -5080 7880 -5070 {
lab=VDD}
N 8220 -4850 8230 -4860 {
lab=row_n[27]}
N 8230 -5060 8230 -4860 {
lab=row_n[27]}
N 8220 -5070 8230 -5060 {
lab=row_n[27]}
N 8220 -4850 8220 -4830 {
lab=row_n[27]}
N 8220 -5090 8220 -5070 {
lab=row_n[27]}
N 8100 -4990 8110 -5000 {
lab=col_n[15]}
N 8110 -5000 8310 -5000 {
lab=col_n[15]}
N 8310 -5000 8320 -4990 {
lab=col_n[15]}
N 8100 -4970 8110 -4980 {
lab=colon_n[15]}
N 8110 -4980 8310 -4980 {
lab=colon_n[15]}
N 8310 -4980 8320 -4970 {
lab=colon_n[15]}
N 8100 -4950 8110 -4960 {
lab=#net31}
N 8110 -4960 8310 -4960 {
lab=#net31}
N 8310 -4960 8320 -4950 {
lab=#net31}
N 8100 -4930 8110 -4940 {
lab=#net32}
N 8110 -4940 8310 -4940 {
lab=#net32}
N 8310 -4940 8320 -4930 {
lab=#net32}
N 8160 -5090 8160 -5070 {
lab=vcom}
N 8200 -5090 8200 -5070 {
lab=ctop}
N 8080 -4990 8100 -4990 {
lab=col_n[15]}
N 8080 -4970 8100 -4970 {
lab=colon_n[15]}
N 8080 -4950 8100 -4950 {
lab=#net31}
N 8080 -4930 8100 -4930 {
lab=#net32}
N 8320 -4930 8340 -4930 {
lab=#net32}
N 8320 -4950 8340 -4950 {
lab=#net31}
N 8320 -4970 8340 -4970 {
lab=colon_n[15]}
N 8320 -4990 8340 -4990 {
lab=col_n[15]}
N 8140 -4850 8140 -4840 {
lab=VSS}
N 8140 -5080 8140 -5070 {
lab=VDD}
N 8480 -4850 8490 -4860 {
lab=row_n[28]}
N 8490 -5060 8490 -4860 {
lab=row_n[28]}
N 8480 -5070 8490 -5060 {
lab=row_n[28]}
N 8480 -4850 8480 -4830 {
lab=row_n[28]}
N 8480 -5090 8480 -5070 {
lab=row_n[28]}
N 8360 -4990 8370 -5000 {
lab=col_n[15]}
N 8370 -5000 8570 -5000 {
lab=col_n[15]}
N 8570 -5000 8580 -4990 {
lab=col_n[15]}
N 8360 -4970 8370 -4980 {
lab=colon_n[15]}
N 8370 -4980 8570 -4980 {
lab=colon_n[15]}
N 8570 -4980 8580 -4970 {
lab=colon_n[15]}
N 8360 -4950 8370 -4960 {
lab=#net31}
N 8370 -4960 8570 -4960 {
lab=#net31}
N 8570 -4960 8580 -4950 {
lab=#net31}
N 8360 -4930 8370 -4940 {
lab=#net32}
N 8370 -4940 8570 -4940 {
lab=#net32}
N 8570 -4940 8580 -4930 {
lab=#net32}
N 8420 -5090 8420 -5070 {
lab=vcom}
N 8460 -5090 8460 -5070 {
lab=ctop}
N 8340 -4990 8360 -4990 {
lab=col_n[15]}
N 8340 -4970 8360 -4970 {
lab=colon_n[15]}
N 8340 -4950 8360 -4950 {
lab=#net31}
N 8340 -4930 8360 -4930 {
lab=#net32}
N 8580 -4930 8600 -4930 {
lab=#net32}
N 8580 -4950 8600 -4950 {
lab=#net31}
N 8580 -4970 8600 -4970 {
lab=colon_n[15]}
N 8580 -4990 8600 -4990 {
lab=col_n[15]}
N 8400 -4850 8400 -4840 {
lab=VSS}
N 8400 -5080 8400 -5070 {
lab=VDD}
N 8740 -4850 8750 -4860 {
lab=row_n[29]}
N 8750 -5060 8750 -4860 {
lab=row_n[29]}
N 8740 -5070 8750 -5060 {
lab=row_n[29]}
N 8740 -4850 8740 -4830 {
lab=row_n[29]}
N 8740 -5090 8740 -5070 {
lab=row_n[29]}
N 8620 -4990 8630 -5000 {
lab=col_n[15]}
N 8630 -5000 8830 -5000 {
lab=col_n[15]}
N 8830 -5000 8840 -4990 {
lab=col_n[15]}
N 8620 -4970 8630 -4980 {
lab=colon_n[15]}
N 8630 -4980 8830 -4980 {
lab=colon_n[15]}
N 8830 -4980 8840 -4970 {
lab=colon_n[15]}
N 8620 -4950 8630 -4960 {
lab=#net31}
N 8630 -4960 8830 -4960 {
lab=#net31}
N 8830 -4960 8840 -4950 {
lab=#net31}
N 8620 -4930 8630 -4940 {
lab=#net32}
N 8630 -4940 8830 -4940 {
lab=#net32}
N 8830 -4940 8840 -4930 {
lab=#net32}
N 8680 -5090 8680 -5070 {
lab=vcom}
N 8720 -5090 8720 -5070 {
lab=ctop}
N 8600 -4990 8620 -4990 {
lab=col_n[15]}
N 8600 -4970 8620 -4970 {
lab=colon_n[15]}
N 8600 -4950 8620 -4950 {
lab=#net31}
N 8600 -4930 8620 -4930 {
lab=#net32}
N 8840 -4930 8860 -4930 {
lab=#net32}
N 8840 -4950 8860 -4950 {
lab=#net31}
N 8840 -4970 8860 -4970 {
lab=colon_n[15]}
N 8840 -4990 8860 -4990 {
lab=col_n[15]}
N 8660 -4850 8660 -4840 {
lab=VSS}
N 8660 -5080 8660 -5070 {
lab=VDD}
N 9000 -4850 9010 -4860 {
lab=row_n[30]}
N 9010 -5060 9010 -4860 {
lab=row_n[30]}
N 9000 -5070 9010 -5060 {
lab=row_n[30]}
N 9000 -4850 9000 -4830 {
lab=row_n[30]}
N 9000 -5090 9000 -5070 {
lab=row_n[30]}
N 8880 -4990 8890 -5000 {
lab=col_n[15]}
N 8890 -5000 9090 -5000 {
lab=col_n[15]}
N 9090 -5000 9100 -4990 {
lab=col_n[15]}
N 8880 -4970 8890 -4980 {
lab=colon_n[15]}
N 8890 -4980 9090 -4980 {
lab=colon_n[15]}
N 9090 -4980 9100 -4970 {
lab=colon_n[15]}
N 8880 -4950 8890 -4960 {
lab=#net31}
N 8890 -4960 9090 -4960 {
lab=#net31}
N 9090 -4960 9100 -4950 {
lab=#net31}
N 8880 -4930 8890 -4940 {
lab=#net32}
N 8890 -4940 9090 -4940 {
lab=#net32}
N 9090 -4940 9100 -4930 {
lab=#net32}
N 8940 -5090 8940 -5070 {
lab=vcom}
N 8980 -5090 8980 -5070 {
lab=ctop}
N 8860 -4990 8880 -4990 {
lab=col_n[15]}
N 8860 -4970 8880 -4970 {
lab=colon_n[15]}
N 8860 -4950 8880 -4950 {
lab=#net31}
N 8860 -4930 8880 -4930 {
lab=#net32}
N 9100 -4930 9120 -4930 {
lab=#net32}
N 9100 -4950 9120 -4950 {
lab=#net31}
N 9100 -4970 9120 -4970 {
lab=colon_n[15]}
N 9100 -4990 9120 -4990 {
lab=col_n[15]}
N 8920 -4850 8920 -4840 {
lab=VSS}
N 8920 -5080 8920 -5070 {
lab=VDD}
N 9260 -4850 9270 -4860 {
lab=row_n[31]}
N 9270 -5060 9270 -4860 {
lab=row_n[31]}
N 9260 -5070 9270 -5060 {
lab=row_n[31]}
N 9260 -4850 9260 -4830 {
lab=row_n[31]}
N 9260 -5090 9260 -5070 {
lab=row_n[31]}
N 9140 -4990 9150 -5000 {
lab=col_n[15]}
N 9150 -5000 9350 -5000 {
lab=col_n[15]}
N 9350 -5000 9360 -4990 {
lab=col_n[15]}
N 9140 -4970 9150 -4980 {
lab=colon_n[15]}
N 9150 -4980 9350 -4980 {
lab=colon_n[15]}
N 9350 -4980 9360 -4970 {
lab=colon_n[15]}
N 9140 -4950 9150 -4960 {
lab=#net31}
N 9150 -4960 9350 -4960 {
lab=#net31}
N 9350 -4960 9360 -4950 {
lab=#net31}
N 9140 -4930 9150 -4940 {
lab=#net32}
N 9150 -4940 9350 -4940 {
lab=#net32}
N 9350 -4940 9360 -4930 {
lab=#net32}
N 9200 -5090 9200 -5070 {
lab=vcom}
N 9240 -5090 9240 -5070 {
lab=ctop}
N 9120 -4990 9140 -4990 {
lab=col_n[15]}
N 9120 -4970 9140 -4970 {
lab=colon_n[15]}
N 9120 -4950 9140 -4950 {
lab=#net31}
N 9120 -4930 9140 -4930 {
lab=#net32}
N 9360 -4930 9380 -4930 {
lab=#net32}
N 9360 -4950 9380 -4950 {
lab=#net31}
N 9360 -4970 9380 -4970 {
lab=colon_n[15]}
N 9360 -4990 9380 -4990 {
lab=col_n[15]}
N 9180 -4850 9180 -4840 {
lab=VSS}
N 9180 -5080 9180 -5070 {
lab=VDD}
N 1200 -5110 1210 -5120 {
lab=row_n[0]}
N 1210 -5320 1210 -5120 {
lab=row_n[0]}
N 1200 -5330 1210 -5320 {
lab=row_n[0]}
N 1200 -5110 1200 -5090 {
lab=row_n[0]}
N 1200 -5350 1200 -5330 {
lab=row_n[0]}
N 1080 -5250 1090 -5260 {
lab=col_n[16]}
N 1090 -5260 1290 -5260 {
lab=col_n[16]}
N 1290 -5260 1300 -5250 {
lab=col_n[16]}
N 1080 -5230 1090 -5240 {
lab=colon_n[16]}
N 1090 -5240 1290 -5240 {
lab=colon_n[16]}
N 1290 -5240 1300 -5230 {
lab=colon_n[16]}
N 1080 -5210 1090 -5220 {
lab=#net33}
N 1090 -5220 1290 -5220 {
lab=#net33}
N 1290 -5220 1300 -5210 {
lab=#net33}
N 1080 -5190 1090 -5200 {
lab=#net34}
N 1090 -5200 1290 -5200 {
lab=#net34}
N 1290 -5200 1300 -5190 {
lab=#net34}
N 1140 -5350 1140 -5330 {
lab=vcom}
N 1180 -5350 1180 -5330 {
lab=ctop}
N 1060 -5250 1080 -5250 {
lab=col_n[16]}
N 1060 -5230 1080 -5230 {
lab=colon_n[16]}
N 1060 -5210 1080 -5210 {
lab=#net33}
N 1060 -5190 1080 -5190 {
lab=#net34}
N 1300 -5190 1320 -5190 {
lab=#net34}
N 1300 -5210 1320 -5210 {
lab=#net33}
N 1300 -5230 1320 -5230 {
lab=colon_n[16]}
N 1300 -5250 1320 -5250 {
lab=col_n[16]}
N 1120 -5110 1120 -5100 {
lab=VSS}
N 1120 -5340 1120 -5330 {
lab=VDD}
N 1460 -5110 1470 -5120 {
lab=row_n[1]}
N 1470 -5320 1470 -5120 {
lab=row_n[1]}
N 1460 -5330 1470 -5320 {
lab=row_n[1]}
N 1460 -5110 1460 -5090 {
lab=row_n[1]}
N 1460 -5350 1460 -5330 {
lab=row_n[1]}
N 1340 -5250 1350 -5260 {
lab=col_n[16]}
N 1350 -5260 1550 -5260 {
lab=col_n[16]}
N 1550 -5260 1560 -5250 {
lab=col_n[16]}
N 1340 -5230 1350 -5240 {
lab=colon_n[16]}
N 1350 -5240 1550 -5240 {
lab=colon_n[16]}
N 1550 -5240 1560 -5230 {
lab=colon_n[16]}
N 1340 -5210 1350 -5220 {
lab=#net33}
N 1350 -5220 1550 -5220 {
lab=#net33}
N 1550 -5220 1560 -5210 {
lab=#net33}
N 1340 -5190 1350 -5200 {
lab=#net34}
N 1350 -5200 1550 -5200 {
lab=#net34}
N 1550 -5200 1560 -5190 {
lab=#net34}
N 1400 -5350 1400 -5330 {
lab=vcom}
N 1440 -5350 1440 -5330 {
lab=ctop}
N 1320 -5250 1340 -5250 {
lab=col_n[16]}
N 1320 -5230 1340 -5230 {
lab=colon_n[16]}
N 1320 -5210 1340 -5210 {
lab=#net33}
N 1320 -5190 1340 -5190 {
lab=#net34}
N 1560 -5190 1580 -5190 {
lab=#net34}
N 1560 -5210 1580 -5210 {
lab=#net33}
N 1560 -5230 1580 -5230 {
lab=colon_n[16]}
N 1560 -5250 1580 -5250 {
lab=col_n[16]}
N 1380 -5110 1380 -5100 {
lab=VSS}
N 1380 -5340 1380 -5330 {
lab=VDD}
N 1720 -5110 1730 -5120 {
lab=row_n[2]}
N 1730 -5320 1730 -5120 {
lab=row_n[2]}
N 1720 -5330 1730 -5320 {
lab=row_n[2]}
N 1720 -5110 1720 -5090 {
lab=row_n[2]}
N 1720 -5350 1720 -5330 {
lab=row_n[2]}
N 1600 -5250 1610 -5260 {
lab=col_n[16]}
N 1610 -5260 1810 -5260 {
lab=col_n[16]}
N 1810 -5260 1820 -5250 {
lab=col_n[16]}
N 1600 -5230 1610 -5240 {
lab=colon_n[16]}
N 1610 -5240 1810 -5240 {
lab=colon_n[16]}
N 1810 -5240 1820 -5230 {
lab=colon_n[16]}
N 1600 -5210 1610 -5220 {
lab=#net33}
N 1610 -5220 1810 -5220 {
lab=#net33}
N 1810 -5220 1820 -5210 {
lab=#net33}
N 1600 -5190 1610 -5200 {
lab=#net34}
N 1610 -5200 1810 -5200 {
lab=#net34}
N 1810 -5200 1820 -5190 {
lab=#net34}
N 1660 -5350 1660 -5330 {
lab=vcom}
N 1700 -5350 1700 -5330 {
lab=ctop}
N 1580 -5250 1600 -5250 {
lab=col_n[16]}
N 1580 -5230 1600 -5230 {
lab=colon_n[16]}
N 1580 -5210 1600 -5210 {
lab=#net33}
N 1580 -5190 1600 -5190 {
lab=#net34}
N 1820 -5190 1840 -5190 {
lab=#net34}
N 1820 -5210 1840 -5210 {
lab=#net33}
N 1820 -5230 1840 -5230 {
lab=colon_n[16]}
N 1820 -5250 1840 -5250 {
lab=col_n[16]}
N 1640 -5110 1640 -5100 {
lab=VSS}
N 1640 -5340 1640 -5330 {
lab=VDD}
N 1980 -5110 1990 -5120 {
lab=row_n[3]}
N 1990 -5320 1990 -5120 {
lab=row_n[3]}
N 1980 -5330 1990 -5320 {
lab=row_n[3]}
N 1980 -5110 1980 -5090 {
lab=row_n[3]}
N 1980 -5350 1980 -5330 {
lab=row_n[3]}
N 1860 -5250 1870 -5260 {
lab=col_n[16]}
N 1870 -5260 2070 -5260 {
lab=col_n[16]}
N 2070 -5260 2080 -5250 {
lab=col_n[16]}
N 1860 -5230 1870 -5240 {
lab=colon_n[16]}
N 1870 -5240 2070 -5240 {
lab=colon_n[16]}
N 2070 -5240 2080 -5230 {
lab=colon_n[16]}
N 1860 -5210 1870 -5220 {
lab=#net33}
N 1870 -5220 2070 -5220 {
lab=#net33}
N 2070 -5220 2080 -5210 {
lab=#net33}
N 1860 -5190 1870 -5200 {
lab=#net34}
N 1870 -5200 2070 -5200 {
lab=#net34}
N 2070 -5200 2080 -5190 {
lab=#net34}
N 1920 -5350 1920 -5330 {
lab=vcom}
N 1960 -5350 1960 -5330 {
lab=ctop}
N 1840 -5250 1860 -5250 {
lab=col_n[16]}
N 1840 -5230 1860 -5230 {
lab=colon_n[16]}
N 1840 -5210 1860 -5210 {
lab=#net33}
N 1840 -5190 1860 -5190 {
lab=#net34}
N 2080 -5190 2100 -5190 {
lab=#net34}
N 2080 -5210 2100 -5210 {
lab=#net33}
N 2080 -5230 2100 -5230 {
lab=colon_n[16]}
N 2080 -5250 2100 -5250 {
lab=col_n[16]}
N 1900 -5110 1900 -5100 {
lab=VSS}
N 1900 -5340 1900 -5330 {
lab=VDD}
N 2240 -5110 2250 -5120 {
lab=row_n[4]}
N 2250 -5320 2250 -5120 {
lab=row_n[4]}
N 2240 -5330 2250 -5320 {
lab=row_n[4]}
N 2240 -5110 2240 -5090 {
lab=row_n[4]}
N 2240 -5350 2240 -5330 {
lab=row_n[4]}
N 2120 -5250 2130 -5260 {
lab=col_n[16]}
N 2130 -5260 2330 -5260 {
lab=col_n[16]}
N 2330 -5260 2340 -5250 {
lab=col_n[16]}
N 2120 -5230 2130 -5240 {
lab=colon_n[16]}
N 2130 -5240 2330 -5240 {
lab=colon_n[16]}
N 2330 -5240 2340 -5230 {
lab=colon_n[16]}
N 2120 -5210 2130 -5220 {
lab=#net33}
N 2130 -5220 2330 -5220 {
lab=#net33}
N 2330 -5220 2340 -5210 {
lab=#net33}
N 2120 -5190 2130 -5200 {
lab=#net34}
N 2130 -5200 2330 -5200 {
lab=#net34}
N 2330 -5200 2340 -5190 {
lab=#net34}
N 2180 -5350 2180 -5330 {
lab=vcom}
N 2220 -5350 2220 -5330 {
lab=ctop}
N 2100 -5250 2120 -5250 {
lab=col_n[16]}
N 2100 -5230 2120 -5230 {
lab=colon_n[16]}
N 2100 -5210 2120 -5210 {
lab=#net33}
N 2100 -5190 2120 -5190 {
lab=#net34}
N 2340 -5190 2360 -5190 {
lab=#net34}
N 2340 -5210 2360 -5210 {
lab=#net33}
N 2340 -5230 2360 -5230 {
lab=colon_n[16]}
N 2340 -5250 2360 -5250 {
lab=col_n[16]}
N 2160 -5110 2160 -5100 {
lab=VSS}
N 2160 -5340 2160 -5330 {
lab=VDD}
N 2500 -5110 2510 -5120 {
lab=row_n[5]}
N 2510 -5320 2510 -5120 {
lab=row_n[5]}
N 2500 -5330 2510 -5320 {
lab=row_n[5]}
N 2500 -5110 2500 -5090 {
lab=row_n[5]}
N 2500 -5350 2500 -5330 {
lab=row_n[5]}
N 2380 -5250 2390 -5260 {
lab=col_n[16]}
N 2390 -5260 2590 -5260 {
lab=col_n[16]}
N 2590 -5260 2600 -5250 {
lab=col_n[16]}
N 2380 -5230 2390 -5240 {
lab=colon_n[16]}
N 2390 -5240 2590 -5240 {
lab=colon_n[16]}
N 2590 -5240 2600 -5230 {
lab=colon_n[16]}
N 2380 -5210 2390 -5220 {
lab=#net33}
N 2390 -5220 2590 -5220 {
lab=#net33}
N 2590 -5220 2600 -5210 {
lab=#net33}
N 2380 -5190 2390 -5200 {
lab=#net34}
N 2390 -5200 2590 -5200 {
lab=#net34}
N 2590 -5200 2600 -5190 {
lab=#net34}
N 2440 -5350 2440 -5330 {
lab=vcom}
N 2480 -5350 2480 -5330 {
lab=ctop}
N 2360 -5250 2380 -5250 {
lab=col_n[16]}
N 2360 -5230 2380 -5230 {
lab=colon_n[16]}
N 2360 -5210 2380 -5210 {
lab=#net33}
N 2360 -5190 2380 -5190 {
lab=#net34}
N 2600 -5190 2620 -5190 {
lab=#net34}
N 2600 -5210 2620 -5210 {
lab=#net33}
N 2600 -5230 2620 -5230 {
lab=colon_n[16]}
N 2600 -5250 2620 -5250 {
lab=col_n[16]}
N 2420 -5110 2420 -5100 {
lab=VSS}
N 2420 -5340 2420 -5330 {
lab=VDD}
N 2760 -5110 2770 -5120 {
lab=row_n[6]}
N 2770 -5320 2770 -5120 {
lab=row_n[6]}
N 2760 -5330 2770 -5320 {
lab=row_n[6]}
N 2760 -5110 2760 -5090 {
lab=row_n[6]}
N 2760 -5350 2760 -5330 {
lab=row_n[6]}
N 2640 -5250 2650 -5260 {
lab=col_n[16]}
N 2650 -5260 2850 -5260 {
lab=col_n[16]}
N 2850 -5260 2860 -5250 {
lab=col_n[16]}
N 2640 -5230 2650 -5240 {
lab=colon_n[16]}
N 2650 -5240 2850 -5240 {
lab=colon_n[16]}
N 2850 -5240 2860 -5230 {
lab=colon_n[16]}
N 2640 -5210 2650 -5220 {
lab=#net33}
N 2650 -5220 2850 -5220 {
lab=#net33}
N 2850 -5220 2860 -5210 {
lab=#net33}
N 2640 -5190 2650 -5200 {
lab=#net34}
N 2650 -5200 2850 -5200 {
lab=#net34}
N 2850 -5200 2860 -5190 {
lab=#net34}
N 2700 -5350 2700 -5330 {
lab=vcom}
N 2740 -5350 2740 -5330 {
lab=ctop}
N 2620 -5250 2640 -5250 {
lab=col_n[16]}
N 2620 -5230 2640 -5230 {
lab=colon_n[16]}
N 2620 -5210 2640 -5210 {
lab=#net33}
N 2620 -5190 2640 -5190 {
lab=#net34}
N 2860 -5190 2880 -5190 {
lab=#net34}
N 2860 -5210 2880 -5210 {
lab=#net33}
N 2860 -5230 2880 -5230 {
lab=colon_n[16]}
N 2860 -5250 2880 -5250 {
lab=col_n[16]}
N 2680 -5110 2680 -5100 {
lab=VSS}
N 2680 -5340 2680 -5330 {
lab=VDD}
N 3020 -5110 3030 -5120 {
lab=row_n[7]}
N 3030 -5320 3030 -5120 {
lab=row_n[7]}
N 3020 -5330 3030 -5320 {
lab=row_n[7]}
N 3020 -5110 3020 -5090 {
lab=row_n[7]}
N 3020 -5350 3020 -5330 {
lab=row_n[7]}
N 2900 -5250 2910 -5260 {
lab=col_n[16]}
N 2910 -5260 3110 -5260 {
lab=col_n[16]}
N 3110 -5260 3120 -5250 {
lab=col_n[16]}
N 2900 -5230 2910 -5240 {
lab=colon_n[16]}
N 2910 -5240 3110 -5240 {
lab=colon_n[16]}
N 3110 -5240 3120 -5230 {
lab=colon_n[16]}
N 2900 -5210 2910 -5220 {
lab=#net33}
N 2910 -5220 3110 -5220 {
lab=#net33}
N 3110 -5220 3120 -5210 {
lab=#net33}
N 2900 -5190 2910 -5200 {
lab=#net34}
N 2910 -5200 3110 -5200 {
lab=#net34}
N 3110 -5200 3120 -5190 {
lab=#net34}
N 2960 -5350 2960 -5330 {
lab=vcom}
N 3000 -5350 3000 -5330 {
lab=ctop}
N 2880 -5250 2900 -5250 {
lab=col_n[16]}
N 2880 -5230 2900 -5230 {
lab=colon_n[16]}
N 2880 -5210 2900 -5210 {
lab=#net33}
N 2880 -5190 2900 -5190 {
lab=#net34}
N 3120 -5190 3140 -5190 {
lab=#net34}
N 3120 -5210 3140 -5210 {
lab=#net33}
N 3120 -5230 3140 -5230 {
lab=colon_n[16]}
N 3120 -5250 3140 -5250 {
lab=col_n[16]}
N 2940 -5110 2940 -5100 {
lab=VSS}
N 2940 -5340 2940 -5330 {
lab=VDD}
N 3280 -5110 3290 -5120 {
lab=row_n[8]}
N 3290 -5320 3290 -5120 {
lab=row_n[8]}
N 3280 -5330 3290 -5320 {
lab=row_n[8]}
N 3280 -5110 3280 -5090 {
lab=row_n[8]}
N 3280 -5350 3280 -5330 {
lab=row_n[8]}
N 3160 -5250 3170 -5260 {
lab=col_n[16]}
N 3170 -5260 3370 -5260 {
lab=col_n[16]}
N 3370 -5260 3380 -5250 {
lab=col_n[16]}
N 3160 -5230 3170 -5240 {
lab=colon_n[16]}
N 3170 -5240 3370 -5240 {
lab=colon_n[16]}
N 3370 -5240 3380 -5230 {
lab=colon_n[16]}
N 3160 -5210 3170 -5220 {
lab=#net33}
N 3170 -5220 3370 -5220 {
lab=#net33}
N 3370 -5220 3380 -5210 {
lab=#net33}
N 3160 -5190 3170 -5200 {
lab=#net34}
N 3170 -5200 3370 -5200 {
lab=#net34}
N 3370 -5200 3380 -5190 {
lab=#net34}
N 3220 -5350 3220 -5330 {
lab=vcom}
N 3260 -5350 3260 -5330 {
lab=ctop}
N 3140 -5250 3160 -5250 {
lab=col_n[16]}
N 3140 -5230 3160 -5230 {
lab=colon_n[16]}
N 3140 -5210 3160 -5210 {
lab=#net33}
N 3140 -5190 3160 -5190 {
lab=#net34}
N 3380 -5190 3400 -5190 {
lab=#net34}
N 3380 -5210 3400 -5210 {
lab=#net33}
N 3380 -5230 3400 -5230 {
lab=colon_n[16]}
N 3380 -5250 3400 -5250 {
lab=col_n[16]}
N 3200 -5110 3200 -5100 {
lab=VSS}
N 3200 -5340 3200 -5330 {
lab=VDD}
N 3540 -5110 3550 -5120 {
lab=row_n[9]}
N 3550 -5320 3550 -5120 {
lab=row_n[9]}
N 3540 -5330 3550 -5320 {
lab=row_n[9]}
N 3540 -5110 3540 -5090 {
lab=row_n[9]}
N 3540 -5350 3540 -5330 {
lab=row_n[9]}
N 3420 -5250 3430 -5260 {
lab=col_n[16]}
N 3430 -5260 3630 -5260 {
lab=col_n[16]}
N 3630 -5260 3640 -5250 {
lab=col_n[16]}
N 3420 -5230 3430 -5240 {
lab=colon_n[16]}
N 3430 -5240 3630 -5240 {
lab=colon_n[16]}
N 3630 -5240 3640 -5230 {
lab=colon_n[16]}
N 3420 -5210 3430 -5220 {
lab=#net33}
N 3430 -5220 3630 -5220 {
lab=#net33}
N 3630 -5220 3640 -5210 {
lab=#net33}
N 3420 -5190 3430 -5200 {
lab=#net34}
N 3430 -5200 3630 -5200 {
lab=#net34}
N 3630 -5200 3640 -5190 {
lab=#net34}
N 3480 -5350 3480 -5330 {
lab=vcom}
N 3520 -5350 3520 -5330 {
lab=ctop}
N 3400 -5250 3420 -5250 {
lab=col_n[16]}
N 3400 -5230 3420 -5230 {
lab=colon_n[16]}
N 3400 -5210 3420 -5210 {
lab=#net33}
N 3400 -5190 3420 -5190 {
lab=#net34}
N 3640 -5190 3660 -5190 {
lab=#net34}
N 3640 -5210 3660 -5210 {
lab=#net33}
N 3640 -5230 3660 -5230 {
lab=colon_n[16]}
N 3640 -5250 3660 -5250 {
lab=col_n[16]}
N 3460 -5110 3460 -5100 {
lab=VSS}
N 3460 -5340 3460 -5330 {
lab=VDD}
N 3800 -5110 3810 -5120 {
lab=row_n[10]}
N 3810 -5320 3810 -5120 {
lab=row_n[10]}
N 3800 -5330 3810 -5320 {
lab=row_n[10]}
N 3800 -5110 3800 -5090 {
lab=row_n[10]}
N 3800 -5350 3800 -5330 {
lab=row_n[10]}
N 3680 -5250 3690 -5260 {
lab=col_n[16]}
N 3690 -5260 3890 -5260 {
lab=col_n[16]}
N 3890 -5260 3900 -5250 {
lab=col_n[16]}
N 3680 -5230 3690 -5240 {
lab=colon_n[16]}
N 3690 -5240 3890 -5240 {
lab=colon_n[16]}
N 3890 -5240 3900 -5230 {
lab=colon_n[16]}
N 3680 -5210 3690 -5220 {
lab=#net33}
N 3690 -5220 3890 -5220 {
lab=#net33}
N 3890 -5220 3900 -5210 {
lab=#net33}
N 3680 -5190 3690 -5200 {
lab=#net34}
N 3690 -5200 3890 -5200 {
lab=#net34}
N 3890 -5200 3900 -5190 {
lab=#net34}
N 3740 -5350 3740 -5330 {
lab=vcom}
N 3780 -5350 3780 -5330 {
lab=ctop}
N 3660 -5250 3680 -5250 {
lab=col_n[16]}
N 3660 -5230 3680 -5230 {
lab=colon_n[16]}
N 3660 -5210 3680 -5210 {
lab=#net33}
N 3660 -5190 3680 -5190 {
lab=#net34}
N 3900 -5190 3920 -5190 {
lab=#net34}
N 3900 -5210 3920 -5210 {
lab=#net33}
N 3900 -5230 3920 -5230 {
lab=colon_n[16]}
N 3900 -5250 3920 -5250 {
lab=col_n[16]}
N 3720 -5110 3720 -5100 {
lab=VSS}
N 3720 -5340 3720 -5330 {
lab=VDD}
N 4060 -5110 4070 -5120 {
lab=row_n[11]}
N 4070 -5320 4070 -5120 {
lab=row_n[11]}
N 4060 -5330 4070 -5320 {
lab=row_n[11]}
N 4060 -5110 4060 -5090 {
lab=row_n[11]}
N 4060 -5350 4060 -5330 {
lab=row_n[11]}
N 3940 -5250 3950 -5260 {
lab=col_n[16]}
N 3950 -5260 4150 -5260 {
lab=col_n[16]}
N 4150 -5260 4160 -5250 {
lab=col_n[16]}
N 3940 -5230 3950 -5240 {
lab=colon_n[16]}
N 3950 -5240 4150 -5240 {
lab=colon_n[16]}
N 4150 -5240 4160 -5230 {
lab=colon_n[16]}
N 3940 -5210 3950 -5220 {
lab=#net33}
N 3950 -5220 4150 -5220 {
lab=#net33}
N 4150 -5220 4160 -5210 {
lab=#net33}
N 3940 -5190 3950 -5200 {
lab=#net34}
N 3950 -5200 4150 -5200 {
lab=#net34}
N 4150 -5200 4160 -5190 {
lab=#net34}
N 4000 -5350 4000 -5330 {
lab=vcom}
N 4040 -5350 4040 -5330 {
lab=ctop}
N 3920 -5250 3940 -5250 {
lab=col_n[16]}
N 3920 -5230 3940 -5230 {
lab=colon_n[16]}
N 3920 -5210 3940 -5210 {
lab=#net33}
N 3920 -5190 3940 -5190 {
lab=#net34}
N 4160 -5190 4180 -5190 {
lab=#net34}
N 4160 -5210 4180 -5210 {
lab=#net33}
N 4160 -5230 4180 -5230 {
lab=colon_n[16]}
N 4160 -5250 4180 -5250 {
lab=col_n[16]}
N 3980 -5110 3980 -5100 {
lab=VSS}
N 3980 -5340 3980 -5330 {
lab=VDD}
N 4320 -5110 4330 -5120 {
lab=row_n[12]}
N 4330 -5320 4330 -5120 {
lab=row_n[12]}
N 4320 -5330 4330 -5320 {
lab=row_n[12]}
N 4320 -5110 4320 -5090 {
lab=row_n[12]}
N 4320 -5350 4320 -5330 {
lab=row_n[12]}
N 4200 -5250 4210 -5260 {
lab=col_n[16]}
N 4210 -5260 4410 -5260 {
lab=col_n[16]}
N 4410 -5260 4420 -5250 {
lab=col_n[16]}
N 4200 -5230 4210 -5240 {
lab=colon_n[16]}
N 4210 -5240 4410 -5240 {
lab=colon_n[16]}
N 4410 -5240 4420 -5230 {
lab=colon_n[16]}
N 4200 -5210 4210 -5220 {
lab=#net33}
N 4210 -5220 4410 -5220 {
lab=#net33}
N 4410 -5220 4420 -5210 {
lab=#net33}
N 4200 -5190 4210 -5200 {
lab=#net34}
N 4210 -5200 4410 -5200 {
lab=#net34}
N 4410 -5200 4420 -5190 {
lab=#net34}
N 4260 -5350 4260 -5330 {
lab=vcom}
N 4300 -5350 4300 -5330 {
lab=ctop}
N 4180 -5250 4200 -5250 {
lab=col_n[16]}
N 4180 -5230 4200 -5230 {
lab=colon_n[16]}
N 4180 -5210 4200 -5210 {
lab=#net33}
N 4180 -5190 4200 -5190 {
lab=#net34}
N 4420 -5190 4440 -5190 {
lab=#net34}
N 4420 -5210 4440 -5210 {
lab=#net33}
N 4420 -5230 4440 -5230 {
lab=colon_n[16]}
N 4420 -5250 4440 -5250 {
lab=col_n[16]}
N 4240 -5110 4240 -5100 {
lab=VSS}
N 4240 -5340 4240 -5330 {
lab=VDD}
N 4580 -5110 4590 -5120 {
lab=row_n[13]}
N 4590 -5320 4590 -5120 {
lab=row_n[13]}
N 4580 -5330 4590 -5320 {
lab=row_n[13]}
N 4580 -5110 4580 -5090 {
lab=row_n[13]}
N 4580 -5350 4580 -5330 {
lab=row_n[13]}
N 4460 -5250 4470 -5260 {
lab=col_n[16]}
N 4470 -5260 4670 -5260 {
lab=col_n[16]}
N 4670 -5260 4680 -5250 {
lab=col_n[16]}
N 4460 -5230 4470 -5240 {
lab=colon_n[16]}
N 4470 -5240 4670 -5240 {
lab=colon_n[16]}
N 4670 -5240 4680 -5230 {
lab=colon_n[16]}
N 4460 -5210 4470 -5220 {
lab=#net33}
N 4470 -5220 4670 -5220 {
lab=#net33}
N 4670 -5220 4680 -5210 {
lab=#net33}
N 4460 -5190 4470 -5200 {
lab=#net34}
N 4470 -5200 4670 -5200 {
lab=#net34}
N 4670 -5200 4680 -5190 {
lab=#net34}
N 4520 -5350 4520 -5330 {
lab=vcom}
N 4560 -5350 4560 -5330 {
lab=ctop}
N 4440 -5250 4460 -5250 {
lab=col_n[16]}
N 4440 -5230 4460 -5230 {
lab=colon_n[16]}
N 4440 -5210 4460 -5210 {
lab=#net33}
N 4440 -5190 4460 -5190 {
lab=#net34}
N 4680 -5190 4700 -5190 {
lab=#net34}
N 4680 -5210 4700 -5210 {
lab=#net33}
N 4680 -5230 4700 -5230 {
lab=colon_n[16]}
N 4680 -5250 4700 -5250 {
lab=col_n[16]}
N 4500 -5110 4500 -5100 {
lab=VSS}
N 4500 -5340 4500 -5330 {
lab=VDD}
N 4840 -5110 4850 -5120 {
lab=row_n[14]}
N 4850 -5320 4850 -5120 {
lab=row_n[14]}
N 4840 -5330 4850 -5320 {
lab=row_n[14]}
N 4840 -5110 4840 -5090 {
lab=row_n[14]}
N 4840 -5350 4840 -5330 {
lab=row_n[14]}
N 4720 -5250 4730 -5260 {
lab=col_n[16]}
N 4730 -5260 4930 -5260 {
lab=col_n[16]}
N 4930 -5260 4940 -5250 {
lab=col_n[16]}
N 4720 -5230 4730 -5240 {
lab=colon_n[16]}
N 4730 -5240 4930 -5240 {
lab=colon_n[16]}
N 4930 -5240 4940 -5230 {
lab=colon_n[16]}
N 4720 -5210 4730 -5220 {
lab=#net33}
N 4730 -5220 4930 -5220 {
lab=#net33}
N 4930 -5220 4940 -5210 {
lab=#net33}
N 4720 -5190 4730 -5200 {
lab=#net34}
N 4730 -5200 4930 -5200 {
lab=#net34}
N 4930 -5200 4940 -5190 {
lab=#net34}
N 4780 -5350 4780 -5330 {
lab=vcom}
N 4820 -5350 4820 -5330 {
lab=ctop}
N 4700 -5250 4720 -5250 {
lab=col_n[16]}
N 4700 -5230 4720 -5230 {
lab=colon_n[16]}
N 4700 -5210 4720 -5210 {
lab=#net33}
N 4700 -5190 4720 -5190 {
lab=#net34}
N 4940 -5190 4960 -5190 {
lab=#net34}
N 4940 -5210 4960 -5210 {
lab=#net33}
N 4940 -5230 4960 -5230 {
lab=colon_n[16]}
N 4940 -5250 4960 -5250 {
lab=col_n[16]}
N 4760 -5110 4760 -5100 {
lab=VSS}
N 4760 -5340 4760 -5330 {
lab=VDD}
N 5100 -5110 5110 -5120 {
lab=row_n[15]}
N 5110 -5320 5110 -5120 {
lab=row_n[15]}
N 5100 -5330 5110 -5320 {
lab=row_n[15]}
N 5100 -5110 5100 -5090 {
lab=row_n[15]}
N 5100 -5350 5100 -5330 {
lab=row_n[15]}
N 4980 -5250 4990 -5260 {
lab=col_n[16]}
N 4990 -5260 5190 -5260 {
lab=col_n[16]}
N 5190 -5260 5200 -5250 {
lab=col_n[16]}
N 4980 -5230 4990 -5240 {
lab=colon_n[16]}
N 4990 -5240 5190 -5240 {
lab=colon_n[16]}
N 5190 -5240 5200 -5230 {
lab=colon_n[16]}
N 4980 -5210 4990 -5220 {
lab=#net33}
N 4990 -5220 5190 -5220 {
lab=#net33}
N 5190 -5220 5200 -5210 {
lab=#net33}
N 4980 -5190 4990 -5200 {
lab=#net34}
N 4990 -5200 5190 -5200 {
lab=#net34}
N 5190 -5200 5200 -5190 {
lab=#net34}
N 5040 -5350 5040 -5330 {
lab=vcom}
N 5080 -5350 5080 -5330 {
lab=ctop}
N 4960 -5250 4980 -5250 {
lab=col_n[16]}
N 4960 -5230 4980 -5230 {
lab=colon_n[16]}
N 4960 -5210 4980 -5210 {
lab=#net33}
N 4960 -5190 4980 -5190 {
lab=#net34}
N 5200 -5190 5220 -5190 {
lab=#net34}
N 5200 -5210 5220 -5210 {
lab=#net33}
N 5200 -5230 5220 -5230 {
lab=colon_n[16]}
N 5200 -5250 5220 -5250 {
lab=col_n[16]}
N 5020 -5110 5020 -5100 {
lab=VSS}
N 5020 -5340 5020 -5330 {
lab=VDD}
N 5360 -5110 5370 -5120 {
lab=row_n[16]}
N 5370 -5320 5370 -5120 {
lab=row_n[16]}
N 5360 -5330 5370 -5320 {
lab=row_n[16]}
N 5360 -5110 5360 -5090 {
lab=row_n[16]}
N 5360 -5350 5360 -5330 {
lab=row_n[16]}
N 5240 -5250 5250 -5260 {
lab=col_n[16]}
N 5250 -5260 5450 -5260 {
lab=col_n[16]}
N 5450 -5260 5460 -5250 {
lab=col_n[16]}
N 5240 -5230 5250 -5240 {
lab=colon_n[16]}
N 5250 -5240 5450 -5240 {
lab=colon_n[16]}
N 5450 -5240 5460 -5230 {
lab=colon_n[16]}
N 5240 -5210 5250 -5220 {
lab=#net33}
N 5250 -5220 5450 -5220 {
lab=#net33}
N 5450 -5220 5460 -5210 {
lab=#net33}
N 5240 -5190 5250 -5200 {
lab=#net34}
N 5250 -5200 5450 -5200 {
lab=#net34}
N 5450 -5200 5460 -5190 {
lab=#net34}
N 5300 -5350 5300 -5330 {
lab=vcom}
N 5340 -5350 5340 -5330 {
lab=ctop}
N 5220 -5250 5240 -5250 {
lab=col_n[16]}
N 5220 -5230 5240 -5230 {
lab=colon_n[16]}
N 5220 -5210 5240 -5210 {
lab=#net33}
N 5220 -5190 5240 -5190 {
lab=#net34}
N 5460 -5190 5480 -5190 {
lab=#net34}
N 5460 -5210 5480 -5210 {
lab=#net33}
N 5460 -5230 5480 -5230 {
lab=colon_n[16]}
N 5460 -5250 5480 -5250 {
lab=col_n[16]}
N 5280 -5110 5280 -5100 {
lab=VSS}
N 5280 -5340 5280 -5330 {
lab=VDD}
N 5620 -5110 5630 -5120 {
lab=row_n[17]}
N 5630 -5320 5630 -5120 {
lab=row_n[17]}
N 5620 -5330 5630 -5320 {
lab=row_n[17]}
N 5620 -5110 5620 -5090 {
lab=row_n[17]}
N 5620 -5350 5620 -5330 {
lab=row_n[17]}
N 5500 -5250 5510 -5260 {
lab=col_n[16]}
N 5510 -5260 5710 -5260 {
lab=col_n[16]}
N 5710 -5260 5720 -5250 {
lab=col_n[16]}
N 5500 -5230 5510 -5240 {
lab=colon_n[16]}
N 5510 -5240 5710 -5240 {
lab=colon_n[16]}
N 5710 -5240 5720 -5230 {
lab=colon_n[16]}
N 5500 -5210 5510 -5220 {
lab=#net33}
N 5510 -5220 5710 -5220 {
lab=#net33}
N 5710 -5220 5720 -5210 {
lab=#net33}
N 5500 -5190 5510 -5200 {
lab=#net34}
N 5510 -5200 5710 -5200 {
lab=#net34}
N 5710 -5200 5720 -5190 {
lab=#net34}
N 5560 -5350 5560 -5330 {
lab=vcom}
N 5600 -5350 5600 -5330 {
lab=ctop}
N 5480 -5250 5500 -5250 {
lab=col_n[16]}
N 5480 -5230 5500 -5230 {
lab=colon_n[16]}
N 5480 -5210 5500 -5210 {
lab=#net33}
N 5480 -5190 5500 -5190 {
lab=#net34}
N 5720 -5190 5740 -5190 {
lab=#net34}
N 5720 -5210 5740 -5210 {
lab=#net33}
N 5720 -5230 5740 -5230 {
lab=colon_n[16]}
N 5720 -5250 5740 -5250 {
lab=col_n[16]}
N 5540 -5110 5540 -5100 {
lab=VSS}
N 5540 -5340 5540 -5330 {
lab=VDD}
N 5880 -5110 5890 -5120 {
lab=row_n[18]}
N 5890 -5320 5890 -5120 {
lab=row_n[18]}
N 5880 -5330 5890 -5320 {
lab=row_n[18]}
N 5880 -5110 5880 -5090 {
lab=row_n[18]}
N 5880 -5350 5880 -5330 {
lab=row_n[18]}
N 5760 -5250 5770 -5260 {
lab=col_n[16]}
N 5770 -5260 5970 -5260 {
lab=col_n[16]}
N 5970 -5260 5980 -5250 {
lab=col_n[16]}
N 5760 -5230 5770 -5240 {
lab=colon_n[16]}
N 5770 -5240 5970 -5240 {
lab=colon_n[16]}
N 5970 -5240 5980 -5230 {
lab=colon_n[16]}
N 5760 -5210 5770 -5220 {
lab=#net33}
N 5770 -5220 5970 -5220 {
lab=#net33}
N 5970 -5220 5980 -5210 {
lab=#net33}
N 5760 -5190 5770 -5200 {
lab=#net34}
N 5770 -5200 5970 -5200 {
lab=#net34}
N 5970 -5200 5980 -5190 {
lab=#net34}
N 5820 -5350 5820 -5330 {
lab=vcom}
N 5860 -5350 5860 -5330 {
lab=ctop}
N 5740 -5250 5760 -5250 {
lab=col_n[16]}
N 5740 -5230 5760 -5230 {
lab=colon_n[16]}
N 5740 -5210 5760 -5210 {
lab=#net33}
N 5740 -5190 5760 -5190 {
lab=#net34}
N 5980 -5190 6000 -5190 {
lab=#net34}
N 5980 -5210 6000 -5210 {
lab=#net33}
N 5980 -5230 6000 -5230 {
lab=colon_n[16]}
N 5980 -5250 6000 -5250 {
lab=col_n[16]}
N 5800 -5110 5800 -5100 {
lab=VSS}
N 5800 -5340 5800 -5330 {
lab=VDD}
N 6140 -5110 6150 -5120 {
lab=row_n[19]}
N 6150 -5320 6150 -5120 {
lab=row_n[19]}
N 6140 -5330 6150 -5320 {
lab=row_n[19]}
N 6140 -5110 6140 -5090 {
lab=row_n[19]}
N 6140 -5350 6140 -5330 {
lab=row_n[19]}
N 6020 -5250 6030 -5260 {
lab=col_n[16]}
N 6030 -5260 6230 -5260 {
lab=col_n[16]}
N 6230 -5260 6240 -5250 {
lab=col_n[16]}
N 6020 -5230 6030 -5240 {
lab=colon_n[16]}
N 6030 -5240 6230 -5240 {
lab=colon_n[16]}
N 6230 -5240 6240 -5230 {
lab=colon_n[16]}
N 6020 -5210 6030 -5220 {
lab=#net33}
N 6030 -5220 6230 -5220 {
lab=#net33}
N 6230 -5220 6240 -5210 {
lab=#net33}
N 6020 -5190 6030 -5200 {
lab=#net34}
N 6030 -5200 6230 -5200 {
lab=#net34}
N 6230 -5200 6240 -5190 {
lab=#net34}
N 6080 -5350 6080 -5330 {
lab=vcom}
N 6120 -5350 6120 -5330 {
lab=ctop}
N 6000 -5250 6020 -5250 {
lab=col_n[16]}
N 6000 -5230 6020 -5230 {
lab=colon_n[16]}
N 6000 -5210 6020 -5210 {
lab=#net33}
N 6000 -5190 6020 -5190 {
lab=#net34}
N 6240 -5190 6260 -5190 {
lab=#net34}
N 6240 -5210 6260 -5210 {
lab=#net33}
N 6240 -5230 6260 -5230 {
lab=colon_n[16]}
N 6240 -5250 6260 -5250 {
lab=col_n[16]}
N 6060 -5110 6060 -5100 {
lab=VSS}
N 6060 -5340 6060 -5330 {
lab=VDD}
N 6400 -5110 6410 -5120 {
lab=row_n[20]}
N 6410 -5320 6410 -5120 {
lab=row_n[20]}
N 6400 -5330 6410 -5320 {
lab=row_n[20]}
N 6400 -5110 6400 -5090 {
lab=row_n[20]}
N 6400 -5350 6400 -5330 {
lab=row_n[20]}
N 6280 -5250 6290 -5260 {
lab=col_n[16]}
N 6290 -5260 6490 -5260 {
lab=col_n[16]}
N 6490 -5260 6500 -5250 {
lab=col_n[16]}
N 6280 -5230 6290 -5240 {
lab=colon_n[16]}
N 6290 -5240 6490 -5240 {
lab=colon_n[16]}
N 6490 -5240 6500 -5230 {
lab=colon_n[16]}
N 6280 -5210 6290 -5220 {
lab=#net33}
N 6290 -5220 6490 -5220 {
lab=#net33}
N 6490 -5220 6500 -5210 {
lab=#net33}
N 6280 -5190 6290 -5200 {
lab=#net34}
N 6290 -5200 6490 -5200 {
lab=#net34}
N 6490 -5200 6500 -5190 {
lab=#net34}
N 6340 -5350 6340 -5330 {
lab=vcom}
N 6380 -5350 6380 -5330 {
lab=ctop}
N 6260 -5250 6280 -5250 {
lab=col_n[16]}
N 6260 -5230 6280 -5230 {
lab=colon_n[16]}
N 6260 -5210 6280 -5210 {
lab=#net33}
N 6260 -5190 6280 -5190 {
lab=#net34}
N 6500 -5190 6520 -5190 {
lab=#net34}
N 6500 -5210 6520 -5210 {
lab=#net33}
N 6500 -5230 6520 -5230 {
lab=colon_n[16]}
N 6500 -5250 6520 -5250 {
lab=col_n[16]}
N 6320 -5110 6320 -5100 {
lab=VSS}
N 6320 -5340 6320 -5330 {
lab=VDD}
N 6660 -5110 6670 -5120 {
lab=row_n[21]}
N 6670 -5320 6670 -5120 {
lab=row_n[21]}
N 6660 -5330 6670 -5320 {
lab=row_n[21]}
N 6660 -5110 6660 -5090 {
lab=row_n[21]}
N 6660 -5350 6660 -5330 {
lab=row_n[21]}
N 6540 -5250 6550 -5260 {
lab=col_n[16]}
N 6550 -5260 6750 -5260 {
lab=col_n[16]}
N 6750 -5260 6760 -5250 {
lab=col_n[16]}
N 6540 -5230 6550 -5240 {
lab=colon_n[16]}
N 6550 -5240 6750 -5240 {
lab=colon_n[16]}
N 6750 -5240 6760 -5230 {
lab=colon_n[16]}
N 6540 -5210 6550 -5220 {
lab=#net33}
N 6550 -5220 6750 -5220 {
lab=#net33}
N 6750 -5220 6760 -5210 {
lab=#net33}
N 6540 -5190 6550 -5200 {
lab=#net34}
N 6550 -5200 6750 -5200 {
lab=#net34}
N 6750 -5200 6760 -5190 {
lab=#net34}
N 6600 -5350 6600 -5330 {
lab=vcom}
N 6640 -5350 6640 -5330 {
lab=ctop}
N 6520 -5250 6540 -5250 {
lab=col_n[16]}
N 6520 -5230 6540 -5230 {
lab=colon_n[16]}
N 6520 -5210 6540 -5210 {
lab=#net33}
N 6520 -5190 6540 -5190 {
lab=#net34}
N 6760 -5190 6780 -5190 {
lab=#net34}
N 6760 -5210 6780 -5210 {
lab=#net33}
N 6760 -5230 6780 -5230 {
lab=colon_n[16]}
N 6760 -5250 6780 -5250 {
lab=col_n[16]}
N 6580 -5110 6580 -5100 {
lab=VSS}
N 6580 -5340 6580 -5330 {
lab=VDD}
N 6920 -5110 6930 -5120 {
lab=row_n[22]}
N 6930 -5320 6930 -5120 {
lab=row_n[22]}
N 6920 -5330 6930 -5320 {
lab=row_n[22]}
N 6920 -5110 6920 -5090 {
lab=row_n[22]}
N 6920 -5350 6920 -5330 {
lab=row_n[22]}
N 6800 -5250 6810 -5260 {
lab=col_n[16]}
N 6810 -5260 7010 -5260 {
lab=col_n[16]}
N 7010 -5260 7020 -5250 {
lab=col_n[16]}
N 6800 -5230 6810 -5240 {
lab=colon_n[16]}
N 6810 -5240 7010 -5240 {
lab=colon_n[16]}
N 7010 -5240 7020 -5230 {
lab=colon_n[16]}
N 6800 -5210 6810 -5220 {
lab=#net33}
N 6810 -5220 7010 -5220 {
lab=#net33}
N 7010 -5220 7020 -5210 {
lab=#net33}
N 6800 -5190 6810 -5200 {
lab=#net34}
N 6810 -5200 7010 -5200 {
lab=#net34}
N 7010 -5200 7020 -5190 {
lab=#net34}
N 6860 -5350 6860 -5330 {
lab=vcom}
N 6900 -5350 6900 -5330 {
lab=ctop}
N 6780 -5250 6800 -5250 {
lab=col_n[16]}
N 6780 -5230 6800 -5230 {
lab=colon_n[16]}
N 6780 -5210 6800 -5210 {
lab=#net33}
N 6780 -5190 6800 -5190 {
lab=#net34}
N 7020 -5190 7040 -5190 {
lab=#net34}
N 7020 -5210 7040 -5210 {
lab=#net33}
N 7020 -5230 7040 -5230 {
lab=colon_n[16]}
N 7020 -5250 7040 -5250 {
lab=col_n[16]}
N 6840 -5110 6840 -5100 {
lab=VSS}
N 6840 -5340 6840 -5330 {
lab=VDD}
N 7180 -5110 7190 -5120 {
lab=row_n[23]}
N 7190 -5320 7190 -5120 {
lab=row_n[23]}
N 7180 -5330 7190 -5320 {
lab=row_n[23]}
N 7180 -5110 7180 -5090 {
lab=row_n[23]}
N 7180 -5350 7180 -5330 {
lab=row_n[23]}
N 7060 -5250 7070 -5260 {
lab=col_n[16]}
N 7070 -5260 7270 -5260 {
lab=col_n[16]}
N 7270 -5260 7280 -5250 {
lab=col_n[16]}
N 7060 -5230 7070 -5240 {
lab=colon_n[16]}
N 7070 -5240 7270 -5240 {
lab=colon_n[16]}
N 7270 -5240 7280 -5230 {
lab=colon_n[16]}
N 7060 -5210 7070 -5220 {
lab=#net33}
N 7070 -5220 7270 -5220 {
lab=#net33}
N 7270 -5220 7280 -5210 {
lab=#net33}
N 7060 -5190 7070 -5200 {
lab=#net34}
N 7070 -5200 7270 -5200 {
lab=#net34}
N 7270 -5200 7280 -5190 {
lab=#net34}
N 7120 -5350 7120 -5330 {
lab=vcom}
N 7160 -5350 7160 -5330 {
lab=ctop}
N 7040 -5250 7060 -5250 {
lab=col_n[16]}
N 7040 -5230 7060 -5230 {
lab=colon_n[16]}
N 7040 -5210 7060 -5210 {
lab=#net33}
N 7040 -5190 7060 -5190 {
lab=#net34}
N 7280 -5190 7300 -5190 {
lab=#net34}
N 7280 -5210 7300 -5210 {
lab=#net33}
N 7280 -5230 7300 -5230 {
lab=colon_n[16]}
N 7280 -5250 7300 -5250 {
lab=col_n[16]}
N 7100 -5110 7100 -5100 {
lab=VSS}
N 7100 -5340 7100 -5330 {
lab=VDD}
N 7440 -5110 7450 -5120 {
lab=row_n[24]}
N 7450 -5320 7450 -5120 {
lab=row_n[24]}
N 7440 -5330 7450 -5320 {
lab=row_n[24]}
N 7440 -5110 7440 -5090 {
lab=row_n[24]}
N 7440 -5350 7440 -5330 {
lab=row_n[24]}
N 7320 -5250 7330 -5260 {
lab=col_n[16]}
N 7330 -5260 7530 -5260 {
lab=col_n[16]}
N 7530 -5260 7540 -5250 {
lab=col_n[16]}
N 7320 -5230 7330 -5240 {
lab=colon_n[16]}
N 7330 -5240 7530 -5240 {
lab=colon_n[16]}
N 7530 -5240 7540 -5230 {
lab=colon_n[16]}
N 7320 -5210 7330 -5220 {
lab=#net33}
N 7330 -5220 7530 -5220 {
lab=#net33}
N 7530 -5220 7540 -5210 {
lab=#net33}
N 7320 -5190 7330 -5200 {
lab=#net34}
N 7330 -5200 7530 -5200 {
lab=#net34}
N 7530 -5200 7540 -5190 {
lab=#net34}
N 7380 -5350 7380 -5330 {
lab=vcom}
N 7420 -5350 7420 -5330 {
lab=ctop}
N 7300 -5250 7320 -5250 {
lab=col_n[16]}
N 7300 -5230 7320 -5230 {
lab=colon_n[16]}
N 7300 -5210 7320 -5210 {
lab=#net33}
N 7300 -5190 7320 -5190 {
lab=#net34}
N 7540 -5190 7560 -5190 {
lab=#net34}
N 7540 -5210 7560 -5210 {
lab=#net33}
N 7540 -5230 7560 -5230 {
lab=colon_n[16]}
N 7540 -5250 7560 -5250 {
lab=col_n[16]}
N 7360 -5110 7360 -5100 {
lab=VSS}
N 7360 -5340 7360 -5330 {
lab=VDD}
N 7700 -5110 7710 -5120 {
lab=row_n[25]}
N 7710 -5320 7710 -5120 {
lab=row_n[25]}
N 7700 -5330 7710 -5320 {
lab=row_n[25]}
N 7700 -5110 7700 -5090 {
lab=row_n[25]}
N 7700 -5350 7700 -5330 {
lab=row_n[25]}
N 7580 -5250 7590 -5260 {
lab=col_n[16]}
N 7590 -5260 7790 -5260 {
lab=col_n[16]}
N 7790 -5260 7800 -5250 {
lab=col_n[16]}
N 7580 -5230 7590 -5240 {
lab=colon_n[16]}
N 7590 -5240 7790 -5240 {
lab=colon_n[16]}
N 7790 -5240 7800 -5230 {
lab=colon_n[16]}
N 7580 -5210 7590 -5220 {
lab=#net33}
N 7590 -5220 7790 -5220 {
lab=#net33}
N 7790 -5220 7800 -5210 {
lab=#net33}
N 7580 -5190 7590 -5200 {
lab=#net34}
N 7590 -5200 7790 -5200 {
lab=#net34}
N 7790 -5200 7800 -5190 {
lab=#net34}
N 7640 -5350 7640 -5330 {
lab=vcom}
N 7680 -5350 7680 -5330 {
lab=ctop}
N 7560 -5250 7580 -5250 {
lab=col_n[16]}
N 7560 -5230 7580 -5230 {
lab=colon_n[16]}
N 7560 -5210 7580 -5210 {
lab=#net33}
N 7560 -5190 7580 -5190 {
lab=#net34}
N 7800 -5190 7820 -5190 {
lab=#net34}
N 7800 -5210 7820 -5210 {
lab=#net33}
N 7800 -5230 7820 -5230 {
lab=colon_n[16]}
N 7800 -5250 7820 -5250 {
lab=col_n[16]}
N 7620 -5110 7620 -5100 {
lab=VSS}
N 7620 -5340 7620 -5330 {
lab=VDD}
N 7960 -5110 7970 -5120 {
lab=row_n[26]}
N 7970 -5320 7970 -5120 {
lab=row_n[26]}
N 7960 -5330 7970 -5320 {
lab=row_n[26]}
N 7960 -5110 7960 -5090 {
lab=row_n[26]}
N 7960 -5350 7960 -5330 {
lab=row_n[26]}
N 7840 -5250 7850 -5260 {
lab=col_n[16]}
N 7850 -5260 8050 -5260 {
lab=col_n[16]}
N 8050 -5260 8060 -5250 {
lab=col_n[16]}
N 7840 -5230 7850 -5240 {
lab=colon_n[16]}
N 7850 -5240 8050 -5240 {
lab=colon_n[16]}
N 8050 -5240 8060 -5230 {
lab=colon_n[16]}
N 7840 -5210 7850 -5220 {
lab=#net33}
N 7850 -5220 8050 -5220 {
lab=#net33}
N 8050 -5220 8060 -5210 {
lab=#net33}
N 7840 -5190 7850 -5200 {
lab=#net34}
N 7850 -5200 8050 -5200 {
lab=#net34}
N 8050 -5200 8060 -5190 {
lab=#net34}
N 7900 -5350 7900 -5330 {
lab=vcom}
N 7940 -5350 7940 -5330 {
lab=ctop}
N 7820 -5250 7840 -5250 {
lab=col_n[16]}
N 7820 -5230 7840 -5230 {
lab=colon_n[16]}
N 7820 -5210 7840 -5210 {
lab=#net33}
N 7820 -5190 7840 -5190 {
lab=#net34}
N 8060 -5190 8080 -5190 {
lab=#net34}
N 8060 -5210 8080 -5210 {
lab=#net33}
N 8060 -5230 8080 -5230 {
lab=colon_n[16]}
N 8060 -5250 8080 -5250 {
lab=col_n[16]}
N 7880 -5110 7880 -5100 {
lab=VSS}
N 7880 -5340 7880 -5330 {
lab=VDD}
N 8220 -5110 8230 -5120 {
lab=row_n[27]}
N 8230 -5320 8230 -5120 {
lab=row_n[27]}
N 8220 -5330 8230 -5320 {
lab=row_n[27]}
N 8220 -5110 8220 -5090 {
lab=row_n[27]}
N 8220 -5350 8220 -5330 {
lab=row_n[27]}
N 8100 -5250 8110 -5260 {
lab=col_n[16]}
N 8110 -5260 8310 -5260 {
lab=col_n[16]}
N 8310 -5260 8320 -5250 {
lab=col_n[16]}
N 8100 -5230 8110 -5240 {
lab=colon_n[16]}
N 8110 -5240 8310 -5240 {
lab=colon_n[16]}
N 8310 -5240 8320 -5230 {
lab=colon_n[16]}
N 8100 -5210 8110 -5220 {
lab=#net33}
N 8110 -5220 8310 -5220 {
lab=#net33}
N 8310 -5220 8320 -5210 {
lab=#net33}
N 8100 -5190 8110 -5200 {
lab=#net34}
N 8110 -5200 8310 -5200 {
lab=#net34}
N 8310 -5200 8320 -5190 {
lab=#net34}
N 8160 -5350 8160 -5330 {
lab=vcom}
N 8200 -5350 8200 -5330 {
lab=ctop}
N 8080 -5250 8100 -5250 {
lab=col_n[16]}
N 8080 -5230 8100 -5230 {
lab=colon_n[16]}
N 8080 -5210 8100 -5210 {
lab=#net33}
N 8080 -5190 8100 -5190 {
lab=#net34}
N 8320 -5190 8340 -5190 {
lab=#net34}
N 8320 -5210 8340 -5210 {
lab=#net33}
N 8320 -5230 8340 -5230 {
lab=colon_n[16]}
N 8320 -5250 8340 -5250 {
lab=col_n[16]}
N 8140 -5110 8140 -5100 {
lab=VSS}
N 8140 -5340 8140 -5330 {
lab=VDD}
N 8480 -5110 8490 -5120 {
lab=row_n[28]}
N 8490 -5320 8490 -5120 {
lab=row_n[28]}
N 8480 -5330 8490 -5320 {
lab=row_n[28]}
N 8480 -5110 8480 -5090 {
lab=row_n[28]}
N 8480 -5350 8480 -5330 {
lab=row_n[28]}
N 8360 -5250 8370 -5260 {
lab=col_n[16]}
N 8370 -5260 8570 -5260 {
lab=col_n[16]}
N 8570 -5260 8580 -5250 {
lab=col_n[16]}
N 8360 -5230 8370 -5240 {
lab=colon_n[16]}
N 8370 -5240 8570 -5240 {
lab=colon_n[16]}
N 8570 -5240 8580 -5230 {
lab=colon_n[16]}
N 8360 -5210 8370 -5220 {
lab=#net33}
N 8370 -5220 8570 -5220 {
lab=#net33}
N 8570 -5220 8580 -5210 {
lab=#net33}
N 8360 -5190 8370 -5200 {
lab=#net34}
N 8370 -5200 8570 -5200 {
lab=#net34}
N 8570 -5200 8580 -5190 {
lab=#net34}
N 8420 -5350 8420 -5330 {
lab=vcom}
N 8460 -5350 8460 -5330 {
lab=ctop}
N 8340 -5250 8360 -5250 {
lab=col_n[16]}
N 8340 -5230 8360 -5230 {
lab=colon_n[16]}
N 8340 -5210 8360 -5210 {
lab=#net33}
N 8340 -5190 8360 -5190 {
lab=#net34}
N 8580 -5190 8600 -5190 {
lab=#net34}
N 8580 -5210 8600 -5210 {
lab=#net33}
N 8580 -5230 8600 -5230 {
lab=colon_n[16]}
N 8580 -5250 8600 -5250 {
lab=col_n[16]}
N 8400 -5110 8400 -5100 {
lab=VSS}
N 8400 -5340 8400 -5330 {
lab=VDD}
N 8740 -5110 8750 -5120 {
lab=row_n[29]}
N 8750 -5320 8750 -5120 {
lab=row_n[29]}
N 8740 -5330 8750 -5320 {
lab=row_n[29]}
N 8740 -5110 8740 -5090 {
lab=row_n[29]}
N 8740 -5350 8740 -5330 {
lab=row_n[29]}
N 8620 -5250 8630 -5260 {
lab=col_n[16]}
N 8630 -5260 8830 -5260 {
lab=col_n[16]}
N 8830 -5260 8840 -5250 {
lab=col_n[16]}
N 8620 -5230 8630 -5240 {
lab=colon_n[16]}
N 8630 -5240 8830 -5240 {
lab=colon_n[16]}
N 8830 -5240 8840 -5230 {
lab=colon_n[16]}
N 8620 -5210 8630 -5220 {
lab=#net33}
N 8630 -5220 8830 -5220 {
lab=#net33}
N 8830 -5220 8840 -5210 {
lab=#net33}
N 8620 -5190 8630 -5200 {
lab=#net34}
N 8630 -5200 8830 -5200 {
lab=#net34}
N 8830 -5200 8840 -5190 {
lab=#net34}
N 8680 -5350 8680 -5330 {
lab=vcom}
N 8720 -5350 8720 -5330 {
lab=ctop}
N 8600 -5250 8620 -5250 {
lab=col_n[16]}
N 8600 -5230 8620 -5230 {
lab=colon_n[16]}
N 8600 -5210 8620 -5210 {
lab=#net33}
N 8600 -5190 8620 -5190 {
lab=#net34}
N 8840 -5190 8860 -5190 {
lab=#net34}
N 8840 -5210 8860 -5210 {
lab=#net33}
N 8840 -5230 8860 -5230 {
lab=colon_n[16]}
N 8840 -5250 8860 -5250 {
lab=col_n[16]}
N 8660 -5110 8660 -5100 {
lab=VSS}
N 8660 -5340 8660 -5330 {
lab=VDD}
N 9000 -5110 9010 -5120 {
lab=row_n[30]}
N 9010 -5320 9010 -5120 {
lab=row_n[30]}
N 9000 -5330 9010 -5320 {
lab=row_n[30]}
N 9000 -5110 9000 -5090 {
lab=row_n[30]}
N 9000 -5350 9000 -5330 {
lab=row_n[30]}
N 8880 -5250 8890 -5260 {
lab=col_n[16]}
N 8890 -5260 9090 -5260 {
lab=col_n[16]}
N 9090 -5260 9100 -5250 {
lab=col_n[16]}
N 8880 -5230 8890 -5240 {
lab=colon_n[16]}
N 8890 -5240 9090 -5240 {
lab=colon_n[16]}
N 9090 -5240 9100 -5230 {
lab=colon_n[16]}
N 8880 -5210 8890 -5220 {
lab=#net33}
N 8890 -5220 9090 -5220 {
lab=#net33}
N 9090 -5220 9100 -5210 {
lab=#net33}
N 8880 -5190 8890 -5200 {
lab=#net34}
N 8890 -5200 9090 -5200 {
lab=#net34}
N 9090 -5200 9100 -5190 {
lab=#net34}
N 8940 -5350 8940 -5330 {
lab=vcom}
N 8980 -5350 8980 -5330 {
lab=ctop}
N 8860 -5250 8880 -5250 {
lab=col_n[16]}
N 8860 -5230 8880 -5230 {
lab=colon_n[16]}
N 8860 -5210 8880 -5210 {
lab=#net33}
N 8860 -5190 8880 -5190 {
lab=#net34}
N 9100 -5190 9120 -5190 {
lab=#net34}
N 9100 -5210 9120 -5210 {
lab=#net33}
N 9100 -5230 9120 -5230 {
lab=colon_n[16]}
N 9100 -5250 9120 -5250 {
lab=col_n[16]}
N 8920 -5110 8920 -5100 {
lab=VSS}
N 8920 -5340 8920 -5330 {
lab=VDD}
N 9260 -5110 9270 -5120 {
lab=row_n[31]}
N 9270 -5320 9270 -5120 {
lab=row_n[31]}
N 9260 -5330 9270 -5320 {
lab=row_n[31]}
N 9260 -5110 9260 -5090 {
lab=row_n[31]}
N 9260 -5350 9260 -5330 {
lab=row_n[31]}
N 9140 -5250 9150 -5260 {
lab=col_n[16]}
N 9150 -5260 9350 -5260 {
lab=col_n[16]}
N 9350 -5260 9360 -5250 {
lab=col_n[16]}
N 9140 -5230 9150 -5240 {
lab=colon_n[16]}
N 9150 -5240 9350 -5240 {
lab=colon_n[16]}
N 9350 -5240 9360 -5230 {
lab=colon_n[16]}
N 9140 -5210 9150 -5220 {
lab=#net33}
N 9150 -5220 9350 -5220 {
lab=#net33}
N 9350 -5220 9360 -5210 {
lab=#net33}
N 9140 -5190 9150 -5200 {
lab=#net34}
N 9150 -5200 9350 -5200 {
lab=#net34}
N 9350 -5200 9360 -5190 {
lab=#net34}
N 9200 -5350 9200 -5330 {
lab=vcom}
N 9240 -5350 9240 -5330 {
lab=ctop}
N 9120 -5250 9140 -5250 {
lab=col_n[16]}
N 9120 -5230 9140 -5230 {
lab=colon_n[16]}
N 9120 -5210 9140 -5210 {
lab=#net33}
N 9120 -5190 9140 -5190 {
lab=#net34}
N 9360 -5190 9380 -5190 {
lab=#net34}
N 9360 -5210 9380 -5210 {
lab=#net33}
N 9360 -5230 9380 -5230 {
lab=colon_n[16]}
N 9360 -5250 9380 -5250 {
lab=col_n[16]}
N 9180 -5110 9180 -5100 {
lab=VSS}
N 9180 -5340 9180 -5330 {
lab=VDD}
N 1200 -5370 1210 -5380 {
lab=row_n[0]}
N 1210 -5580 1210 -5380 {
lab=row_n[0]}
N 1200 -5590 1210 -5580 {
lab=row_n[0]}
N 1200 -5370 1200 -5350 {
lab=row_n[0]}
N 1200 -5610 1200 -5590 {
lab=row_n[0]}
N 1080 -5510 1090 -5520 {
lab=col_n[17]}
N 1090 -5520 1290 -5520 {
lab=col_n[17]}
N 1290 -5520 1300 -5510 {
lab=col_n[17]}
N 1080 -5490 1090 -5500 {
lab=colon_n[17]}
N 1090 -5500 1290 -5500 {
lab=colon_n[17]}
N 1290 -5500 1300 -5490 {
lab=colon_n[17]}
N 1080 -5470 1090 -5480 {
lab=#net35}
N 1090 -5480 1290 -5480 {
lab=#net35}
N 1290 -5480 1300 -5470 {
lab=#net35}
N 1080 -5450 1090 -5460 {
lab=#net36}
N 1090 -5460 1290 -5460 {
lab=#net36}
N 1290 -5460 1300 -5450 {
lab=#net36}
N 1140 -5610 1140 -5590 {
lab=vcom}
N 1180 -5610 1180 -5590 {
lab=ctop}
N 1060 -5510 1080 -5510 {
lab=col_n[17]}
N 1060 -5490 1080 -5490 {
lab=colon_n[17]}
N 1060 -5470 1080 -5470 {
lab=#net35}
N 1060 -5450 1080 -5450 {
lab=#net36}
N 1300 -5450 1320 -5450 {
lab=#net36}
N 1300 -5470 1320 -5470 {
lab=#net35}
N 1300 -5490 1320 -5490 {
lab=colon_n[17]}
N 1300 -5510 1320 -5510 {
lab=col_n[17]}
N 1120 -5370 1120 -5360 {
lab=VSS}
N 1120 -5600 1120 -5590 {
lab=VDD}
N 1460 -5370 1470 -5380 {
lab=row_n[1]}
N 1470 -5580 1470 -5380 {
lab=row_n[1]}
N 1460 -5590 1470 -5580 {
lab=row_n[1]}
N 1460 -5370 1460 -5350 {
lab=row_n[1]}
N 1460 -5610 1460 -5590 {
lab=row_n[1]}
N 1340 -5510 1350 -5520 {
lab=col_n[17]}
N 1350 -5520 1550 -5520 {
lab=col_n[17]}
N 1550 -5520 1560 -5510 {
lab=col_n[17]}
N 1340 -5490 1350 -5500 {
lab=colon_n[17]}
N 1350 -5500 1550 -5500 {
lab=colon_n[17]}
N 1550 -5500 1560 -5490 {
lab=colon_n[17]}
N 1340 -5470 1350 -5480 {
lab=#net35}
N 1350 -5480 1550 -5480 {
lab=#net35}
N 1550 -5480 1560 -5470 {
lab=#net35}
N 1340 -5450 1350 -5460 {
lab=#net36}
N 1350 -5460 1550 -5460 {
lab=#net36}
N 1550 -5460 1560 -5450 {
lab=#net36}
N 1400 -5610 1400 -5590 {
lab=vcom}
N 1440 -5610 1440 -5590 {
lab=ctop}
N 1320 -5510 1340 -5510 {
lab=col_n[17]}
N 1320 -5490 1340 -5490 {
lab=colon_n[17]}
N 1320 -5470 1340 -5470 {
lab=#net35}
N 1320 -5450 1340 -5450 {
lab=#net36}
N 1560 -5450 1580 -5450 {
lab=#net36}
N 1560 -5470 1580 -5470 {
lab=#net35}
N 1560 -5490 1580 -5490 {
lab=colon_n[17]}
N 1560 -5510 1580 -5510 {
lab=col_n[17]}
N 1380 -5370 1380 -5360 {
lab=VSS}
N 1380 -5600 1380 -5590 {
lab=VDD}
N 1720 -5370 1730 -5380 {
lab=row_n[2]}
N 1730 -5580 1730 -5380 {
lab=row_n[2]}
N 1720 -5590 1730 -5580 {
lab=row_n[2]}
N 1720 -5370 1720 -5350 {
lab=row_n[2]}
N 1720 -5610 1720 -5590 {
lab=row_n[2]}
N 1600 -5510 1610 -5520 {
lab=col_n[17]}
N 1610 -5520 1810 -5520 {
lab=col_n[17]}
N 1810 -5520 1820 -5510 {
lab=col_n[17]}
N 1600 -5490 1610 -5500 {
lab=colon_n[17]}
N 1610 -5500 1810 -5500 {
lab=colon_n[17]}
N 1810 -5500 1820 -5490 {
lab=colon_n[17]}
N 1600 -5470 1610 -5480 {
lab=#net35}
N 1610 -5480 1810 -5480 {
lab=#net35}
N 1810 -5480 1820 -5470 {
lab=#net35}
N 1600 -5450 1610 -5460 {
lab=#net36}
N 1610 -5460 1810 -5460 {
lab=#net36}
N 1810 -5460 1820 -5450 {
lab=#net36}
N 1660 -5610 1660 -5590 {
lab=vcom}
N 1700 -5610 1700 -5590 {
lab=ctop}
N 1580 -5510 1600 -5510 {
lab=col_n[17]}
N 1580 -5490 1600 -5490 {
lab=colon_n[17]}
N 1580 -5470 1600 -5470 {
lab=#net35}
N 1580 -5450 1600 -5450 {
lab=#net36}
N 1820 -5450 1840 -5450 {
lab=#net36}
N 1820 -5470 1840 -5470 {
lab=#net35}
N 1820 -5490 1840 -5490 {
lab=colon_n[17]}
N 1820 -5510 1840 -5510 {
lab=col_n[17]}
N 1640 -5370 1640 -5360 {
lab=VSS}
N 1640 -5600 1640 -5590 {
lab=VDD}
N 1980 -5370 1990 -5380 {
lab=row_n[3]}
N 1990 -5580 1990 -5380 {
lab=row_n[3]}
N 1980 -5590 1990 -5580 {
lab=row_n[3]}
N 1980 -5370 1980 -5350 {
lab=row_n[3]}
N 1980 -5610 1980 -5590 {
lab=row_n[3]}
N 1860 -5510 1870 -5520 {
lab=col_n[17]}
N 1870 -5520 2070 -5520 {
lab=col_n[17]}
N 2070 -5520 2080 -5510 {
lab=col_n[17]}
N 1860 -5490 1870 -5500 {
lab=colon_n[17]}
N 1870 -5500 2070 -5500 {
lab=colon_n[17]}
N 2070 -5500 2080 -5490 {
lab=colon_n[17]}
N 1860 -5470 1870 -5480 {
lab=#net35}
N 1870 -5480 2070 -5480 {
lab=#net35}
N 2070 -5480 2080 -5470 {
lab=#net35}
N 1860 -5450 1870 -5460 {
lab=#net36}
N 1870 -5460 2070 -5460 {
lab=#net36}
N 2070 -5460 2080 -5450 {
lab=#net36}
N 1920 -5610 1920 -5590 {
lab=vcom}
N 1960 -5610 1960 -5590 {
lab=ctop}
N 1840 -5510 1860 -5510 {
lab=col_n[17]}
N 1840 -5490 1860 -5490 {
lab=colon_n[17]}
N 1840 -5470 1860 -5470 {
lab=#net35}
N 1840 -5450 1860 -5450 {
lab=#net36}
N 2080 -5450 2100 -5450 {
lab=#net36}
N 2080 -5470 2100 -5470 {
lab=#net35}
N 2080 -5490 2100 -5490 {
lab=colon_n[17]}
N 2080 -5510 2100 -5510 {
lab=col_n[17]}
N 1900 -5370 1900 -5360 {
lab=VSS}
N 1900 -5600 1900 -5590 {
lab=VDD}
N 2240 -5370 2250 -5380 {
lab=row_n[4]}
N 2250 -5580 2250 -5380 {
lab=row_n[4]}
N 2240 -5590 2250 -5580 {
lab=row_n[4]}
N 2240 -5370 2240 -5350 {
lab=row_n[4]}
N 2240 -5610 2240 -5590 {
lab=row_n[4]}
N 2120 -5510 2130 -5520 {
lab=col_n[17]}
N 2130 -5520 2330 -5520 {
lab=col_n[17]}
N 2330 -5520 2340 -5510 {
lab=col_n[17]}
N 2120 -5490 2130 -5500 {
lab=colon_n[17]}
N 2130 -5500 2330 -5500 {
lab=colon_n[17]}
N 2330 -5500 2340 -5490 {
lab=colon_n[17]}
N 2120 -5470 2130 -5480 {
lab=#net35}
N 2130 -5480 2330 -5480 {
lab=#net35}
N 2330 -5480 2340 -5470 {
lab=#net35}
N 2120 -5450 2130 -5460 {
lab=#net36}
N 2130 -5460 2330 -5460 {
lab=#net36}
N 2330 -5460 2340 -5450 {
lab=#net36}
N 2180 -5610 2180 -5590 {
lab=vcom}
N 2220 -5610 2220 -5590 {
lab=ctop}
N 2100 -5510 2120 -5510 {
lab=col_n[17]}
N 2100 -5490 2120 -5490 {
lab=colon_n[17]}
N 2100 -5470 2120 -5470 {
lab=#net35}
N 2100 -5450 2120 -5450 {
lab=#net36}
N 2340 -5450 2360 -5450 {
lab=#net36}
N 2340 -5470 2360 -5470 {
lab=#net35}
N 2340 -5490 2360 -5490 {
lab=colon_n[17]}
N 2340 -5510 2360 -5510 {
lab=col_n[17]}
N 2160 -5370 2160 -5360 {
lab=VSS}
N 2160 -5600 2160 -5590 {
lab=VDD}
N 2500 -5370 2510 -5380 {
lab=row_n[5]}
N 2510 -5580 2510 -5380 {
lab=row_n[5]}
N 2500 -5590 2510 -5580 {
lab=row_n[5]}
N 2500 -5370 2500 -5350 {
lab=row_n[5]}
N 2500 -5610 2500 -5590 {
lab=row_n[5]}
N 2380 -5510 2390 -5520 {
lab=col_n[17]}
N 2390 -5520 2590 -5520 {
lab=col_n[17]}
N 2590 -5520 2600 -5510 {
lab=col_n[17]}
N 2380 -5490 2390 -5500 {
lab=colon_n[17]}
N 2390 -5500 2590 -5500 {
lab=colon_n[17]}
N 2590 -5500 2600 -5490 {
lab=colon_n[17]}
N 2380 -5470 2390 -5480 {
lab=#net35}
N 2390 -5480 2590 -5480 {
lab=#net35}
N 2590 -5480 2600 -5470 {
lab=#net35}
N 2380 -5450 2390 -5460 {
lab=#net36}
N 2390 -5460 2590 -5460 {
lab=#net36}
N 2590 -5460 2600 -5450 {
lab=#net36}
N 2440 -5610 2440 -5590 {
lab=vcom}
N 2480 -5610 2480 -5590 {
lab=ctop}
N 2360 -5510 2380 -5510 {
lab=col_n[17]}
N 2360 -5490 2380 -5490 {
lab=colon_n[17]}
N 2360 -5470 2380 -5470 {
lab=#net35}
N 2360 -5450 2380 -5450 {
lab=#net36}
N 2600 -5450 2620 -5450 {
lab=#net36}
N 2600 -5470 2620 -5470 {
lab=#net35}
N 2600 -5490 2620 -5490 {
lab=colon_n[17]}
N 2600 -5510 2620 -5510 {
lab=col_n[17]}
N 2420 -5370 2420 -5360 {
lab=VSS}
N 2420 -5600 2420 -5590 {
lab=VDD}
N 2760 -5370 2770 -5380 {
lab=row_n[6]}
N 2770 -5580 2770 -5380 {
lab=row_n[6]}
N 2760 -5590 2770 -5580 {
lab=row_n[6]}
N 2760 -5370 2760 -5350 {
lab=row_n[6]}
N 2760 -5610 2760 -5590 {
lab=row_n[6]}
N 2640 -5510 2650 -5520 {
lab=col_n[17]}
N 2650 -5520 2850 -5520 {
lab=col_n[17]}
N 2850 -5520 2860 -5510 {
lab=col_n[17]}
N 2640 -5490 2650 -5500 {
lab=colon_n[17]}
N 2650 -5500 2850 -5500 {
lab=colon_n[17]}
N 2850 -5500 2860 -5490 {
lab=colon_n[17]}
N 2640 -5470 2650 -5480 {
lab=#net35}
N 2650 -5480 2850 -5480 {
lab=#net35}
N 2850 -5480 2860 -5470 {
lab=#net35}
N 2640 -5450 2650 -5460 {
lab=#net36}
N 2650 -5460 2850 -5460 {
lab=#net36}
N 2850 -5460 2860 -5450 {
lab=#net36}
N 2700 -5610 2700 -5590 {
lab=vcom}
N 2740 -5610 2740 -5590 {
lab=ctop}
N 2620 -5510 2640 -5510 {
lab=col_n[17]}
N 2620 -5490 2640 -5490 {
lab=colon_n[17]}
N 2620 -5470 2640 -5470 {
lab=#net35}
N 2620 -5450 2640 -5450 {
lab=#net36}
N 2860 -5450 2880 -5450 {
lab=#net36}
N 2860 -5470 2880 -5470 {
lab=#net35}
N 2860 -5490 2880 -5490 {
lab=colon_n[17]}
N 2860 -5510 2880 -5510 {
lab=col_n[17]}
N 2680 -5370 2680 -5360 {
lab=VSS}
N 2680 -5600 2680 -5590 {
lab=VDD}
N 3020 -5370 3030 -5380 {
lab=row_n[7]}
N 3030 -5580 3030 -5380 {
lab=row_n[7]}
N 3020 -5590 3030 -5580 {
lab=row_n[7]}
N 3020 -5370 3020 -5350 {
lab=row_n[7]}
N 3020 -5610 3020 -5590 {
lab=row_n[7]}
N 2900 -5510 2910 -5520 {
lab=col_n[17]}
N 2910 -5520 3110 -5520 {
lab=col_n[17]}
N 3110 -5520 3120 -5510 {
lab=col_n[17]}
N 2900 -5490 2910 -5500 {
lab=colon_n[17]}
N 2910 -5500 3110 -5500 {
lab=colon_n[17]}
N 3110 -5500 3120 -5490 {
lab=colon_n[17]}
N 2900 -5470 2910 -5480 {
lab=#net35}
N 2910 -5480 3110 -5480 {
lab=#net35}
N 3110 -5480 3120 -5470 {
lab=#net35}
N 2900 -5450 2910 -5460 {
lab=#net36}
N 2910 -5460 3110 -5460 {
lab=#net36}
N 3110 -5460 3120 -5450 {
lab=#net36}
N 2960 -5610 2960 -5590 {
lab=vcom}
N 3000 -5610 3000 -5590 {
lab=ctop}
N 2880 -5510 2900 -5510 {
lab=col_n[17]}
N 2880 -5490 2900 -5490 {
lab=colon_n[17]}
N 2880 -5470 2900 -5470 {
lab=#net35}
N 2880 -5450 2900 -5450 {
lab=#net36}
N 3120 -5450 3140 -5450 {
lab=#net36}
N 3120 -5470 3140 -5470 {
lab=#net35}
N 3120 -5490 3140 -5490 {
lab=colon_n[17]}
N 3120 -5510 3140 -5510 {
lab=col_n[17]}
N 2940 -5370 2940 -5360 {
lab=VSS}
N 2940 -5600 2940 -5590 {
lab=VDD}
N 3280 -5370 3290 -5380 {
lab=row_n[8]}
N 3290 -5580 3290 -5380 {
lab=row_n[8]}
N 3280 -5590 3290 -5580 {
lab=row_n[8]}
N 3280 -5370 3280 -5350 {
lab=row_n[8]}
N 3280 -5610 3280 -5590 {
lab=row_n[8]}
N 3160 -5510 3170 -5520 {
lab=col_n[17]}
N 3170 -5520 3370 -5520 {
lab=col_n[17]}
N 3370 -5520 3380 -5510 {
lab=col_n[17]}
N 3160 -5490 3170 -5500 {
lab=colon_n[17]}
N 3170 -5500 3370 -5500 {
lab=colon_n[17]}
N 3370 -5500 3380 -5490 {
lab=colon_n[17]}
N 3160 -5470 3170 -5480 {
lab=#net35}
N 3170 -5480 3370 -5480 {
lab=#net35}
N 3370 -5480 3380 -5470 {
lab=#net35}
N 3160 -5450 3170 -5460 {
lab=#net36}
N 3170 -5460 3370 -5460 {
lab=#net36}
N 3370 -5460 3380 -5450 {
lab=#net36}
N 3220 -5610 3220 -5590 {
lab=vcom}
N 3260 -5610 3260 -5590 {
lab=ctop}
N 3140 -5510 3160 -5510 {
lab=col_n[17]}
N 3140 -5490 3160 -5490 {
lab=colon_n[17]}
N 3140 -5470 3160 -5470 {
lab=#net35}
N 3140 -5450 3160 -5450 {
lab=#net36}
N 3380 -5450 3400 -5450 {
lab=#net36}
N 3380 -5470 3400 -5470 {
lab=#net35}
N 3380 -5490 3400 -5490 {
lab=colon_n[17]}
N 3380 -5510 3400 -5510 {
lab=col_n[17]}
N 3200 -5370 3200 -5360 {
lab=VSS}
N 3200 -5600 3200 -5590 {
lab=VDD}
N 3540 -5370 3550 -5380 {
lab=row_n[9]}
N 3550 -5580 3550 -5380 {
lab=row_n[9]}
N 3540 -5590 3550 -5580 {
lab=row_n[9]}
N 3540 -5370 3540 -5350 {
lab=row_n[9]}
N 3540 -5610 3540 -5590 {
lab=row_n[9]}
N 3420 -5510 3430 -5520 {
lab=col_n[17]}
N 3430 -5520 3630 -5520 {
lab=col_n[17]}
N 3630 -5520 3640 -5510 {
lab=col_n[17]}
N 3420 -5490 3430 -5500 {
lab=colon_n[17]}
N 3430 -5500 3630 -5500 {
lab=colon_n[17]}
N 3630 -5500 3640 -5490 {
lab=colon_n[17]}
N 3420 -5470 3430 -5480 {
lab=#net35}
N 3430 -5480 3630 -5480 {
lab=#net35}
N 3630 -5480 3640 -5470 {
lab=#net35}
N 3420 -5450 3430 -5460 {
lab=#net36}
N 3430 -5460 3630 -5460 {
lab=#net36}
N 3630 -5460 3640 -5450 {
lab=#net36}
N 3480 -5610 3480 -5590 {
lab=vcom}
N 3520 -5610 3520 -5590 {
lab=ctop}
N 3400 -5510 3420 -5510 {
lab=col_n[17]}
N 3400 -5490 3420 -5490 {
lab=colon_n[17]}
N 3400 -5470 3420 -5470 {
lab=#net35}
N 3400 -5450 3420 -5450 {
lab=#net36}
N 3640 -5450 3660 -5450 {
lab=#net36}
N 3640 -5470 3660 -5470 {
lab=#net35}
N 3640 -5490 3660 -5490 {
lab=colon_n[17]}
N 3640 -5510 3660 -5510 {
lab=col_n[17]}
N 3460 -5370 3460 -5360 {
lab=VSS}
N 3460 -5600 3460 -5590 {
lab=VDD}
N 3800 -5370 3810 -5380 {
lab=row_n[10]}
N 3810 -5580 3810 -5380 {
lab=row_n[10]}
N 3800 -5590 3810 -5580 {
lab=row_n[10]}
N 3800 -5370 3800 -5350 {
lab=row_n[10]}
N 3800 -5610 3800 -5590 {
lab=row_n[10]}
N 3680 -5510 3690 -5520 {
lab=col_n[17]}
N 3690 -5520 3890 -5520 {
lab=col_n[17]}
N 3890 -5520 3900 -5510 {
lab=col_n[17]}
N 3680 -5490 3690 -5500 {
lab=colon_n[17]}
N 3690 -5500 3890 -5500 {
lab=colon_n[17]}
N 3890 -5500 3900 -5490 {
lab=colon_n[17]}
N 3680 -5470 3690 -5480 {
lab=#net35}
N 3690 -5480 3890 -5480 {
lab=#net35}
N 3890 -5480 3900 -5470 {
lab=#net35}
N 3680 -5450 3690 -5460 {
lab=#net36}
N 3690 -5460 3890 -5460 {
lab=#net36}
N 3890 -5460 3900 -5450 {
lab=#net36}
N 3740 -5610 3740 -5590 {
lab=vcom}
N 3780 -5610 3780 -5590 {
lab=ctop}
N 3660 -5510 3680 -5510 {
lab=col_n[17]}
N 3660 -5490 3680 -5490 {
lab=colon_n[17]}
N 3660 -5470 3680 -5470 {
lab=#net35}
N 3660 -5450 3680 -5450 {
lab=#net36}
N 3900 -5450 3920 -5450 {
lab=#net36}
N 3900 -5470 3920 -5470 {
lab=#net35}
N 3900 -5490 3920 -5490 {
lab=colon_n[17]}
N 3900 -5510 3920 -5510 {
lab=col_n[17]}
N 3720 -5370 3720 -5360 {
lab=VSS}
N 3720 -5600 3720 -5590 {
lab=VDD}
N 4060 -5370 4070 -5380 {
lab=row_n[11]}
N 4070 -5580 4070 -5380 {
lab=row_n[11]}
N 4060 -5590 4070 -5580 {
lab=row_n[11]}
N 4060 -5370 4060 -5350 {
lab=row_n[11]}
N 4060 -5610 4060 -5590 {
lab=row_n[11]}
N 3940 -5510 3950 -5520 {
lab=col_n[17]}
N 3950 -5520 4150 -5520 {
lab=col_n[17]}
N 4150 -5520 4160 -5510 {
lab=col_n[17]}
N 3940 -5490 3950 -5500 {
lab=colon_n[17]}
N 3950 -5500 4150 -5500 {
lab=colon_n[17]}
N 4150 -5500 4160 -5490 {
lab=colon_n[17]}
N 3940 -5470 3950 -5480 {
lab=#net35}
N 3950 -5480 4150 -5480 {
lab=#net35}
N 4150 -5480 4160 -5470 {
lab=#net35}
N 3940 -5450 3950 -5460 {
lab=#net36}
N 3950 -5460 4150 -5460 {
lab=#net36}
N 4150 -5460 4160 -5450 {
lab=#net36}
N 4000 -5610 4000 -5590 {
lab=vcom}
N 4040 -5610 4040 -5590 {
lab=ctop}
N 3920 -5510 3940 -5510 {
lab=col_n[17]}
N 3920 -5490 3940 -5490 {
lab=colon_n[17]}
N 3920 -5470 3940 -5470 {
lab=#net35}
N 3920 -5450 3940 -5450 {
lab=#net36}
N 4160 -5450 4180 -5450 {
lab=#net36}
N 4160 -5470 4180 -5470 {
lab=#net35}
N 4160 -5490 4180 -5490 {
lab=colon_n[17]}
N 4160 -5510 4180 -5510 {
lab=col_n[17]}
N 3980 -5370 3980 -5360 {
lab=VSS}
N 3980 -5600 3980 -5590 {
lab=VDD}
N 4320 -5370 4330 -5380 {
lab=row_n[12]}
N 4330 -5580 4330 -5380 {
lab=row_n[12]}
N 4320 -5590 4330 -5580 {
lab=row_n[12]}
N 4320 -5370 4320 -5350 {
lab=row_n[12]}
N 4320 -5610 4320 -5590 {
lab=row_n[12]}
N 4200 -5510 4210 -5520 {
lab=col_n[17]}
N 4210 -5520 4410 -5520 {
lab=col_n[17]}
N 4410 -5520 4420 -5510 {
lab=col_n[17]}
N 4200 -5490 4210 -5500 {
lab=colon_n[17]}
N 4210 -5500 4410 -5500 {
lab=colon_n[17]}
N 4410 -5500 4420 -5490 {
lab=colon_n[17]}
N 4200 -5470 4210 -5480 {
lab=#net35}
N 4210 -5480 4410 -5480 {
lab=#net35}
N 4410 -5480 4420 -5470 {
lab=#net35}
N 4200 -5450 4210 -5460 {
lab=#net36}
N 4210 -5460 4410 -5460 {
lab=#net36}
N 4410 -5460 4420 -5450 {
lab=#net36}
N 4260 -5610 4260 -5590 {
lab=vcom}
N 4300 -5610 4300 -5590 {
lab=ctop}
N 4180 -5510 4200 -5510 {
lab=col_n[17]}
N 4180 -5490 4200 -5490 {
lab=colon_n[17]}
N 4180 -5470 4200 -5470 {
lab=#net35}
N 4180 -5450 4200 -5450 {
lab=#net36}
N 4420 -5450 4440 -5450 {
lab=#net36}
N 4420 -5470 4440 -5470 {
lab=#net35}
N 4420 -5490 4440 -5490 {
lab=colon_n[17]}
N 4420 -5510 4440 -5510 {
lab=col_n[17]}
N 4240 -5370 4240 -5360 {
lab=VSS}
N 4240 -5600 4240 -5590 {
lab=VDD}
N 4580 -5370 4590 -5380 {
lab=row_n[13]}
N 4590 -5580 4590 -5380 {
lab=row_n[13]}
N 4580 -5590 4590 -5580 {
lab=row_n[13]}
N 4580 -5370 4580 -5350 {
lab=row_n[13]}
N 4580 -5610 4580 -5590 {
lab=row_n[13]}
N 4460 -5510 4470 -5520 {
lab=col_n[17]}
N 4470 -5520 4670 -5520 {
lab=col_n[17]}
N 4670 -5520 4680 -5510 {
lab=col_n[17]}
N 4460 -5490 4470 -5500 {
lab=colon_n[17]}
N 4470 -5500 4670 -5500 {
lab=colon_n[17]}
N 4670 -5500 4680 -5490 {
lab=colon_n[17]}
N 4460 -5470 4470 -5480 {
lab=#net35}
N 4470 -5480 4670 -5480 {
lab=#net35}
N 4670 -5480 4680 -5470 {
lab=#net35}
N 4460 -5450 4470 -5460 {
lab=#net36}
N 4470 -5460 4670 -5460 {
lab=#net36}
N 4670 -5460 4680 -5450 {
lab=#net36}
N 4520 -5610 4520 -5590 {
lab=vcom}
N 4560 -5610 4560 -5590 {
lab=ctop}
N 4440 -5510 4460 -5510 {
lab=col_n[17]}
N 4440 -5490 4460 -5490 {
lab=colon_n[17]}
N 4440 -5470 4460 -5470 {
lab=#net35}
N 4440 -5450 4460 -5450 {
lab=#net36}
N 4680 -5450 4700 -5450 {
lab=#net36}
N 4680 -5470 4700 -5470 {
lab=#net35}
N 4680 -5490 4700 -5490 {
lab=colon_n[17]}
N 4680 -5510 4700 -5510 {
lab=col_n[17]}
N 4500 -5370 4500 -5360 {
lab=VSS}
N 4500 -5600 4500 -5590 {
lab=VDD}
N 4840 -5370 4850 -5380 {
lab=row_n[14]}
N 4850 -5580 4850 -5380 {
lab=row_n[14]}
N 4840 -5590 4850 -5580 {
lab=row_n[14]}
N 4840 -5370 4840 -5350 {
lab=row_n[14]}
N 4840 -5610 4840 -5590 {
lab=row_n[14]}
N 4720 -5510 4730 -5520 {
lab=col_n[17]}
N 4730 -5520 4930 -5520 {
lab=col_n[17]}
N 4930 -5520 4940 -5510 {
lab=col_n[17]}
N 4720 -5490 4730 -5500 {
lab=colon_n[17]}
N 4730 -5500 4930 -5500 {
lab=colon_n[17]}
N 4930 -5500 4940 -5490 {
lab=colon_n[17]}
N 4720 -5470 4730 -5480 {
lab=#net35}
N 4730 -5480 4930 -5480 {
lab=#net35}
N 4930 -5480 4940 -5470 {
lab=#net35}
N 4720 -5450 4730 -5460 {
lab=#net36}
N 4730 -5460 4930 -5460 {
lab=#net36}
N 4930 -5460 4940 -5450 {
lab=#net36}
N 4780 -5610 4780 -5590 {
lab=vcom}
N 4820 -5610 4820 -5590 {
lab=ctop}
N 4700 -5510 4720 -5510 {
lab=col_n[17]}
N 4700 -5490 4720 -5490 {
lab=colon_n[17]}
N 4700 -5470 4720 -5470 {
lab=#net35}
N 4700 -5450 4720 -5450 {
lab=#net36}
N 4940 -5450 4960 -5450 {
lab=#net36}
N 4940 -5470 4960 -5470 {
lab=#net35}
N 4940 -5490 4960 -5490 {
lab=colon_n[17]}
N 4940 -5510 4960 -5510 {
lab=col_n[17]}
N 4760 -5370 4760 -5360 {
lab=VSS}
N 4760 -5600 4760 -5590 {
lab=VDD}
N 5100 -5370 5110 -5380 {
lab=row_n[15]}
N 5110 -5580 5110 -5380 {
lab=row_n[15]}
N 5100 -5590 5110 -5580 {
lab=row_n[15]}
N 5100 -5370 5100 -5350 {
lab=row_n[15]}
N 5100 -5610 5100 -5590 {
lab=row_n[15]}
N 4980 -5510 4990 -5520 {
lab=col_n[17]}
N 4990 -5520 5190 -5520 {
lab=col_n[17]}
N 5190 -5520 5200 -5510 {
lab=col_n[17]}
N 4980 -5490 4990 -5500 {
lab=colon_n[17]}
N 4990 -5500 5190 -5500 {
lab=colon_n[17]}
N 5190 -5500 5200 -5490 {
lab=colon_n[17]}
N 4980 -5470 4990 -5480 {
lab=#net35}
N 4990 -5480 5190 -5480 {
lab=#net35}
N 5190 -5480 5200 -5470 {
lab=#net35}
N 4980 -5450 4990 -5460 {
lab=#net36}
N 4990 -5460 5190 -5460 {
lab=#net36}
N 5190 -5460 5200 -5450 {
lab=#net36}
N 5040 -5610 5040 -5590 {
lab=vcom}
N 5080 -5610 5080 -5590 {
lab=ctop}
N 4960 -5510 4980 -5510 {
lab=col_n[17]}
N 4960 -5490 4980 -5490 {
lab=colon_n[17]}
N 4960 -5470 4980 -5470 {
lab=#net35}
N 4960 -5450 4980 -5450 {
lab=#net36}
N 5200 -5450 5220 -5450 {
lab=#net36}
N 5200 -5470 5220 -5470 {
lab=#net35}
N 5200 -5490 5220 -5490 {
lab=colon_n[17]}
N 5200 -5510 5220 -5510 {
lab=col_n[17]}
N 5020 -5370 5020 -5360 {
lab=VSS}
N 5020 -5600 5020 -5590 {
lab=VDD}
N 5360 -5370 5370 -5380 {
lab=row_n[16]}
N 5370 -5580 5370 -5380 {
lab=row_n[16]}
N 5360 -5590 5370 -5580 {
lab=row_n[16]}
N 5360 -5370 5360 -5350 {
lab=row_n[16]}
N 5360 -5610 5360 -5590 {
lab=row_n[16]}
N 5240 -5510 5250 -5520 {
lab=col_n[17]}
N 5250 -5520 5450 -5520 {
lab=col_n[17]}
N 5450 -5520 5460 -5510 {
lab=col_n[17]}
N 5240 -5490 5250 -5500 {
lab=colon_n[17]}
N 5250 -5500 5450 -5500 {
lab=colon_n[17]}
N 5450 -5500 5460 -5490 {
lab=colon_n[17]}
N 5240 -5470 5250 -5480 {
lab=#net35}
N 5250 -5480 5450 -5480 {
lab=#net35}
N 5450 -5480 5460 -5470 {
lab=#net35}
N 5240 -5450 5250 -5460 {
lab=#net36}
N 5250 -5460 5450 -5460 {
lab=#net36}
N 5450 -5460 5460 -5450 {
lab=#net36}
N 5300 -5610 5300 -5590 {
lab=vcom}
N 5340 -5610 5340 -5590 {
lab=ctop}
N 5220 -5510 5240 -5510 {
lab=col_n[17]}
N 5220 -5490 5240 -5490 {
lab=colon_n[17]}
N 5220 -5470 5240 -5470 {
lab=#net35}
N 5220 -5450 5240 -5450 {
lab=#net36}
N 5460 -5450 5480 -5450 {
lab=#net36}
N 5460 -5470 5480 -5470 {
lab=#net35}
N 5460 -5490 5480 -5490 {
lab=colon_n[17]}
N 5460 -5510 5480 -5510 {
lab=col_n[17]}
N 5280 -5370 5280 -5360 {
lab=VSS}
N 5280 -5600 5280 -5590 {
lab=VDD}
N 5620 -5370 5630 -5380 {
lab=row_n[17]}
N 5630 -5580 5630 -5380 {
lab=row_n[17]}
N 5620 -5590 5630 -5580 {
lab=row_n[17]}
N 5620 -5370 5620 -5350 {
lab=row_n[17]}
N 5620 -5610 5620 -5590 {
lab=row_n[17]}
N 5500 -5510 5510 -5520 {
lab=col_n[17]}
N 5510 -5520 5710 -5520 {
lab=col_n[17]}
N 5710 -5520 5720 -5510 {
lab=col_n[17]}
N 5500 -5490 5510 -5500 {
lab=colon_n[17]}
N 5510 -5500 5710 -5500 {
lab=colon_n[17]}
N 5710 -5500 5720 -5490 {
lab=colon_n[17]}
N 5500 -5470 5510 -5480 {
lab=#net35}
N 5510 -5480 5710 -5480 {
lab=#net35}
N 5710 -5480 5720 -5470 {
lab=#net35}
N 5500 -5450 5510 -5460 {
lab=#net36}
N 5510 -5460 5710 -5460 {
lab=#net36}
N 5710 -5460 5720 -5450 {
lab=#net36}
N 5560 -5610 5560 -5590 {
lab=vcom}
N 5600 -5610 5600 -5590 {
lab=ctop}
N 5480 -5510 5500 -5510 {
lab=col_n[17]}
N 5480 -5490 5500 -5490 {
lab=colon_n[17]}
N 5480 -5470 5500 -5470 {
lab=#net35}
N 5480 -5450 5500 -5450 {
lab=#net36}
N 5720 -5450 5740 -5450 {
lab=#net36}
N 5720 -5470 5740 -5470 {
lab=#net35}
N 5720 -5490 5740 -5490 {
lab=colon_n[17]}
N 5720 -5510 5740 -5510 {
lab=col_n[17]}
N 5540 -5370 5540 -5360 {
lab=VSS}
N 5540 -5600 5540 -5590 {
lab=VDD}
N 5880 -5370 5890 -5380 {
lab=row_n[18]}
N 5890 -5580 5890 -5380 {
lab=row_n[18]}
N 5880 -5590 5890 -5580 {
lab=row_n[18]}
N 5880 -5370 5880 -5350 {
lab=row_n[18]}
N 5880 -5610 5880 -5590 {
lab=row_n[18]}
N 5760 -5510 5770 -5520 {
lab=col_n[17]}
N 5770 -5520 5970 -5520 {
lab=col_n[17]}
N 5970 -5520 5980 -5510 {
lab=col_n[17]}
N 5760 -5490 5770 -5500 {
lab=colon_n[17]}
N 5770 -5500 5970 -5500 {
lab=colon_n[17]}
N 5970 -5500 5980 -5490 {
lab=colon_n[17]}
N 5760 -5470 5770 -5480 {
lab=#net35}
N 5770 -5480 5970 -5480 {
lab=#net35}
N 5970 -5480 5980 -5470 {
lab=#net35}
N 5760 -5450 5770 -5460 {
lab=#net36}
N 5770 -5460 5970 -5460 {
lab=#net36}
N 5970 -5460 5980 -5450 {
lab=#net36}
N 5820 -5610 5820 -5590 {
lab=vcom}
N 5860 -5610 5860 -5590 {
lab=ctop}
N 5740 -5510 5760 -5510 {
lab=col_n[17]}
N 5740 -5490 5760 -5490 {
lab=colon_n[17]}
N 5740 -5470 5760 -5470 {
lab=#net35}
N 5740 -5450 5760 -5450 {
lab=#net36}
N 5980 -5450 6000 -5450 {
lab=#net36}
N 5980 -5470 6000 -5470 {
lab=#net35}
N 5980 -5490 6000 -5490 {
lab=colon_n[17]}
N 5980 -5510 6000 -5510 {
lab=col_n[17]}
N 5800 -5370 5800 -5360 {
lab=VSS}
N 5800 -5600 5800 -5590 {
lab=VDD}
N 6140 -5370 6150 -5380 {
lab=row_n[19]}
N 6150 -5580 6150 -5380 {
lab=row_n[19]}
N 6140 -5590 6150 -5580 {
lab=row_n[19]}
N 6140 -5370 6140 -5350 {
lab=row_n[19]}
N 6140 -5610 6140 -5590 {
lab=row_n[19]}
N 6020 -5510 6030 -5520 {
lab=col_n[17]}
N 6030 -5520 6230 -5520 {
lab=col_n[17]}
N 6230 -5520 6240 -5510 {
lab=col_n[17]}
N 6020 -5490 6030 -5500 {
lab=colon_n[17]}
N 6030 -5500 6230 -5500 {
lab=colon_n[17]}
N 6230 -5500 6240 -5490 {
lab=colon_n[17]}
N 6020 -5470 6030 -5480 {
lab=#net35}
N 6030 -5480 6230 -5480 {
lab=#net35}
N 6230 -5480 6240 -5470 {
lab=#net35}
N 6020 -5450 6030 -5460 {
lab=#net36}
N 6030 -5460 6230 -5460 {
lab=#net36}
N 6230 -5460 6240 -5450 {
lab=#net36}
N 6080 -5610 6080 -5590 {
lab=vcom}
N 6120 -5610 6120 -5590 {
lab=ctop}
N 6000 -5510 6020 -5510 {
lab=col_n[17]}
N 6000 -5490 6020 -5490 {
lab=colon_n[17]}
N 6000 -5470 6020 -5470 {
lab=#net35}
N 6000 -5450 6020 -5450 {
lab=#net36}
N 6240 -5450 6260 -5450 {
lab=#net36}
N 6240 -5470 6260 -5470 {
lab=#net35}
N 6240 -5490 6260 -5490 {
lab=colon_n[17]}
N 6240 -5510 6260 -5510 {
lab=col_n[17]}
N 6060 -5370 6060 -5360 {
lab=VSS}
N 6060 -5600 6060 -5590 {
lab=VDD}
N 6400 -5370 6410 -5380 {
lab=row_n[20]}
N 6410 -5580 6410 -5380 {
lab=row_n[20]}
N 6400 -5590 6410 -5580 {
lab=row_n[20]}
N 6400 -5370 6400 -5350 {
lab=row_n[20]}
N 6400 -5610 6400 -5590 {
lab=row_n[20]}
N 6280 -5510 6290 -5520 {
lab=col_n[17]}
N 6290 -5520 6490 -5520 {
lab=col_n[17]}
N 6490 -5520 6500 -5510 {
lab=col_n[17]}
N 6280 -5490 6290 -5500 {
lab=colon_n[17]}
N 6290 -5500 6490 -5500 {
lab=colon_n[17]}
N 6490 -5500 6500 -5490 {
lab=colon_n[17]}
N 6280 -5470 6290 -5480 {
lab=#net35}
N 6290 -5480 6490 -5480 {
lab=#net35}
N 6490 -5480 6500 -5470 {
lab=#net35}
N 6280 -5450 6290 -5460 {
lab=#net36}
N 6290 -5460 6490 -5460 {
lab=#net36}
N 6490 -5460 6500 -5450 {
lab=#net36}
N 6340 -5610 6340 -5590 {
lab=vcom}
N 6380 -5610 6380 -5590 {
lab=ctop}
N 6260 -5510 6280 -5510 {
lab=col_n[17]}
N 6260 -5490 6280 -5490 {
lab=colon_n[17]}
N 6260 -5470 6280 -5470 {
lab=#net35}
N 6260 -5450 6280 -5450 {
lab=#net36}
N 6500 -5450 6520 -5450 {
lab=#net36}
N 6500 -5470 6520 -5470 {
lab=#net35}
N 6500 -5490 6520 -5490 {
lab=colon_n[17]}
N 6500 -5510 6520 -5510 {
lab=col_n[17]}
N 6320 -5370 6320 -5360 {
lab=VSS}
N 6320 -5600 6320 -5590 {
lab=VDD}
N 6660 -5370 6670 -5380 {
lab=row_n[21]}
N 6670 -5580 6670 -5380 {
lab=row_n[21]}
N 6660 -5590 6670 -5580 {
lab=row_n[21]}
N 6660 -5370 6660 -5350 {
lab=row_n[21]}
N 6660 -5610 6660 -5590 {
lab=row_n[21]}
N 6540 -5510 6550 -5520 {
lab=col_n[17]}
N 6550 -5520 6750 -5520 {
lab=col_n[17]}
N 6750 -5520 6760 -5510 {
lab=col_n[17]}
N 6540 -5490 6550 -5500 {
lab=colon_n[17]}
N 6550 -5500 6750 -5500 {
lab=colon_n[17]}
N 6750 -5500 6760 -5490 {
lab=colon_n[17]}
N 6540 -5470 6550 -5480 {
lab=#net35}
N 6550 -5480 6750 -5480 {
lab=#net35}
N 6750 -5480 6760 -5470 {
lab=#net35}
N 6540 -5450 6550 -5460 {
lab=#net36}
N 6550 -5460 6750 -5460 {
lab=#net36}
N 6750 -5460 6760 -5450 {
lab=#net36}
N 6600 -5610 6600 -5590 {
lab=vcom}
N 6640 -5610 6640 -5590 {
lab=ctop}
N 6520 -5510 6540 -5510 {
lab=col_n[17]}
N 6520 -5490 6540 -5490 {
lab=colon_n[17]}
N 6520 -5470 6540 -5470 {
lab=#net35}
N 6520 -5450 6540 -5450 {
lab=#net36}
N 6760 -5450 6780 -5450 {
lab=#net36}
N 6760 -5470 6780 -5470 {
lab=#net35}
N 6760 -5490 6780 -5490 {
lab=colon_n[17]}
N 6760 -5510 6780 -5510 {
lab=col_n[17]}
N 6580 -5370 6580 -5360 {
lab=VSS}
N 6580 -5600 6580 -5590 {
lab=VDD}
N 6920 -5370 6930 -5380 {
lab=row_n[22]}
N 6930 -5580 6930 -5380 {
lab=row_n[22]}
N 6920 -5590 6930 -5580 {
lab=row_n[22]}
N 6920 -5370 6920 -5350 {
lab=row_n[22]}
N 6920 -5610 6920 -5590 {
lab=row_n[22]}
N 6800 -5510 6810 -5520 {
lab=col_n[17]}
N 6810 -5520 7010 -5520 {
lab=col_n[17]}
N 7010 -5520 7020 -5510 {
lab=col_n[17]}
N 6800 -5490 6810 -5500 {
lab=colon_n[17]}
N 6810 -5500 7010 -5500 {
lab=colon_n[17]}
N 7010 -5500 7020 -5490 {
lab=colon_n[17]}
N 6800 -5470 6810 -5480 {
lab=#net35}
N 6810 -5480 7010 -5480 {
lab=#net35}
N 7010 -5480 7020 -5470 {
lab=#net35}
N 6800 -5450 6810 -5460 {
lab=#net36}
N 6810 -5460 7010 -5460 {
lab=#net36}
N 7010 -5460 7020 -5450 {
lab=#net36}
N 6860 -5610 6860 -5590 {
lab=vcom}
N 6900 -5610 6900 -5590 {
lab=ctop}
N 6780 -5510 6800 -5510 {
lab=col_n[17]}
N 6780 -5490 6800 -5490 {
lab=colon_n[17]}
N 6780 -5470 6800 -5470 {
lab=#net35}
N 6780 -5450 6800 -5450 {
lab=#net36}
N 7020 -5450 7040 -5450 {
lab=#net36}
N 7020 -5470 7040 -5470 {
lab=#net35}
N 7020 -5490 7040 -5490 {
lab=colon_n[17]}
N 7020 -5510 7040 -5510 {
lab=col_n[17]}
N 6840 -5370 6840 -5360 {
lab=VSS}
N 6840 -5600 6840 -5590 {
lab=VDD}
N 7180 -5370 7190 -5380 {
lab=row_n[23]}
N 7190 -5580 7190 -5380 {
lab=row_n[23]}
N 7180 -5590 7190 -5580 {
lab=row_n[23]}
N 7180 -5370 7180 -5350 {
lab=row_n[23]}
N 7180 -5610 7180 -5590 {
lab=row_n[23]}
N 7060 -5510 7070 -5520 {
lab=col_n[17]}
N 7070 -5520 7270 -5520 {
lab=col_n[17]}
N 7270 -5520 7280 -5510 {
lab=col_n[17]}
N 7060 -5490 7070 -5500 {
lab=colon_n[17]}
N 7070 -5500 7270 -5500 {
lab=colon_n[17]}
N 7270 -5500 7280 -5490 {
lab=colon_n[17]}
N 7060 -5470 7070 -5480 {
lab=#net35}
N 7070 -5480 7270 -5480 {
lab=#net35}
N 7270 -5480 7280 -5470 {
lab=#net35}
N 7060 -5450 7070 -5460 {
lab=#net36}
N 7070 -5460 7270 -5460 {
lab=#net36}
N 7270 -5460 7280 -5450 {
lab=#net36}
N 7120 -5610 7120 -5590 {
lab=vcom}
N 7160 -5610 7160 -5590 {
lab=ctop}
N 7040 -5510 7060 -5510 {
lab=col_n[17]}
N 7040 -5490 7060 -5490 {
lab=colon_n[17]}
N 7040 -5470 7060 -5470 {
lab=#net35}
N 7040 -5450 7060 -5450 {
lab=#net36}
N 7280 -5450 7300 -5450 {
lab=#net36}
N 7280 -5470 7300 -5470 {
lab=#net35}
N 7280 -5490 7300 -5490 {
lab=colon_n[17]}
N 7280 -5510 7300 -5510 {
lab=col_n[17]}
N 7100 -5370 7100 -5360 {
lab=VSS}
N 7100 -5600 7100 -5590 {
lab=VDD}
N 7440 -5370 7450 -5380 {
lab=row_n[24]}
N 7450 -5580 7450 -5380 {
lab=row_n[24]}
N 7440 -5590 7450 -5580 {
lab=row_n[24]}
N 7440 -5370 7440 -5350 {
lab=row_n[24]}
N 7440 -5610 7440 -5590 {
lab=row_n[24]}
N 7320 -5510 7330 -5520 {
lab=col_n[17]}
N 7330 -5520 7530 -5520 {
lab=col_n[17]}
N 7530 -5520 7540 -5510 {
lab=col_n[17]}
N 7320 -5490 7330 -5500 {
lab=colon_n[17]}
N 7330 -5500 7530 -5500 {
lab=colon_n[17]}
N 7530 -5500 7540 -5490 {
lab=colon_n[17]}
N 7320 -5470 7330 -5480 {
lab=#net35}
N 7330 -5480 7530 -5480 {
lab=#net35}
N 7530 -5480 7540 -5470 {
lab=#net35}
N 7320 -5450 7330 -5460 {
lab=#net36}
N 7330 -5460 7530 -5460 {
lab=#net36}
N 7530 -5460 7540 -5450 {
lab=#net36}
N 7380 -5610 7380 -5590 {
lab=vcom}
N 7420 -5610 7420 -5590 {
lab=ctop}
N 7300 -5510 7320 -5510 {
lab=col_n[17]}
N 7300 -5490 7320 -5490 {
lab=colon_n[17]}
N 7300 -5470 7320 -5470 {
lab=#net35}
N 7300 -5450 7320 -5450 {
lab=#net36}
N 7540 -5450 7560 -5450 {
lab=#net36}
N 7540 -5470 7560 -5470 {
lab=#net35}
N 7540 -5490 7560 -5490 {
lab=colon_n[17]}
N 7540 -5510 7560 -5510 {
lab=col_n[17]}
N 7360 -5370 7360 -5360 {
lab=VSS}
N 7360 -5600 7360 -5590 {
lab=VDD}
N 7700 -5370 7710 -5380 {
lab=row_n[25]}
N 7710 -5580 7710 -5380 {
lab=row_n[25]}
N 7700 -5590 7710 -5580 {
lab=row_n[25]}
N 7700 -5370 7700 -5350 {
lab=row_n[25]}
N 7700 -5610 7700 -5590 {
lab=row_n[25]}
N 7580 -5510 7590 -5520 {
lab=col_n[17]}
N 7590 -5520 7790 -5520 {
lab=col_n[17]}
N 7790 -5520 7800 -5510 {
lab=col_n[17]}
N 7580 -5490 7590 -5500 {
lab=colon_n[17]}
N 7590 -5500 7790 -5500 {
lab=colon_n[17]}
N 7790 -5500 7800 -5490 {
lab=colon_n[17]}
N 7580 -5470 7590 -5480 {
lab=#net35}
N 7590 -5480 7790 -5480 {
lab=#net35}
N 7790 -5480 7800 -5470 {
lab=#net35}
N 7580 -5450 7590 -5460 {
lab=#net36}
N 7590 -5460 7790 -5460 {
lab=#net36}
N 7790 -5460 7800 -5450 {
lab=#net36}
N 7640 -5610 7640 -5590 {
lab=vcom}
N 7680 -5610 7680 -5590 {
lab=ctop}
N 7560 -5510 7580 -5510 {
lab=col_n[17]}
N 7560 -5490 7580 -5490 {
lab=colon_n[17]}
N 7560 -5470 7580 -5470 {
lab=#net35}
N 7560 -5450 7580 -5450 {
lab=#net36}
N 7800 -5450 7820 -5450 {
lab=#net36}
N 7800 -5470 7820 -5470 {
lab=#net35}
N 7800 -5490 7820 -5490 {
lab=colon_n[17]}
N 7800 -5510 7820 -5510 {
lab=col_n[17]}
N 7620 -5370 7620 -5360 {
lab=VSS}
N 7620 -5600 7620 -5590 {
lab=VDD}
N 7960 -5370 7970 -5380 {
lab=row_n[26]}
N 7970 -5580 7970 -5380 {
lab=row_n[26]}
N 7960 -5590 7970 -5580 {
lab=row_n[26]}
N 7960 -5370 7960 -5350 {
lab=row_n[26]}
N 7960 -5610 7960 -5590 {
lab=row_n[26]}
N 7840 -5510 7850 -5520 {
lab=col_n[17]}
N 7850 -5520 8050 -5520 {
lab=col_n[17]}
N 8050 -5520 8060 -5510 {
lab=col_n[17]}
N 7840 -5490 7850 -5500 {
lab=colon_n[17]}
N 7850 -5500 8050 -5500 {
lab=colon_n[17]}
N 8050 -5500 8060 -5490 {
lab=colon_n[17]}
N 7840 -5470 7850 -5480 {
lab=#net35}
N 7850 -5480 8050 -5480 {
lab=#net35}
N 8050 -5480 8060 -5470 {
lab=#net35}
N 7840 -5450 7850 -5460 {
lab=#net36}
N 7850 -5460 8050 -5460 {
lab=#net36}
N 8050 -5460 8060 -5450 {
lab=#net36}
N 7900 -5610 7900 -5590 {
lab=vcom}
N 7940 -5610 7940 -5590 {
lab=ctop}
N 7820 -5510 7840 -5510 {
lab=col_n[17]}
N 7820 -5490 7840 -5490 {
lab=colon_n[17]}
N 7820 -5470 7840 -5470 {
lab=#net35}
N 7820 -5450 7840 -5450 {
lab=#net36}
N 8060 -5450 8080 -5450 {
lab=#net36}
N 8060 -5470 8080 -5470 {
lab=#net35}
N 8060 -5490 8080 -5490 {
lab=colon_n[17]}
N 8060 -5510 8080 -5510 {
lab=col_n[17]}
N 7880 -5370 7880 -5360 {
lab=VSS}
N 7880 -5600 7880 -5590 {
lab=VDD}
N 8220 -5370 8230 -5380 {
lab=row_n[27]}
N 8230 -5580 8230 -5380 {
lab=row_n[27]}
N 8220 -5590 8230 -5580 {
lab=row_n[27]}
N 8220 -5370 8220 -5350 {
lab=row_n[27]}
N 8220 -5610 8220 -5590 {
lab=row_n[27]}
N 8100 -5510 8110 -5520 {
lab=col_n[17]}
N 8110 -5520 8310 -5520 {
lab=col_n[17]}
N 8310 -5520 8320 -5510 {
lab=col_n[17]}
N 8100 -5490 8110 -5500 {
lab=colon_n[17]}
N 8110 -5500 8310 -5500 {
lab=colon_n[17]}
N 8310 -5500 8320 -5490 {
lab=colon_n[17]}
N 8100 -5470 8110 -5480 {
lab=#net35}
N 8110 -5480 8310 -5480 {
lab=#net35}
N 8310 -5480 8320 -5470 {
lab=#net35}
N 8100 -5450 8110 -5460 {
lab=#net36}
N 8110 -5460 8310 -5460 {
lab=#net36}
N 8310 -5460 8320 -5450 {
lab=#net36}
N 8160 -5610 8160 -5590 {
lab=vcom}
N 8200 -5610 8200 -5590 {
lab=ctop}
N 8080 -5510 8100 -5510 {
lab=col_n[17]}
N 8080 -5490 8100 -5490 {
lab=colon_n[17]}
N 8080 -5470 8100 -5470 {
lab=#net35}
N 8080 -5450 8100 -5450 {
lab=#net36}
N 8320 -5450 8340 -5450 {
lab=#net36}
N 8320 -5470 8340 -5470 {
lab=#net35}
N 8320 -5490 8340 -5490 {
lab=colon_n[17]}
N 8320 -5510 8340 -5510 {
lab=col_n[17]}
N 8140 -5370 8140 -5360 {
lab=VSS}
N 8140 -5600 8140 -5590 {
lab=VDD}
N 8480 -5370 8490 -5380 {
lab=row_n[28]}
N 8490 -5580 8490 -5380 {
lab=row_n[28]}
N 8480 -5590 8490 -5580 {
lab=row_n[28]}
N 8480 -5370 8480 -5350 {
lab=row_n[28]}
N 8480 -5610 8480 -5590 {
lab=row_n[28]}
N 8360 -5510 8370 -5520 {
lab=col_n[17]}
N 8370 -5520 8570 -5520 {
lab=col_n[17]}
N 8570 -5520 8580 -5510 {
lab=col_n[17]}
N 8360 -5490 8370 -5500 {
lab=colon_n[17]}
N 8370 -5500 8570 -5500 {
lab=colon_n[17]}
N 8570 -5500 8580 -5490 {
lab=colon_n[17]}
N 8360 -5470 8370 -5480 {
lab=#net35}
N 8370 -5480 8570 -5480 {
lab=#net35}
N 8570 -5480 8580 -5470 {
lab=#net35}
N 8360 -5450 8370 -5460 {
lab=#net36}
N 8370 -5460 8570 -5460 {
lab=#net36}
N 8570 -5460 8580 -5450 {
lab=#net36}
N 8420 -5610 8420 -5590 {
lab=vcom}
N 8460 -5610 8460 -5590 {
lab=ctop}
N 8340 -5510 8360 -5510 {
lab=col_n[17]}
N 8340 -5490 8360 -5490 {
lab=colon_n[17]}
N 8340 -5470 8360 -5470 {
lab=#net35}
N 8340 -5450 8360 -5450 {
lab=#net36}
N 8580 -5450 8600 -5450 {
lab=#net36}
N 8580 -5470 8600 -5470 {
lab=#net35}
N 8580 -5490 8600 -5490 {
lab=colon_n[17]}
N 8580 -5510 8600 -5510 {
lab=col_n[17]}
N 8400 -5370 8400 -5360 {
lab=VSS}
N 8400 -5600 8400 -5590 {
lab=VDD}
N 8740 -5370 8750 -5380 {
lab=row_n[29]}
N 8750 -5580 8750 -5380 {
lab=row_n[29]}
N 8740 -5590 8750 -5580 {
lab=row_n[29]}
N 8740 -5370 8740 -5350 {
lab=row_n[29]}
N 8740 -5610 8740 -5590 {
lab=row_n[29]}
N 8620 -5510 8630 -5520 {
lab=col_n[17]}
N 8630 -5520 8830 -5520 {
lab=col_n[17]}
N 8830 -5520 8840 -5510 {
lab=col_n[17]}
N 8620 -5490 8630 -5500 {
lab=colon_n[17]}
N 8630 -5500 8830 -5500 {
lab=colon_n[17]}
N 8830 -5500 8840 -5490 {
lab=colon_n[17]}
N 8620 -5470 8630 -5480 {
lab=#net35}
N 8630 -5480 8830 -5480 {
lab=#net35}
N 8830 -5480 8840 -5470 {
lab=#net35}
N 8620 -5450 8630 -5460 {
lab=#net36}
N 8630 -5460 8830 -5460 {
lab=#net36}
N 8830 -5460 8840 -5450 {
lab=#net36}
N 8680 -5610 8680 -5590 {
lab=vcom}
N 8720 -5610 8720 -5590 {
lab=ctop}
N 8600 -5510 8620 -5510 {
lab=col_n[17]}
N 8600 -5490 8620 -5490 {
lab=colon_n[17]}
N 8600 -5470 8620 -5470 {
lab=#net35}
N 8600 -5450 8620 -5450 {
lab=#net36}
N 8840 -5450 8860 -5450 {
lab=#net36}
N 8840 -5470 8860 -5470 {
lab=#net35}
N 8840 -5490 8860 -5490 {
lab=colon_n[17]}
N 8840 -5510 8860 -5510 {
lab=col_n[17]}
N 8660 -5370 8660 -5360 {
lab=VSS}
N 8660 -5600 8660 -5590 {
lab=VDD}
N 9000 -5370 9010 -5380 {
lab=row_n[30]}
N 9010 -5580 9010 -5380 {
lab=row_n[30]}
N 9000 -5590 9010 -5580 {
lab=row_n[30]}
N 9000 -5370 9000 -5350 {
lab=row_n[30]}
N 9000 -5610 9000 -5590 {
lab=row_n[30]}
N 8880 -5510 8890 -5520 {
lab=col_n[17]}
N 8890 -5520 9090 -5520 {
lab=col_n[17]}
N 9090 -5520 9100 -5510 {
lab=col_n[17]}
N 8880 -5490 8890 -5500 {
lab=colon_n[17]}
N 8890 -5500 9090 -5500 {
lab=colon_n[17]}
N 9090 -5500 9100 -5490 {
lab=colon_n[17]}
N 8880 -5470 8890 -5480 {
lab=#net35}
N 8890 -5480 9090 -5480 {
lab=#net35}
N 9090 -5480 9100 -5470 {
lab=#net35}
N 8880 -5450 8890 -5460 {
lab=#net36}
N 8890 -5460 9090 -5460 {
lab=#net36}
N 9090 -5460 9100 -5450 {
lab=#net36}
N 8940 -5610 8940 -5590 {
lab=vcom}
N 8980 -5610 8980 -5590 {
lab=ctop}
N 8860 -5510 8880 -5510 {
lab=col_n[17]}
N 8860 -5490 8880 -5490 {
lab=colon_n[17]}
N 8860 -5470 8880 -5470 {
lab=#net35}
N 8860 -5450 8880 -5450 {
lab=#net36}
N 9100 -5450 9120 -5450 {
lab=#net36}
N 9100 -5470 9120 -5470 {
lab=#net35}
N 9100 -5490 9120 -5490 {
lab=colon_n[17]}
N 9100 -5510 9120 -5510 {
lab=col_n[17]}
N 8920 -5370 8920 -5360 {
lab=VSS}
N 8920 -5600 8920 -5590 {
lab=VDD}
N 9260 -5370 9270 -5380 {
lab=row_n[31]}
N 9270 -5580 9270 -5380 {
lab=row_n[31]}
N 9260 -5590 9270 -5580 {
lab=row_n[31]}
N 9260 -5370 9260 -5350 {
lab=row_n[31]}
N 9260 -5610 9260 -5590 {
lab=row_n[31]}
N 9140 -5510 9150 -5520 {
lab=col_n[17]}
N 9150 -5520 9350 -5520 {
lab=col_n[17]}
N 9350 -5520 9360 -5510 {
lab=col_n[17]}
N 9140 -5490 9150 -5500 {
lab=colon_n[17]}
N 9150 -5500 9350 -5500 {
lab=colon_n[17]}
N 9350 -5500 9360 -5490 {
lab=colon_n[17]}
N 9140 -5470 9150 -5480 {
lab=#net35}
N 9150 -5480 9350 -5480 {
lab=#net35}
N 9350 -5480 9360 -5470 {
lab=#net35}
N 9140 -5450 9150 -5460 {
lab=#net36}
N 9150 -5460 9350 -5460 {
lab=#net36}
N 9350 -5460 9360 -5450 {
lab=#net36}
N 9200 -5610 9200 -5590 {
lab=vcom}
N 9240 -5610 9240 -5590 {
lab=ctop}
N 9120 -5510 9140 -5510 {
lab=col_n[17]}
N 9120 -5490 9140 -5490 {
lab=colon_n[17]}
N 9120 -5470 9140 -5470 {
lab=#net35}
N 9120 -5450 9140 -5450 {
lab=#net36}
N 9360 -5450 9380 -5450 {
lab=#net36}
N 9360 -5470 9380 -5470 {
lab=#net35}
N 9360 -5490 9380 -5490 {
lab=colon_n[17]}
N 9360 -5510 9380 -5510 {
lab=col_n[17]}
N 9180 -5370 9180 -5360 {
lab=VSS}
N 9180 -5600 9180 -5590 {
lab=VDD}
N 1200 -5630 1210 -5640 {
lab=row_n[0]}
N 1210 -5840 1210 -5640 {
lab=row_n[0]}
N 1200 -5850 1210 -5840 {
lab=row_n[0]}
N 1200 -5630 1200 -5610 {
lab=row_n[0]}
N 1200 -5870 1200 -5850 {
lab=row_n[0]}
N 1080 -5770 1090 -5780 {
lab=col_n[18]}
N 1090 -5780 1290 -5780 {
lab=col_n[18]}
N 1290 -5780 1300 -5770 {
lab=col_n[18]}
N 1080 -5750 1090 -5760 {
lab=colon_n[18]}
N 1090 -5760 1290 -5760 {
lab=colon_n[18]}
N 1290 -5760 1300 -5750 {
lab=colon_n[18]}
N 1080 -5730 1090 -5740 {
lab=#net37}
N 1090 -5740 1290 -5740 {
lab=#net37}
N 1290 -5740 1300 -5730 {
lab=#net37}
N 1080 -5710 1090 -5720 {
lab=#net38}
N 1090 -5720 1290 -5720 {
lab=#net38}
N 1290 -5720 1300 -5710 {
lab=#net38}
N 1140 -5870 1140 -5850 {
lab=vcom}
N 1180 -5870 1180 -5850 {
lab=ctop}
N 1060 -5770 1080 -5770 {
lab=col_n[18]}
N 1060 -5750 1080 -5750 {
lab=colon_n[18]}
N 1060 -5730 1080 -5730 {
lab=#net37}
N 1060 -5710 1080 -5710 {
lab=#net38}
N 1300 -5710 1320 -5710 {
lab=#net38}
N 1300 -5730 1320 -5730 {
lab=#net37}
N 1300 -5750 1320 -5750 {
lab=colon_n[18]}
N 1300 -5770 1320 -5770 {
lab=col_n[18]}
N 1120 -5630 1120 -5620 {
lab=VSS}
N 1120 -5860 1120 -5850 {
lab=VDD}
N 1460 -5630 1470 -5640 {
lab=row_n[1]}
N 1470 -5840 1470 -5640 {
lab=row_n[1]}
N 1460 -5850 1470 -5840 {
lab=row_n[1]}
N 1460 -5630 1460 -5610 {
lab=row_n[1]}
N 1460 -5870 1460 -5850 {
lab=row_n[1]}
N 1340 -5770 1350 -5780 {
lab=col_n[18]}
N 1350 -5780 1550 -5780 {
lab=col_n[18]}
N 1550 -5780 1560 -5770 {
lab=col_n[18]}
N 1340 -5750 1350 -5760 {
lab=colon_n[18]}
N 1350 -5760 1550 -5760 {
lab=colon_n[18]}
N 1550 -5760 1560 -5750 {
lab=colon_n[18]}
N 1340 -5730 1350 -5740 {
lab=#net37}
N 1350 -5740 1550 -5740 {
lab=#net37}
N 1550 -5740 1560 -5730 {
lab=#net37}
N 1340 -5710 1350 -5720 {
lab=#net38}
N 1350 -5720 1550 -5720 {
lab=#net38}
N 1550 -5720 1560 -5710 {
lab=#net38}
N 1400 -5870 1400 -5850 {
lab=vcom}
N 1440 -5870 1440 -5850 {
lab=ctop}
N 1320 -5770 1340 -5770 {
lab=col_n[18]}
N 1320 -5750 1340 -5750 {
lab=colon_n[18]}
N 1320 -5730 1340 -5730 {
lab=#net37}
N 1320 -5710 1340 -5710 {
lab=#net38}
N 1560 -5710 1580 -5710 {
lab=#net38}
N 1560 -5730 1580 -5730 {
lab=#net37}
N 1560 -5750 1580 -5750 {
lab=colon_n[18]}
N 1560 -5770 1580 -5770 {
lab=col_n[18]}
N 1380 -5630 1380 -5620 {
lab=VSS}
N 1380 -5860 1380 -5850 {
lab=VDD}
N 1720 -5630 1730 -5640 {
lab=row_n[2]}
N 1730 -5840 1730 -5640 {
lab=row_n[2]}
N 1720 -5850 1730 -5840 {
lab=row_n[2]}
N 1720 -5630 1720 -5610 {
lab=row_n[2]}
N 1720 -5870 1720 -5850 {
lab=row_n[2]}
N 1600 -5770 1610 -5780 {
lab=col_n[18]}
N 1610 -5780 1810 -5780 {
lab=col_n[18]}
N 1810 -5780 1820 -5770 {
lab=col_n[18]}
N 1600 -5750 1610 -5760 {
lab=colon_n[18]}
N 1610 -5760 1810 -5760 {
lab=colon_n[18]}
N 1810 -5760 1820 -5750 {
lab=colon_n[18]}
N 1600 -5730 1610 -5740 {
lab=#net37}
N 1610 -5740 1810 -5740 {
lab=#net37}
N 1810 -5740 1820 -5730 {
lab=#net37}
N 1600 -5710 1610 -5720 {
lab=#net38}
N 1610 -5720 1810 -5720 {
lab=#net38}
N 1810 -5720 1820 -5710 {
lab=#net38}
N 1660 -5870 1660 -5850 {
lab=vcom}
N 1700 -5870 1700 -5850 {
lab=ctop}
N 1580 -5770 1600 -5770 {
lab=col_n[18]}
N 1580 -5750 1600 -5750 {
lab=colon_n[18]}
N 1580 -5730 1600 -5730 {
lab=#net37}
N 1580 -5710 1600 -5710 {
lab=#net38}
N 1820 -5710 1840 -5710 {
lab=#net38}
N 1820 -5730 1840 -5730 {
lab=#net37}
N 1820 -5750 1840 -5750 {
lab=colon_n[18]}
N 1820 -5770 1840 -5770 {
lab=col_n[18]}
N 1640 -5630 1640 -5620 {
lab=VSS}
N 1640 -5860 1640 -5850 {
lab=VDD}
N 1980 -5630 1990 -5640 {
lab=row_n[3]}
N 1990 -5840 1990 -5640 {
lab=row_n[3]}
N 1980 -5850 1990 -5840 {
lab=row_n[3]}
N 1980 -5630 1980 -5610 {
lab=row_n[3]}
N 1980 -5870 1980 -5850 {
lab=row_n[3]}
N 1860 -5770 1870 -5780 {
lab=col_n[18]}
N 1870 -5780 2070 -5780 {
lab=col_n[18]}
N 2070 -5780 2080 -5770 {
lab=col_n[18]}
N 1860 -5750 1870 -5760 {
lab=colon_n[18]}
N 1870 -5760 2070 -5760 {
lab=colon_n[18]}
N 2070 -5760 2080 -5750 {
lab=colon_n[18]}
N 1860 -5730 1870 -5740 {
lab=#net37}
N 1870 -5740 2070 -5740 {
lab=#net37}
N 2070 -5740 2080 -5730 {
lab=#net37}
N 1860 -5710 1870 -5720 {
lab=#net38}
N 1870 -5720 2070 -5720 {
lab=#net38}
N 2070 -5720 2080 -5710 {
lab=#net38}
N 1920 -5870 1920 -5850 {
lab=vcom}
N 1960 -5870 1960 -5850 {
lab=ctop}
N 1840 -5770 1860 -5770 {
lab=col_n[18]}
N 1840 -5750 1860 -5750 {
lab=colon_n[18]}
N 1840 -5730 1860 -5730 {
lab=#net37}
N 1840 -5710 1860 -5710 {
lab=#net38}
N 2080 -5710 2100 -5710 {
lab=#net38}
N 2080 -5730 2100 -5730 {
lab=#net37}
N 2080 -5750 2100 -5750 {
lab=colon_n[18]}
N 2080 -5770 2100 -5770 {
lab=col_n[18]}
N 1900 -5630 1900 -5620 {
lab=VSS}
N 1900 -5860 1900 -5850 {
lab=VDD}
N 2240 -5630 2250 -5640 {
lab=row_n[4]}
N 2250 -5840 2250 -5640 {
lab=row_n[4]}
N 2240 -5850 2250 -5840 {
lab=row_n[4]}
N 2240 -5630 2240 -5610 {
lab=row_n[4]}
N 2240 -5870 2240 -5850 {
lab=row_n[4]}
N 2120 -5770 2130 -5780 {
lab=col_n[18]}
N 2130 -5780 2330 -5780 {
lab=col_n[18]}
N 2330 -5780 2340 -5770 {
lab=col_n[18]}
N 2120 -5750 2130 -5760 {
lab=colon_n[18]}
N 2130 -5760 2330 -5760 {
lab=colon_n[18]}
N 2330 -5760 2340 -5750 {
lab=colon_n[18]}
N 2120 -5730 2130 -5740 {
lab=#net37}
N 2130 -5740 2330 -5740 {
lab=#net37}
N 2330 -5740 2340 -5730 {
lab=#net37}
N 2120 -5710 2130 -5720 {
lab=#net38}
N 2130 -5720 2330 -5720 {
lab=#net38}
N 2330 -5720 2340 -5710 {
lab=#net38}
N 2180 -5870 2180 -5850 {
lab=vcom}
N 2220 -5870 2220 -5850 {
lab=ctop}
N 2100 -5770 2120 -5770 {
lab=col_n[18]}
N 2100 -5750 2120 -5750 {
lab=colon_n[18]}
N 2100 -5730 2120 -5730 {
lab=#net37}
N 2100 -5710 2120 -5710 {
lab=#net38}
N 2340 -5710 2360 -5710 {
lab=#net38}
N 2340 -5730 2360 -5730 {
lab=#net37}
N 2340 -5750 2360 -5750 {
lab=colon_n[18]}
N 2340 -5770 2360 -5770 {
lab=col_n[18]}
N 2160 -5630 2160 -5620 {
lab=VSS}
N 2160 -5860 2160 -5850 {
lab=VDD}
N 2500 -5630 2510 -5640 {
lab=row_n[5]}
N 2510 -5840 2510 -5640 {
lab=row_n[5]}
N 2500 -5850 2510 -5840 {
lab=row_n[5]}
N 2500 -5630 2500 -5610 {
lab=row_n[5]}
N 2500 -5870 2500 -5850 {
lab=row_n[5]}
N 2380 -5770 2390 -5780 {
lab=col_n[18]}
N 2390 -5780 2590 -5780 {
lab=col_n[18]}
N 2590 -5780 2600 -5770 {
lab=col_n[18]}
N 2380 -5750 2390 -5760 {
lab=colon_n[18]}
N 2390 -5760 2590 -5760 {
lab=colon_n[18]}
N 2590 -5760 2600 -5750 {
lab=colon_n[18]}
N 2380 -5730 2390 -5740 {
lab=#net37}
N 2390 -5740 2590 -5740 {
lab=#net37}
N 2590 -5740 2600 -5730 {
lab=#net37}
N 2380 -5710 2390 -5720 {
lab=#net38}
N 2390 -5720 2590 -5720 {
lab=#net38}
N 2590 -5720 2600 -5710 {
lab=#net38}
N 2440 -5870 2440 -5850 {
lab=vcom}
N 2480 -5870 2480 -5850 {
lab=ctop}
N 2360 -5770 2380 -5770 {
lab=col_n[18]}
N 2360 -5750 2380 -5750 {
lab=colon_n[18]}
N 2360 -5730 2380 -5730 {
lab=#net37}
N 2360 -5710 2380 -5710 {
lab=#net38}
N 2600 -5710 2620 -5710 {
lab=#net38}
N 2600 -5730 2620 -5730 {
lab=#net37}
N 2600 -5750 2620 -5750 {
lab=colon_n[18]}
N 2600 -5770 2620 -5770 {
lab=col_n[18]}
N 2420 -5630 2420 -5620 {
lab=VSS}
N 2420 -5860 2420 -5850 {
lab=VDD}
N 2760 -5630 2770 -5640 {
lab=row_n[6]}
N 2770 -5840 2770 -5640 {
lab=row_n[6]}
N 2760 -5850 2770 -5840 {
lab=row_n[6]}
N 2760 -5630 2760 -5610 {
lab=row_n[6]}
N 2760 -5870 2760 -5850 {
lab=row_n[6]}
N 2640 -5770 2650 -5780 {
lab=col_n[18]}
N 2650 -5780 2850 -5780 {
lab=col_n[18]}
N 2850 -5780 2860 -5770 {
lab=col_n[18]}
N 2640 -5750 2650 -5760 {
lab=colon_n[18]}
N 2650 -5760 2850 -5760 {
lab=colon_n[18]}
N 2850 -5760 2860 -5750 {
lab=colon_n[18]}
N 2640 -5730 2650 -5740 {
lab=#net37}
N 2650 -5740 2850 -5740 {
lab=#net37}
N 2850 -5740 2860 -5730 {
lab=#net37}
N 2640 -5710 2650 -5720 {
lab=#net38}
N 2650 -5720 2850 -5720 {
lab=#net38}
N 2850 -5720 2860 -5710 {
lab=#net38}
N 2700 -5870 2700 -5850 {
lab=vcom}
N 2740 -5870 2740 -5850 {
lab=ctop}
N 2620 -5770 2640 -5770 {
lab=col_n[18]}
N 2620 -5750 2640 -5750 {
lab=colon_n[18]}
N 2620 -5730 2640 -5730 {
lab=#net37}
N 2620 -5710 2640 -5710 {
lab=#net38}
N 2860 -5710 2880 -5710 {
lab=#net38}
N 2860 -5730 2880 -5730 {
lab=#net37}
N 2860 -5750 2880 -5750 {
lab=colon_n[18]}
N 2860 -5770 2880 -5770 {
lab=col_n[18]}
N 2680 -5630 2680 -5620 {
lab=VSS}
N 2680 -5860 2680 -5850 {
lab=VDD}
N 3020 -5630 3030 -5640 {
lab=row_n[7]}
N 3030 -5840 3030 -5640 {
lab=row_n[7]}
N 3020 -5850 3030 -5840 {
lab=row_n[7]}
N 3020 -5630 3020 -5610 {
lab=row_n[7]}
N 3020 -5870 3020 -5850 {
lab=row_n[7]}
N 2900 -5770 2910 -5780 {
lab=col_n[18]}
N 2910 -5780 3110 -5780 {
lab=col_n[18]}
N 3110 -5780 3120 -5770 {
lab=col_n[18]}
N 2900 -5750 2910 -5760 {
lab=colon_n[18]}
N 2910 -5760 3110 -5760 {
lab=colon_n[18]}
N 3110 -5760 3120 -5750 {
lab=colon_n[18]}
N 2900 -5730 2910 -5740 {
lab=#net37}
N 2910 -5740 3110 -5740 {
lab=#net37}
N 3110 -5740 3120 -5730 {
lab=#net37}
N 2900 -5710 2910 -5720 {
lab=#net38}
N 2910 -5720 3110 -5720 {
lab=#net38}
N 3110 -5720 3120 -5710 {
lab=#net38}
N 2960 -5870 2960 -5850 {
lab=vcom}
N 3000 -5870 3000 -5850 {
lab=ctop}
N 2880 -5770 2900 -5770 {
lab=col_n[18]}
N 2880 -5750 2900 -5750 {
lab=colon_n[18]}
N 2880 -5730 2900 -5730 {
lab=#net37}
N 2880 -5710 2900 -5710 {
lab=#net38}
N 3120 -5710 3140 -5710 {
lab=#net38}
N 3120 -5730 3140 -5730 {
lab=#net37}
N 3120 -5750 3140 -5750 {
lab=colon_n[18]}
N 3120 -5770 3140 -5770 {
lab=col_n[18]}
N 2940 -5630 2940 -5620 {
lab=VSS}
N 2940 -5860 2940 -5850 {
lab=VDD}
N 3280 -5630 3290 -5640 {
lab=row_n[8]}
N 3290 -5840 3290 -5640 {
lab=row_n[8]}
N 3280 -5850 3290 -5840 {
lab=row_n[8]}
N 3280 -5630 3280 -5610 {
lab=row_n[8]}
N 3280 -5870 3280 -5850 {
lab=row_n[8]}
N 3160 -5770 3170 -5780 {
lab=col_n[18]}
N 3170 -5780 3370 -5780 {
lab=col_n[18]}
N 3370 -5780 3380 -5770 {
lab=col_n[18]}
N 3160 -5750 3170 -5760 {
lab=colon_n[18]}
N 3170 -5760 3370 -5760 {
lab=colon_n[18]}
N 3370 -5760 3380 -5750 {
lab=colon_n[18]}
N 3160 -5730 3170 -5740 {
lab=#net37}
N 3170 -5740 3370 -5740 {
lab=#net37}
N 3370 -5740 3380 -5730 {
lab=#net37}
N 3160 -5710 3170 -5720 {
lab=#net38}
N 3170 -5720 3370 -5720 {
lab=#net38}
N 3370 -5720 3380 -5710 {
lab=#net38}
N 3220 -5870 3220 -5850 {
lab=vcom}
N 3260 -5870 3260 -5850 {
lab=ctop}
N 3140 -5770 3160 -5770 {
lab=col_n[18]}
N 3140 -5750 3160 -5750 {
lab=colon_n[18]}
N 3140 -5730 3160 -5730 {
lab=#net37}
N 3140 -5710 3160 -5710 {
lab=#net38}
N 3380 -5710 3400 -5710 {
lab=#net38}
N 3380 -5730 3400 -5730 {
lab=#net37}
N 3380 -5750 3400 -5750 {
lab=colon_n[18]}
N 3380 -5770 3400 -5770 {
lab=col_n[18]}
N 3200 -5630 3200 -5620 {
lab=VSS}
N 3200 -5860 3200 -5850 {
lab=VDD}
N 3540 -5630 3550 -5640 {
lab=row_n[9]}
N 3550 -5840 3550 -5640 {
lab=row_n[9]}
N 3540 -5850 3550 -5840 {
lab=row_n[9]}
N 3540 -5630 3540 -5610 {
lab=row_n[9]}
N 3540 -5870 3540 -5850 {
lab=row_n[9]}
N 3420 -5770 3430 -5780 {
lab=col_n[18]}
N 3430 -5780 3630 -5780 {
lab=col_n[18]}
N 3630 -5780 3640 -5770 {
lab=col_n[18]}
N 3420 -5750 3430 -5760 {
lab=colon_n[18]}
N 3430 -5760 3630 -5760 {
lab=colon_n[18]}
N 3630 -5760 3640 -5750 {
lab=colon_n[18]}
N 3420 -5730 3430 -5740 {
lab=#net37}
N 3430 -5740 3630 -5740 {
lab=#net37}
N 3630 -5740 3640 -5730 {
lab=#net37}
N 3420 -5710 3430 -5720 {
lab=#net38}
N 3430 -5720 3630 -5720 {
lab=#net38}
N 3630 -5720 3640 -5710 {
lab=#net38}
N 3480 -5870 3480 -5850 {
lab=vcom}
N 3520 -5870 3520 -5850 {
lab=ctop}
N 3400 -5770 3420 -5770 {
lab=col_n[18]}
N 3400 -5750 3420 -5750 {
lab=colon_n[18]}
N 3400 -5730 3420 -5730 {
lab=#net37}
N 3400 -5710 3420 -5710 {
lab=#net38}
N 3640 -5710 3660 -5710 {
lab=#net38}
N 3640 -5730 3660 -5730 {
lab=#net37}
N 3640 -5750 3660 -5750 {
lab=colon_n[18]}
N 3640 -5770 3660 -5770 {
lab=col_n[18]}
N 3460 -5630 3460 -5620 {
lab=VSS}
N 3460 -5860 3460 -5850 {
lab=VDD}
N 3800 -5630 3810 -5640 {
lab=row_n[10]}
N 3810 -5840 3810 -5640 {
lab=row_n[10]}
N 3800 -5850 3810 -5840 {
lab=row_n[10]}
N 3800 -5630 3800 -5610 {
lab=row_n[10]}
N 3800 -5870 3800 -5850 {
lab=row_n[10]}
N 3680 -5770 3690 -5780 {
lab=col_n[18]}
N 3690 -5780 3890 -5780 {
lab=col_n[18]}
N 3890 -5780 3900 -5770 {
lab=col_n[18]}
N 3680 -5750 3690 -5760 {
lab=colon_n[18]}
N 3690 -5760 3890 -5760 {
lab=colon_n[18]}
N 3890 -5760 3900 -5750 {
lab=colon_n[18]}
N 3680 -5730 3690 -5740 {
lab=#net37}
N 3690 -5740 3890 -5740 {
lab=#net37}
N 3890 -5740 3900 -5730 {
lab=#net37}
N 3680 -5710 3690 -5720 {
lab=#net38}
N 3690 -5720 3890 -5720 {
lab=#net38}
N 3890 -5720 3900 -5710 {
lab=#net38}
N 3740 -5870 3740 -5850 {
lab=vcom}
N 3780 -5870 3780 -5850 {
lab=ctop}
N 3660 -5770 3680 -5770 {
lab=col_n[18]}
N 3660 -5750 3680 -5750 {
lab=colon_n[18]}
N 3660 -5730 3680 -5730 {
lab=#net37}
N 3660 -5710 3680 -5710 {
lab=#net38}
N 3900 -5710 3920 -5710 {
lab=#net38}
N 3900 -5730 3920 -5730 {
lab=#net37}
N 3900 -5750 3920 -5750 {
lab=colon_n[18]}
N 3900 -5770 3920 -5770 {
lab=col_n[18]}
N 3720 -5630 3720 -5620 {
lab=VSS}
N 3720 -5860 3720 -5850 {
lab=VDD}
N 4060 -5630 4070 -5640 {
lab=row_n[11]}
N 4070 -5840 4070 -5640 {
lab=row_n[11]}
N 4060 -5850 4070 -5840 {
lab=row_n[11]}
N 4060 -5630 4060 -5610 {
lab=row_n[11]}
N 4060 -5870 4060 -5850 {
lab=row_n[11]}
N 3940 -5770 3950 -5780 {
lab=col_n[18]}
N 3950 -5780 4150 -5780 {
lab=col_n[18]}
N 4150 -5780 4160 -5770 {
lab=col_n[18]}
N 3940 -5750 3950 -5760 {
lab=colon_n[18]}
N 3950 -5760 4150 -5760 {
lab=colon_n[18]}
N 4150 -5760 4160 -5750 {
lab=colon_n[18]}
N 3940 -5730 3950 -5740 {
lab=#net37}
N 3950 -5740 4150 -5740 {
lab=#net37}
N 4150 -5740 4160 -5730 {
lab=#net37}
N 3940 -5710 3950 -5720 {
lab=#net38}
N 3950 -5720 4150 -5720 {
lab=#net38}
N 4150 -5720 4160 -5710 {
lab=#net38}
N 4000 -5870 4000 -5850 {
lab=vcom}
N 4040 -5870 4040 -5850 {
lab=ctop}
N 3920 -5770 3940 -5770 {
lab=col_n[18]}
N 3920 -5750 3940 -5750 {
lab=colon_n[18]}
N 3920 -5730 3940 -5730 {
lab=#net37}
N 3920 -5710 3940 -5710 {
lab=#net38}
N 4160 -5710 4180 -5710 {
lab=#net38}
N 4160 -5730 4180 -5730 {
lab=#net37}
N 4160 -5750 4180 -5750 {
lab=colon_n[18]}
N 4160 -5770 4180 -5770 {
lab=col_n[18]}
N 3980 -5630 3980 -5620 {
lab=VSS}
N 3980 -5860 3980 -5850 {
lab=VDD}
N 4320 -5630 4330 -5640 {
lab=row_n[12]}
N 4330 -5840 4330 -5640 {
lab=row_n[12]}
N 4320 -5850 4330 -5840 {
lab=row_n[12]}
N 4320 -5630 4320 -5610 {
lab=row_n[12]}
N 4320 -5870 4320 -5850 {
lab=row_n[12]}
N 4200 -5770 4210 -5780 {
lab=col_n[18]}
N 4210 -5780 4410 -5780 {
lab=col_n[18]}
N 4410 -5780 4420 -5770 {
lab=col_n[18]}
N 4200 -5750 4210 -5760 {
lab=colon_n[18]}
N 4210 -5760 4410 -5760 {
lab=colon_n[18]}
N 4410 -5760 4420 -5750 {
lab=colon_n[18]}
N 4200 -5730 4210 -5740 {
lab=#net37}
N 4210 -5740 4410 -5740 {
lab=#net37}
N 4410 -5740 4420 -5730 {
lab=#net37}
N 4200 -5710 4210 -5720 {
lab=#net38}
N 4210 -5720 4410 -5720 {
lab=#net38}
N 4410 -5720 4420 -5710 {
lab=#net38}
N 4260 -5870 4260 -5850 {
lab=vcom}
N 4300 -5870 4300 -5850 {
lab=ctop}
N 4180 -5770 4200 -5770 {
lab=col_n[18]}
N 4180 -5750 4200 -5750 {
lab=colon_n[18]}
N 4180 -5730 4200 -5730 {
lab=#net37}
N 4180 -5710 4200 -5710 {
lab=#net38}
N 4420 -5710 4440 -5710 {
lab=#net38}
N 4420 -5730 4440 -5730 {
lab=#net37}
N 4420 -5750 4440 -5750 {
lab=colon_n[18]}
N 4420 -5770 4440 -5770 {
lab=col_n[18]}
N 4240 -5630 4240 -5620 {
lab=VSS}
N 4240 -5860 4240 -5850 {
lab=VDD}
N 4580 -5630 4590 -5640 {
lab=row_n[13]}
N 4590 -5840 4590 -5640 {
lab=row_n[13]}
N 4580 -5850 4590 -5840 {
lab=row_n[13]}
N 4580 -5630 4580 -5610 {
lab=row_n[13]}
N 4580 -5870 4580 -5850 {
lab=row_n[13]}
N 4460 -5770 4470 -5780 {
lab=col_n[18]}
N 4470 -5780 4670 -5780 {
lab=col_n[18]}
N 4670 -5780 4680 -5770 {
lab=col_n[18]}
N 4460 -5750 4470 -5760 {
lab=colon_n[18]}
N 4470 -5760 4670 -5760 {
lab=colon_n[18]}
N 4670 -5760 4680 -5750 {
lab=colon_n[18]}
N 4460 -5730 4470 -5740 {
lab=#net37}
N 4470 -5740 4670 -5740 {
lab=#net37}
N 4670 -5740 4680 -5730 {
lab=#net37}
N 4460 -5710 4470 -5720 {
lab=#net38}
N 4470 -5720 4670 -5720 {
lab=#net38}
N 4670 -5720 4680 -5710 {
lab=#net38}
N 4520 -5870 4520 -5850 {
lab=vcom}
N 4560 -5870 4560 -5850 {
lab=ctop}
N 4440 -5770 4460 -5770 {
lab=col_n[18]}
N 4440 -5750 4460 -5750 {
lab=colon_n[18]}
N 4440 -5730 4460 -5730 {
lab=#net37}
N 4440 -5710 4460 -5710 {
lab=#net38}
N 4680 -5710 4700 -5710 {
lab=#net38}
N 4680 -5730 4700 -5730 {
lab=#net37}
N 4680 -5750 4700 -5750 {
lab=colon_n[18]}
N 4680 -5770 4700 -5770 {
lab=col_n[18]}
N 4500 -5630 4500 -5620 {
lab=VSS}
N 4500 -5860 4500 -5850 {
lab=VDD}
N 4840 -5630 4850 -5640 {
lab=row_n[14]}
N 4850 -5840 4850 -5640 {
lab=row_n[14]}
N 4840 -5850 4850 -5840 {
lab=row_n[14]}
N 4840 -5630 4840 -5610 {
lab=row_n[14]}
N 4840 -5870 4840 -5850 {
lab=row_n[14]}
N 4720 -5770 4730 -5780 {
lab=col_n[18]}
N 4730 -5780 4930 -5780 {
lab=col_n[18]}
N 4930 -5780 4940 -5770 {
lab=col_n[18]}
N 4720 -5750 4730 -5760 {
lab=colon_n[18]}
N 4730 -5760 4930 -5760 {
lab=colon_n[18]}
N 4930 -5760 4940 -5750 {
lab=colon_n[18]}
N 4720 -5730 4730 -5740 {
lab=#net37}
N 4730 -5740 4930 -5740 {
lab=#net37}
N 4930 -5740 4940 -5730 {
lab=#net37}
N 4720 -5710 4730 -5720 {
lab=#net38}
N 4730 -5720 4930 -5720 {
lab=#net38}
N 4930 -5720 4940 -5710 {
lab=#net38}
N 4780 -5870 4780 -5850 {
lab=vcom}
N 4820 -5870 4820 -5850 {
lab=ctop}
N 4700 -5770 4720 -5770 {
lab=col_n[18]}
N 4700 -5750 4720 -5750 {
lab=colon_n[18]}
N 4700 -5730 4720 -5730 {
lab=#net37}
N 4700 -5710 4720 -5710 {
lab=#net38}
N 4940 -5710 4960 -5710 {
lab=#net38}
N 4940 -5730 4960 -5730 {
lab=#net37}
N 4940 -5750 4960 -5750 {
lab=colon_n[18]}
N 4940 -5770 4960 -5770 {
lab=col_n[18]}
N 4760 -5630 4760 -5620 {
lab=VSS}
N 4760 -5860 4760 -5850 {
lab=VDD}
N 5100 -5630 5110 -5640 {
lab=row_n[15]}
N 5110 -5840 5110 -5640 {
lab=row_n[15]}
N 5100 -5850 5110 -5840 {
lab=row_n[15]}
N 5100 -5630 5100 -5610 {
lab=row_n[15]}
N 5100 -5870 5100 -5850 {
lab=row_n[15]}
N 4980 -5770 4990 -5780 {
lab=col_n[18]}
N 4990 -5780 5190 -5780 {
lab=col_n[18]}
N 5190 -5780 5200 -5770 {
lab=col_n[18]}
N 4980 -5750 4990 -5760 {
lab=colon_n[18]}
N 4990 -5760 5190 -5760 {
lab=colon_n[18]}
N 5190 -5760 5200 -5750 {
lab=colon_n[18]}
N 4980 -5730 4990 -5740 {
lab=#net37}
N 4990 -5740 5190 -5740 {
lab=#net37}
N 5190 -5740 5200 -5730 {
lab=#net37}
N 4980 -5710 4990 -5720 {
lab=#net38}
N 4990 -5720 5190 -5720 {
lab=#net38}
N 5190 -5720 5200 -5710 {
lab=#net38}
N 5040 -5870 5040 -5850 {
lab=vcom}
N 5080 -5870 5080 -5850 {
lab=ctop}
N 4960 -5770 4980 -5770 {
lab=col_n[18]}
N 4960 -5750 4980 -5750 {
lab=colon_n[18]}
N 4960 -5730 4980 -5730 {
lab=#net37}
N 4960 -5710 4980 -5710 {
lab=#net38}
N 5200 -5710 5220 -5710 {
lab=#net38}
N 5200 -5730 5220 -5730 {
lab=#net37}
N 5200 -5750 5220 -5750 {
lab=colon_n[18]}
N 5200 -5770 5220 -5770 {
lab=col_n[18]}
N 5020 -5630 5020 -5620 {
lab=VSS}
N 5020 -5860 5020 -5850 {
lab=VDD}
N 5360 -5630 5370 -5640 {
lab=row_n[16]}
N 5370 -5840 5370 -5640 {
lab=row_n[16]}
N 5360 -5850 5370 -5840 {
lab=row_n[16]}
N 5360 -5630 5360 -5610 {
lab=row_n[16]}
N 5360 -5870 5360 -5850 {
lab=row_n[16]}
N 5240 -5770 5250 -5780 {
lab=col_n[18]}
N 5250 -5780 5450 -5780 {
lab=col_n[18]}
N 5450 -5780 5460 -5770 {
lab=col_n[18]}
N 5240 -5750 5250 -5760 {
lab=colon_n[18]}
N 5250 -5760 5450 -5760 {
lab=colon_n[18]}
N 5450 -5760 5460 -5750 {
lab=colon_n[18]}
N 5240 -5730 5250 -5740 {
lab=#net37}
N 5250 -5740 5450 -5740 {
lab=#net37}
N 5450 -5740 5460 -5730 {
lab=#net37}
N 5240 -5710 5250 -5720 {
lab=#net38}
N 5250 -5720 5450 -5720 {
lab=#net38}
N 5450 -5720 5460 -5710 {
lab=#net38}
N 5300 -5870 5300 -5850 {
lab=vcom}
N 5340 -5870 5340 -5850 {
lab=ctop}
N 5220 -5770 5240 -5770 {
lab=col_n[18]}
N 5220 -5750 5240 -5750 {
lab=colon_n[18]}
N 5220 -5730 5240 -5730 {
lab=#net37}
N 5220 -5710 5240 -5710 {
lab=#net38}
N 5460 -5710 5480 -5710 {
lab=#net38}
N 5460 -5730 5480 -5730 {
lab=#net37}
N 5460 -5750 5480 -5750 {
lab=colon_n[18]}
N 5460 -5770 5480 -5770 {
lab=col_n[18]}
N 5280 -5630 5280 -5620 {
lab=VSS}
N 5280 -5860 5280 -5850 {
lab=VDD}
N 5620 -5630 5630 -5640 {
lab=row_n[17]}
N 5630 -5840 5630 -5640 {
lab=row_n[17]}
N 5620 -5850 5630 -5840 {
lab=row_n[17]}
N 5620 -5630 5620 -5610 {
lab=row_n[17]}
N 5620 -5870 5620 -5850 {
lab=row_n[17]}
N 5500 -5770 5510 -5780 {
lab=col_n[18]}
N 5510 -5780 5710 -5780 {
lab=col_n[18]}
N 5710 -5780 5720 -5770 {
lab=col_n[18]}
N 5500 -5750 5510 -5760 {
lab=colon_n[18]}
N 5510 -5760 5710 -5760 {
lab=colon_n[18]}
N 5710 -5760 5720 -5750 {
lab=colon_n[18]}
N 5500 -5730 5510 -5740 {
lab=#net37}
N 5510 -5740 5710 -5740 {
lab=#net37}
N 5710 -5740 5720 -5730 {
lab=#net37}
N 5500 -5710 5510 -5720 {
lab=#net38}
N 5510 -5720 5710 -5720 {
lab=#net38}
N 5710 -5720 5720 -5710 {
lab=#net38}
N 5560 -5870 5560 -5850 {
lab=vcom}
N 5600 -5870 5600 -5850 {
lab=ctop}
N 5480 -5770 5500 -5770 {
lab=col_n[18]}
N 5480 -5750 5500 -5750 {
lab=colon_n[18]}
N 5480 -5730 5500 -5730 {
lab=#net37}
N 5480 -5710 5500 -5710 {
lab=#net38}
N 5720 -5710 5740 -5710 {
lab=#net38}
N 5720 -5730 5740 -5730 {
lab=#net37}
N 5720 -5750 5740 -5750 {
lab=colon_n[18]}
N 5720 -5770 5740 -5770 {
lab=col_n[18]}
N 5540 -5630 5540 -5620 {
lab=VSS}
N 5540 -5860 5540 -5850 {
lab=VDD}
N 5880 -5630 5890 -5640 {
lab=row_n[18]}
N 5890 -5840 5890 -5640 {
lab=row_n[18]}
N 5880 -5850 5890 -5840 {
lab=row_n[18]}
N 5880 -5630 5880 -5610 {
lab=row_n[18]}
N 5880 -5870 5880 -5850 {
lab=row_n[18]}
N 5760 -5770 5770 -5780 {
lab=col_n[18]}
N 5770 -5780 5970 -5780 {
lab=col_n[18]}
N 5970 -5780 5980 -5770 {
lab=col_n[18]}
N 5760 -5750 5770 -5760 {
lab=colon_n[18]}
N 5770 -5760 5970 -5760 {
lab=colon_n[18]}
N 5970 -5760 5980 -5750 {
lab=colon_n[18]}
N 5760 -5730 5770 -5740 {
lab=#net37}
N 5770 -5740 5970 -5740 {
lab=#net37}
N 5970 -5740 5980 -5730 {
lab=#net37}
N 5760 -5710 5770 -5720 {
lab=#net38}
N 5770 -5720 5970 -5720 {
lab=#net38}
N 5970 -5720 5980 -5710 {
lab=#net38}
N 5820 -5870 5820 -5850 {
lab=vcom}
N 5860 -5870 5860 -5850 {
lab=ctop}
N 5740 -5770 5760 -5770 {
lab=col_n[18]}
N 5740 -5750 5760 -5750 {
lab=colon_n[18]}
N 5740 -5730 5760 -5730 {
lab=#net37}
N 5740 -5710 5760 -5710 {
lab=#net38}
N 5980 -5710 6000 -5710 {
lab=#net38}
N 5980 -5730 6000 -5730 {
lab=#net37}
N 5980 -5750 6000 -5750 {
lab=colon_n[18]}
N 5980 -5770 6000 -5770 {
lab=col_n[18]}
N 5800 -5630 5800 -5620 {
lab=VSS}
N 5800 -5860 5800 -5850 {
lab=VDD}
N 6140 -5630 6150 -5640 {
lab=row_n[19]}
N 6150 -5840 6150 -5640 {
lab=row_n[19]}
N 6140 -5850 6150 -5840 {
lab=row_n[19]}
N 6140 -5630 6140 -5610 {
lab=row_n[19]}
N 6140 -5870 6140 -5850 {
lab=row_n[19]}
N 6020 -5770 6030 -5780 {
lab=col_n[18]}
N 6030 -5780 6230 -5780 {
lab=col_n[18]}
N 6230 -5780 6240 -5770 {
lab=col_n[18]}
N 6020 -5750 6030 -5760 {
lab=colon_n[18]}
N 6030 -5760 6230 -5760 {
lab=colon_n[18]}
N 6230 -5760 6240 -5750 {
lab=colon_n[18]}
N 6020 -5730 6030 -5740 {
lab=#net37}
N 6030 -5740 6230 -5740 {
lab=#net37}
N 6230 -5740 6240 -5730 {
lab=#net37}
N 6020 -5710 6030 -5720 {
lab=#net38}
N 6030 -5720 6230 -5720 {
lab=#net38}
N 6230 -5720 6240 -5710 {
lab=#net38}
N 6080 -5870 6080 -5850 {
lab=vcom}
N 6120 -5870 6120 -5850 {
lab=ctop}
N 6000 -5770 6020 -5770 {
lab=col_n[18]}
N 6000 -5750 6020 -5750 {
lab=colon_n[18]}
N 6000 -5730 6020 -5730 {
lab=#net37}
N 6000 -5710 6020 -5710 {
lab=#net38}
N 6240 -5710 6260 -5710 {
lab=#net38}
N 6240 -5730 6260 -5730 {
lab=#net37}
N 6240 -5750 6260 -5750 {
lab=colon_n[18]}
N 6240 -5770 6260 -5770 {
lab=col_n[18]}
N 6060 -5630 6060 -5620 {
lab=VSS}
N 6060 -5860 6060 -5850 {
lab=VDD}
N 6400 -5630 6410 -5640 {
lab=row_n[20]}
N 6410 -5840 6410 -5640 {
lab=row_n[20]}
N 6400 -5850 6410 -5840 {
lab=row_n[20]}
N 6400 -5630 6400 -5610 {
lab=row_n[20]}
N 6400 -5870 6400 -5850 {
lab=row_n[20]}
N 6280 -5770 6290 -5780 {
lab=col_n[18]}
N 6290 -5780 6490 -5780 {
lab=col_n[18]}
N 6490 -5780 6500 -5770 {
lab=col_n[18]}
N 6280 -5750 6290 -5760 {
lab=colon_n[18]}
N 6290 -5760 6490 -5760 {
lab=colon_n[18]}
N 6490 -5760 6500 -5750 {
lab=colon_n[18]}
N 6280 -5730 6290 -5740 {
lab=#net37}
N 6290 -5740 6490 -5740 {
lab=#net37}
N 6490 -5740 6500 -5730 {
lab=#net37}
N 6280 -5710 6290 -5720 {
lab=#net38}
N 6290 -5720 6490 -5720 {
lab=#net38}
N 6490 -5720 6500 -5710 {
lab=#net38}
N 6340 -5870 6340 -5850 {
lab=vcom}
N 6380 -5870 6380 -5850 {
lab=ctop}
N 6260 -5770 6280 -5770 {
lab=col_n[18]}
N 6260 -5750 6280 -5750 {
lab=colon_n[18]}
N 6260 -5730 6280 -5730 {
lab=#net37}
N 6260 -5710 6280 -5710 {
lab=#net38}
N 6500 -5710 6520 -5710 {
lab=#net38}
N 6500 -5730 6520 -5730 {
lab=#net37}
N 6500 -5750 6520 -5750 {
lab=colon_n[18]}
N 6500 -5770 6520 -5770 {
lab=col_n[18]}
N 6320 -5630 6320 -5620 {
lab=VSS}
N 6320 -5860 6320 -5850 {
lab=VDD}
N 6660 -5630 6670 -5640 {
lab=row_n[21]}
N 6670 -5840 6670 -5640 {
lab=row_n[21]}
N 6660 -5850 6670 -5840 {
lab=row_n[21]}
N 6660 -5630 6660 -5610 {
lab=row_n[21]}
N 6660 -5870 6660 -5850 {
lab=row_n[21]}
N 6540 -5770 6550 -5780 {
lab=col_n[18]}
N 6550 -5780 6750 -5780 {
lab=col_n[18]}
N 6750 -5780 6760 -5770 {
lab=col_n[18]}
N 6540 -5750 6550 -5760 {
lab=colon_n[18]}
N 6550 -5760 6750 -5760 {
lab=colon_n[18]}
N 6750 -5760 6760 -5750 {
lab=colon_n[18]}
N 6540 -5730 6550 -5740 {
lab=#net37}
N 6550 -5740 6750 -5740 {
lab=#net37}
N 6750 -5740 6760 -5730 {
lab=#net37}
N 6540 -5710 6550 -5720 {
lab=#net38}
N 6550 -5720 6750 -5720 {
lab=#net38}
N 6750 -5720 6760 -5710 {
lab=#net38}
N 6600 -5870 6600 -5850 {
lab=vcom}
N 6640 -5870 6640 -5850 {
lab=ctop}
N 6520 -5770 6540 -5770 {
lab=col_n[18]}
N 6520 -5750 6540 -5750 {
lab=colon_n[18]}
N 6520 -5730 6540 -5730 {
lab=#net37}
N 6520 -5710 6540 -5710 {
lab=#net38}
N 6760 -5710 6780 -5710 {
lab=#net38}
N 6760 -5730 6780 -5730 {
lab=#net37}
N 6760 -5750 6780 -5750 {
lab=colon_n[18]}
N 6760 -5770 6780 -5770 {
lab=col_n[18]}
N 6580 -5630 6580 -5620 {
lab=VSS}
N 6580 -5860 6580 -5850 {
lab=VDD}
N 6920 -5630 6930 -5640 {
lab=row_n[22]}
N 6930 -5840 6930 -5640 {
lab=row_n[22]}
N 6920 -5850 6930 -5840 {
lab=row_n[22]}
N 6920 -5630 6920 -5610 {
lab=row_n[22]}
N 6920 -5870 6920 -5850 {
lab=row_n[22]}
N 6800 -5770 6810 -5780 {
lab=col_n[18]}
N 6810 -5780 7010 -5780 {
lab=col_n[18]}
N 7010 -5780 7020 -5770 {
lab=col_n[18]}
N 6800 -5750 6810 -5760 {
lab=colon_n[18]}
N 6810 -5760 7010 -5760 {
lab=colon_n[18]}
N 7010 -5760 7020 -5750 {
lab=colon_n[18]}
N 6800 -5730 6810 -5740 {
lab=#net37}
N 6810 -5740 7010 -5740 {
lab=#net37}
N 7010 -5740 7020 -5730 {
lab=#net37}
N 6800 -5710 6810 -5720 {
lab=#net38}
N 6810 -5720 7010 -5720 {
lab=#net38}
N 7010 -5720 7020 -5710 {
lab=#net38}
N 6860 -5870 6860 -5850 {
lab=vcom}
N 6900 -5870 6900 -5850 {
lab=ctop}
N 6780 -5770 6800 -5770 {
lab=col_n[18]}
N 6780 -5750 6800 -5750 {
lab=colon_n[18]}
N 6780 -5730 6800 -5730 {
lab=#net37}
N 6780 -5710 6800 -5710 {
lab=#net38}
N 7020 -5710 7040 -5710 {
lab=#net38}
N 7020 -5730 7040 -5730 {
lab=#net37}
N 7020 -5750 7040 -5750 {
lab=colon_n[18]}
N 7020 -5770 7040 -5770 {
lab=col_n[18]}
N 6840 -5630 6840 -5620 {
lab=VSS}
N 6840 -5860 6840 -5850 {
lab=VDD}
N 7180 -5630 7190 -5640 {
lab=row_n[23]}
N 7190 -5840 7190 -5640 {
lab=row_n[23]}
N 7180 -5850 7190 -5840 {
lab=row_n[23]}
N 7180 -5630 7180 -5610 {
lab=row_n[23]}
N 7180 -5870 7180 -5850 {
lab=row_n[23]}
N 7060 -5770 7070 -5780 {
lab=col_n[18]}
N 7070 -5780 7270 -5780 {
lab=col_n[18]}
N 7270 -5780 7280 -5770 {
lab=col_n[18]}
N 7060 -5750 7070 -5760 {
lab=colon_n[18]}
N 7070 -5760 7270 -5760 {
lab=colon_n[18]}
N 7270 -5760 7280 -5750 {
lab=colon_n[18]}
N 7060 -5730 7070 -5740 {
lab=#net37}
N 7070 -5740 7270 -5740 {
lab=#net37}
N 7270 -5740 7280 -5730 {
lab=#net37}
N 7060 -5710 7070 -5720 {
lab=#net38}
N 7070 -5720 7270 -5720 {
lab=#net38}
N 7270 -5720 7280 -5710 {
lab=#net38}
N 7120 -5870 7120 -5850 {
lab=vcom}
N 7160 -5870 7160 -5850 {
lab=ctop}
N 7040 -5770 7060 -5770 {
lab=col_n[18]}
N 7040 -5750 7060 -5750 {
lab=colon_n[18]}
N 7040 -5730 7060 -5730 {
lab=#net37}
N 7040 -5710 7060 -5710 {
lab=#net38}
N 7280 -5710 7300 -5710 {
lab=#net38}
N 7280 -5730 7300 -5730 {
lab=#net37}
N 7280 -5750 7300 -5750 {
lab=colon_n[18]}
N 7280 -5770 7300 -5770 {
lab=col_n[18]}
N 7100 -5630 7100 -5620 {
lab=VSS}
N 7100 -5860 7100 -5850 {
lab=VDD}
N 7440 -5630 7450 -5640 {
lab=row_n[24]}
N 7450 -5840 7450 -5640 {
lab=row_n[24]}
N 7440 -5850 7450 -5840 {
lab=row_n[24]}
N 7440 -5630 7440 -5610 {
lab=row_n[24]}
N 7440 -5870 7440 -5850 {
lab=row_n[24]}
N 7320 -5770 7330 -5780 {
lab=col_n[18]}
N 7330 -5780 7530 -5780 {
lab=col_n[18]}
N 7530 -5780 7540 -5770 {
lab=col_n[18]}
N 7320 -5750 7330 -5760 {
lab=colon_n[18]}
N 7330 -5760 7530 -5760 {
lab=colon_n[18]}
N 7530 -5760 7540 -5750 {
lab=colon_n[18]}
N 7320 -5730 7330 -5740 {
lab=#net37}
N 7330 -5740 7530 -5740 {
lab=#net37}
N 7530 -5740 7540 -5730 {
lab=#net37}
N 7320 -5710 7330 -5720 {
lab=#net38}
N 7330 -5720 7530 -5720 {
lab=#net38}
N 7530 -5720 7540 -5710 {
lab=#net38}
N 7380 -5870 7380 -5850 {
lab=vcom}
N 7420 -5870 7420 -5850 {
lab=ctop}
N 7300 -5770 7320 -5770 {
lab=col_n[18]}
N 7300 -5750 7320 -5750 {
lab=colon_n[18]}
N 7300 -5730 7320 -5730 {
lab=#net37}
N 7300 -5710 7320 -5710 {
lab=#net38}
N 7540 -5710 7560 -5710 {
lab=#net38}
N 7540 -5730 7560 -5730 {
lab=#net37}
N 7540 -5750 7560 -5750 {
lab=colon_n[18]}
N 7540 -5770 7560 -5770 {
lab=col_n[18]}
N 7360 -5630 7360 -5620 {
lab=VSS}
N 7360 -5860 7360 -5850 {
lab=VDD}
N 7700 -5630 7710 -5640 {
lab=row_n[25]}
N 7710 -5840 7710 -5640 {
lab=row_n[25]}
N 7700 -5850 7710 -5840 {
lab=row_n[25]}
N 7700 -5630 7700 -5610 {
lab=row_n[25]}
N 7700 -5870 7700 -5850 {
lab=row_n[25]}
N 7580 -5770 7590 -5780 {
lab=col_n[18]}
N 7590 -5780 7790 -5780 {
lab=col_n[18]}
N 7790 -5780 7800 -5770 {
lab=col_n[18]}
N 7580 -5750 7590 -5760 {
lab=colon_n[18]}
N 7590 -5760 7790 -5760 {
lab=colon_n[18]}
N 7790 -5760 7800 -5750 {
lab=colon_n[18]}
N 7580 -5730 7590 -5740 {
lab=#net37}
N 7590 -5740 7790 -5740 {
lab=#net37}
N 7790 -5740 7800 -5730 {
lab=#net37}
N 7580 -5710 7590 -5720 {
lab=#net38}
N 7590 -5720 7790 -5720 {
lab=#net38}
N 7790 -5720 7800 -5710 {
lab=#net38}
N 7640 -5870 7640 -5850 {
lab=vcom}
N 7680 -5870 7680 -5850 {
lab=ctop}
N 7560 -5770 7580 -5770 {
lab=col_n[18]}
N 7560 -5750 7580 -5750 {
lab=colon_n[18]}
N 7560 -5730 7580 -5730 {
lab=#net37}
N 7560 -5710 7580 -5710 {
lab=#net38}
N 7800 -5710 7820 -5710 {
lab=#net38}
N 7800 -5730 7820 -5730 {
lab=#net37}
N 7800 -5750 7820 -5750 {
lab=colon_n[18]}
N 7800 -5770 7820 -5770 {
lab=col_n[18]}
N 7620 -5630 7620 -5620 {
lab=VSS}
N 7620 -5860 7620 -5850 {
lab=VDD}
N 7960 -5630 7970 -5640 {
lab=row_n[26]}
N 7970 -5840 7970 -5640 {
lab=row_n[26]}
N 7960 -5850 7970 -5840 {
lab=row_n[26]}
N 7960 -5630 7960 -5610 {
lab=row_n[26]}
N 7960 -5870 7960 -5850 {
lab=row_n[26]}
N 7840 -5770 7850 -5780 {
lab=col_n[18]}
N 7850 -5780 8050 -5780 {
lab=col_n[18]}
N 8050 -5780 8060 -5770 {
lab=col_n[18]}
N 7840 -5750 7850 -5760 {
lab=colon_n[18]}
N 7850 -5760 8050 -5760 {
lab=colon_n[18]}
N 8050 -5760 8060 -5750 {
lab=colon_n[18]}
N 7840 -5730 7850 -5740 {
lab=#net37}
N 7850 -5740 8050 -5740 {
lab=#net37}
N 8050 -5740 8060 -5730 {
lab=#net37}
N 7840 -5710 7850 -5720 {
lab=#net38}
N 7850 -5720 8050 -5720 {
lab=#net38}
N 8050 -5720 8060 -5710 {
lab=#net38}
N 7900 -5870 7900 -5850 {
lab=vcom}
N 7940 -5870 7940 -5850 {
lab=ctop}
N 7820 -5770 7840 -5770 {
lab=col_n[18]}
N 7820 -5750 7840 -5750 {
lab=colon_n[18]}
N 7820 -5730 7840 -5730 {
lab=#net37}
N 7820 -5710 7840 -5710 {
lab=#net38}
N 8060 -5710 8080 -5710 {
lab=#net38}
N 8060 -5730 8080 -5730 {
lab=#net37}
N 8060 -5750 8080 -5750 {
lab=colon_n[18]}
N 8060 -5770 8080 -5770 {
lab=col_n[18]}
N 7880 -5630 7880 -5620 {
lab=VSS}
N 7880 -5860 7880 -5850 {
lab=VDD}
N 8220 -5630 8230 -5640 {
lab=row_n[27]}
N 8230 -5840 8230 -5640 {
lab=row_n[27]}
N 8220 -5850 8230 -5840 {
lab=row_n[27]}
N 8220 -5630 8220 -5610 {
lab=row_n[27]}
N 8220 -5870 8220 -5850 {
lab=row_n[27]}
N 8100 -5770 8110 -5780 {
lab=col_n[18]}
N 8110 -5780 8310 -5780 {
lab=col_n[18]}
N 8310 -5780 8320 -5770 {
lab=col_n[18]}
N 8100 -5750 8110 -5760 {
lab=colon_n[18]}
N 8110 -5760 8310 -5760 {
lab=colon_n[18]}
N 8310 -5760 8320 -5750 {
lab=colon_n[18]}
N 8100 -5730 8110 -5740 {
lab=#net37}
N 8110 -5740 8310 -5740 {
lab=#net37}
N 8310 -5740 8320 -5730 {
lab=#net37}
N 8100 -5710 8110 -5720 {
lab=#net38}
N 8110 -5720 8310 -5720 {
lab=#net38}
N 8310 -5720 8320 -5710 {
lab=#net38}
N 8160 -5870 8160 -5850 {
lab=vcom}
N 8200 -5870 8200 -5850 {
lab=ctop}
N 8080 -5770 8100 -5770 {
lab=col_n[18]}
N 8080 -5750 8100 -5750 {
lab=colon_n[18]}
N 8080 -5730 8100 -5730 {
lab=#net37}
N 8080 -5710 8100 -5710 {
lab=#net38}
N 8320 -5710 8340 -5710 {
lab=#net38}
N 8320 -5730 8340 -5730 {
lab=#net37}
N 8320 -5750 8340 -5750 {
lab=colon_n[18]}
N 8320 -5770 8340 -5770 {
lab=col_n[18]}
N 8140 -5630 8140 -5620 {
lab=VSS}
N 8140 -5860 8140 -5850 {
lab=VDD}
N 8480 -5630 8490 -5640 {
lab=row_n[28]}
N 8490 -5840 8490 -5640 {
lab=row_n[28]}
N 8480 -5850 8490 -5840 {
lab=row_n[28]}
N 8480 -5630 8480 -5610 {
lab=row_n[28]}
N 8480 -5870 8480 -5850 {
lab=row_n[28]}
N 8360 -5770 8370 -5780 {
lab=col_n[18]}
N 8370 -5780 8570 -5780 {
lab=col_n[18]}
N 8570 -5780 8580 -5770 {
lab=col_n[18]}
N 8360 -5750 8370 -5760 {
lab=colon_n[18]}
N 8370 -5760 8570 -5760 {
lab=colon_n[18]}
N 8570 -5760 8580 -5750 {
lab=colon_n[18]}
N 8360 -5730 8370 -5740 {
lab=#net37}
N 8370 -5740 8570 -5740 {
lab=#net37}
N 8570 -5740 8580 -5730 {
lab=#net37}
N 8360 -5710 8370 -5720 {
lab=#net38}
N 8370 -5720 8570 -5720 {
lab=#net38}
N 8570 -5720 8580 -5710 {
lab=#net38}
N 8420 -5870 8420 -5850 {
lab=vcom}
N 8460 -5870 8460 -5850 {
lab=ctop}
N 8340 -5770 8360 -5770 {
lab=col_n[18]}
N 8340 -5750 8360 -5750 {
lab=colon_n[18]}
N 8340 -5730 8360 -5730 {
lab=#net37}
N 8340 -5710 8360 -5710 {
lab=#net38}
N 8580 -5710 8600 -5710 {
lab=#net38}
N 8580 -5730 8600 -5730 {
lab=#net37}
N 8580 -5750 8600 -5750 {
lab=colon_n[18]}
N 8580 -5770 8600 -5770 {
lab=col_n[18]}
N 8400 -5630 8400 -5620 {
lab=VSS}
N 8400 -5860 8400 -5850 {
lab=VDD}
N 8740 -5630 8750 -5640 {
lab=row_n[29]}
N 8750 -5840 8750 -5640 {
lab=row_n[29]}
N 8740 -5850 8750 -5840 {
lab=row_n[29]}
N 8740 -5630 8740 -5610 {
lab=row_n[29]}
N 8740 -5870 8740 -5850 {
lab=row_n[29]}
N 8620 -5770 8630 -5780 {
lab=col_n[18]}
N 8630 -5780 8830 -5780 {
lab=col_n[18]}
N 8830 -5780 8840 -5770 {
lab=col_n[18]}
N 8620 -5750 8630 -5760 {
lab=colon_n[18]}
N 8630 -5760 8830 -5760 {
lab=colon_n[18]}
N 8830 -5760 8840 -5750 {
lab=colon_n[18]}
N 8620 -5730 8630 -5740 {
lab=#net37}
N 8630 -5740 8830 -5740 {
lab=#net37}
N 8830 -5740 8840 -5730 {
lab=#net37}
N 8620 -5710 8630 -5720 {
lab=#net38}
N 8630 -5720 8830 -5720 {
lab=#net38}
N 8830 -5720 8840 -5710 {
lab=#net38}
N 8680 -5870 8680 -5850 {
lab=vcom}
N 8720 -5870 8720 -5850 {
lab=ctop}
N 8600 -5770 8620 -5770 {
lab=col_n[18]}
N 8600 -5750 8620 -5750 {
lab=colon_n[18]}
N 8600 -5730 8620 -5730 {
lab=#net37}
N 8600 -5710 8620 -5710 {
lab=#net38}
N 8840 -5710 8860 -5710 {
lab=#net38}
N 8840 -5730 8860 -5730 {
lab=#net37}
N 8840 -5750 8860 -5750 {
lab=colon_n[18]}
N 8840 -5770 8860 -5770 {
lab=col_n[18]}
N 8660 -5630 8660 -5620 {
lab=VSS}
N 8660 -5860 8660 -5850 {
lab=VDD}
N 9000 -5630 9010 -5640 {
lab=row_n[30]}
N 9010 -5840 9010 -5640 {
lab=row_n[30]}
N 9000 -5850 9010 -5840 {
lab=row_n[30]}
N 9000 -5630 9000 -5610 {
lab=row_n[30]}
N 9000 -5870 9000 -5850 {
lab=row_n[30]}
N 8880 -5770 8890 -5780 {
lab=col_n[18]}
N 8890 -5780 9090 -5780 {
lab=col_n[18]}
N 9090 -5780 9100 -5770 {
lab=col_n[18]}
N 8880 -5750 8890 -5760 {
lab=colon_n[18]}
N 8890 -5760 9090 -5760 {
lab=colon_n[18]}
N 9090 -5760 9100 -5750 {
lab=colon_n[18]}
N 8880 -5730 8890 -5740 {
lab=#net37}
N 8890 -5740 9090 -5740 {
lab=#net37}
N 9090 -5740 9100 -5730 {
lab=#net37}
N 8880 -5710 8890 -5720 {
lab=#net38}
N 8890 -5720 9090 -5720 {
lab=#net38}
N 9090 -5720 9100 -5710 {
lab=#net38}
N 8940 -5870 8940 -5850 {
lab=vcom}
N 8980 -5870 8980 -5850 {
lab=ctop}
N 8860 -5770 8880 -5770 {
lab=col_n[18]}
N 8860 -5750 8880 -5750 {
lab=colon_n[18]}
N 8860 -5730 8880 -5730 {
lab=#net37}
N 8860 -5710 8880 -5710 {
lab=#net38}
N 9100 -5710 9120 -5710 {
lab=#net38}
N 9100 -5730 9120 -5730 {
lab=#net37}
N 9100 -5750 9120 -5750 {
lab=colon_n[18]}
N 9100 -5770 9120 -5770 {
lab=col_n[18]}
N 8920 -5630 8920 -5620 {
lab=VSS}
N 8920 -5860 8920 -5850 {
lab=VDD}
N 9260 -5630 9270 -5640 {
lab=row_n[31]}
N 9270 -5840 9270 -5640 {
lab=row_n[31]}
N 9260 -5850 9270 -5840 {
lab=row_n[31]}
N 9260 -5630 9260 -5610 {
lab=row_n[31]}
N 9260 -5870 9260 -5850 {
lab=row_n[31]}
N 9140 -5770 9150 -5780 {
lab=col_n[18]}
N 9150 -5780 9350 -5780 {
lab=col_n[18]}
N 9350 -5780 9360 -5770 {
lab=col_n[18]}
N 9140 -5750 9150 -5760 {
lab=colon_n[18]}
N 9150 -5760 9350 -5760 {
lab=colon_n[18]}
N 9350 -5760 9360 -5750 {
lab=colon_n[18]}
N 9140 -5730 9150 -5740 {
lab=#net37}
N 9150 -5740 9350 -5740 {
lab=#net37}
N 9350 -5740 9360 -5730 {
lab=#net37}
N 9140 -5710 9150 -5720 {
lab=#net38}
N 9150 -5720 9350 -5720 {
lab=#net38}
N 9350 -5720 9360 -5710 {
lab=#net38}
N 9200 -5870 9200 -5850 {
lab=vcom}
N 9240 -5870 9240 -5850 {
lab=ctop}
N 9120 -5770 9140 -5770 {
lab=col_n[18]}
N 9120 -5750 9140 -5750 {
lab=colon_n[18]}
N 9120 -5730 9140 -5730 {
lab=#net37}
N 9120 -5710 9140 -5710 {
lab=#net38}
N 9360 -5710 9380 -5710 {
lab=#net38}
N 9360 -5730 9380 -5730 {
lab=#net37}
N 9360 -5750 9380 -5750 {
lab=colon_n[18]}
N 9360 -5770 9380 -5770 {
lab=col_n[18]}
N 9180 -5630 9180 -5620 {
lab=VSS}
N 9180 -5860 9180 -5850 {
lab=VDD}
N 1200 -5890 1210 -5900 {
lab=row_n[0]}
N 1210 -6100 1210 -5900 {
lab=row_n[0]}
N 1200 -6110 1210 -6100 {
lab=row_n[0]}
N 1200 -5890 1200 -5870 {
lab=row_n[0]}
N 1200 -6130 1200 -6110 {
lab=row_n[0]}
N 1080 -6030 1090 -6040 {
lab=col_n[19]}
N 1090 -6040 1290 -6040 {
lab=col_n[19]}
N 1290 -6040 1300 -6030 {
lab=col_n[19]}
N 1080 -6010 1090 -6020 {
lab=colon_n[19]}
N 1090 -6020 1290 -6020 {
lab=colon_n[19]}
N 1290 -6020 1300 -6010 {
lab=colon_n[19]}
N 1080 -5990 1090 -6000 {
lab=#net39}
N 1090 -6000 1290 -6000 {
lab=#net39}
N 1290 -6000 1300 -5990 {
lab=#net39}
N 1080 -5970 1090 -5980 {
lab=#net40}
N 1090 -5980 1290 -5980 {
lab=#net40}
N 1290 -5980 1300 -5970 {
lab=#net40}
N 1140 -6130 1140 -6110 {
lab=vcom}
N 1180 -6130 1180 -6110 {
lab=ctop}
N 1060 -6030 1080 -6030 {
lab=col_n[19]}
N 1060 -6010 1080 -6010 {
lab=colon_n[19]}
N 1060 -5990 1080 -5990 {
lab=#net39}
N 1060 -5970 1080 -5970 {
lab=#net40}
N 1300 -5970 1320 -5970 {
lab=#net40}
N 1300 -5990 1320 -5990 {
lab=#net39}
N 1300 -6010 1320 -6010 {
lab=colon_n[19]}
N 1300 -6030 1320 -6030 {
lab=col_n[19]}
N 1120 -5890 1120 -5880 {
lab=VSS}
N 1120 -6120 1120 -6110 {
lab=VDD}
N 1460 -5890 1470 -5900 {
lab=row_n[1]}
N 1470 -6100 1470 -5900 {
lab=row_n[1]}
N 1460 -6110 1470 -6100 {
lab=row_n[1]}
N 1460 -5890 1460 -5870 {
lab=row_n[1]}
N 1460 -6130 1460 -6110 {
lab=row_n[1]}
N 1340 -6030 1350 -6040 {
lab=col_n[19]}
N 1350 -6040 1550 -6040 {
lab=col_n[19]}
N 1550 -6040 1560 -6030 {
lab=col_n[19]}
N 1340 -6010 1350 -6020 {
lab=colon_n[19]}
N 1350 -6020 1550 -6020 {
lab=colon_n[19]}
N 1550 -6020 1560 -6010 {
lab=colon_n[19]}
N 1340 -5990 1350 -6000 {
lab=#net39}
N 1350 -6000 1550 -6000 {
lab=#net39}
N 1550 -6000 1560 -5990 {
lab=#net39}
N 1340 -5970 1350 -5980 {
lab=#net40}
N 1350 -5980 1550 -5980 {
lab=#net40}
N 1550 -5980 1560 -5970 {
lab=#net40}
N 1400 -6130 1400 -6110 {
lab=vcom}
N 1440 -6130 1440 -6110 {
lab=ctop}
N 1320 -6030 1340 -6030 {
lab=col_n[19]}
N 1320 -6010 1340 -6010 {
lab=colon_n[19]}
N 1320 -5990 1340 -5990 {
lab=#net39}
N 1320 -5970 1340 -5970 {
lab=#net40}
N 1560 -5970 1580 -5970 {
lab=#net40}
N 1560 -5990 1580 -5990 {
lab=#net39}
N 1560 -6010 1580 -6010 {
lab=colon_n[19]}
N 1560 -6030 1580 -6030 {
lab=col_n[19]}
N 1380 -5890 1380 -5880 {
lab=VSS}
N 1380 -6120 1380 -6110 {
lab=VDD}
N 1720 -5890 1730 -5900 {
lab=row_n[2]}
N 1730 -6100 1730 -5900 {
lab=row_n[2]}
N 1720 -6110 1730 -6100 {
lab=row_n[2]}
N 1720 -5890 1720 -5870 {
lab=row_n[2]}
N 1720 -6130 1720 -6110 {
lab=row_n[2]}
N 1600 -6030 1610 -6040 {
lab=col_n[19]}
N 1610 -6040 1810 -6040 {
lab=col_n[19]}
N 1810 -6040 1820 -6030 {
lab=col_n[19]}
N 1600 -6010 1610 -6020 {
lab=colon_n[19]}
N 1610 -6020 1810 -6020 {
lab=colon_n[19]}
N 1810 -6020 1820 -6010 {
lab=colon_n[19]}
N 1600 -5990 1610 -6000 {
lab=#net39}
N 1610 -6000 1810 -6000 {
lab=#net39}
N 1810 -6000 1820 -5990 {
lab=#net39}
N 1600 -5970 1610 -5980 {
lab=#net40}
N 1610 -5980 1810 -5980 {
lab=#net40}
N 1810 -5980 1820 -5970 {
lab=#net40}
N 1660 -6130 1660 -6110 {
lab=vcom}
N 1700 -6130 1700 -6110 {
lab=ctop}
N 1580 -6030 1600 -6030 {
lab=col_n[19]}
N 1580 -6010 1600 -6010 {
lab=colon_n[19]}
N 1580 -5990 1600 -5990 {
lab=#net39}
N 1580 -5970 1600 -5970 {
lab=#net40}
N 1820 -5970 1840 -5970 {
lab=#net40}
N 1820 -5990 1840 -5990 {
lab=#net39}
N 1820 -6010 1840 -6010 {
lab=colon_n[19]}
N 1820 -6030 1840 -6030 {
lab=col_n[19]}
N 1640 -5890 1640 -5880 {
lab=VSS}
N 1640 -6120 1640 -6110 {
lab=VDD}
N 1980 -5890 1990 -5900 {
lab=row_n[3]}
N 1990 -6100 1990 -5900 {
lab=row_n[3]}
N 1980 -6110 1990 -6100 {
lab=row_n[3]}
N 1980 -5890 1980 -5870 {
lab=row_n[3]}
N 1980 -6130 1980 -6110 {
lab=row_n[3]}
N 1860 -6030 1870 -6040 {
lab=col_n[19]}
N 1870 -6040 2070 -6040 {
lab=col_n[19]}
N 2070 -6040 2080 -6030 {
lab=col_n[19]}
N 1860 -6010 1870 -6020 {
lab=colon_n[19]}
N 1870 -6020 2070 -6020 {
lab=colon_n[19]}
N 2070 -6020 2080 -6010 {
lab=colon_n[19]}
N 1860 -5990 1870 -6000 {
lab=#net39}
N 1870 -6000 2070 -6000 {
lab=#net39}
N 2070 -6000 2080 -5990 {
lab=#net39}
N 1860 -5970 1870 -5980 {
lab=#net40}
N 1870 -5980 2070 -5980 {
lab=#net40}
N 2070 -5980 2080 -5970 {
lab=#net40}
N 1920 -6130 1920 -6110 {
lab=vcom}
N 1960 -6130 1960 -6110 {
lab=ctop}
N 1840 -6030 1860 -6030 {
lab=col_n[19]}
N 1840 -6010 1860 -6010 {
lab=colon_n[19]}
N 1840 -5990 1860 -5990 {
lab=#net39}
N 1840 -5970 1860 -5970 {
lab=#net40}
N 2080 -5970 2100 -5970 {
lab=#net40}
N 2080 -5990 2100 -5990 {
lab=#net39}
N 2080 -6010 2100 -6010 {
lab=colon_n[19]}
N 2080 -6030 2100 -6030 {
lab=col_n[19]}
N 1900 -5890 1900 -5880 {
lab=VSS}
N 1900 -6120 1900 -6110 {
lab=VDD}
N 2240 -5890 2250 -5900 {
lab=row_n[4]}
N 2250 -6100 2250 -5900 {
lab=row_n[4]}
N 2240 -6110 2250 -6100 {
lab=row_n[4]}
N 2240 -5890 2240 -5870 {
lab=row_n[4]}
N 2240 -6130 2240 -6110 {
lab=row_n[4]}
N 2120 -6030 2130 -6040 {
lab=col_n[19]}
N 2130 -6040 2330 -6040 {
lab=col_n[19]}
N 2330 -6040 2340 -6030 {
lab=col_n[19]}
N 2120 -6010 2130 -6020 {
lab=colon_n[19]}
N 2130 -6020 2330 -6020 {
lab=colon_n[19]}
N 2330 -6020 2340 -6010 {
lab=colon_n[19]}
N 2120 -5990 2130 -6000 {
lab=#net39}
N 2130 -6000 2330 -6000 {
lab=#net39}
N 2330 -6000 2340 -5990 {
lab=#net39}
N 2120 -5970 2130 -5980 {
lab=#net40}
N 2130 -5980 2330 -5980 {
lab=#net40}
N 2330 -5980 2340 -5970 {
lab=#net40}
N 2180 -6130 2180 -6110 {
lab=vcom}
N 2220 -6130 2220 -6110 {
lab=ctop}
N 2100 -6030 2120 -6030 {
lab=col_n[19]}
N 2100 -6010 2120 -6010 {
lab=colon_n[19]}
N 2100 -5990 2120 -5990 {
lab=#net39}
N 2100 -5970 2120 -5970 {
lab=#net40}
N 2340 -5970 2360 -5970 {
lab=#net40}
N 2340 -5990 2360 -5990 {
lab=#net39}
N 2340 -6010 2360 -6010 {
lab=colon_n[19]}
N 2340 -6030 2360 -6030 {
lab=col_n[19]}
N 2160 -5890 2160 -5880 {
lab=VSS}
N 2160 -6120 2160 -6110 {
lab=VDD}
N 2500 -5890 2510 -5900 {
lab=row_n[5]}
N 2510 -6100 2510 -5900 {
lab=row_n[5]}
N 2500 -6110 2510 -6100 {
lab=row_n[5]}
N 2500 -5890 2500 -5870 {
lab=row_n[5]}
N 2500 -6130 2500 -6110 {
lab=row_n[5]}
N 2380 -6030 2390 -6040 {
lab=col_n[19]}
N 2390 -6040 2590 -6040 {
lab=col_n[19]}
N 2590 -6040 2600 -6030 {
lab=col_n[19]}
N 2380 -6010 2390 -6020 {
lab=colon_n[19]}
N 2390 -6020 2590 -6020 {
lab=colon_n[19]}
N 2590 -6020 2600 -6010 {
lab=colon_n[19]}
N 2380 -5990 2390 -6000 {
lab=#net39}
N 2390 -6000 2590 -6000 {
lab=#net39}
N 2590 -6000 2600 -5990 {
lab=#net39}
N 2380 -5970 2390 -5980 {
lab=#net40}
N 2390 -5980 2590 -5980 {
lab=#net40}
N 2590 -5980 2600 -5970 {
lab=#net40}
N 2440 -6130 2440 -6110 {
lab=vcom}
N 2480 -6130 2480 -6110 {
lab=ctop}
N 2360 -6030 2380 -6030 {
lab=col_n[19]}
N 2360 -6010 2380 -6010 {
lab=colon_n[19]}
N 2360 -5990 2380 -5990 {
lab=#net39}
N 2360 -5970 2380 -5970 {
lab=#net40}
N 2600 -5970 2620 -5970 {
lab=#net40}
N 2600 -5990 2620 -5990 {
lab=#net39}
N 2600 -6010 2620 -6010 {
lab=colon_n[19]}
N 2600 -6030 2620 -6030 {
lab=col_n[19]}
N 2420 -5890 2420 -5880 {
lab=VSS}
N 2420 -6120 2420 -6110 {
lab=VDD}
N 2760 -5890 2770 -5900 {
lab=row_n[6]}
N 2770 -6100 2770 -5900 {
lab=row_n[6]}
N 2760 -6110 2770 -6100 {
lab=row_n[6]}
N 2760 -5890 2760 -5870 {
lab=row_n[6]}
N 2760 -6130 2760 -6110 {
lab=row_n[6]}
N 2640 -6030 2650 -6040 {
lab=col_n[19]}
N 2650 -6040 2850 -6040 {
lab=col_n[19]}
N 2850 -6040 2860 -6030 {
lab=col_n[19]}
N 2640 -6010 2650 -6020 {
lab=colon_n[19]}
N 2650 -6020 2850 -6020 {
lab=colon_n[19]}
N 2850 -6020 2860 -6010 {
lab=colon_n[19]}
N 2640 -5990 2650 -6000 {
lab=#net39}
N 2650 -6000 2850 -6000 {
lab=#net39}
N 2850 -6000 2860 -5990 {
lab=#net39}
N 2640 -5970 2650 -5980 {
lab=#net40}
N 2650 -5980 2850 -5980 {
lab=#net40}
N 2850 -5980 2860 -5970 {
lab=#net40}
N 2700 -6130 2700 -6110 {
lab=vcom}
N 2740 -6130 2740 -6110 {
lab=ctop}
N 2620 -6030 2640 -6030 {
lab=col_n[19]}
N 2620 -6010 2640 -6010 {
lab=colon_n[19]}
N 2620 -5990 2640 -5990 {
lab=#net39}
N 2620 -5970 2640 -5970 {
lab=#net40}
N 2860 -5970 2880 -5970 {
lab=#net40}
N 2860 -5990 2880 -5990 {
lab=#net39}
N 2860 -6010 2880 -6010 {
lab=colon_n[19]}
N 2860 -6030 2880 -6030 {
lab=col_n[19]}
N 2680 -5890 2680 -5880 {
lab=VSS}
N 2680 -6120 2680 -6110 {
lab=VDD}
N 3020 -5890 3030 -5900 {
lab=row_n[7]}
N 3030 -6100 3030 -5900 {
lab=row_n[7]}
N 3020 -6110 3030 -6100 {
lab=row_n[7]}
N 3020 -5890 3020 -5870 {
lab=row_n[7]}
N 3020 -6130 3020 -6110 {
lab=row_n[7]}
N 2900 -6030 2910 -6040 {
lab=col_n[19]}
N 2910 -6040 3110 -6040 {
lab=col_n[19]}
N 3110 -6040 3120 -6030 {
lab=col_n[19]}
N 2900 -6010 2910 -6020 {
lab=colon_n[19]}
N 2910 -6020 3110 -6020 {
lab=colon_n[19]}
N 3110 -6020 3120 -6010 {
lab=colon_n[19]}
N 2900 -5990 2910 -6000 {
lab=#net39}
N 2910 -6000 3110 -6000 {
lab=#net39}
N 3110 -6000 3120 -5990 {
lab=#net39}
N 2900 -5970 2910 -5980 {
lab=#net40}
N 2910 -5980 3110 -5980 {
lab=#net40}
N 3110 -5980 3120 -5970 {
lab=#net40}
N 2960 -6130 2960 -6110 {
lab=vcom}
N 3000 -6130 3000 -6110 {
lab=ctop}
N 2880 -6030 2900 -6030 {
lab=col_n[19]}
N 2880 -6010 2900 -6010 {
lab=colon_n[19]}
N 2880 -5990 2900 -5990 {
lab=#net39}
N 2880 -5970 2900 -5970 {
lab=#net40}
N 3120 -5970 3140 -5970 {
lab=#net40}
N 3120 -5990 3140 -5990 {
lab=#net39}
N 3120 -6010 3140 -6010 {
lab=colon_n[19]}
N 3120 -6030 3140 -6030 {
lab=col_n[19]}
N 2940 -5890 2940 -5880 {
lab=VSS}
N 2940 -6120 2940 -6110 {
lab=VDD}
N 3280 -5890 3290 -5900 {
lab=row_n[8]}
N 3290 -6100 3290 -5900 {
lab=row_n[8]}
N 3280 -6110 3290 -6100 {
lab=row_n[8]}
N 3280 -5890 3280 -5870 {
lab=row_n[8]}
N 3280 -6130 3280 -6110 {
lab=row_n[8]}
N 3160 -6030 3170 -6040 {
lab=col_n[19]}
N 3170 -6040 3370 -6040 {
lab=col_n[19]}
N 3370 -6040 3380 -6030 {
lab=col_n[19]}
N 3160 -6010 3170 -6020 {
lab=colon_n[19]}
N 3170 -6020 3370 -6020 {
lab=colon_n[19]}
N 3370 -6020 3380 -6010 {
lab=colon_n[19]}
N 3160 -5990 3170 -6000 {
lab=#net39}
N 3170 -6000 3370 -6000 {
lab=#net39}
N 3370 -6000 3380 -5990 {
lab=#net39}
N 3160 -5970 3170 -5980 {
lab=#net40}
N 3170 -5980 3370 -5980 {
lab=#net40}
N 3370 -5980 3380 -5970 {
lab=#net40}
N 3220 -6130 3220 -6110 {
lab=vcom}
N 3260 -6130 3260 -6110 {
lab=ctop}
N 3140 -6030 3160 -6030 {
lab=col_n[19]}
N 3140 -6010 3160 -6010 {
lab=colon_n[19]}
N 3140 -5990 3160 -5990 {
lab=#net39}
N 3140 -5970 3160 -5970 {
lab=#net40}
N 3380 -5970 3400 -5970 {
lab=#net40}
N 3380 -5990 3400 -5990 {
lab=#net39}
N 3380 -6010 3400 -6010 {
lab=colon_n[19]}
N 3380 -6030 3400 -6030 {
lab=col_n[19]}
N 3200 -5890 3200 -5880 {
lab=VSS}
N 3200 -6120 3200 -6110 {
lab=VDD}
N 3540 -5890 3550 -5900 {
lab=row_n[9]}
N 3550 -6100 3550 -5900 {
lab=row_n[9]}
N 3540 -6110 3550 -6100 {
lab=row_n[9]}
N 3540 -5890 3540 -5870 {
lab=row_n[9]}
N 3540 -6130 3540 -6110 {
lab=row_n[9]}
N 3420 -6030 3430 -6040 {
lab=col_n[19]}
N 3430 -6040 3630 -6040 {
lab=col_n[19]}
N 3630 -6040 3640 -6030 {
lab=col_n[19]}
N 3420 -6010 3430 -6020 {
lab=colon_n[19]}
N 3430 -6020 3630 -6020 {
lab=colon_n[19]}
N 3630 -6020 3640 -6010 {
lab=colon_n[19]}
N 3420 -5990 3430 -6000 {
lab=#net39}
N 3430 -6000 3630 -6000 {
lab=#net39}
N 3630 -6000 3640 -5990 {
lab=#net39}
N 3420 -5970 3430 -5980 {
lab=#net40}
N 3430 -5980 3630 -5980 {
lab=#net40}
N 3630 -5980 3640 -5970 {
lab=#net40}
N 3480 -6130 3480 -6110 {
lab=vcom}
N 3520 -6130 3520 -6110 {
lab=ctop}
N 3400 -6030 3420 -6030 {
lab=col_n[19]}
N 3400 -6010 3420 -6010 {
lab=colon_n[19]}
N 3400 -5990 3420 -5990 {
lab=#net39}
N 3400 -5970 3420 -5970 {
lab=#net40}
N 3640 -5970 3660 -5970 {
lab=#net40}
N 3640 -5990 3660 -5990 {
lab=#net39}
N 3640 -6010 3660 -6010 {
lab=colon_n[19]}
N 3640 -6030 3660 -6030 {
lab=col_n[19]}
N 3460 -5890 3460 -5880 {
lab=VSS}
N 3460 -6120 3460 -6110 {
lab=VDD}
N 3800 -5890 3810 -5900 {
lab=row_n[10]}
N 3810 -6100 3810 -5900 {
lab=row_n[10]}
N 3800 -6110 3810 -6100 {
lab=row_n[10]}
N 3800 -5890 3800 -5870 {
lab=row_n[10]}
N 3800 -6130 3800 -6110 {
lab=row_n[10]}
N 3680 -6030 3690 -6040 {
lab=col_n[19]}
N 3690 -6040 3890 -6040 {
lab=col_n[19]}
N 3890 -6040 3900 -6030 {
lab=col_n[19]}
N 3680 -6010 3690 -6020 {
lab=colon_n[19]}
N 3690 -6020 3890 -6020 {
lab=colon_n[19]}
N 3890 -6020 3900 -6010 {
lab=colon_n[19]}
N 3680 -5990 3690 -6000 {
lab=#net39}
N 3690 -6000 3890 -6000 {
lab=#net39}
N 3890 -6000 3900 -5990 {
lab=#net39}
N 3680 -5970 3690 -5980 {
lab=#net40}
N 3690 -5980 3890 -5980 {
lab=#net40}
N 3890 -5980 3900 -5970 {
lab=#net40}
N 3740 -6130 3740 -6110 {
lab=vcom}
N 3780 -6130 3780 -6110 {
lab=ctop}
N 3660 -6030 3680 -6030 {
lab=col_n[19]}
N 3660 -6010 3680 -6010 {
lab=colon_n[19]}
N 3660 -5990 3680 -5990 {
lab=#net39}
N 3660 -5970 3680 -5970 {
lab=#net40}
N 3900 -5970 3920 -5970 {
lab=#net40}
N 3900 -5990 3920 -5990 {
lab=#net39}
N 3900 -6010 3920 -6010 {
lab=colon_n[19]}
N 3900 -6030 3920 -6030 {
lab=col_n[19]}
N 3720 -5890 3720 -5880 {
lab=VSS}
N 3720 -6120 3720 -6110 {
lab=VDD}
N 4060 -5890 4070 -5900 {
lab=row_n[11]}
N 4070 -6100 4070 -5900 {
lab=row_n[11]}
N 4060 -6110 4070 -6100 {
lab=row_n[11]}
N 4060 -5890 4060 -5870 {
lab=row_n[11]}
N 4060 -6130 4060 -6110 {
lab=row_n[11]}
N 3940 -6030 3950 -6040 {
lab=col_n[19]}
N 3950 -6040 4150 -6040 {
lab=col_n[19]}
N 4150 -6040 4160 -6030 {
lab=col_n[19]}
N 3940 -6010 3950 -6020 {
lab=colon_n[19]}
N 3950 -6020 4150 -6020 {
lab=colon_n[19]}
N 4150 -6020 4160 -6010 {
lab=colon_n[19]}
N 3940 -5990 3950 -6000 {
lab=#net39}
N 3950 -6000 4150 -6000 {
lab=#net39}
N 4150 -6000 4160 -5990 {
lab=#net39}
N 3940 -5970 3950 -5980 {
lab=#net40}
N 3950 -5980 4150 -5980 {
lab=#net40}
N 4150 -5980 4160 -5970 {
lab=#net40}
N 4000 -6130 4000 -6110 {
lab=vcom}
N 4040 -6130 4040 -6110 {
lab=ctop}
N 3920 -6030 3940 -6030 {
lab=col_n[19]}
N 3920 -6010 3940 -6010 {
lab=colon_n[19]}
N 3920 -5990 3940 -5990 {
lab=#net39}
N 3920 -5970 3940 -5970 {
lab=#net40}
N 4160 -5970 4180 -5970 {
lab=#net40}
N 4160 -5990 4180 -5990 {
lab=#net39}
N 4160 -6010 4180 -6010 {
lab=colon_n[19]}
N 4160 -6030 4180 -6030 {
lab=col_n[19]}
N 3980 -5890 3980 -5880 {
lab=VSS}
N 3980 -6120 3980 -6110 {
lab=VDD}
N 4320 -5890 4330 -5900 {
lab=row_n[12]}
N 4330 -6100 4330 -5900 {
lab=row_n[12]}
N 4320 -6110 4330 -6100 {
lab=row_n[12]}
N 4320 -5890 4320 -5870 {
lab=row_n[12]}
N 4320 -6130 4320 -6110 {
lab=row_n[12]}
N 4200 -6030 4210 -6040 {
lab=col_n[19]}
N 4210 -6040 4410 -6040 {
lab=col_n[19]}
N 4410 -6040 4420 -6030 {
lab=col_n[19]}
N 4200 -6010 4210 -6020 {
lab=colon_n[19]}
N 4210 -6020 4410 -6020 {
lab=colon_n[19]}
N 4410 -6020 4420 -6010 {
lab=colon_n[19]}
N 4200 -5990 4210 -6000 {
lab=#net39}
N 4210 -6000 4410 -6000 {
lab=#net39}
N 4410 -6000 4420 -5990 {
lab=#net39}
N 4200 -5970 4210 -5980 {
lab=#net40}
N 4210 -5980 4410 -5980 {
lab=#net40}
N 4410 -5980 4420 -5970 {
lab=#net40}
N 4260 -6130 4260 -6110 {
lab=vcom}
N 4300 -6130 4300 -6110 {
lab=ctop}
N 4180 -6030 4200 -6030 {
lab=col_n[19]}
N 4180 -6010 4200 -6010 {
lab=colon_n[19]}
N 4180 -5990 4200 -5990 {
lab=#net39}
N 4180 -5970 4200 -5970 {
lab=#net40}
N 4420 -5970 4440 -5970 {
lab=#net40}
N 4420 -5990 4440 -5990 {
lab=#net39}
N 4420 -6010 4440 -6010 {
lab=colon_n[19]}
N 4420 -6030 4440 -6030 {
lab=col_n[19]}
N 4240 -5890 4240 -5880 {
lab=VSS}
N 4240 -6120 4240 -6110 {
lab=VDD}
N 4580 -5890 4590 -5900 {
lab=row_n[13]}
N 4590 -6100 4590 -5900 {
lab=row_n[13]}
N 4580 -6110 4590 -6100 {
lab=row_n[13]}
N 4580 -5890 4580 -5870 {
lab=row_n[13]}
N 4580 -6130 4580 -6110 {
lab=row_n[13]}
N 4460 -6030 4470 -6040 {
lab=col_n[19]}
N 4470 -6040 4670 -6040 {
lab=col_n[19]}
N 4670 -6040 4680 -6030 {
lab=col_n[19]}
N 4460 -6010 4470 -6020 {
lab=colon_n[19]}
N 4470 -6020 4670 -6020 {
lab=colon_n[19]}
N 4670 -6020 4680 -6010 {
lab=colon_n[19]}
N 4460 -5990 4470 -6000 {
lab=#net39}
N 4470 -6000 4670 -6000 {
lab=#net39}
N 4670 -6000 4680 -5990 {
lab=#net39}
N 4460 -5970 4470 -5980 {
lab=#net40}
N 4470 -5980 4670 -5980 {
lab=#net40}
N 4670 -5980 4680 -5970 {
lab=#net40}
N 4520 -6130 4520 -6110 {
lab=vcom}
N 4560 -6130 4560 -6110 {
lab=ctop}
N 4440 -6030 4460 -6030 {
lab=col_n[19]}
N 4440 -6010 4460 -6010 {
lab=colon_n[19]}
N 4440 -5990 4460 -5990 {
lab=#net39}
N 4440 -5970 4460 -5970 {
lab=#net40}
N 4680 -5970 4700 -5970 {
lab=#net40}
N 4680 -5990 4700 -5990 {
lab=#net39}
N 4680 -6010 4700 -6010 {
lab=colon_n[19]}
N 4680 -6030 4700 -6030 {
lab=col_n[19]}
N 4500 -5890 4500 -5880 {
lab=VSS}
N 4500 -6120 4500 -6110 {
lab=VDD}
N 4840 -5890 4850 -5900 {
lab=row_n[14]}
N 4850 -6100 4850 -5900 {
lab=row_n[14]}
N 4840 -6110 4850 -6100 {
lab=row_n[14]}
N 4840 -5890 4840 -5870 {
lab=row_n[14]}
N 4840 -6130 4840 -6110 {
lab=row_n[14]}
N 4720 -6030 4730 -6040 {
lab=col_n[19]}
N 4730 -6040 4930 -6040 {
lab=col_n[19]}
N 4930 -6040 4940 -6030 {
lab=col_n[19]}
N 4720 -6010 4730 -6020 {
lab=colon_n[19]}
N 4730 -6020 4930 -6020 {
lab=colon_n[19]}
N 4930 -6020 4940 -6010 {
lab=colon_n[19]}
N 4720 -5990 4730 -6000 {
lab=#net39}
N 4730 -6000 4930 -6000 {
lab=#net39}
N 4930 -6000 4940 -5990 {
lab=#net39}
N 4720 -5970 4730 -5980 {
lab=#net40}
N 4730 -5980 4930 -5980 {
lab=#net40}
N 4930 -5980 4940 -5970 {
lab=#net40}
N 4780 -6130 4780 -6110 {
lab=vcom}
N 4820 -6130 4820 -6110 {
lab=ctop}
N 4700 -6030 4720 -6030 {
lab=col_n[19]}
N 4700 -6010 4720 -6010 {
lab=colon_n[19]}
N 4700 -5990 4720 -5990 {
lab=#net39}
N 4700 -5970 4720 -5970 {
lab=#net40}
N 4940 -5970 4960 -5970 {
lab=#net40}
N 4940 -5990 4960 -5990 {
lab=#net39}
N 4940 -6010 4960 -6010 {
lab=colon_n[19]}
N 4940 -6030 4960 -6030 {
lab=col_n[19]}
N 4760 -5890 4760 -5880 {
lab=VSS}
N 4760 -6120 4760 -6110 {
lab=VDD}
N 5100 -5890 5110 -5900 {
lab=row_n[15]}
N 5110 -6100 5110 -5900 {
lab=row_n[15]}
N 5100 -6110 5110 -6100 {
lab=row_n[15]}
N 5100 -5890 5100 -5870 {
lab=row_n[15]}
N 5100 -6130 5100 -6110 {
lab=row_n[15]}
N 4980 -6030 4990 -6040 {
lab=col_n[19]}
N 4990 -6040 5190 -6040 {
lab=col_n[19]}
N 5190 -6040 5200 -6030 {
lab=col_n[19]}
N 4980 -6010 4990 -6020 {
lab=colon_n[19]}
N 4990 -6020 5190 -6020 {
lab=colon_n[19]}
N 5190 -6020 5200 -6010 {
lab=colon_n[19]}
N 4980 -5990 4990 -6000 {
lab=#net39}
N 4990 -6000 5190 -6000 {
lab=#net39}
N 5190 -6000 5200 -5990 {
lab=#net39}
N 4980 -5970 4990 -5980 {
lab=#net40}
N 4990 -5980 5190 -5980 {
lab=#net40}
N 5190 -5980 5200 -5970 {
lab=#net40}
N 5040 -6130 5040 -6110 {
lab=vcom}
N 5080 -6130 5080 -6110 {
lab=ctop}
N 4960 -6030 4980 -6030 {
lab=col_n[19]}
N 4960 -6010 4980 -6010 {
lab=colon_n[19]}
N 4960 -5990 4980 -5990 {
lab=#net39}
N 4960 -5970 4980 -5970 {
lab=#net40}
N 5200 -5970 5220 -5970 {
lab=#net40}
N 5200 -5990 5220 -5990 {
lab=#net39}
N 5200 -6010 5220 -6010 {
lab=colon_n[19]}
N 5200 -6030 5220 -6030 {
lab=col_n[19]}
N 5020 -5890 5020 -5880 {
lab=VSS}
N 5020 -6120 5020 -6110 {
lab=VDD}
N 5360 -5890 5370 -5900 {
lab=row_n[16]}
N 5370 -6100 5370 -5900 {
lab=row_n[16]}
N 5360 -6110 5370 -6100 {
lab=row_n[16]}
N 5360 -5890 5360 -5870 {
lab=row_n[16]}
N 5360 -6130 5360 -6110 {
lab=row_n[16]}
N 5240 -6030 5250 -6040 {
lab=col_n[19]}
N 5250 -6040 5450 -6040 {
lab=col_n[19]}
N 5450 -6040 5460 -6030 {
lab=col_n[19]}
N 5240 -6010 5250 -6020 {
lab=colon_n[19]}
N 5250 -6020 5450 -6020 {
lab=colon_n[19]}
N 5450 -6020 5460 -6010 {
lab=colon_n[19]}
N 5240 -5990 5250 -6000 {
lab=#net39}
N 5250 -6000 5450 -6000 {
lab=#net39}
N 5450 -6000 5460 -5990 {
lab=#net39}
N 5240 -5970 5250 -5980 {
lab=#net40}
N 5250 -5980 5450 -5980 {
lab=#net40}
N 5450 -5980 5460 -5970 {
lab=#net40}
N 5300 -6130 5300 -6110 {
lab=vcom}
N 5340 -6130 5340 -6110 {
lab=ctop}
N 5220 -6030 5240 -6030 {
lab=col_n[19]}
N 5220 -6010 5240 -6010 {
lab=colon_n[19]}
N 5220 -5990 5240 -5990 {
lab=#net39}
N 5220 -5970 5240 -5970 {
lab=#net40}
N 5460 -5970 5480 -5970 {
lab=#net40}
N 5460 -5990 5480 -5990 {
lab=#net39}
N 5460 -6010 5480 -6010 {
lab=colon_n[19]}
N 5460 -6030 5480 -6030 {
lab=col_n[19]}
N 5280 -5890 5280 -5880 {
lab=VSS}
N 5280 -6120 5280 -6110 {
lab=VDD}
N 5620 -5890 5630 -5900 {
lab=row_n[17]}
N 5630 -6100 5630 -5900 {
lab=row_n[17]}
N 5620 -6110 5630 -6100 {
lab=row_n[17]}
N 5620 -5890 5620 -5870 {
lab=row_n[17]}
N 5620 -6130 5620 -6110 {
lab=row_n[17]}
N 5500 -6030 5510 -6040 {
lab=col_n[19]}
N 5510 -6040 5710 -6040 {
lab=col_n[19]}
N 5710 -6040 5720 -6030 {
lab=col_n[19]}
N 5500 -6010 5510 -6020 {
lab=colon_n[19]}
N 5510 -6020 5710 -6020 {
lab=colon_n[19]}
N 5710 -6020 5720 -6010 {
lab=colon_n[19]}
N 5500 -5990 5510 -6000 {
lab=#net39}
N 5510 -6000 5710 -6000 {
lab=#net39}
N 5710 -6000 5720 -5990 {
lab=#net39}
N 5500 -5970 5510 -5980 {
lab=#net40}
N 5510 -5980 5710 -5980 {
lab=#net40}
N 5710 -5980 5720 -5970 {
lab=#net40}
N 5560 -6130 5560 -6110 {
lab=vcom}
N 5600 -6130 5600 -6110 {
lab=ctop}
N 5480 -6030 5500 -6030 {
lab=col_n[19]}
N 5480 -6010 5500 -6010 {
lab=colon_n[19]}
N 5480 -5990 5500 -5990 {
lab=#net39}
N 5480 -5970 5500 -5970 {
lab=#net40}
N 5720 -5970 5740 -5970 {
lab=#net40}
N 5720 -5990 5740 -5990 {
lab=#net39}
N 5720 -6010 5740 -6010 {
lab=colon_n[19]}
N 5720 -6030 5740 -6030 {
lab=col_n[19]}
N 5540 -5890 5540 -5880 {
lab=VSS}
N 5540 -6120 5540 -6110 {
lab=VDD}
N 5880 -5890 5890 -5900 {
lab=row_n[18]}
N 5890 -6100 5890 -5900 {
lab=row_n[18]}
N 5880 -6110 5890 -6100 {
lab=row_n[18]}
N 5880 -5890 5880 -5870 {
lab=row_n[18]}
N 5880 -6130 5880 -6110 {
lab=row_n[18]}
N 5760 -6030 5770 -6040 {
lab=col_n[19]}
N 5770 -6040 5970 -6040 {
lab=col_n[19]}
N 5970 -6040 5980 -6030 {
lab=col_n[19]}
N 5760 -6010 5770 -6020 {
lab=colon_n[19]}
N 5770 -6020 5970 -6020 {
lab=colon_n[19]}
N 5970 -6020 5980 -6010 {
lab=colon_n[19]}
N 5760 -5990 5770 -6000 {
lab=#net39}
N 5770 -6000 5970 -6000 {
lab=#net39}
N 5970 -6000 5980 -5990 {
lab=#net39}
N 5760 -5970 5770 -5980 {
lab=#net40}
N 5770 -5980 5970 -5980 {
lab=#net40}
N 5970 -5980 5980 -5970 {
lab=#net40}
N 5820 -6130 5820 -6110 {
lab=vcom}
N 5860 -6130 5860 -6110 {
lab=ctop}
N 5740 -6030 5760 -6030 {
lab=col_n[19]}
N 5740 -6010 5760 -6010 {
lab=colon_n[19]}
N 5740 -5990 5760 -5990 {
lab=#net39}
N 5740 -5970 5760 -5970 {
lab=#net40}
N 5980 -5970 6000 -5970 {
lab=#net40}
N 5980 -5990 6000 -5990 {
lab=#net39}
N 5980 -6010 6000 -6010 {
lab=colon_n[19]}
N 5980 -6030 6000 -6030 {
lab=col_n[19]}
N 5800 -5890 5800 -5880 {
lab=VSS}
N 5800 -6120 5800 -6110 {
lab=VDD}
N 6140 -5890 6150 -5900 {
lab=row_n[19]}
N 6150 -6100 6150 -5900 {
lab=row_n[19]}
N 6140 -6110 6150 -6100 {
lab=row_n[19]}
N 6140 -5890 6140 -5870 {
lab=row_n[19]}
N 6140 -6130 6140 -6110 {
lab=row_n[19]}
N 6020 -6030 6030 -6040 {
lab=col_n[19]}
N 6030 -6040 6230 -6040 {
lab=col_n[19]}
N 6230 -6040 6240 -6030 {
lab=col_n[19]}
N 6020 -6010 6030 -6020 {
lab=colon_n[19]}
N 6030 -6020 6230 -6020 {
lab=colon_n[19]}
N 6230 -6020 6240 -6010 {
lab=colon_n[19]}
N 6020 -5990 6030 -6000 {
lab=#net39}
N 6030 -6000 6230 -6000 {
lab=#net39}
N 6230 -6000 6240 -5990 {
lab=#net39}
N 6020 -5970 6030 -5980 {
lab=#net40}
N 6030 -5980 6230 -5980 {
lab=#net40}
N 6230 -5980 6240 -5970 {
lab=#net40}
N 6080 -6130 6080 -6110 {
lab=vcom}
N 6120 -6130 6120 -6110 {
lab=ctop}
N 6000 -6030 6020 -6030 {
lab=col_n[19]}
N 6000 -6010 6020 -6010 {
lab=colon_n[19]}
N 6000 -5990 6020 -5990 {
lab=#net39}
N 6000 -5970 6020 -5970 {
lab=#net40}
N 6240 -5970 6260 -5970 {
lab=#net40}
N 6240 -5990 6260 -5990 {
lab=#net39}
N 6240 -6010 6260 -6010 {
lab=colon_n[19]}
N 6240 -6030 6260 -6030 {
lab=col_n[19]}
N 6060 -5890 6060 -5880 {
lab=VSS}
N 6060 -6120 6060 -6110 {
lab=VDD}
N 6400 -5890 6410 -5900 {
lab=row_n[20]}
N 6410 -6100 6410 -5900 {
lab=row_n[20]}
N 6400 -6110 6410 -6100 {
lab=row_n[20]}
N 6400 -5890 6400 -5870 {
lab=row_n[20]}
N 6400 -6130 6400 -6110 {
lab=row_n[20]}
N 6280 -6030 6290 -6040 {
lab=col_n[19]}
N 6290 -6040 6490 -6040 {
lab=col_n[19]}
N 6490 -6040 6500 -6030 {
lab=col_n[19]}
N 6280 -6010 6290 -6020 {
lab=colon_n[19]}
N 6290 -6020 6490 -6020 {
lab=colon_n[19]}
N 6490 -6020 6500 -6010 {
lab=colon_n[19]}
N 6280 -5990 6290 -6000 {
lab=#net39}
N 6290 -6000 6490 -6000 {
lab=#net39}
N 6490 -6000 6500 -5990 {
lab=#net39}
N 6280 -5970 6290 -5980 {
lab=#net40}
N 6290 -5980 6490 -5980 {
lab=#net40}
N 6490 -5980 6500 -5970 {
lab=#net40}
N 6340 -6130 6340 -6110 {
lab=vcom}
N 6380 -6130 6380 -6110 {
lab=ctop}
N 6260 -6030 6280 -6030 {
lab=col_n[19]}
N 6260 -6010 6280 -6010 {
lab=colon_n[19]}
N 6260 -5990 6280 -5990 {
lab=#net39}
N 6260 -5970 6280 -5970 {
lab=#net40}
N 6500 -5970 6520 -5970 {
lab=#net40}
N 6500 -5990 6520 -5990 {
lab=#net39}
N 6500 -6010 6520 -6010 {
lab=colon_n[19]}
N 6500 -6030 6520 -6030 {
lab=col_n[19]}
N 6320 -5890 6320 -5880 {
lab=VSS}
N 6320 -6120 6320 -6110 {
lab=VDD}
N 6660 -5890 6670 -5900 {
lab=row_n[21]}
N 6670 -6100 6670 -5900 {
lab=row_n[21]}
N 6660 -6110 6670 -6100 {
lab=row_n[21]}
N 6660 -5890 6660 -5870 {
lab=row_n[21]}
N 6660 -6130 6660 -6110 {
lab=row_n[21]}
N 6540 -6030 6550 -6040 {
lab=col_n[19]}
N 6550 -6040 6750 -6040 {
lab=col_n[19]}
N 6750 -6040 6760 -6030 {
lab=col_n[19]}
N 6540 -6010 6550 -6020 {
lab=colon_n[19]}
N 6550 -6020 6750 -6020 {
lab=colon_n[19]}
N 6750 -6020 6760 -6010 {
lab=colon_n[19]}
N 6540 -5990 6550 -6000 {
lab=#net39}
N 6550 -6000 6750 -6000 {
lab=#net39}
N 6750 -6000 6760 -5990 {
lab=#net39}
N 6540 -5970 6550 -5980 {
lab=#net40}
N 6550 -5980 6750 -5980 {
lab=#net40}
N 6750 -5980 6760 -5970 {
lab=#net40}
N 6600 -6130 6600 -6110 {
lab=vcom}
N 6640 -6130 6640 -6110 {
lab=ctop}
N 6520 -6030 6540 -6030 {
lab=col_n[19]}
N 6520 -6010 6540 -6010 {
lab=colon_n[19]}
N 6520 -5990 6540 -5990 {
lab=#net39}
N 6520 -5970 6540 -5970 {
lab=#net40}
N 6760 -5970 6780 -5970 {
lab=#net40}
N 6760 -5990 6780 -5990 {
lab=#net39}
N 6760 -6010 6780 -6010 {
lab=colon_n[19]}
N 6760 -6030 6780 -6030 {
lab=col_n[19]}
N 6580 -5890 6580 -5880 {
lab=VSS}
N 6580 -6120 6580 -6110 {
lab=VDD}
N 6920 -5890 6930 -5900 {
lab=row_n[22]}
N 6930 -6100 6930 -5900 {
lab=row_n[22]}
N 6920 -6110 6930 -6100 {
lab=row_n[22]}
N 6920 -5890 6920 -5870 {
lab=row_n[22]}
N 6920 -6130 6920 -6110 {
lab=row_n[22]}
N 6800 -6030 6810 -6040 {
lab=col_n[19]}
N 6810 -6040 7010 -6040 {
lab=col_n[19]}
N 7010 -6040 7020 -6030 {
lab=col_n[19]}
N 6800 -6010 6810 -6020 {
lab=colon_n[19]}
N 6810 -6020 7010 -6020 {
lab=colon_n[19]}
N 7010 -6020 7020 -6010 {
lab=colon_n[19]}
N 6800 -5990 6810 -6000 {
lab=#net39}
N 6810 -6000 7010 -6000 {
lab=#net39}
N 7010 -6000 7020 -5990 {
lab=#net39}
N 6800 -5970 6810 -5980 {
lab=#net40}
N 6810 -5980 7010 -5980 {
lab=#net40}
N 7010 -5980 7020 -5970 {
lab=#net40}
N 6860 -6130 6860 -6110 {
lab=vcom}
N 6900 -6130 6900 -6110 {
lab=ctop}
N 6780 -6030 6800 -6030 {
lab=col_n[19]}
N 6780 -6010 6800 -6010 {
lab=colon_n[19]}
N 6780 -5990 6800 -5990 {
lab=#net39}
N 6780 -5970 6800 -5970 {
lab=#net40}
N 7020 -5970 7040 -5970 {
lab=#net40}
N 7020 -5990 7040 -5990 {
lab=#net39}
N 7020 -6010 7040 -6010 {
lab=colon_n[19]}
N 7020 -6030 7040 -6030 {
lab=col_n[19]}
N 6840 -5890 6840 -5880 {
lab=VSS}
N 6840 -6120 6840 -6110 {
lab=VDD}
N 7180 -5890 7190 -5900 {
lab=row_n[23]}
N 7190 -6100 7190 -5900 {
lab=row_n[23]}
N 7180 -6110 7190 -6100 {
lab=row_n[23]}
N 7180 -5890 7180 -5870 {
lab=row_n[23]}
N 7180 -6130 7180 -6110 {
lab=row_n[23]}
N 7060 -6030 7070 -6040 {
lab=col_n[19]}
N 7070 -6040 7270 -6040 {
lab=col_n[19]}
N 7270 -6040 7280 -6030 {
lab=col_n[19]}
N 7060 -6010 7070 -6020 {
lab=colon_n[19]}
N 7070 -6020 7270 -6020 {
lab=colon_n[19]}
N 7270 -6020 7280 -6010 {
lab=colon_n[19]}
N 7060 -5990 7070 -6000 {
lab=#net39}
N 7070 -6000 7270 -6000 {
lab=#net39}
N 7270 -6000 7280 -5990 {
lab=#net39}
N 7060 -5970 7070 -5980 {
lab=#net40}
N 7070 -5980 7270 -5980 {
lab=#net40}
N 7270 -5980 7280 -5970 {
lab=#net40}
N 7120 -6130 7120 -6110 {
lab=vcom}
N 7160 -6130 7160 -6110 {
lab=ctop}
N 7040 -6030 7060 -6030 {
lab=col_n[19]}
N 7040 -6010 7060 -6010 {
lab=colon_n[19]}
N 7040 -5990 7060 -5990 {
lab=#net39}
N 7040 -5970 7060 -5970 {
lab=#net40}
N 7280 -5970 7300 -5970 {
lab=#net40}
N 7280 -5990 7300 -5990 {
lab=#net39}
N 7280 -6010 7300 -6010 {
lab=colon_n[19]}
N 7280 -6030 7300 -6030 {
lab=col_n[19]}
N 7100 -5890 7100 -5880 {
lab=VSS}
N 7100 -6120 7100 -6110 {
lab=VDD}
N 7440 -5890 7450 -5900 {
lab=row_n[24]}
N 7450 -6100 7450 -5900 {
lab=row_n[24]}
N 7440 -6110 7450 -6100 {
lab=row_n[24]}
N 7440 -5890 7440 -5870 {
lab=row_n[24]}
N 7440 -6130 7440 -6110 {
lab=row_n[24]}
N 7320 -6030 7330 -6040 {
lab=col_n[19]}
N 7330 -6040 7530 -6040 {
lab=col_n[19]}
N 7530 -6040 7540 -6030 {
lab=col_n[19]}
N 7320 -6010 7330 -6020 {
lab=colon_n[19]}
N 7330 -6020 7530 -6020 {
lab=colon_n[19]}
N 7530 -6020 7540 -6010 {
lab=colon_n[19]}
N 7320 -5990 7330 -6000 {
lab=#net39}
N 7330 -6000 7530 -6000 {
lab=#net39}
N 7530 -6000 7540 -5990 {
lab=#net39}
N 7320 -5970 7330 -5980 {
lab=#net40}
N 7330 -5980 7530 -5980 {
lab=#net40}
N 7530 -5980 7540 -5970 {
lab=#net40}
N 7380 -6130 7380 -6110 {
lab=vcom}
N 7420 -6130 7420 -6110 {
lab=ctop}
N 7300 -6030 7320 -6030 {
lab=col_n[19]}
N 7300 -6010 7320 -6010 {
lab=colon_n[19]}
N 7300 -5990 7320 -5990 {
lab=#net39}
N 7300 -5970 7320 -5970 {
lab=#net40}
N 7540 -5970 7560 -5970 {
lab=#net40}
N 7540 -5990 7560 -5990 {
lab=#net39}
N 7540 -6010 7560 -6010 {
lab=colon_n[19]}
N 7540 -6030 7560 -6030 {
lab=col_n[19]}
N 7360 -5890 7360 -5880 {
lab=VSS}
N 7360 -6120 7360 -6110 {
lab=VDD}
N 7700 -5890 7710 -5900 {
lab=row_n[25]}
N 7710 -6100 7710 -5900 {
lab=row_n[25]}
N 7700 -6110 7710 -6100 {
lab=row_n[25]}
N 7700 -5890 7700 -5870 {
lab=row_n[25]}
N 7700 -6130 7700 -6110 {
lab=row_n[25]}
N 7580 -6030 7590 -6040 {
lab=col_n[19]}
N 7590 -6040 7790 -6040 {
lab=col_n[19]}
N 7790 -6040 7800 -6030 {
lab=col_n[19]}
N 7580 -6010 7590 -6020 {
lab=colon_n[19]}
N 7590 -6020 7790 -6020 {
lab=colon_n[19]}
N 7790 -6020 7800 -6010 {
lab=colon_n[19]}
N 7580 -5990 7590 -6000 {
lab=#net39}
N 7590 -6000 7790 -6000 {
lab=#net39}
N 7790 -6000 7800 -5990 {
lab=#net39}
N 7580 -5970 7590 -5980 {
lab=#net40}
N 7590 -5980 7790 -5980 {
lab=#net40}
N 7790 -5980 7800 -5970 {
lab=#net40}
N 7640 -6130 7640 -6110 {
lab=vcom}
N 7680 -6130 7680 -6110 {
lab=ctop}
N 7560 -6030 7580 -6030 {
lab=col_n[19]}
N 7560 -6010 7580 -6010 {
lab=colon_n[19]}
N 7560 -5990 7580 -5990 {
lab=#net39}
N 7560 -5970 7580 -5970 {
lab=#net40}
N 7800 -5970 7820 -5970 {
lab=#net40}
N 7800 -5990 7820 -5990 {
lab=#net39}
N 7800 -6010 7820 -6010 {
lab=colon_n[19]}
N 7800 -6030 7820 -6030 {
lab=col_n[19]}
N 7620 -5890 7620 -5880 {
lab=VSS}
N 7620 -6120 7620 -6110 {
lab=VDD}
N 7960 -5890 7970 -5900 {
lab=row_n[26]}
N 7970 -6100 7970 -5900 {
lab=row_n[26]}
N 7960 -6110 7970 -6100 {
lab=row_n[26]}
N 7960 -5890 7960 -5870 {
lab=row_n[26]}
N 7960 -6130 7960 -6110 {
lab=row_n[26]}
N 7840 -6030 7850 -6040 {
lab=col_n[19]}
N 7850 -6040 8050 -6040 {
lab=col_n[19]}
N 8050 -6040 8060 -6030 {
lab=col_n[19]}
N 7840 -6010 7850 -6020 {
lab=colon_n[19]}
N 7850 -6020 8050 -6020 {
lab=colon_n[19]}
N 8050 -6020 8060 -6010 {
lab=colon_n[19]}
N 7840 -5990 7850 -6000 {
lab=#net39}
N 7850 -6000 8050 -6000 {
lab=#net39}
N 8050 -6000 8060 -5990 {
lab=#net39}
N 7840 -5970 7850 -5980 {
lab=#net40}
N 7850 -5980 8050 -5980 {
lab=#net40}
N 8050 -5980 8060 -5970 {
lab=#net40}
N 7900 -6130 7900 -6110 {
lab=vcom}
N 7940 -6130 7940 -6110 {
lab=ctop}
N 7820 -6030 7840 -6030 {
lab=col_n[19]}
N 7820 -6010 7840 -6010 {
lab=colon_n[19]}
N 7820 -5990 7840 -5990 {
lab=#net39}
N 7820 -5970 7840 -5970 {
lab=#net40}
N 8060 -5970 8080 -5970 {
lab=#net40}
N 8060 -5990 8080 -5990 {
lab=#net39}
N 8060 -6010 8080 -6010 {
lab=colon_n[19]}
N 8060 -6030 8080 -6030 {
lab=col_n[19]}
N 7880 -5890 7880 -5880 {
lab=VSS}
N 7880 -6120 7880 -6110 {
lab=VDD}
N 8220 -5890 8230 -5900 {
lab=row_n[27]}
N 8230 -6100 8230 -5900 {
lab=row_n[27]}
N 8220 -6110 8230 -6100 {
lab=row_n[27]}
N 8220 -5890 8220 -5870 {
lab=row_n[27]}
N 8220 -6130 8220 -6110 {
lab=row_n[27]}
N 8100 -6030 8110 -6040 {
lab=col_n[19]}
N 8110 -6040 8310 -6040 {
lab=col_n[19]}
N 8310 -6040 8320 -6030 {
lab=col_n[19]}
N 8100 -6010 8110 -6020 {
lab=colon_n[19]}
N 8110 -6020 8310 -6020 {
lab=colon_n[19]}
N 8310 -6020 8320 -6010 {
lab=colon_n[19]}
N 8100 -5990 8110 -6000 {
lab=#net39}
N 8110 -6000 8310 -6000 {
lab=#net39}
N 8310 -6000 8320 -5990 {
lab=#net39}
N 8100 -5970 8110 -5980 {
lab=#net40}
N 8110 -5980 8310 -5980 {
lab=#net40}
N 8310 -5980 8320 -5970 {
lab=#net40}
N 8160 -6130 8160 -6110 {
lab=vcom}
N 8200 -6130 8200 -6110 {
lab=ctop}
N 8080 -6030 8100 -6030 {
lab=col_n[19]}
N 8080 -6010 8100 -6010 {
lab=colon_n[19]}
N 8080 -5990 8100 -5990 {
lab=#net39}
N 8080 -5970 8100 -5970 {
lab=#net40}
N 8320 -5970 8340 -5970 {
lab=#net40}
N 8320 -5990 8340 -5990 {
lab=#net39}
N 8320 -6010 8340 -6010 {
lab=colon_n[19]}
N 8320 -6030 8340 -6030 {
lab=col_n[19]}
N 8140 -5890 8140 -5880 {
lab=VSS}
N 8140 -6120 8140 -6110 {
lab=VDD}
N 8480 -5890 8490 -5900 {
lab=row_n[28]}
N 8490 -6100 8490 -5900 {
lab=row_n[28]}
N 8480 -6110 8490 -6100 {
lab=row_n[28]}
N 8480 -5890 8480 -5870 {
lab=row_n[28]}
N 8480 -6130 8480 -6110 {
lab=row_n[28]}
N 8360 -6030 8370 -6040 {
lab=col_n[19]}
N 8370 -6040 8570 -6040 {
lab=col_n[19]}
N 8570 -6040 8580 -6030 {
lab=col_n[19]}
N 8360 -6010 8370 -6020 {
lab=colon_n[19]}
N 8370 -6020 8570 -6020 {
lab=colon_n[19]}
N 8570 -6020 8580 -6010 {
lab=colon_n[19]}
N 8360 -5990 8370 -6000 {
lab=#net39}
N 8370 -6000 8570 -6000 {
lab=#net39}
N 8570 -6000 8580 -5990 {
lab=#net39}
N 8360 -5970 8370 -5980 {
lab=#net40}
N 8370 -5980 8570 -5980 {
lab=#net40}
N 8570 -5980 8580 -5970 {
lab=#net40}
N 8420 -6130 8420 -6110 {
lab=vcom}
N 8460 -6130 8460 -6110 {
lab=ctop}
N 8340 -6030 8360 -6030 {
lab=col_n[19]}
N 8340 -6010 8360 -6010 {
lab=colon_n[19]}
N 8340 -5990 8360 -5990 {
lab=#net39}
N 8340 -5970 8360 -5970 {
lab=#net40}
N 8580 -5970 8600 -5970 {
lab=#net40}
N 8580 -5990 8600 -5990 {
lab=#net39}
N 8580 -6010 8600 -6010 {
lab=colon_n[19]}
N 8580 -6030 8600 -6030 {
lab=col_n[19]}
N 8400 -5890 8400 -5880 {
lab=VSS}
N 8400 -6120 8400 -6110 {
lab=VDD}
N 8740 -5890 8750 -5900 {
lab=row_n[29]}
N 8750 -6100 8750 -5900 {
lab=row_n[29]}
N 8740 -6110 8750 -6100 {
lab=row_n[29]}
N 8740 -5890 8740 -5870 {
lab=row_n[29]}
N 8740 -6130 8740 -6110 {
lab=row_n[29]}
N 8620 -6030 8630 -6040 {
lab=col_n[19]}
N 8630 -6040 8830 -6040 {
lab=col_n[19]}
N 8830 -6040 8840 -6030 {
lab=col_n[19]}
N 8620 -6010 8630 -6020 {
lab=colon_n[19]}
N 8630 -6020 8830 -6020 {
lab=colon_n[19]}
N 8830 -6020 8840 -6010 {
lab=colon_n[19]}
N 8620 -5990 8630 -6000 {
lab=#net39}
N 8630 -6000 8830 -6000 {
lab=#net39}
N 8830 -6000 8840 -5990 {
lab=#net39}
N 8620 -5970 8630 -5980 {
lab=#net40}
N 8630 -5980 8830 -5980 {
lab=#net40}
N 8830 -5980 8840 -5970 {
lab=#net40}
N 8680 -6130 8680 -6110 {
lab=vcom}
N 8720 -6130 8720 -6110 {
lab=ctop}
N 8600 -6030 8620 -6030 {
lab=col_n[19]}
N 8600 -6010 8620 -6010 {
lab=colon_n[19]}
N 8600 -5990 8620 -5990 {
lab=#net39}
N 8600 -5970 8620 -5970 {
lab=#net40}
N 8840 -5970 8860 -5970 {
lab=#net40}
N 8840 -5990 8860 -5990 {
lab=#net39}
N 8840 -6010 8860 -6010 {
lab=colon_n[19]}
N 8840 -6030 8860 -6030 {
lab=col_n[19]}
N 8660 -5890 8660 -5880 {
lab=VSS}
N 8660 -6120 8660 -6110 {
lab=VDD}
N 9000 -5890 9010 -5900 {
lab=row_n[30]}
N 9010 -6100 9010 -5900 {
lab=row_n[30]}
N 9000 -6110 9010 -6100 {
lab=row_n[30]}
N 9000 -5890 9000 -5870 {
lab=row_n[30]}
N 9000 -6130 9000 -6110 {
lab=row_n[30]}
N 8880 -6030 8890 -6040 {
lab=col_n[19]}
N 8890 -6040 9090 -6040 {
lab=col_n[19]}
N 9090 -6040 9100 -6030 {
lab=col_n[19]}
N 8880 -6010 8890 -6020 {
lab=colon_n[19]}
N 8890 -6020 9090 -6020 {
lab=colon_n[19]}
N 9090 -6020 9100 -6010 {
lab=colon_n[19]}
N 8880 -5990 8890 -6000 {
lab=#net39}
N 8890 -6000 9090 -6000 {
lab=#net39}
N 9090 -6000 9100 -5990 {
lab=#net39}
N 8880 -5970 8890 -5980 {
lab=#net40}
N 8890 -5980 9090 -5980 {
lab=#net40}
N 9090 -5980 9100 -5970 {
lab=#net40}
N 8940 -6130 8940 -6110 {
lab=vcom}
N 8980 -6130 8980 -6110 {
lab=ctop}
N 8860 -6030 8880 -6030 {
lab=col_n[19]}
N 8860 -6010 8880 -6010 {
lab=colon_n[19]}
N 8860 -5990 8880 -5990 {
lab=#net39}
N 8860 -5970 8880 -5970 {
lab=#net40}
N 9100 -5970 9120 -5970 {
lab=#net40}
N 9100 -5990 9120 -5990 {
lab=#net39}
N 9100 -6010 9120 -6010 {
lab=colon_n[19]}
N 9100 -6030 9120 -6030 {
lab=col_n[19]}
N 8920 -5890 8920 -5880 {
lab=VSS}
N 8920 -6120 8920 -6110 {
lab=VDD}
N 9260 -5890 9270 -5900 {
lab=row_n[31]}
N 9270 -6100 9270 -5900 {
lab=row_n[31]}
N 9260 -6110 9270 -6100 {
lab=row_n[31]}
N 9260 -5890 9260 -5870 {
lab=row_n[31]}
N 9260 -6130 9260 -6110 {
lab=row_n[31]}
N 9140 -6030 9150 -6040 {
lab=col_n[19]}
N 9150 -6040 9350 -6040 {
lab=col_n[19]}
N 9350 -6040 9360 -6030 {
lab=col_n[19]}
N 9140 -6010 9150 -6020 {
lab=colon_n[19]}
N 9150 -6020 9350 -6020 {
lab=colon_n[19]}
N 9350 -6020 9360 -6010 {
lab=colon_n[19]}
N 9140 -5990 9150 -6000 {
lab=#net39}
N 9150 -6000 9350 -6000 {
lab=#net39}
N 9350 -6000 9360 -5990 {
lab=#net39}
N 9140 -5970 9150 -5980 {
lab=#net40}
N 9150 -5980 9350 -5980 {
lab=#net40}
N 9350 -5980 9360 -5970 {
lab=#net40}
N 9200 -6130 9200 -6110 {
lab=vcom}
N 9240 -6130 9240 -6110 {
lab=ctop}
N 9120 -6030 9140 -6030 {
lab=col_n[19]}
N 9120 -6010 9140 -6010 {
lab=colon_n[19]}
N 9120 -5990 9140 -5990 {
lab=#net39}
N 9120 -5970 9140 -5970 {
lab=#net40}
N 9360 -5970 9380 -5970 {
lab=#net40}
N 9360 -5990 9380 -5990 {
lab=#net39}
N 9360 -6010 9380 -6010 {
lab=colon_n[19]}
N 9360 -6030 9380 -6030 {
lab=col_n[19]}
N 9180 -5890 9180 -5880 {
lab=VSS}
N 9180 -6120 9180 -6110 {
lab=VDD}
N 1200 -6150 1210 -6160 {
lab=row_n[0]}
N 1210 -6360 1210 -6160 {
lab=row_n[0]}
N 1200 -6370 1210 -6360 {
lab=row_n[0]}
N 1200 -6150 1200 -6130 {
lab=row_n[0]}
N 1200 -6390 1200 -6370 {
lab=row_n[0]}
N 1080 -6290 1090 -6300 {
lab=col_n[20]}
N 1090 -6300 1290 -6300 {
lab=col_n[20]}
N 1290 -6300 1300 -6290 {
lab=col_n[20]}
N 1080 -6270 1090 -6280 {
lab=colon_n[20]}
N 1090 -6280 1290 -6280 {
lab=colon_n[20]}
N 1290 -6280 1300 -6270 {
lab=colon_n[20]}
N 1080 -6250 1090 -6260 {
lab=#net41}
N 1090 -6260 1290 -6260 {
lab=#net41}
N 1290 -6260 1300 -6250 {
lab=#net41}
N 1080 -6230 1090 -6240 {
lab=#net42}
N 1090 -6240 1290 -6240 {
lab=#net42}
N 1290 -6240 1300 -6230 {
lab=#net42}
N 1140 -6390 1140 -6370 {
lab=vcom}
N 1180 -6390 1180 -6370 {
lab=ctop}
N 1060 -6290 1080 -6290 {
lab=col_n[20]}
N 1060 -6270 1080 -6270 {
lab=colon_n[20]}
N 1060 -6250 1080 -6250 {
lab=#net41}
N 1060 -6230 1080 -6230 {
lab=#net42}
N 1300 -6230 1320 -6230 {
lab=#net42}
N 1300 -6250 1320 -6250 {
lab=#net41}
N 1300 -6270 1320 -6270 {
lab=colon_n[20]}
N 1300 -6290 1320 -6290 {
lab=col_n[20]}
N 1120 -6150 1120 -6140 {
lab=VSS}
N 1120 -6380 1120 -6370 {
lab=VDD}
N 1460 -6150 1470 -6160 {
lab=row_n[1]}
N 1470 -6360 1470 -6160 {
lab=row_n[1]}
N 1460 -6370 1470 -6360 {
lab=row_n[1]}
N 1460 -6150 1460 -6130 {
lab=row_n[1]}
N 1460 -6390 1460 -6370 {
lab=row_n[1]}
N 1340 -6290 1350 -6300 {
lab=col_n[20]}
N 1350 -6300 1550 -6300 {
lab=col_n[20]}
N 1550 -6300 1560 -6290 {
lab=col_n[20]}
N 1340 -6270 1350 -6280 {
lab=colon_n[20]}
N 1350 -6280 1550 -6280 {
lab=colon_n[20]}
N 1550 -6280 1560 -6270 {
lab=colon_n[20]}
N 1340 -6250 1350 -6260 {
lab=#net41}
N 1350 -6260 1550 -6260 {
lab=#net41}
N 1550 -6260 1560 -6250 {
lab=#net41}
N 1340 -6230 1350 -6240 {
lab=#net42}
N 1350 -6240 1550 -6240 {
lab=#net42}
N 1550 -6240 1560 -6230 {
lab=#net42}
N 1400 -6390 1400 -6370 {
lab=vcom}
N 1440 -6390 1440 -6370 {
lab=ctop}
N 1320 -6290 1340 -6290 {
lab=col_n[20]}
N 1320 -6270 1340 -6270 {
lab=colon_n[20]}
N 1320 -6250 1340 -6250 {
lab=#net41}
N 1320 -6230 1340 -6230 {
lab=#net42}
N 1560 -6230 1580 -6230 {
lab=#net42}
N 1560 -6250 1580 -6250 {
lab=#net41}
N 1560 -6270 1580 -6270 {
lab=colon_n[20]}
N 1560 -6290 1580 -6290 {
lab=col_n[20]}
N 1380 -6150 1380 -6140 {
lab=VSS}
N 1380 -6380 1380 -6370 {
lab=VDD}
N 1720 -6150 1730 -6160 {
lab=row_n[2]}
N 1730 -6360 1730 -6160 {
lab=row_n[2]}
N 1720 -6370 1730 -6360 {
lab=row_n[2]}
N 1720 -6150 1720 -6130 {
lab=row_n[2]}
N 1720 -6390 1720 -6370 {
lab=row_n[2]}
N 1600 -6290 1610 -6300 {
lab=col_n[20]}
N 1610 -6300 1810 -6300 {
lab=col_n[20]}
N 1810 -6300 1820 -6290 {
lab=col_n[20]}
N 1600 -6270 1610 -6280 {
lab=colon_n[20]}
N 1610 -6280 1810 -6280 {
lab=colon_n[20]}
N 1810 -6280 1820 -6270 {
lab=colon_n[20]}
N 1600 -6250 1610 -6260 {
lab=#net41}
N 1610 -6260 1810 -6260 {
lab=#net41}
N 1810 -6260 1820 -6250 {
lab=#net41}
N 1600 -6230 1610 -6240 {
lab=#net42}
N 1610 -6240 1810 -6240 {
lab=#net42}
N 1810 -6240 1820 -6230 {
lab=#net42}
N 1660 -6390 1660 -6370 {
lab=vcom}
N 1700 -6390 1700 -6370 {
lab=ctop}
N 1580 -6290 1600 -6290 {
lab=col_n[20]}
N 1580 -6270 1600 -6270 {
lab=colon_n[20]}
N 1580 -6250 1600 -6250 {
lab=#net41}
N 1580 -6230 1600 -6230 {
lab=#net42}
N 1820 -6230 1840 -6230 {
lab=#net42}
N 1820 -6250 1840 -6250 {
lab=#net41}
N 1820 -6270 1840 -6270 {
lab=colon_n[20]}
N 1820 -6290 1840 -6290 {
lab=col_n[20]}
N 1640 -6150 1640 -6140 {
lab=VSS}
N 1640 -6380 1640 -6370 {
lab=VDD}
N 1980 -6150 1990 -6160 {
lab=row_n[3]}
N 1990 -6360 1990 -6160 {
lab=row_n[3]}
N 1980 -6370 1990 -6360 {
lab=row_n[3]}
N 1980 -6150 1980 -6130 {
lab=row_n[3]}
N 1980 -6390 1980 -6370 {
lab=row_n[3]}
N 1860 -6290 1870 -6300 {
lab=col_n[20]}
N 1870 -6300 2070 -6300 {
lab=col_n[20]}
N 2070 -6300 2080 -6290 {
lab=col_n[20]}
N 1860 -6270 1870 -6280 {
lab=colon_n[20]}
N 1870 -6280 2070 -6280 {
lab=colon_n[20]}
N 2070 -6280 2080 -6270 {
lab=colon_n[20]}
N 1860 -6250 1870 -6260 {
lab=#net41}
N 1870 -6260 2070 -6260 {
lab=#net41}
N 2070 -6260 2080 -6250 {
lab=#net41}
N 1860 -6230 1870 -6240 {
lab=#net42}
N 1870 -6240 2070 -6240 {
lab=#net42}
N 2070 -6240 2080 -6230 {
lab=#net42}
N 1920 -6390 1920 -6370 {
lab=vcom}
N 1960 -6390 1960 -6370 {
lab=ctop}
N 1840 -6290 1860 -6290 {
lab=col_n[20]}
N 1840 -6270 1860 -6270 {
lab=colon_n[20]}
N 1840 -6250 1860 -6250 {
lab=#net41}
N 1840 -6230 1860 -6230 {
lab=#net42}
N 2080 -6230 2100 -6230 {
lab=#net42}
N 2080 -6250 2100 -6250 {
lab=#net41}
N 2080 -6270 2100 -6270 {
lab=colon_n[20]}
N 2080 -6290 2100 -6290 {
lab=col_n[20]}
N 1900 -6150 1900 -6140 {
lab=VSS}
N 1900 -6380 1900 -6370 {
lab=VDD}
N 2240 -6150 2250 -6160 {
lab=row_n[4]}
N 2250 -6360 2250 -6160 {
lab=row_n[4]}
N 2240 -6370 2250 -6360 {
lab=row_n[4]}
N 2240 -6150 2240 -6130 {
lab=row_n[4]}
N 2240 -6390 2240 -6370 {
lab=row_n[4]}
N 2120 -6290 2130 -6300 {
lab=col_n[20]}
N 2130 -6300 2330 -6300 {
lab=col_n[20]}
N 2330 -6300 2340 -6290 {
lab=col_n[20]}
N 2120 -6270 2130 -6280 {
lab=colon_n[20]}
N 2130 -6280 2330 -6280 {
lab=colon_n[20]}
N 2330 -6280 2340 -6270 {
lab=colon_n[20]}
N 2120 -6250 2130 -6260 {
lab=#net41}
N 2130 -6260 2330 -6260 {
lab=#net41}
N 2330 -6260 2340 -6250 {
lab=#net41}
N 2120 -6230 2130 -6240 {
lab=#net42}
N 2130 -6240 2330 -6240 {
lab=#net42}
N 2330 -6240 2340 -6230 {
lab=#net42}
N 2180 -6390 2180 -6370 {
lab=vcom}
N 2220 -6390 2220 -6370 {
lab=ctop}
N 2100 -6290 2120 -6290 {
lab=col_n[20]}
N 2100 -6270 2120 -6270 {
lab=colon_n[20]}
N 2100 -6250 2120 -6250 {
lab=#net41}
N 2100 -6230 2120 -6230 {
lab=#net42}
N 2340 -6230 2360 -6230 {
lab=#net42}
N 2340 -6250 2360 -6250 {
lab=#net41}
N 2340 -6270 2360 -6270 {
lab=colon_n[20]}
N 2340 -6290 2360 -6290 {
lab=col_n[20]}
N 2160 -6150 2160 -6140 {
lab=VSS}
N 2160 -6380 2160 -6370 {
lab=VDD}
N 2500 -6150 2510 -6160 {
lab=row_n[5]}
N 2510 -6360 2510 -6160 {
lab=row_n[5]}
N 2500 -6370 2510 -6360 {
lab=row_n[5]}
N 2500 -6150 2500 -6130 {
lab=row_n[5]}
N 2500 -6390 2500 -6370 {
lab=row_n[5]}
N 2380 -6290 2390 -6300 {
lab=col_n[20]}
N 2390 -6300 2590 -6300 {
lab=col_n[20]}
N 2590 -6300 2600 -6290 {
lab=col_n[20]}
N 2380 -6270 2390 -6280 {
lab=colon_n[20]}
N 2390 -6280 2590 -6280 {
lab=colon_n[20]}
N 2590 -6280 2600 -6270 {
lab=colon_n[20]}
N 2380 -6250 2390 -6260 {
lab=#net41}
N 2390 -6260 2590 -6260 {
lab=#net41}
N 2590 -6260 2600 -6250 {
lab=#net41}
N 2380 -6230 2390 -6240 {
lab=#net42}
N 2390 -6240 2590 -6240 {
lab=#net42}
N 2590 -6240 2600 -6230 {
lab=#net42}
N 2440 -6390 2440 -6370 {
lab=vcom}
N 2480 -6390 2480 -6370 {
lab=ctop}
N 2360 -6290 2380 -6290 {
lab=col_n[20]}
N 2360 -6270 2380 -6270 {
lab=colon_n[20]}
N 2360 -6250 2380 -6250 {
lab=#net41}
N 2360 -6230 2380 -6230 {
lab=#net42}
N 2600 -6230 2620 -6230 {
lab=#net42}
N 2600 -6250 2620 -6250 {
lab=#net41}
N 2600 -6270 2620 -6270 {
lab=colon_n[20]}
N 2600 -6290 2620 -6290 {
lab=col_n[20]}
N 2420 -6150 2420 -6140 {
lab=VSS}
N 2420 -6380 2420 -6370 {
lab=VDD}
N 2760 -6150 2770 -6160 {
lab=row_n[6]}
N 2770 -6360 2770 -6160 {
lab=row_n[6]}
N 2760 -6370 2770 -6360 {
lab=row_n[6]}
N 2760 -6150 2760 -6130 {
lab=row_n[6]}
N 2760 -6390 2760 -6370 {
lab=row_n[6]}
N 2640 -6290 2650 -6300 {
lab=col_n[20]}
N 2650 -6300 2850 -6300 {
lab=col_n[20]}
N 2850 -6300 2860 -6290 {
lab=col_n[20]}
N 2640 -6270 2650 -6280 {
lab=colon_n[20]}
N 2650 -6280 2850 -6280 {
lab=colon_n[20]}
N 2850 -6280 2860 -6270 {
lab=colon_n[20]}
N 2640 -6250 2650 -6260 {
lab=#net41}
N 2650 -6260 2850 -6260 {
lab=#net41}
N 2850 -6260 2860 -6250 {
lab=#net41}
N 2640 -6230 2650 -6240 {
lab=#net42}
N 2650 -6240 2850 -6240 {
lab=#net42}
N 2850 -6240 2860 -6230 {
lab=#net42}
N 2700 -6390 2700 -6370 {
lab=vcom}
N 2740 -6390 2740 -6370 {
lab=ctop}
N 2620 -6290 2640 -6290 {
lab=col_n[20]}
N 2620 -6270 2640 -6270 {
lab=colon_n[20]}
N 2620 -6250 2640 -6250 {
lab=#net41}
N 2620 -6230 2640 -6230 {
lab=#net42}
N 2860 -6230 2880 -6230 {
lab=#net42}
N 2860 -6250 2880 -6250 {
lab=#net41}
N 2860 -6270 2880 -6270 {
lab=colon_n[20]}
N 2860 -6290 2880 -6290 {
lab=col_n[20]}
N 2680 -6150 2680 -6140 {
lab=VSS}
N 2680 -6380 2680 -6370 {
lab=VDD}
N 3020 -6150 3030 -6160 {
lab=row_n[7]}
N 3030 -6360 3030 -6160 {
lab=row_n[7]}
N 3020 -6370 3030 -6360 {
lab=row_n[7]}
N 3020 -6150 3020 -6130 {
lab=row_n[7]}
N 3020 -6390 3020 -6370 {
lab=row_n[7]}
N 2900 -6290 2910 -6300 {
lab=col_n[20]}
N 2910 -6300 3110 -6300 {
lab=col_n[20]}
N 3110 -6300 3120 -6290 {
lab=col_n[20]}
N 2900 -6270 2910 -6280 {
lab=colon_n[20]}
N 2910 -6280 3110 -6280 {
lab=colon_n[20]}
N 3110 -6280 3120 -6270 {
lab=colon_n[20]}
N 2900 -6250 2910 -6260 {
lab=#net41}
N 2910 -6260 3110 -6260 {
lab=#net41}
N 3110 -6260 3120 -6250 {
lab=#net41}
N 2900 -6230 2910 -6240 {
lab=#net42}
N 2910 -6240 3110 -6240 {
lab=#net42}
N 3110 -6240 3120 -6230 {
lab=#net42}
N 2960 -6390 2960 -6370 {
lab=vcom}
N 3000 -6390 3000 -6370 {
lab=ctop}
N 2880 -6290 2900 -6290 {
lab=col_n[20]}
N 2880 -6270 2900 -6270 {
lab=colon_n[20]}
N 2880 -6250 2900 -6250 {
lab=#net41}
N 2880 -6230 2900 -6230 {
lab=#net42}
N 3120 -6230 3140 -6230 {
lab=#net42}
N 3120 -6250 3140 -6250 {
lab=#net41}
N 3120 -6270 3140 -6270 {
lab=colon_n[20]}
N 3120 -6290 3140 -6290 {
lab=col_n[20]}
N 2940 -6150 2940 -6140 {
lab=VSS}
N 2940 -6380 2940 -6370 {
lab=VDD}
N 3280 -6150 3290 -6160 {
lab=row_n[8]}
N 3290 -6360 3290 -6160 {
lab=row_n[8]}
N 3280 -6370 3290 -6360 {
lab=row_n[8]}
N 3280 -6150 3280 -6130 {
lab=row_n[8]}
N 3280 -6390 3280 -6370 {
lab=row_n[8]}
N 3160 -6290 3170 -6300 {
lab=col_n[20]}
N 3170 -6300 3370 -6300 {
lab=col_n[20]}
N 3370 -6300 3380 -6290 {
lab=col_n[20]}
N 3160 -6270 3170 -6280 {
lab=colon_n[20]}
N 3170 -6280 3370 -6280 {
lab=colon_n[20]}
N 3370 -6280 3380 -6270 {
lab=colon_n[20]}
N 3160 -6250 3170 -6260 {
lab=#net41}
N 3170 -6260 3370 -6260 {
lab=#net41}
N 3370 -6260 3380 -6250 {
lab=#net41}
N 3160 -6230 3170 -6240 {
lab=#net42}
N 3170 -6240 3370 -6240 {
lab=#net42}
N 3370 -6240 3380 -6230 {
lab=#net42}
N 3220 -6390 3220 -6370 {
lab=vcom}
N 3260 -6390 3260 -6370 {
lab=ctop}
N 3140 -6290 3160 -6290 {
lab=col_n[20]}
N 3140 -6270 3160 -6270 {
lab=colon_n[20]}
N 3140 -6250 3160 -6250 {
lab=#net41}
N 3140 -6230 3160 -6230 {
lab=#net42}
N 3380 -6230 3400 -6230 {
lab=#net42}
N 3380 -6250 3400 -6250 {
lab=#net41}
N 3380 -6270 3400 -6270 {
lab=colon_n[20]}
N 3380 -6290 3400 -6290 {
lab=col_n[20]}
N 3200 -6150 3200 -6140 {
lab=VSS}
N 3200 -6380 3200 -6370 {
lab=VDD}
N 3540 -6150 3550 -6160 {
lab=row_n[9]}
N 3550 -6360 3550 -6160 {
lab=row_n[9]}
N 3540 -6370 3550 -6360 {
lab=row_n[9]}
N 3540 -6150 3540 -6130 {
lab=row_n[9]}
N 3540 -6390 3540 -6370 {
lab=row_n[9]}
N 3420 -6290 3430 -6300 {
lab=col_n[20]}
N 3430 -6300 3630 -6300 {
lab=col_n[20]}
N 3630 -6300 3640 -6290 {
lab=col_n[20]}
N 3420 -6270 3430 -6280 {
lab=colon_n[20]}
N 3430 -6280 3630 -6280 {
lab=colon_n[20]}
N 3630 -6280 3640 -6270 {
lab=colon_n[20]}
N 3420 -6250 3430 -6260 {
lab=#net41}
N 3430 -6260 3630 -6260 {
lab=#net41}
N 3630 -6260 3640 -6250 {
lab=#net41}
N 3420 -6230 3430 -6240 {
lab=#net42}
N 3430 -6240 3630 -6240 {
lab=#net42}
N 3630 -6240 3640 -6230 {
lab=#net42}
N 3480 -6390 3480 -6370 {
lab=vcom}
N 3520 -6390 3520 -6370 {
lab=ctop}
N 3400 -6290 3420 -6290 {
lab=col_n[20]}
N 3400 -6270 3420 -6270 {
lab=colon_n[20]}
N 3400 -6250 3420 -6250 {
lab=#net41}
N 3400 -6230 3420 -6230 {
lab=#net42}
N 3640 -6230 3660 -6230 {
lab=#net42}
N 3640 -6250 3660 -6250 {
lab=#net41}
N 3640 -6270 3660 -6270 {
lab=colon_n[20]}
N 3640 -6290 3660 -6290 {
lab=col_n[20]}
N 3460 -6150 3460 -6140 {
lab=VSS}
N 3460 -6380 3460 -6370 {
lab=VDD}
N 3800 -6150 3810 -6160 {
lab=row_n[10]}
N 3810 -6360 3810 -6160 {
lab=row_n[10]}
N 3800 -6370 3810 -6360 {
lab=row_n[10]}
N 3800 -6150 3800 -6130 {
lab=row_n[10]}
N 3800 -6390 3800 -6370 {
lab=row_n[10]}
N 3680 -6290 3690 -6300 {
lab=col_n[20]}
N 3690 -6300 3890 -6300 {
lab=col_n[20]}
N 3890 -6300 3900 -6290 {
lab=col_n[20]}
N 3680 -6270 3690 -6280 {
lab=colon_n[20]}
N 3690 -6280 3890 -6280 {
lab=colon_n[20]}
N 3890 -6280 3900 -6270 {
lab=colon_n[20]}
N 3680 -6250 3690 -6260 {
lab=#net41}
N 3690 -6260 3890 -6260 {
lab=#net41}
N 3890 -6260 3900 -6250 {
lab=#net41}
N 3680 -6230 3690 -6240 {
lab=#net42}
N 3690 -6240 3890 -6240 {
lab=#net42}
N 3890 -6240 3900 -6230 {
lab=#net42}
N 3740 -6390 3740 -6370 {
lab=vcom}
N 3780 -6390 3780 -6370 {
lab=ctop}
N 3660 -6290 3680 -6290 {
lab=col_n[20]}
N 3660 -6270 3680 -6270 {
lab=colon_n[20]}
N 3660 -6250 3680 -6250 {
lab=#net41}
N 3660 -6230 3680 -6230 {
lab=#net42}
N 3900 -6230 3920 -6230 {
lab=#net42}
N 3900 -6250 3920 -6250 {
lab=#net41}
N 3900 -6270 3920 -6270 {
lab=colon_n[20]}
N 3900 -6290 3920 -6290 {
lab=col_n[20]}
N 3720 -6150 3720 -6140 {
lab=VSS}
N 3720 -6380 3720 -6370 {
lab=VDD}
N 4060 -6150 4070 -6160 {
lab=row_n[11]}
N 4070 -6360 4070 -6160 {
lab=row_n[11]}
N 4060 -6370 4070 -6360 {
lab=row_n[11]}
N 4060 -6150 4060 -6130 {
lab=row_n[11]}
N 4060 -6390 4060 -6370 {
lab=row_n[11]}
N 3940 -6290 3950 -6300 {
lab=col_n[20]}
N 3950 -6300 4150 -6300 {
lab=col_n[20]}
N 4150 -6300 4160 -6290 {
lab=col_n[20]}
N 3940 -6270 3950 -6280 {
lab=colon_n[20]}
N 3950 -6280 4150 -6280 {
lab=colon_n[20]}
N 4150 -6280 4160 -6270 {
lab=colon_n[20]}
N 3940 -6250 3950 -6260 {
lab=#net41}
N 3950 -6260 4150 -6260 {
lab=#net41}
N 4150 -6260 4160 -6250 {
lab=#net41}
N 3940 -6230 3950 -6240 {
lab=#net42}
N 3950 -6240 4150 -6240 {
lab=#net42}
N 4150 -6240 4160 -6230 {
lab=#net42}
N 4000 -6390 4000 -6370 {
lab=vcom}
N 4040 -6390 4040 -6370 {
lab=ctop}
N 3920 -6290 3940 -6290 {
lab=col_n[20]}
N 3920 -6270 3940 -6270 {
lab=colon_n[20]}
N 3920 -6250 3940 -6250 {
lab=#net41}
N 3920 -6230 3940 -6230 {
lab=#net42}
N 4160 -6230 4180 -6230 {
lab=#net42}
N 4160 -6250 4180 -6250 {
lab=#net41}
N 4160 -6270 4180 -6270 {
lab=colon_n[20]}
N 4160 -6290 4180 -6290 {
lab=col_n[20]}
N 3980 -6150 3980 -6140 {
lab=VSS}
N 3980 -6380 3980 -6370 {
lab=VDD}
N 4320 -6150 4330 -6160 {
lab=row_n[12]}
N 4330 -6360 4330 -6160 {
lab=row_n[12]}
N 4320 -6370 4330 -6360 {
lab=row_n[12]}
N 4320 -6150 4320 -6130 {
lab=row_n[12]}
N 4320 -6390 4320 -6370 {
lab=row_n[12]}
N 4200 -6290 4210 -6300 {
lab=col_n[20]}
N 4210 -6300 4410 -6300 {
lab=col_n[20]}
N 4410 -6300 4420 -6290 {
lab=col_n[20]}
N 4200 -6270 4210 -6280 {
lab=colon_n[20]}
N 4210 -6280 4410 -6280 {
lab=colon_n[20]}
N 4410 -6280 4420 -6270 {
lab=colon_n[20]}
N 4200 -6250 4210 -6260 {
lab=#net41}
N 4210 -6260 4410 -6260 {
lab=#net41}
N 4410 -6260 4420 -6250 {
lab=#net41}
N 4200 -6230 4210 -6240 {
lab=#net42}
N 4210 -6240 4410 -6240 {
lab=#net42}
N 4410 -6240 4420 -6230 {
lab=#net42}
N 4260 -6390 4260 -6370 {
lab=vcom}
N 4300 -6390 4300 -6370 {
lab=ctop}
N 4180 -6290 4200 -6290 {
lab=col_n[20]}
N 4180 -6270 4200 -6270 {
lab=colon_n[20]}
N 4180 -6250 4200 -6250 {
lab=#net41}
N 4180 -6230 4200 -6230 {
lab=#net42}
N 4420 -6230 4440 -6230 {
lab=#net42}
N 4420 -6250 4440 -6250 {
lab=#net41}
N 4420 -6270 4440 -6270 {
lab=colon_n[20]}
N 4420 -6290 4440 -6290 {
lab=col_n[20]}
N 4240 -6150 4240 -6140 {
lab=VSS}
N 4240 -6380 4240 -6370 {
lab=VDD}
N 4580 -6150 4590 -6160 {
lab=row_n[13]}
N 4590 -6360 4590 -6160 {
lab=row_n[13]}
N 4580 -6370 4590 -6360 {
lab=row_n[13]}
N 4580 -6150 4580 -6130 {
lab=row_n[13]}
N 4580 -6390 4580 -6370 {
lab=row_n[13]}
N 4460 -6290 4470 -6300 {
lab=col_n[20]}
N 4470 -6300 4670 -6300 {
lab=col_n[20]}
N 4670 -6300 4680 -6290 {
lab=col_n[20]}
N 4460 -6270 4470 -6280 {
lab=colon_n[20]}
N 4470 -6280 4670 -6280 {
lab=colon_n[20]}
N 4670 -6280 4680 -6270 {
lab=colon_n[20]}
N 4460 -6250 4470 -6260 {
lab=#net41}
N 4470 -6260 4670 -6260 {
lab=#net41}
N 4670 -6260 4680 -6250 {
lab=#net41}
N 4460 -6230 4470 -6240 {
lab=#net42}
N 4470 -6240 4670 -6240 {
lab=#net42}
N 4670 -6240 4680 -6230 {
lab=#net42}
N 4520 -6390 4520 -6370 {
lab=vcom}
N 4560 -6390 4560 -6370 {
lab=ctop}
N 4440 -6290 4460 -6290 {
lab=col_n[20]}
N 4440 -6270 4460 -6270 {
lab=colon_n[20]}
N 4440 -6250 4460 -6250 {
lab=#net41}
N 4440 -6230 4460 -6230 {
lab=#net42}
N 4680 -6230 4700 -6230 {
lab=#net42}
N 4680 -6250 4700 -6250 {
lab=#net41}
N 4680 -6270 4700 -6270 {
lab=colon_n[20]}
N 4680 -6290 4700 -6290 {
lab=col_n[20]}
N 4500 -6150 4500 -6140 {
lab=VSS}
N 4500 -6380 4500 -6370 {
lab=VDD}
N 4840 -6150 4850 -6160 {
lab=row_n[14]}
N 4850 -6360 4850 -6160 {
lab=row_n[14]}
N 4840 -6370 4850 -6360 {
lab=row_n[14]}
N 4840 -6150 4840 -6130 {
lab=row_n[14]}
N 4840 -6390 4840 -6370 {
lab=row_n[14]}
N 4720 -6290 4730 -6300 {
lab=col_n[20]}
N 4730 -6300 4930 -6300 {
lab=col_n[20]}
N 4930 -6300 4940 -6290 {
lab=col_n[20]}
N 4720 -6270 4730 -6280 {
lab=colon_n[20]}
N 4730 -6280 4930 -6280 {
lab=colon_n[20]}
N 4930 -6280 4940 -6270 {
lab=colon_n[20]}
N 4720 -6250 4730 -6260 {
lab=#net41}
N 4730 -6260 4930 -6260 {
lab=#net41}
N 4930 -6260 4940 -6250 {
lab=#net41}
N 4720 -6230 4730 -6240 {
lab=#net42}
N 4730 -6240 4930 -6240 {
lab=#net42}
N 4930 -6240 4940 -6230 {
lab=#net42}
N 4780 -6390 4780 -6370 {
lab=vcom}
N 4820 -6390 4820 -6370 {
lab=ctop}
N 4700 -6290 4720 -6290 {
lab=col_n[20]}
N 4700 -6270 4720 -6270 {
lab=colon_n[20]}
N 4700 -6250 4720 -6250 {
lab=#net41}
N 4700 -6230 4720 -6230 {
lab=#net42}
N 4940 -6230 4960 -6230 {
lab=#net42}
N 4940 -6250 4960 -6250 {
lab=#net41}
N 4940 -6270 4960 -6270 {
lab=colon_n[20]}
N 4940 -6290 4960 -6290 {
lab=col_n[20]}
N 4760 -6150 4760 -6140 {
lab=VSS}
N 4760 -6380 4760 -6370 {
lab=VDD}
N 5100 -6150 5110 -6160 {
lab=row_n[15]}
N 5110 -6360 5110 -6160 {
lab=row_n[15]}
N 5100 -6370 5110 -6360 {
lab=row_n[15]}
N 5100 -6150 5100 -6130 {
lab=row_n[15]}
N 5100 -6390 5100 -6370 {
lab=row_n[15]}
N 4980 -6290 4990 -6300 {
lab=col_n[20]}
N 4990 -6300 5190 -6300 {
lab=col_n[20]}
N 5190 -6300 5200 -6290 {
lab=col_n[20]}
N 4980 -6270 4990 -6280 {
lab=colon_n[20]}
N 4990 -6280 5190 -6280 {
lab=colon_n[20]}
N 5190 -6280 5200 -6270 {
lab=colon_n[20]}
N 4980 -6250 4990 -6260 {
lab=#net41}
N 4990 -6260 5190 -6260 {
lab=#net41}
N 5190 -6260 5200 -6250 {
lab=#net41}
N 4980 -6230 4990 -6240 {
lab=#net42}
N 4990 -6240 5190 -6240 {
lab=#net42}
N 5190 -6240 5200 -6230 {
lab=#net42}
N 5040 -6390 5040 -6370 {
lab=vcom}
N 5080 -6390 5080 -6370 {
lab=ctop}
N 4960 -6290 4980 -6290 {
lab=col_n[20]}
N 4960 -6270 4980 -6270 {
lab=colon_n[20]}
N 4960 -6250 4980 -6250 {
lab=#net41}
N 4960 -6230 4980 -6230 {
lab=#net42}
N 5200 -6230 5220 -6230 {
lab=#net42}
N 5200 -6250 5220 -6250 {
lab=#net41}
N 5200 -6270 5220 -6270 {
lab=colon_n[20]}
N 5200 -6290 5220 -6290 {
lab=col_n[20]}
N 5020 -6150 5020 -6140 {
lab=VSS}
N 5020 -6380 5020 -6370 {
lab=VDD}
N 5360 -6150 5370 -6160 {
lab=row_n[16]}
N 5370 -6360 5370 -6160 {
lab=row_n[16]}
N 5360 -6370 5370 -6360 {
lab=row_n[16]}
N 5360 -6150 5360 -6130 {
lab=row_n[16]}
N 5360 -6390 5360 -6370 {
lab=row_n[16]}
N 5240 -6290 5250 -6300 {
lab=col_n[20]}
N 5250 -6300 5450 -6300 {
lab=col_n[20]}
N 5450 -6300 5460 -6290 {
lab=col_n[20]}
N 5240 -6270 5250 -6280 {
lab=colon_n[20]}
N 5250 -6280 5450 -6280 {
lab=colon_n[20]}
N 5450 -6280 5460 -6270 {
lab=colon_n[20]}
N 5240 -6250 5250 -6260 {
lab=#net41}
N 5250 -6260 5450 -6260 {
lab=#net41}
N 5450 -6260 5460 -6250 {
lab=#net41}
N 5240 -6230 5250 -6240 {
lab=#net42}
N 5250 -6240 5450 -6240 {
lab=#net42}
N 5450 -6240 5460 -6230 {
lab=#net42}
N 5300 -6390 5300 -6370 {
lab=vcom}
N 5340 -6390 5340 -6370 {
lab=ctop}
N 5220 -6290 5240 -6290 {
lab=col_n[20]}
N 5220 -6270 5240 -6270 {
lab=colon_n[20]}
N 5220 -6250 5240 -6250 {
lab=#net41}
N 5220 -6230 5240 -6230 {
lab=#net42}
N 5460 -6230 5480 -6230 {
lab=#net42}
N 5460 -6250 5480 -6250 {
lab=#net41}
N 5460 -6270 5480 -6270 {
lab=colon_n[20]}
N 5460 -6290 5480 -6290 {
lab=col_n[20]}
N 5280 -6150 5280 -6140 {
lab=VSS}
N 5280 -6380 5280 -6370 {
lab=VDD}
N 5620 -6150 5630 -6160 {
lab=row_n[17]}
N 5630 -6360 5630 -6160 {
lab=row_n[17]}
N 5620 -6370 5630 -6360 {
lab=row_n[17]}
N 5620 -6150 5620 -6130 {
lab=row_n[17]}
N 5620 -6390 5620 -6370 {
lab=row_n[17]}
N 5500 -6290 5510 -6300 {
lab=col_n[20]}
N 5510 -6300 5710 -6300 {
lab=col_n[20]}
N 5710 -6300 5720 -6290 {
lab=col_n[20]}
N 5500 -6270 5510 -6280 {
lab=colon_n[20]}
N 5510 -6280 5710 -6280 {
lab=colon_n[20]}
N 5710 -6280 5720 -6270 {
lab=colon_n[20]}
N 5500 -6250 5510 -6260 {
lab=#net41}
N 5510 -6260 5710 -6260 {
lab=#net41}
N 5710 -6260 5720 -6250 {
lab=#net41}
N 5500 -6230 5510 -6240 {
lab=#net42}
N 5510 -6240 5710 -6240 {
lab=#net42}
N 5710 -6240 5720 -6230 {
lab=#net42}
N 5560 -6390 5560 -6370 {
lab=vcom}
N 5600 -6390 5600 -6370 {
lab=ctop}
N 5480 -6290 5500 -6290 {
lab=col_n[20]}
N 5480 -6270 5500 -6270 {
lab=colon_n[20]}
N 5480 -6250 5500 -6250 {
lab=#net41}
N 5480 -6230 5500 -6230 {
lab=#net42}
N 5720 -6230 5740 -6230 {
lab=#net42}
N 5720 -6250 5740 -6250 {
lab=#net41}
N 5720 -6270 5740 -6270 {
lab=colon_n[20]}
N 5720 -6290 5740 -6290 {
lab=col_n[20]}
N 5540 -6150 5540 -6140 {
lab=VSS}
N 5540 -6380 5540 -6370 {
lab=VDD}
N 5880 -6150 5890 -6160 {
lab=row_n[18]}
N 5890 -6360 5890 -6160 {
lab=row_n[18]}
N 5880 -6370 5890 -6360 {
lab=row_n[18]}
N 5880 -6150 5880 -6130 {
lab=row_n[18]}
N 5880 -6390 5880 -6370 {
lab=row_n[18]}
N 5760 -6290 5770 -6300 {
lab=col_n[20]}
N 5770 -6300 5970 -6300 {
lab=col_n[20]}
N 5970 -6300 5980 -6290 {
lab=col_n[20]}
N 5760 -6270 5770 -6280 {
lab=colon_n[20]}
N 5770 -6280 5970 -6280 {
lab=colon_n[20]}
N 5970 -6280 5980 -6270 {
lab=colon_n[20]}
N 5760 -6250 5770 -6260 {
lab=#net41}
N 5770 -6260 5970 -6260 {
lab=#net41}
N 5970 -6260 5980 -6250 {
lab=#net41}
N 5760 -6230 5770 -6240 {
lab=#net42}
N 5770 -6240 5970 -6240 {
lab=#net42}
N 5970 -6240 5980 -6230 {
lab=#net42}
N 5820 -6390 5820 -6370 {
lab=vcom}
N 5860 -6390 5860 -6370 {
lab=ctop}
N 5740 -6290 5760 -6290 {
lab=col_n[20]}
N 5740 -6270 5760 -6270 {
lab=colon_n[20]}
N 5740 -6250 5760 -6250 {
lab=#net41}
N 5740 -6230 5760 -6230 {
lab=#net42}
N 5980 -6230 6000 -6230 {
lab=#net42}
N 5980 -6250 6000 -6250 {
lab=#net41}
N 5980 -6270 6000 -6270 {
lab=colon_n[20]}
N 5980 -6290 6000 -6290 {
lab=col_n[20]}
N 5800 -6150 5800 -6140 {
lab=VSS}
N 5800 -6380 5800 -6370 {
lab=VDD}
N 6140 -6150 6150 -6160 {
lab=row_n[19]}
N 6150 -6360 6150 -6160 {
lab=row_n[19]}
N 6140 -6370 6150 -6360 {
lab=row_n[19]}
N 6140 -6150 6140 -6130 {
lab=row_n[19]}
N 6140 -6390 6140 -6370 {
lab=row_n[19]}
N 6020 -6290 6030 -6300 {
lab=col_n[20]}
N 6030 -6300 6230 -6300 {
lab=col_n[20]}
N 6230 -6300 6240 -6290 {
lab=col_n[20]}
N 6020 -6270 6030 -6280 {
lab=colon_n[20]}
N 6030 -6280 6230 -6280 {
lab=colon_n[20]}
N 6230 -6280 6240 -6270 {
lab=colon_n[20]}
N 6020 -6250 6030 -6260 {
lab=#net41}
N 6030 -6260 6230 -6260 {
lab=#net41}
N 6230 -6260 6240 -6250 {
lab=#net41}
N 6020 -6230 6030 -6240 {
lab=#net42}
N 6030 -6240 6230 -6240 {
lab=#net42}
N 6230 -6240 6240 -6230 {
lab=#net42}
N 6080 -6390 6080 -6370 {
lab=vcom}
N 6120 -6390 6120 -6370 {
lab=ctop}
N 6000 -6290 6020 -6290 {
lab=col_n[20]}
N 6000 -6270 6020 -6270 {
lab=colon_n[20]}
N 6000 -6250 6020 -6250 {
lab=#net41}
N 6000 -6230 6020 -6230 {
lab=#net42}
N 6240 -6230 6260 -6230 {
lab=#net42}
N 6240 -6250 6260 -6250 {
lab=#net41}
N 6240 -6270 6260 -6270 {
lab=colon_n[20]}
N 6240 -6290 6260 -6290 {
lab=col_n[20]}
N 6060 -6150 6060 -6140 {
lab=VSS}
N 6060 -6380 6060 -6370 {
lab=VDD}
N 6400 -6150 6410 -6160 {
lab=row_n[20]}
N 6410 -6360 6410 -6160 {
lab=row_n[20]}
N 6400 -6370 6410 -6360 {
lab=row_n[20]}
N 6400 -6150 6400 -6130 {
lab=row_n[20]}
N 6400 -6390 6400 -6370 {
lab=row_n[20]}
N 6280 -6290 6290 -6300 {
lab=col_n[20]}
N 6290 -6300 6490 -6300 {
lab=col_n[20]}
N 6490 -6300 6500 -6290 {
lab=col_n[20]}
N 6280 -6270 6290 -6280 {
lab=colon_n[20]}
N 6290 -6280 6490 -6280 {
lab=colon_n[20]}
N 6490 -6280 6500 -6270 {
lab=colon_n[20]}
N 6280 -6250 6290 -6260 {
lab=#net41}
N 6290 -6260 6490 -6260 {
lab=#net41}
N 6490 -6260 6500 -6250 {
lab=#net41}
N 6280 -6230 6290 -6240 {
lab=#net42}
N 6290 -6240 6490 -6240 {
lab=#net42}
N 6490 -6240 6500 -6230 {
lab=#net42}
N 6340 -6390 6340 -6370 {
lab=vcom}
N 6380 -6390 6380 -6370 {
lab=ctop}
N 6260 -6290 6280 -6290 {
lab=col_n[20]}
N 6260 -6270 6280 -6270 {
lab=colon_n[20]}
N 6260 -6250 6280 -6250 {
lab=#net41}
N 6260 -6230 6280 -6230 {
lab=#net42}
N 6500 -6230 6520 -6230 {
lab=#net42}
N 6500 -6250 6520 -6250 {
lab=#net41}
N 6500 -6270 6520 -6270 {
lab=colon_n[20]}
N 6500 -6290 6520 -6290 {
lab=col_n[20]}
N 6320 -6150 6320 -6140 {
lab=VSS}
N 6320 -6380 6320 -6370 {
lab=VDD}
N 6660 -6150 6670 -6160 {
lab=row_n[21]}
N 6670 -6360 6670 -6160 {
lab=row_n[21]}
N 6660 -6370 6670 -6360 {
lab=row_n[21]}
N 6660 -6150 6660 -6130 {
lab=row_n[21]}
N 6660 -6390 6660 -6370 {
lab=row_n[21]}
N 6540 -6290 6550 -6300 {
lab=col_n[20]}
N 6550 -6300 6750 -6300 {
lab=col_n[20]}
N 6750 -6300 6760 -6290 {
lab=col_n[20]}
N 6540 -6270 6550 -6280 {
lab=colon_n[20]}
N 6550 -6280 6750 -6280 {
lab=colon_n[20]}
N 6750 -6280 6760 -6270 {
lab=colon_n[20]}
N 6540 -6250 6550 -6260 {
lab=#net41}
N 6550 -6260 6750 -6260 {
lab=#net41}
N 6750 -6260 6760 -6250 {
lab=#net41}
N 6540 -6230 6550 -6240 {
lab=#net42}
N 6550 -6240 6750 -6240 {
lab=#net42}
N 6750 -6240 6760 -6230 {
lab=#net42}
N 6600 -6390 6600 -6370 {
lab=vcom}
N 6640 -6390 6640 -6370 {
lab=ctop}
N 6520 -6290 6540 -6290 {
lab=col_n[20]}
N 6520 -6270 6540 -6270 {
lab=colon_n[20]}
N 6520 -6250 6540 -6250 {
lab=#net41}
N 6520 -6230 6540 -6230 {
lab=#net42}
N 6760 -6230 6780 -6230 {
lab=#net42}
N 6760 -6250 6780 -6250 {
lab=#net41}
N 6760 -6270 6780 -6270 {
lab=colon_n[20]}
N 6760 -6290 6780 -6290 {
lab=col_n[20]}
N 6580 -6150 6580 -6140 {
lab=VSS}
N 6580 -6380 6580 -6370 {
lab=VDD}
N 6920 -6150 6930 -6160 {
lab=row_n[22]}
N 6930 -6360 6930 -6160 {
lab=row_n[22]}
N 6920 -6370 6930 -6360 {
lab=row_n[22]}
N 6920 -6150 6920 -6130 {
lab=row_n[22]}
N 6920 -6390 6920 -6370 {
lab=row_n[22]}
N 6800 -6290 6810 -6300 {
lab=col_n[20]}
N 6810 -6300 7010 -6300 {
lab=col_n[20]}
N 7010 -6300 7020 -6290 {
lab=col_n[20]}
N 6800 -6270 6810 -6280 {
lab=colon_n[20]}
N 6810 -6280 7010 -6280 {
lab=colon_n[20]}
N 7010 -6280 7020 -6270 {
lab=colon_n[20]}
N 6800 -6250 6810 -6260 {
lab=#net41}
N 6810 -6260 7010 -6260 {
lab=#net41}
N 7010 -6260 7020 -6250 {
lab=#net41}
N 6800 -6230 6810 -6240 {
lab=#net42}
N 6810 -6240 7010 -6240 {
lab=#net42}
N 7010 -6240 7020 -6230 {
lab=#net42}
N 6860 -6390 6860 -6370 {
lab=vcom}
N 6900 -6390 6900 -6370 {
lab=ctop}
N 6780 -6290 6800 -6290 {
lab=col_n[20]}
N 6780 -6270 6800 -6270 {
lab=colon_n[20]}
N 6780 -6250 6800 -6250 {
lab=#net41}
N 6780 -6230 6800 -6230 {
lab=#net42}
N 7020 -6230 7040 -6230 {
lab=#net42}
N 7020 -6250 7040 -6250 {
lab=#net41}
N 7020 -6270 7040 -6270 {
lab=colon_n[20]}
N 7020 -6290 7040 -6290 {
lab=col_n[20]}
N 6840 -6150 6840 -6140 {
lab=VSS}
N 6840 -6380 6840 -6370 {
lab=VDD}
N 7180 -6150 7190 -6160 {
lab=row_n[23]}
N 7190 -6360 7190 -6160 {
lab=row_n[23]}
N 7180 -6370 7190 -6360 {
lab=row_n[23]}
N 7180 -6150 7180 -6130 {
lab=row_n[23]}
N 7180 -6390 7180 -6370 {
lab=row_n[23]}
N 7060 -6290 7070 -6300 {
lab=col_n[20]}
N 7070 -6300 7270 -6300 {
lab=col_n[20]}
N 7270 -6300 7280 -6290 {
lab=col_n[20]}
N 7060 -6270 7070 -6280 {
lab=colon_n[20]}
N 7070 -6280 7270 -6280 {
lab=colon_n[20]}
N 7270 -6280 7280 -6270 {
lab=colon_n[20]}
N 7060 -6250 7070 -6260 {
lab=#net41}
N 7070 -6260 7270 -6260 {
lab=#net41}
N 7270 -6260 7280 -6250 {
lab=#net41}
N 7060 -6230 7070 -6240 {
lab=#net42}
N 7070 -6240 7270 -6240 {
lab=#net42}
N 7270 -6240 7280 -6230 {
lab=#net42}
N 7120 -6390 7120 -6370 {
lab=vcom}
N 7160 -6390 7160 -6370 {
lab=ctop}
N 7040 -6290 7060 -6290 {
lab=col_n[20]}
N 7040 -6270 7060 -6270 {
lab=colon_n[20]}
N 7040 -6250 7060 -6250 {
lab=#net41}
N 7040 -6230 7060 -6230 {
lab=#net42}
N 7280 -6230 7300 -6230 {
lab=#net42}
N 7280 -6250 7300 -6250 {
lab=#net41}
N 7280 -6270 7300 -6270 {
lab=colon_n[20]}
N 7280 -6290 7300 -6290 {
lab=col_n[20]}
N 7100 -6150 7100 -6140 {
lab=VSS}
N 7100 -6380 7100 -6370 {
lab=VDD}
N 7440 -6150 7450 -6160 {
lab=row_n[24]}
N 7450 -6360 7450 -6160 {
lab=row_n[24]}
N 7440 -6370 7450 -6360 {
lab=row_n[24]}
N 7440 -6150 7440 -6130 {
lab=row_n[24]}
N 7440 -6390 7440 -6370 {
lab=row_n[24]}
N 7320 -6290 7330 -6300 {
lab=col_n[20]}
N 7330 -6300 7530 -6300 {
lab=col_n[20]}
N 7530 -6300 7540 -6290 {
lab=col_n[20]}
N 7320 -6270 7330 -6280 {
lab=colon_n[20]}
N 7330 -6280 7530 -6280 {
lab=colon_n[20]}
N 7530 -6280 7540 -6270 {
lab=colon_n[20]}
N 7320 -6250 7330 -6260 {
lab=#net41}
N 7330 -6260 7530 -6260 {
lab=#net41}
N 7530 -6260 7540 -6250 {
lab=#net41}
N 7320 -6230 7330 -6240 {
lab=#net42}
N 7330 -6240 7530 -6240 {
lab=#net42}
N 7530 -6240 7540 -6230 {
lab=#net42}
N 7380 -6390 7380 -6370 {
lab=vcom}
N 7420 -6390 7420 -6370 {
lab=ctop}
N 7300 -6290 7320 -6290 {
lab=col_n[20]}
N 7300 -6270 7320 -6270 {
lab=colon_n[20]}
N 7300 -6250 7320 -6250 {
lab=#net41}
N 7300 -6230 7320 -6230 {
lab=#net42}
N 7540 -6230 7560 -6230 {
lab=#net42}
N 7540 -6250 7560 -6250 {
lab=#net41}
N 7540 -6270 7560 -6270 {
lab=colon_n[20]}
N 7540 -6290 7560 -6290 {
lab=col_n[20]}
N 7360 -6150 7360 -6140 {
lab=VSS}
N 7360 -6380 7360 -6370 {
lab=VDD}
N 7700 -6150 7710 -6160 {
lab=row_n[25]}
N 7710 -6360 7710 -6160 {
lab=row_n[25]}
N 7700 -6370 7710 -6360 {
lab=row_n[25]}
N 7700 -6150 7700 -6130 {
lab=row_n[25]}
N 7700 -6390 7700 -6370 {
lab=row_n[25]}
N 7580 -6290 7590 -6300 {
lab=col_n[20]}
N 7590 -6300 7790 -6300 {
lab=col_n[20]}
N 7790 -6300 7800 -6290 {
lab=col_n[20]}
N 7580 -6270 7590 -6280 {
lab=colon_n[20]}
N 7590 -6280 7790 -6280 {
lab=colon_n[20]}
N 7790 -6280 7800 -6270 {
lab=colon_n[20]}
N 7580 -6250 7590 -6260 {
lab=#net41}
N 7590 -6260 7790 -6260 {
lab=#net41}
N 7790 -6260 7800 -6250 {
lab=#net41}
N 7580 -6230 7590 -6240 {
lab=#net42}
N 7590 -6240 7790 -6240 {
lab=#net42}
N 7790 -6240 7800 -6230 {
lab=#net42}
N 7640 -6390 7640 -6370 {
lab=vcom}
N 7680 -6390 7680 -6370 {
lab=ctop}
N 7560 -6290 7580 -6290 {
lab=col_n[20]}
N 7560 -6270 7580 -6270 {
lab=colon_n[20]}
N 7560 -6250 7580 -6250 {
lab=#net41}
N 7560 -6230 7580 -6230 {
lab=#net42}
N 7800 -6230 7820 -6230 {
lab=#net42}
N 7800 -6250 7820 -6250 {
lab=#net41}
N 7800 -6270 7820 -6270 {
lab=colon_n[20]}
N 7800 -6290 7820 -6290 {
lab=col_n[20]}
N 7620 -6150 7620 -6140 {
lab=VSS}
N 7620 -6380 7620 -6370 {
lab=VDD}
N 7960 -6150 7970 -6160 {
lab=row_n[26]}
N 7970 -6360 7970 -6160 {
lab=row_n[26]}
N 7960 -6370 7970 -6360 {
lab=row_n[26]}
N 7960 -6150 7960 -6130 {
lab=row_n[26]}
N 7960 -6390 7960 -6370 {
lab=row_n[26]}
N 7840 -6290 7850 -6300 {
lab=col_n[20]}
N 7850 -6300 8050 -6300 {
lab=col_n[20]}
N 8050 -6300 8060 -6290 {
lab=col_n[20]}
N 7840 -6270 7850 -6280 {
lab=colon_n[20]}
N 7850 -6280 8050 -6280 {
lab=colon_n[20]}
N 8050 -6280 8060 -6270 {
lab=colon_n[20]}
N 7840 -6250 7850 -6260 {
lab=#net41}
N 7850 -6260 8050 -6260 {
lab=#net41}
N 8050 -6260 8060 -6250 {
lab=#net41}
N 7840 -6230 7850 -6240 {
lab=#net42}
N 7850 -6240 8050 -6240 {
lab=#net42}
N 8050 -6240 8060 -6230 {
lab=#net42}
N 7900 -6390 7900 -6370 {
lab=vcom}
N 7940 -6390 7940 -6370 {
lab=ctop}
N 7820 -6290 7840 -6290 {
lab=col_n[20]}
N 7820 -6270 7840 -6270 {
lab=colon_n[20]}
N 7820 -6250 7840 -6250 {
lab=#net41}
N 7820 -6230 7840 -6230 {
lab=#net42}
N 8060 -6230 8080 -6230 {
lab=#net42}
N 8060 -6250 8080 -6250 {
lab=#net41}
N 8060 -6270 8080 -6270 {
lab=colon_n[20]}
N 8060 -6290 8080 -6290 {
lab=col_n[20]}
N 7880 -6150 7880 -6140 {
lab=VSS}
N 7880 -6380 7880 -6370 {
lab=VDD}
N 8220 -6150 8230 -6160 {
lab=row_n[27]}
N 8230 -6360 8230 -6160 {
lab=row_n[27]}
N 8220 -6370 8230 -6360 {
lab=row_n[27]}
N 8220 -6150 8220 -6130 {
lab=row_n[27]}
N 8220 -6390 8220 -6370 {
lab=row_n[27]}
N 8100 -6290 8110 -6300 {
lab=col_n[20]}
N 8110 -6300 8310 -6300 {
lab=col_n[20]}
N 8310 -6300 8320 -6290 {
lab=col_n[20]}
N 8100 -6270 8110 -6280 {
lab=colon_n[20]}
N 8110 -6280 8310 -6280 {
lab=colon_n[20]}
N 8310 -6280 8320 -6270 {
lab=colon_n[20]}
N 8100 -6250 8110 -6260 {
lab=#net41}
N 8110 -6260 8310 -6260 {
lab=#net41}
N 8310 -6260 8320 -6250 {
lab=#net41}
N 8100 -6230 8110 -6240 {
lab=#net42}
N 8110 -6240 8310 -6240 {
lab=#net42}
N 8310 -6240 8320 -6230 {
lab=#net42}
N 8160 -6390 8160 -6370 {
lab=vcom}
N 8200 -6390 8200 -6370 {
lab=ctop}
N 8080 -6290 8100 -6290 {
lab=col_n[20]}
N 8080 -6270 8100 -6270 {
lab=colon_n[20]}
N 8080 -6250 8100 -6250 {
lab=#net41}
N 8080 -6230 8100 -6230 {
lab=#net42}
N 8320 -6230 8340 -6230 {
lab=#net42}
N 8320 -6250 8340 -6250 {
lab=#net41}
N 8320 -6270 8340 -6270 {
lab=colon_n[20]}
N 8320 -6290 8340 -6290 {
lab=col_n[20]}
N 8140 -6150 8140 -6140 {
lab=VSS}
N 8140 -6380 8140 -6370 {
lab=VDD}
N 8480 -6150 8490 -6160 {
lab=row_n[28]}
N 8490 -6360 8490 -6160 {
lab=row_n[28]}
N 8480 -6370 8490 -6360 {
lab=row_n[28]}
N 8480 -6150 8480 -6130 {
lab=row_n[28]}
N 8480 -6390 8480 -6370 {
lab=row_n[28]}
N 8360 -6290 8370 -6300 {
lab=col_n[20]}
N 8370 -6300 8570 -6300 {
lab=col_n[20]}
N 8570 -6300 8580 -6290 {
lab=col_n[20]}
N 8360 -6270 8370 -6280 {
lab=colon_n[20]}
N 8370 -6280 8570 -6280 {
lab=colon_n[20]}
N 8570 -6280 8580 -6270 {
lab=colon_n[20]}
N 8360 -6250 8370 -6260 {
lab=#net41}
N 8370 -6260 8570 -6260 {
lab=#net41}
N 8570 -6260 8580 -6250 {
lab=#net41}
N 8360 -6230 8370 -6240 {
lab=#net42}
N 8370 -6240 8570 -6240 {
lab=#net42}
N 8570 -6240 8580 -6230 {
lab=#net42}
N 8420 -6390 8420 -6370 {
lab=vcom}
N 8460 -6390 8460 -6370 {
lab=ctop}
N 8340 -6290 8360 -6290 {
lab=col_n[20]}
N 8340 -6270 8360 -6270 {
lab=colon_n[20]}
N 8340 -6250 8360 -6250 {
lab=#net41}
N 8340 -6230 8360 -6230 {
lab=#net42}
N 8580 -6230 8600 -6230 {
lab=#net42}
N 8580 -6250 8600 -6250 {
lab=#net41}
N 8580 -6270 8600 -6270 {
lab=colon_n[20]}
N 8580 -6290 8600 -6290 {
lab=col_n[20]}
N 8400 -6150 8400 -6140 {
lab=VSS}
N 8400 -6380 8400 -6370 {
lab=VDD}
N 8740 -6150 8750 -6160 {
lab=row_n[29]}
N 8750 -6360 8750 -6160 {
lab=row_n[29]}
N 8740 -6370 8750 -6360 {
lab=row_n[29]}
N 8740 -6150 8740 -6130 {
lab=row_n[29]}
N 8740 -6390 8740 -6370 {
lab=row_n[29]}
N 8620 -6290 8630 -6300 {
lab=col_n[20]}
N 8630 -6300 8830 -6300 {
lab=col_n[20]}
N 8830 -6300 8840 -6290 {
lab=col_n[20]}
N 8620 -6270 8630 -6280 {
lab=colon_n[20]}
N 8630 -6280 8830 -6280 {
lab=colon_n[20]}
N 8830 -6280 8840 -6270 {
lab=colon_n[20]}
N 8620 -6250 8630 -6260 {
lab=#net41}
N 8630 -6260 8830 -6260 {
lab=#net41}
N 8830 -6260 8840 -6250 {
lab=#net41}
N 8620 -6230 8630 -6240 {
lab=#net42}
N 8630 -6240 8830 -6240 {
lab=#net42}
N 8830 -6240 8840 -6230 {
lab=#net42}
N 8680 -6390 8680 -6370 {
lab=vcom}
N 8720 -6390 8720 -6370 {
lab=ctop}
N 8600 -6290 8620 -6290 {
lab=col_n[20]}
N 8600 -6270 8620 -6270 {
lab=colon_n[20]}
N 8600 -6250 8620 -6250 {
lab=#net41}
N 8600 -6230 8620 -6230 {
lab=#net42}
N 8840 -6230 8860 -6230 {
lab=#net42}
N 8840 -6250 8860 -6250 {
lab=#net41}
N 8840 -6270 8860 -6270 {
lab=colon_n[20]}
N 8840 -6290 8860 -6290 {
lab=col_n[20]}
N 8660 -6150 8660 -6140 {
lab=VSS}
N 8660 -6380 8660 -6370 {
lab=VDD}
N 9000 -6150 9010 -6160 {
lab=row_n[30]}
N 9010 -6360 9010 -6160 {
lab=row_n[30]}
N 9000 -6370 9010 -6360 {
lab=row_n[30]}
N 9000 -6150 9000 -6130 {
lab=row_n[30]}
N 9000 -6390 9000 -6370 {
lab=row_n[30]}
N 8880 -6290 8890 -6300 {
lab=col_n[20]}
N 8890 -6300 9090 -6300 {
lab=col_n[20]}
N 9090 -6300 9100 -6290 {
lab=col_n[20]}
N 8880 -6270 8890 -6280 {
lab=colon_n[20]}
N 8890 -6280 9090 -6280 {
lab=colon_n[20]}
N 9090 -6280 9100 -6270 {
lab=colon_n[20]}
N 8880 -6250 8890 -6260 {
lab=#net41}
N 8890 -6260 9090 -6260 {
lab=#net41}
N 9090 -6260 9100 -6250 {
lab=#net41}
N 8880 -6230 8890 -6240 {
lab=#net42}
N 8890 -6240 9090 -6240 {
lab=#net42}
N 9090 -6240 9100 -6230 {
lab=#net42}
N 8940 -6390 8940 -6370 {
lab=vcom}
N 8980 -6390 8980 -6370 {
lab=ctop}
N 8860 -6290 8880 -6290 {
lab=col_n[20]}
N 8860 -6270 8880 -6270 {
lab=colon_n[20]}
N 8860 -6250 8880 -6250 {
lab=#net41}
N 8860 -6230 8880 -6230 {
lab=#net42}
N 9100 -6230 9120 -6230 {
lab=#net42}
N 9100 -6250 9120 -6250 {
lab=#net41}
N 9100 -6270 9120 -6270 {
lab=colon_n[20]}
N 9100 -6290 9120 -6290 {
lab=col_n[20]}
N 8920 -6150 8920 -6140 {
lab=VSS}
N 8920 -6380 8920 -6370 {
lab=VDD}
N 9260 -6150 9270 -6160 {
lab=row_n[31]}
N 9270 -6360 9270 -6160 {
lab=row_n[31]}
N 9260 -6370 9270 -6360 {
lab=row_n[31]}
N 9260 -6150 9260 -6130 {
lab=row_n[31]}
N 9260 -6390 9260 -6370 {
lab=row_n[31]}
N 9140 -6290 9150 -6300 {
lab=col_n[20]}
N 9150 -6300 9350 -6300 {
lab=col_n[20]}
N 9350 -6300 9360 -6290 {
lab=col_n[20]}
N 9140 -6270 9150 -6280 {
lab=colon_n[20]}
N 9150 -6280 9350 -6280 {
lab=colon_n[20]}
N 9350 -6280 9360 -6270 {
lab=colon_n[20]}
N 9140 -6250 9150 -6260 {
lab=#net41}
N 9150 -6260 9350 -6260 {
lab=#net41}
N 9350 -6260 9360 -6250 {
lab=#net41}
N 9140 -6230 9150 -6240 {
lab=#net42}
N 9150 -6240 9350 -6240 {
lab=#net42}
N 9350 -6240 9360 -6230 {
lab=#net42}
N 9200 -6390 9200 -6370 {
lab=vcom}
N 9240 -6390 9240 -6370 {
lab=ctop}
N 9120 -6290 9140 -6290 {
lab=col_n[20]}
N 9120 -6270 9140 -6270 {
lab=colon_n[20]}
N 9120 -6250 9140 -6250 {
lab=#net41}
N 9120 -6230 9140 -6230 {
lab=#net42}
N 9360 -6230 9380 -6230 {
lab=#net42}
N 9360 -6250 9380 -6250 {
lab=#net41}
N 9360 -6270 9380 -6270 {
lab=colon_n[20]}
N 9360 -6290 9380 -6290 {
lab=col_n[20]}
N 9180 -6150 9180 -6140 {
lab=VSS}
N 9180 -6380 9180 -6370 {
lab=VDD}
N 1200 -6410 1210 -6420 {
lab=row_n[0]}
N 1210 -6620 1210 -6420 {
lab=row_n[0]}
N 1200 -6630 1210 -6620 {
lab=row_n[0]}
N 1200 -6410 1200 -6390 {
lab=row_n[0]}
N 1200 -6650 1200 -6630 {
lab=row_n[0]}
N 1080 -6550 1090 -6560 {
lab=col_n[21]}
N 1090 -6560 1290 -6560 {
lab=col_n[21]}
N 1290 -6560 1300 -6550 {
lab=col_n[21]}
N 1080 -6530 1090 -6540 {
lab=colon_n[21]}
N 1090 -6540 1290 -6540 {
lab=colon_n[21]}
N 1290 -6540 1300 -6530 {
lab=colon_n[21]}
N 1080 -6510 1090 -6520 {
lab=#net43}
N 1090 -6520 1290 -6520 {
lab=#net43}
N 1290 -6520 1300 -6510 {
lab=#net43}
N 1080 -6490 1090 -6500 {
lab=#net44}
N 1090 -6500 1290 -6500 {
lab=#net44}
N 1290 -6500 1300 -6490 {
lab=#net44}
N 1140 -6650 1140 -6630 {
lab=vcom}
N 1180 -6650 1180 -6630 {
lab=ctop}
N 1060 -6550 1080 -6550 {
lab=col_n[21]}
N 1060 -6530 1080 -6530 {
lab=colon_n[21]}
N 1060 -6510 1080 -6510 {
lab=#net43}
N 1060 -6490 1080 -6490 {
lab=#net44}
N 1300 -6490 1320 -6490 {
lab=#net44}
N 1300 -6510 1320 -6510 {
lab=#net43}
N 1300 -6530 1320 -6530 {
lab=colon_n[21]}
N 1300 -6550 1320 -6550 {
lab=col_n[21]}
N 1120 -6410 1120 -6400 {
lab=VSS}
N 1120 -6640 1120 -6630 {
lab=VDD}
N 1460 -6410 1470 -6420 {
lab=row_n[1]}
N 1470 -6620 1470 -6420 {
lab=row_n[1]}
N 1460 -6630 1470 -6620 {
lab=row_n[1]}
N 1460 -6410 1460 -6390 {
lab=row_n[1]}
N 1460 -6650 1460 -6630 {
lab=row_n[1]}
N 1340 -6550 1350 -6560 {
lab=col_n[21]}
N 1350 -6560 1550 -6560 {
lab=col_n[21]}
N 1550 -6560 1560 -6550 {
lab=col_n[21]}
N 1340 -6530 1350 -6540 {
lab=colon_n[21]}
N 1350 -6540 1550 -6540 {
lab=colon_n[21]}
N 1550 -6540 1560 -6530 {
lab=colon_n[21]}
N 1340 -6510 1350 -6520 {
lab=#net43}
N 1350 -6520 1550 -6520 {
lab=#net43}
N 1550 -6520 1560 -6510 {
lab=#net43}
N 1340 -6490 1350 -6500 {
lab=#net44}
N 1350 -6500 1550 -6500 {
lab=#net44}
N 1550 -6500 1560 -6490 {
lab=#net44}
N 1400 -6650 1400 -6630 {
lab=vcom}
N 1440 -6650 1440 -6630 {
lab=ctop}
N 1320 -6550 1340 -6550 {
lab=col_n[21]}
N 1320 -6530 1340 -6530 {
lab=colon_n[21]}
N 1320 -6510 1340 -6510 {
lab=#net43}
N 1320 -6490 1340 -6490 {
lab=#net44}
N 1560 -6490 1580 -6490 {
lab=#net44}
N 1560 -6510 1580 -6510 {
lab=#net43}
N 1560 -6530 1580 -6530 {
lab=colon_n[21]}
N 1560 -6550 1580 -6550 {
lab=col_n[21]}
N 1380 -6410 1380 -6400 {
lab=VSS}
N 1380 -6640 1380 -6630 {
lab=VDD}
N 1720 -6410 1730 -6420 {
lab=row_n[2]}
N 1730 -6620 1730 -6420 {
lab=row_n[2]}
N 1720 -6630 1730 -6620 {
lab=row_n[2]}
N 1720 -6410 1720 -6390 {
lab=row_n[2]}
N 1720 -6650 1720 -6630 {
lab=row_n[2]}
N 1600 -6550 1610 -6560 {
lab=col_n[21]}
N 1610 -6560 1810 -6560 {
lab=col_n[21]}
N 1810 -6560 1820 -6550 {
lab=col_n[21]}
N 1600 -6530 1610 -6540 {
lab=colon_n[21]}
N 1610 -6540 1810 -6540 {
lab=colon_n[21]}
N 1810 -6540 1820 -6530 {
lab=colon_n[21]}
N 1600 -6510 1610 -6520 {
lab=#net43}
N 1610 -6520 1810 -6520 {
lab=#net43}
N 1810 -6520 1820 -6510 {
lab=#net43}
N 1600 -6490 1610 -6500 {
lab=#net44}
N 1610 -6500 1810 -6500 {
lab=#net44}
N 1810 -6500 1820 -6490 {
lab=#net44}
N 1660 -6650 1660 -6630 {
lab=vcom}
N 1700 -6650 1700 -6630 {
lab=ctop}
N 1580 -6550 1600 -6550 {
lab=col_n[21]}
N 1580 -6530 1600 -6530 {
lab=colon_n[21]}
N 1580 -6510 1600 -6510 {
lab=#net43}
N 1580 -6490 1600 -6490 {
lab=#net44}
N 1820 -6490 1840 -6490 {
lab=#net44}
N 1820 -6510 1840 -6510 {
lab=#net43}
N 1820 -6530 1840 -6530 {
lab=colon_n[21]}
N 1820 -6550 1840 -6550 {
lab=col_n[21]}
N 1640 -6410 1640 -6400 {
lab=VSS}
N 1640 -6640 1640 -6630 {
lab=VDD}
N 1980 -6410 1990 -6420 {
lab=row_n[3]}
N 1990 -6620 1990 -6420 {
lab=row_n[3]}
N 1980 -6630 1990 -6620 {
lab=row_n[3]}
N 1980 -6410 1980 -6390 {
lab=row_n[3]}
N 1980 -6650 1980 -6630 {
lab=row_n[3]}
N 1860 -6550 1870 -6560 {
lab=col_n[21]}
N 1870 -6560 2070 -6560 {
lab=col_n[21]}
N 2070 -6560 2080 -6550 {
lab=col_n[21]}
N 1860 -6530 1870 -6540 {
lab=colon_n[21]}
N 1870 -6540 2070 -6540 {
lab=colon_n[21]}
N 2070 -6540 2080 -6530 {
lab=colon_n[21]}
N 1860 -6510 1870 -6520 {
lab=#net43}
N 1870 -6520 2070 -6520 {
lab=#net43}
N 2070 -6520 2080 -6510 {
lab=#net43}
N 1860 -6490 1870 -6500 {
lab=#net44}
N 1870 -6500 2070 -6500 {
lab=#net44}
N 2070 -6500 2080 -6490 {
lab=#net44}
N 1920 -6650 1920 -6630 {
lab=vcom}
N 1960 -6650 1960 -6630 {
lab=ctop}
N 1840 -6550 1860 -6550 {
lab=col_n[21]}
N 1840 -6530 1860 -6530 {
lab=colon_n[21]}
N 1840 -6510 1860 -6510 {
lab=#net43}
N 1840 -6490 1860 -6490 {
lab=#net44}
N 2080 -6490 2100 -6490 {
lab=#net44}
N 2080 -6510 2100 -6510 {
lab=#net43}
N 2080 -6530 2100 -6530 {
lab=colon_n[21]}
N 2080 -6550 2100 -6550 {
lab=col_n[21]}
N 1900 -6410 1900 -6400 {
lab=VSS}
N 1900 -6640 1900 -6630 {
lab=VDD}
N 2240 -6410 2250 -6420 {
lab=row_n[4]}
N 2250 -6620 2250 -6420 {
lab=row_n[4]}
N 2240 -6630 2250 -6620 {
lab=row_n[4]}
N 2240 -6410 2240 -6390 {
lab=row_n[4]}
N 2240 -6650 2240 -6630 {
lab=row_n[4]}
N 2120 -6550 2130 -6560 {
lab=col_n[21]}
N 2130 -6560 2330 -6560 {
lab=col_n[21]}
N 2330 -6560 2340 -6550 {
lab=col_n[21]}
N 2120 -6530 2130 -6540 {
lab=colon_n[21]}
N 2130 -6540 2330 -6540 {
lab=colon_n[21]}
N 2330 -6540 2340 -6530 {
lab=colon_n[21]}
N 2120 -6510 2130 -6520 {
lab=#net43}
N 2130 -6520 2330 -6520 {
lab=#net43}
N 2330 -6520 2340 -6510 {
lab=#net43}
N 2120 -6490 2130 -6500 {
lab=#net44}
N 2130 -6500 2330 -6500 {
lab=#net44}
N 2330 -6500 2340 -6490 {
lab=#net44}
N 2180 -6650 2180 -6630 {
lab=vcom}
N 2220 -6650 2220 -6630 {
lab=ctop}
N 2100 -6550 2120 -6550 {
lab=col_n[21]}
N 2100 -6530 2120 -6530 {
lab=colon_n[21]}
N 2100 -6510 2120 -6510 {
lab=#net43}
N 2100 -6490 2120 -6490 {
lab=#net44}
N 2340 -6490 2360 -6490 {
lab=#net44}
N 2340 -6510 2360 -6510 {
lab=#net43}
N 2340 -6530 2360 -6530 {
lab=colon_n[21]}
N 2340 -6550 2360 -6550 {
lab=col_n[21]}
N 2160 -6410 2160 -6400 {
lab=VSS}
N 2160 -6640 2160 -6630 {
lab=VDD}
N 2500 -6410 2510 -6420 {
lab=row_n[5]}
N 2510 -6620 2510 -6420 {
lab=row_n[5]}
N 2500 -6630 2510 -6620 {
lab=row_n[5]}
N 2500 -6410 2500 -6390 {
lab=row_n[5]}
N 2500 -6650 2500 -6630 {
lab=row_n[5]}
N 2380 -6550 2390 -6560 {
lab=col_n[21]}
N 2390 -6560 2590 -6560 {
lab=col_n[21]}
N 2590 -6560 2600 -6550 {
lab=col_n[21]}
N 2380 -6530 2390 -6540 {
lab=colon_n[21]}
N 2390 -6540 2590 -6540 {
lab=colon_n[21]}
N 2590 -6540 2600 -6530 {
lab=colon_n[21]}
N 2380 -6510 2390 -6520 {
lab=#net43}
N 2390 -6520 2590 -6520 {
lab=#net43}
N 2590 -6520 2600 -6510 {
lab=#net43}
N 2380 -6490 2390 -6500 {
lab=#net44}
N 2390 -6500 2590 -6500 {
lab=#net44}
N 2590 -6500 2600 -6490 {
lab=#net44}
N 2440 -6650 2440 -6630 {
lab=vcom}
N 2480 -6650 2480 -6630 {
lab=ctop}
N 2360 -6550 2380 -6550 {
lab=col_n[21]}
N 2360 -6530 2380 -6530 {
lab=colon_n[21]}
N 2360 -6510 2380 -6510 {
lab=#net43}
N 2360 -6490 2380 -6490 {
lab=#net44}
N 2600 -6490 2620 -6490 {
lab=#net44}
N 2600 -6510 2620 -6510 {
lab=#net43}
N 2600 -6530 2620 -6530 {
lab=colon_n[21]}
N 2600 -6550 2620 -6550 {
lab=col_n[21]}
N 2420 -6410 2420 -6400 {
lab=VSS}
N 2420 -6640 2420 -6630 {
lab=VDD}
N 2760 -6410 2770 -6420 {
lab=row_n[6]}
N 2770 -6620 2770 -6420 {
lab=row_n[6]}
N 2760 -6630 2770 -6620 {
lab=row_n[6]}
N 2760 -6410 2760 -6390 {
lab=row_n[6]}
N 2760 -6650 2760 -6630 {
lab=row_n[6]}
N 2640 -6550 2650 -6560 {
lab=col_n[21]}
N 2650 -6560 2850 -6560 {
lab=col_n[21]}
N 2850 -6560 2860 -6550 {
lab=col_n[21]}
N 2640 -6530 2650 -6540 {
lab=colon_n[21]}
N 2650 -6540 2850 -6540 {
lab=colon_n[21]}
N 2850 -6540 2860 -6530 {
lab=colon_n[21]}
N 2640 -6510 2650 -6520 {
lab=#net43}
N 2650 -6520 2850 -6520 {
lab=#net43}
N 2850 -6520 2860 -6510 {
lab=#net43}
N 2640 -6490 2650 -6500 {
lab=#net44}
N 2650 -6500 2850 -6500 {
lab=#net44}
N 2850 -6500 2860 -6490 {
lab=#net44}
N 2700 -6650 2700 -6630 {
lab=vcom}
N 2740 -6650 2740 -6630 {
lab=ctop}
N 2620 -6550 2640 -6550 {
lab=col_n[21]}
N 2620 -6530 2640 -6530 {
lab=colon_n[21]}
N 2620 -6510 2640 -6510 {
lab=#net43}
N 2620 -6490 2640 -6490 {
lab=#net44}
N 2860 -6490 2880 -6490 {
lab=#net44}
N 2860 -6510 2880 -6510 {
lab=#net43}
N 2860 -6530 2880 -6530 {
lab=colon_n[21]}
N 2860 -6550 2880 -6550 {
lab=col_n[21]}
N 2680 -6410 2680 -6400 {
lab=VSS}
N 2680 -6640 2680 -6630 {
lab=VDD}
N 3020 -6410 3030 -6420 {
lab=row_n[7]}
N 3030 -6620 3030 -6420 {
lab=row_n[7]}
N 3020 -6630 3030 -6620 {
lab=row_n[7]}
N 3020 -6410 3020 -6390 {
lab=row_n[7]}
N 3020 -6650 3020 -6630 {
lab=row_n[7]}
N 2900 -6550 2910 -6560 {
lab=col_n[21]}
N 2910 -6560 3110 -6560 {
lab=col_n[21]}
N 3110 -6560 3120 -6550 {
lab=col_n[21]}
N 2900 -6530 2910 -6540 {
lab=colon_n[21]}
N 2910 -6540 3110 -6540 {
lab=colon_n[21]}
N 3110 -6540 3120 -6530 {
lab=colon_n[21]}
N 2900 -6510 2910 -6520 {
lab=#net43}
N 2910 -6520 3110 -6520 {
lab=#net43}
N 3110 -6520 3120 -6510 {
lab=#net43}
N 2900 -6490 2910 -6500 {
lab=#net44}
N 2910 -6500 3110 -6500 {
lab=#net44}
N 3110 -6500 3120 -6490 {
lab=#net44}
N 2960 -6650 2960 -6630 {
lab=vcom}
N 3000 -6650 3000 -6630 {
lab=ctop}
N 2880 -6550 2900 -6550 {
lab=col_n[21]}
N 2880 -6530 2900 -6530 {
lab=colon_n[21]}
N 2880 -6510 2900 -6510 {
lab=#net43}
N 2880 -6490 2900 -6490 {
lab=#net44}
N 3120 -6490 3140 -6490 {
lab=#net44}
N 3120 -6510 3140 -6510 {
lab=#net43}
N 3120 -6530 3140 -6530 {
lab=colon_n[21]}
N 3120 -6550 3140 -6550 {
lab=col_n[21]}
N 2940 -6410 2940 -6400 {
lab=VSS}
N 2940 -6640 2940 -6630 {
lab=VDD}
N 3280 -6410 3290 -6420 {
lab=row_n[8]}
N 3290 -6620 3290 -6420 {
lab=row_n[8]}
N 3280 -6630 3290 -6620 {
lab=row_n[8]}
N 3280 -6410 3280 -6390 {
lab=row_n[8]}
N 3280 -6650 3280 -6630 {
lab=row_n[8]}
N 3160 -6550 3170 -6560 {
lab=col_n[21]}
N 3170 -6560 3370 -6560 {
lab=col_n[21]}
N 3370 -6560 3380 -6550 {
lab=col_n[21]}
N 3160 -6530 3170 -6540 {
lab=colon_n[21]}
N 3170 -6540 3370 -6540 {
lab=colon_n[21]}
N 3370 -6540 3380 -6530 {
lab=colon_n[21]}
N 3160 -6510 3170 -6520 {
lab=#net43}
N 3170 -6520 3370 -6520 {
lab=#net43}
N 3370 -6520 3380 -6510 {
lab=#net43}
N 3160 -6490 3170 -6500 {
lab=#net44}
N 3170 -6500 3370 -6500 {
lab=#net44}
N 3370 -6500 3380 -6490 {
lab=#net44}
N 3220 -6650 3220 -6630 {
lab=vcom}
N 3260 -6650 3260 -6630 {
lab=ctop}
N 3140 -6550 3160 -6550 {
lab=col_n[21]}
N 3140 -6530 3160 -6530 {
lab=colon_n[21]}
N 3140 -6510 3160 -6510 {
lab=#net43}
N 3140 -6490 3160 -6490 {
lab=#net44}
N 3380 -6490 3400 -6490 {
lab=#net44}
N 3380 -6510 3400 -6510 {
lab=#net43}
N 3380 -6530 3400 -6530 {
lab=colon_n[21]}
N 3380 -6550 3400 -6550 {
lab=col_n[21]}
N 3200 -6410 3200 -6400 {
lab=VSS}
N 3200 -6640 3200 -6630 {
lab=VDD}
N 3540 -6410 3550 -6420 {
lab=row_n[9]}
N 3550 -6620 3550 -6420 {
lab=row_n[9]}
N 3540 -6630 3550 -6620 {
lab=row_n[9]}
N 3540 -6410 3540 -6390 {
lab=row_n[9]}
N 3540 -6650 3540 -6630 {
lab=row_n[9]}
N 3420 -6550 3430 -6560 {
lab=col_n[21]}
N 3430 -6560 3630 -6560 {
lab=col_n[21]}
N 3630 -6560 3640 -6550 {
lab=col_n[21]}
N 3420 -6530 3430 -6540 {
lab=colon_n[21]}
N 3430 -6540 3630 -6540 {
lab=colon_n[21]}
N 3630 -6540 3640 -6530 {
lab=colon_n[21]}
N 3420 -6510 3430 -6520 {
lab=#net43}
N 3430 -6520 3630 -6520 {
lab=#net43}
N 3630 -6520 3640 -6510 {
lab=#net43}
N 3420 -6490 3430 -6500 {
lab=#net44}
N 3430 -6500 3630 -6500 {
lab=#net44}
N 3630 -6500 3640 -6490 {
lab=#net44}
N 3480 -6650 3480 -6630 {
lab=vcom}
N 3520 -6650 3520 -6630 {
lab=ctop}
N 3400 -6550 3420 -6550 {
lab=col_n[21]}
N 3400 -6530 3420 -6530 {
lab=colon_n[21]}
N 3400 -6510 3420 -6510 {
lab=#net43}
N 3400 -6490 3420 -6490 {
lab=#net44}
N 3640 -6490 3660 -6490 {
lab=#net44}
N 3640 -6510 3660 -6510 {
lab=#net43}
N 3640 -6530 3660 -6530 {
lab=colon_n[21]}
N 3640 -6550 3660 -6550 {
lab=col_n[21]}
N 3460 -6410 3460 -6400 {
lab=VSS}
N 3460 -6640 3460 -6630 {
lab=VDD}
N 3800 -6410 3810 -6420 {
lab=row_n[10]}
N 3810 -6620 3810 -6420 {
lab=row_n[10]}
N 3800 -6630 3810 -6620 {
lab=row_n[10]}
N 3800 -6410 3800 -6390 {
lab=row_n[10]}
N 3800 -6650 3800 -6630 {
lab=row_n[10]}
N 3680 -6550 3690 -6560 {
lab=col_n[21]}
N 3690 -6560 3890 -6560 {
lab=col_n[21]}
N 3890 -6560 3900 -6550 {
lab=col_n[21]}
N 3680 -6530 3690 -6540 {
lab=colon_n[21]}
N 3690 -6540 3890 -6540 {
lab=colon_n[21]}
N 3890 -6540 3900 -6530 {
lab=colon_n[21]}
N 3680 -6510 3690 -6520 {
lab=#net43}
N 3690 -6520 3890 -6520 {
lab=#net43}
N 3890 -6520 3900 -6510 {
lab=#net43}
N 3680 -6490 3690 -6500 {
lab=#net44}
N 3690 -6500 3890 -6500 {
lab=#net44}
N 3890 -6500 3900 -6490 {
lab=#net44}
N 3740 -6650 3740 -6630 {
lab=vcom}
N 3780 -6650 3780 -6630 {
lab=ctop}
N 3660 -6550 3680 -6550 {
lab=col_n[21]}
N 3660 -6530 3680 -6530 {
lab=colon_n[21]}
N 3660 -6510 3680 -6510 {
lab=#net43}
N 3660 -6490 3680 -6490 {
lab=#net44}
N 3900 -6490 3920 -6490 {
lab=#net44}
N 3900 -6510 3920 -6510 {
lab=#net43}
N 3900 -6530 3920 -6530 {
lab=colon_n[21]}
N 3900 -6550 3920 -6550 {
lab=col_n[21]}
N 3720 -6410 3720 -6400 {
lab=VSS}
N 3720 -6640 3720 -6630 {
lab=VDD}
N 4060 -6410 4070 -6420 {
lab=row_n[11]}
N 4070 -6620 4070 -6420 {
lab=row_n[11]}
N 4060 -6630 4070 -6620 {
lab=row_n[11]}
N 4060 -6410 4060 -6390 {
lab=row_n[11]}
N 4060 -6650 4060 -6630 {
lab=row_n[11]}
N 3940 -6550 3950 -6560 {
lab=col_n[21]}
N 3950 -6560 4150 -6560 {
lab=col_n[21]}
N 4150 -6560 4160 -6550 {
lab=col_n[21]}
N 3940 -6530 3950 -6540 {
lab=colon_n[21]}
N 3950 -6540 4150 -6540 {
lab=colon_n[21]}
N 4150 -6540 4160 -6530 {
lab=colon_n[21]}
N 3940 -6510 3950 -6520 {
lab=#net43}
N 3950 -6520 4150 -6520 {
lab=#net43}
N 4150 -6520 4160 -6510 {
lab=#net43}
N 3940 -6490 3950 -6500 {
lab=#net44}
N 3950 -6500 4150 -6500 {
lab=#net44}
N 4150 -6500 4160 -6490 {
lab=#net44}
N 4000 -6650 4000 -6630 {
lab=vcom}
N 4040 -6650 4040 -6630 {
lab=ctop}
N 3920 -6550 3940 -6550 {
lab=col_n[21]}
N 3920 -6530 3940 -6530 {
lab=colon_n[21]}
N 3920 -6510 3940 -6510 {
lab=#net43}
N 3920 -6490 3940 -6490 {
lab=#net44}
N 4160 -6490 4180 -6490 {
lab=#net44}
N 4160 -6510 4180 -6510 {
lab=#net43}
N 4160 -6530 4180 -6530 {
lab=colon_n[21]}
N 4160 -6550 4180 -6550 {
lab=col_n[21]}
N 3980 -6410 3980 -6400 {
lab=VSS}
N 3980 -6640 3980 -6630 {
lab=VDD}
N 4320 -6410 4330 -6420 {
lab=row_n[12]}
N 4330 -6620 4330 -6420 {
lab=row_n[12]}
N 4320 -6630 4330 -6620 {
lab=row_n[12]}
N 4320 -6410 4320 -6390 {
lab=row_n[12]}
N 4320 -6650 4320 -6630 {
lab=row_n[12]}
N 4200 -6550 4210 -6560 {
lab=col_n[21]}
N 4210 -6560 4410 -6560 {
lab=col_n[21]}
N 4410 -6560 4420 -6550 {
lab=col_n[21]}
N 4200 -6530 4210 -6540 {
lab=colon_n[21]}
N 4210 -6540 4410 -6540 {
lab=colon_n[21]}
N 4410 -6540 4420 -6530 {
lab=colon_n[21]}
N 4200 -6510 4210 -6520 {
lab=#net43}
N 4210 -6520 4410 -6520 {
lab=#net43}
N 4410 -6520 4420 -6510 {
lab=#net43}
N 4200 -6490 4210 -6500 {
lab=#net44}
N 4210 -6500 4410 -6500 {
lab=#net44}
N 4410 -6500 4420 -6490 {
lab=#net44}
N 4260 -6650 4260 -6630 {
lab=vcom}
N 4300 -6650 4300 -6630 {
lab=ctop}
N 4180 -6550 4200 -6550 {
lab=col_n[21]}
N 4180 -6530 4200 -6530 {
lab=colon_n[21]}
N 4180 -6510 4200 -6510 {
lab=#net43}
N 4180 -6490 4200 -6490 {
lab=#net44}
N 4420 -6490 4440 -6490 {
lab=#net44}
N 4420 -6510 4440 -6510 {
lab=#net43}
N 4420 -6530 4440 -6530 {
lab=colon_n[21]}
N 4420 -6550 4440 -6550 {
lab=col_n[21]}
N 4240 -6410 4240 -6400 {
lab=VSS}
N 4240 -6640 4240 -6630 {
lab=VDD}
N 4580 -6410 4590 -6420 {
lab=row_n[13]}
N 4590 -6620 4590 -6420 {
lab=row_n[13]}
N 4580 -6630 4590 -6620 {
lab=row_n[13]}
N 4580 -6410 4580 -6390 {
lab=row_n[13]}
N 4580 -6650 4580 -6630 {
lab=row_n[13]}
N 4460 -6550 4470 -6560 {
lab=col_n[21]}
N 4470 -6560 4670 -6560 {
lab=col_n[21]}
N 4670 -6560 4680 -6550 {
lab=col_n[21]}
N 4460 -6530 4470 -6540 {
lab=colon_n[21]}
N 4470 -6540 4670 -6540 {
lab=colon_n[21]}
N 4670 -6540 4680 -6530 {
lab=colon_n[21]}
N 4460 -6510 4470 -6520 {
lab=#net43}
N 4470 -6520 4670 -6520 {
lab=#net43}
N 4670 -6520 4680 -6510 {
lab=#net43}
N 4460 -6490 4470 -6500 {
lab=#net44}
N 4470 -6500 4670 -6500 {
lab=#net44}
N 4670 -6500 4680 -6490 {
lab=#net44}
N 4520 -6650 4520 -6630 {
lab=vcom}
N 4560 -6650 4560 -6630 {
lab=ctop}
N 4440 -6550 4460 -6550 {
lab=col_n[21]}
N 4440 -6530 4460 -6530 {
lab=colon_n[21]}
N 4440 -6510 4460 -6510 {
lab=#net43}
N 4440 -6490 4460 -6490 {
lab=#net44}
N 4680 -6490 4700 -6490 {
lab=#net44}
N 4680 -6510 4700 -6510 {
lab=#net43}
N 4680 -6530 4700 -6530 {
lab=colon_n[21]}
N 4680 -6550 4700 -6550 {
lab=col_n[21]}
N 4500 -6410 4500 -6400 {
lab=VSS}
N 4500 -6640 4500 -6630 {
lab=VDD}
N 4840 -6410 4850 -6420 {
lab=row_n[14]}
N 4850 -6620 4850 -6420 {
lab=row_n[14]}
N 4840 -6630 4850 -6620 {
lab=row_n[14]}
N 4840 -6410 4840 -6390 {
lab=row_n[14]}
N 4840 -6650 4840 -6630 {
lab=row_n[14]}
N 4720 -6550 4730 -6560 {
lab=col_n[21]}
N 4730 -6560 4930 -6560 {
lab=col_n[21]}
N 4930 -6560 4940 -6550 {
lab=col_n[21]}
N 4720 -6530 4730 -6540 {
lab=colon_n[21]}
N 4730 -6540 4930 -6540 {
lab=colon_n[21]}
N 4930 -6540 4940 -6530 {
lab=colon_n[21]}
N 4720 -6510 4730 -6520 {
lab=#net43}
N 4730 -6520 4930 -6520 {
lab=#net43}
N 4930 -6520 4940 -6510 {
lab=#net43}
N 4720 -6490 4730 -6500 {
lab=#net44}
N 4730 -6500 4930 -6500 {
lab=#net44}
N 4930 -6500 4940 -6490 {
lab=#net44}
N 4780 -6650 4780 -6630 {
lab=vcom}
N 4820 -6650 4820 -6630 {
lab=ctop}
N 4700 -6550 4720 -6550 {
lab=col_n[21]}
N 4700 -6530 4720 -6530 {
lab=colon_n[21]}
N 4700 -6510 4720 -6510 {
lab=#net43}
N 4700 -6490 4720 -6490 {
lab=#net44}
N 4940 -6490 4960 -6490 {
lab=#net44}
N 4940 -6510 4960 -6510 {
lab=#net43}
N 4940 -6530 4960 -6530 {
lab=colon_n[21]}
N 4940 -6550 4960 -6550 {
lab=col_n[21]}
N 4760 -6410 4760 -6400 {
lab=VSS}
N 4760 -6640 4760 -6630 {
lab=VDD}
N 5100 -6410 5110 -6420 {
lab=row_n[15]}
N 5110 -6620 5110 -6420 {
lab=row_n[15]}
N 5100 -6630 5110 -6620 {
lab=row_n[15]}
N 5100 -6410 5100 -6390 {
lab=row_n[15]}
N 5100 -6650 5100 -6630 {
lab=row_n[15]}
N 4980 -6550 4990 -6560 {
lab=col_n[21]}
N 4990 -6560 5190 -6560 {
lab=col_n[21]}
N 5190 -6560 5200 -6550 {
lab=col_n[21]}
N 4980 -6530 4990 -6540 {
lab=colon_n[21]}
N 4990 -6540 5190 -6540 {
lab=colon_n[21]}
N 5190 -6540 5200 -6530 {
lab=colon_n[21]}
N 4980 -6510 4990 -6520 {
lab=#net43}
N 4990 -6520 5190 -6520 {
lab=#net43}
N 5190 -6520 5200 -6510 {
lab=#net43}
N 4980 -6490 4990 -6500 {
lab=#net44}
N 4990 -6500 5190 -6500 {
lab=#net44}
N 5190 -6500 5200 -6490 {
lab=#net44}
N 5040 -6650 5040 -6630 {
lab=vcom}
N 5080 -6650 5080 -6630 {
lab=ctop}
N 4960 -6550 4980 -6550 {
lab=col_n[21]}
N 4960 -6530 4980 -6530 {
lab=colon_n[21]}
N 4960 -6510 4980 -6510 {
lab=#net43}
N 4960 -6490 4980 -6490 {
lab=#net44}
N 5200 -6490 5220 -6490 {
lab=#net44}
N 5200 -6510 5220 -6510 {
lab=#net43}
N 5200 -6530 5220 -6530 {
lab=colon_n[21]}
N 5200 -6550 5220 -6550 {
lab=col_n[21]}
N 5020 -6410 5020 -6400 {
lab=VSS}
N 5020 -6640 5020 -6630 {
lab=VDD}
N 5360 -6410 5370 -6420 {
lab=row_n[16]}
N 5370 -6620 5370 -6420 {
lab=row_n[16]}
N 5360 -6630 5370 -6620 {
lab=row_n[16]}
N 5360 -6410 5360 -6390 {
lab=row_n[16]}
N 5360 -6650 5360 -6630 {
lab=row_n[16]}
N 5240 -6550 5250 -6560 {
lab=col_n[21]}
N 5250 -6560 5450 -6560 {
lab=col_n[21]}
N 5450 -6560 5460 -6550 {
lab=col_n[21]}
N 5240 -6530 5250 -6540 {
lab=colon_n[21]}
N 5250 -6540 5450 -6540 {
lab=colon_n[21]}
N 5450 -6540 5460 -6530 {
lab=colon_n[21]}
N 5240 -6510 5250 -6520 {
lab=#net43}
N 5250 -6520 5450 -6520 {
lab=#net43}
N 5450 -6520 5460 -6510 {
lab=#net43}
N 5240 -6490 5250 -6500 {
lab=#net44}
N 5250 -6500 5450 -6500 {
lab=#net44}
N 5450 -6500 5460 -6490 {
lab=#net44}
N 5300 -6650 5300 -6630 {
lab=vcom}
N 5340 -6650 5340 -6630 {
lab=ctop}
N 5220 -6550 5240 -6550 {
lab=col_n[21]}
N 5220 -6530 5240 -6530 {
lab=colon_n[21]}
N 5220 -6510 5240 -6510 {
lab=#net43}
N 5220 -6490 5240 -6490 {
lab=#net44}
N 5460 -6490 5480 -6490 {
lab=#net44}
N 5460 -6510 5480 -6510 {
lab=#net43}
N 5460 -6530 5480 -6530 {
lab=colon_n[21]}
N 5460 -6550 5480 -6550 {
lab=col_n[21]}
N 5280 -6410 5280 -6400 {
lab=VSS}
N 5280 -6640 5280 -6630 {
lab=VDD}
N 5620 -6410 5630 -6420 {
lab=row_n[17]}
N 5630 -6620 5630 -6420 {
lab=row_n[17]}
N 5620 -6630 5630 -6620 {
lab=row_n[17]}
N 5620 -6410 5620 -6390 {
lab=row_n[17]}
N 5620 -6650 5620 -6630 {
lab=row_n[17]}
N 5500 -6550 5510 -6560 {
lab=col_n[21]}
N 5510 -6560 5710 -6560 {
lab=col_n[21]}
N 5710 -6560 5720 -6550 {
lab=col_n[21]}
N 5500 -6530 5510 -6540 {
lab=colon_n[21]}
N 5510 -6540 5710 -6540 {
lab=colon_n[21]}
N 5710 -6540 5720 -6530 {
lab=colon_n[21]}
N 5500 -6510 5510 -6520 {
lab=#net43}
N 5510 -6520 5710 -6520 {
lab=#net43}
N 5710 -6520 5720 -6510 {
lab=#net43}
N 5500 -6490 5510 -6500 {
lab=#net44}
N 5510 -6500 5710 -6500 {
lab=#net44}
N 5710 -6500 5720 -6490 {
lab=#net44}
N 5560 -6650 5560 -6630 {
lab=vcom}
N 5600 -6650 5600 -6630 {
lab=ctop}
N 5480 -6550 5500 -6550 {
lab=col_n[21]}
N 5480 -6530 5500 -6530 {
lab=colon_n[21]}
N 5480 -6510 5500 -6510 {
lab=#net43}
N 5480 -6490 5500 -6490 {
lab=#net44}
N 5720 -6490 5740 -6490 {
lab=#net44}
N 5720 -6510 5740 -6510 {
lab=#net43}
N 5720 -6530 5740 -6530 {
lab=colon_n[21]}
N 5720 -6550 5740 -6550 {
lab=col_n[21]}
N 5540 -6410 5540 -6400 {
lab=VSS}
N 5540 -6640 5540 -6630 {
lab=VDD}
N 5880 -6410 5890 -6420 {
lab=row_n[18]}
N 5890 -6620 5890 -6420 {
lab=row_n[18]}
N 5880 -6630 5890 -6620 {
lab=row_n[18]}
N 5880 -6410 5880 -6390 {
lab=row_n[18]}
N 5880 -6650 5880 -6630 {
lab=row_n[18]}
N 5760 -6550 5770 -6560 {
lab=col_n[21]}
N 5770 -6560 5970 -6560 {
lab=col_n[21]}
N 5970 -6560 5980 -6550 {
lab=col_n[21]}
N 5760 -6530 5770 -6540 {
lab=colon_n[21]}
N 5770 -6540 5970 -6540 {
lab=colon_n[21]}
N 5970 -6540 5980 -6530 {
lab=colon_n[21]}
N 5760 -6510 5770 -6520 {
lab=#net43}
N 5770 -6520 5970 -6520 {
lab=#net43}
N 5970 -6520 5980 -6510 {
lab=#net43}
N 5760 -6490 5770 -6500 {
lab=#net44}
N 5770 -6500 5970 -6500 {
lab=#net44}
N 5970 -6500 5980 -6490 {
lab=#net44}
N 5820 -6650 5820 -6630 {
lab=vcom}
N 5860 -6650 5860 -6630 {
lab=ctop}
N 5740 -6550 5760 -6550 {
lab=col_n[21]}
N 5740 -6530 5760 -6530 {
lab=colon_n[21]}
N 5740 -6510 5760 -6510 {
lab=#net43}
N 5740 -6490 5760 -6490 {
lab=#net44}
N 5980 -6490 6000 -6490 {
lab=#net44}
N 5980 -6510 6000 -6510 {
lab=#net43}
N 5980 -6530 6000 -6530 {
lab=colon_n[21]}
N 5980 -6550 6000 -6550 {
lab=col_n[21]}
N 5800 -6410 5800 -6400 {
lab=VSS}
N 5800 -6640 5800 -6630 {
lab=VDD}
N 6140 -6410 6150 -6420 {
lab=row_n[19]}
N 6150 -6620 6150 -6420 {
lab=row_n[19]}
N 6140 -6630 6150 -6620 {
lab=row_n[19]}
N 6140 -6410 6140 -6390 {
lab=row_n[19]}
N 6140 -6650 6140 -6630 {
lab=row_n[19]}
N 6020 -6550 6030 -6560 {
lab=col_n[21]}
N 6030 -6560 6230 -6560 {
lab=col_n[21]}
N 6230 -6560 6240 -6550 {
lab=col_n[21]}
N 6020 -6530 6030 -6540 {
lab=colon_n[21]}
N 6030 -6540 6230 -6540 {
lab=colon_n[21]}
N 6230 -6540 6240 -6530 {
lab=colon_n[21]}
N 6020 -6510 6030 -6520 {
lab=#net43}
N 6030 -6520 6230 -6520 {
lab=#net43}
N 6230 -6520 6240 -6510 {
lab=#net43}
N 6020 -6490 6030 -6500 {
lab=#net44}
N 6030 -6500 6230 -6500 {
lab=#net44}
N 6230 -6500 6240 -6490 {
lab=#net44}
N 6080 -6650 6080 -6630 {
lab=vcom}
N 6120 -6650 6120 -6630 {
lab=ctop}
N 6000 -6550 6020 -6550 {
lab=col_n[21]}
N 6000 -6530 6020 -6530 {
lab=colon_n[21]}
N 6000 -6510 6020 -6510 {
lab=#net43}
N 6000 -6490 6020 -6490 {
lab=#net44}
N 6240 -6490 6260 -6490 {
lab=#net44}
N 6240 -6510 6260 -6510 {
lab=#net43}
N 6240 -6530 6260 -6530 {
lab=colon_n[21]}
N 6240 -6550 6260 -6550 {
lab=col_n[21]}
N 6060 -6410 6060 -6400 {
lab=VSS}
N 6060 -6640 6060 -6630 {
lab=VDD}
N 6400 -6410 6410 -6420 {
lab=row_n[20]}
N 6410 -6620 6410 -6420 {
lab=row_n[20]}
N 6400 -6630 6410 -6620 {
lab=row_n[20]}
N 6400 -6410 6400 -6390 {
lab=row_n[20]}
N 6400 -6650 6400 -6630 {
lab=row_n[20]}
N 6280 -6550 6290 -6560 {
lab=col_n[21]}
N 6290 -6560 6490 -6560 {
lab=col_n[21]}
N 6490 -6560 6500 -6550 {
lab=col_n[21]}
N 6280 -6530 6290 -6540 {
lab=colon_n[21]}
N 6290 -6540 6490 -6540 {
lab=colon_n[21]}
N 6490 -6540 6500 -6530 {
lab=colon_n[21]}
N 6280 -6510 6290 -6520 {
lab=#net43}
N 6290 -6520 6490 -6520 {
lab=#net43}
N 6490 -6520 6500 -6510 {
lab=#net43}
N 6280 -6490 6290 -6500 {
lab=#net44}
N 6290 -6500 6490 -6500 {
lab=#net44}
N 6490 -6500 6500 -6490 {
lab=#net44}
N 6340 -6650 6340 -6630 {
lab=vcom}
N 6380 -6650 6380 -6630 {
lab=ctop}
N 6260 -6550 6280 -6550 {
lab=col_n[21]}
N 6260 -6530 6280 -6530 {
lab=colon_n[21]}
N 6260 -6510 6280 -6510 {
lab=#net43}
N 6260 -6490 6280 -6490 {
lab=#net44}
N 6500 -6490 6520 -6490 {
lab=#net44}
N 6500 -6510 6520 -6510 {
lab=#net43}
N 6500 -6530 6520 -6530 {
lab=colon_n[21]}
N 6500 -6550 6520 -6550 {
lab=col_n[21]}
N 6320 -6410 6320 -6400 {
lab=VSS}
N 6320 -6640 6320 -6630 {
lab=VDD}
N 6660 -6410 6670 -6420 {
lab=row_n[21]}
N 6670 -6620 6670 -6420 {
lab=row_n[21]}
N 6660 -6630 6670 -6620 {
lab=row_n[21]}
N 6660 -6410 6660 -6390 {
lab=row_n[21]}
N 6660 -6650 6660 -6630 {
lab=row_n[21]}
N 6540 -6550 6550 -6560 {
lab=col_n[21]}
N 6550 -6560 6750 -6560 {
lab=col_n[21]}
N 6750 -6560 6760 -6550 {
lab=col_n[21]}
N 6540 -6530 6550 -6540 {
lab=colon_n[21]}
N 6550 -6540 6750 -6540 {
lab=colon_n[21]}
N 6750 -6540 6760 -6530 {
lab=colon_n[21]}
N 6540 -6510 6550 -6520 {
lab=#net43}
N 6550 -6520 6750 -6520 {
lab=#net43}
N 6750 -6520 6760 -6510 {
lab=#net43}
N 6540 -6490 6550 -6500 {
lab=#net44}
N 6550 -6500 6750 -6500 {
lab=#net44}
N 6750 -6500 6760 -6490 {
lab=#net44}
N 6600 -6650 6600 -6630 {
lab=vcom}
N 6640 -6650 6640 -6630 {
lab=ctop}
N 6520 -6550 6540 -6550 {
lab=col_n[21]}
N 6520 -6530 6540 -6530 {
lab=colon_n[21]}
N 6520 -6510 6540 -6510 {
lab=#net43}
N 6520 -6490 6540 -6490 {
lab=#net44}
N 6760 -6490 6780 -6490 {
lab=#net44}
N 6760 -6510 6780 -6510 {
lab=#net43}
N 6760 -6530 6780 -6530 {
lab=colon_n[21]}
N 6760 -6550 6780 -6550 {
lab=col_n[21]}
N 6580 -6410 6580 -6400 {
lab=VSS}
N 6580 -6640 6580 -6630 {
lab=VDD}
N 6920 -6410 6930 -6420 {
lab=row_n[22]}
N 6930 -6620 6930 -6420 {
lab=row_n[22]}
N 6920 -6630 6930 -6620 {
lab=row_n[22]}
N 6920 -6410 6920 -6390 {
lab=row_n[22]}
N 6920 -6650 6920 -6630 {
lab=row_n[22]}
N 6800 -6550 6810 -6560 {
lab=col_n[21]}
N 6810 -6560 7010 -6560 {
lab=col_n[21]}
N 7010 -6560 7020 -6550 {
lab=col_n[21]}
N 6800 -6530 6810 -6540 {
lab=colon_n[21]}
N 6810 -6540 7010 -6540 {
lab=colon_n[21]}
N 7010 -6540 7020 -6530 {
lab=colon_n[21]}
N 6800 -6510 6810 -6520 {
lab=#net43}
N 6810 -6520 7010 -6520 {
lab=#net43}
N 7010 -6520 7020 -6510 {
lab=#net43}
N 6800 -6490 6810 -6500 {
lab=#net44}
N 6810 -6500 7010 -6500 {
lab=#net44}
N 7010 -6500 7020 -6490 {
lab=#net44}
N 6860 -6650 6860 -6630 {
lab=vcom}
N 6900 -6650 6900 -6630 {
lab=ctop}
N 6780 -6550 6800 -6550 {
lab=col_n[21]}
N 6780 -6530 6800 -6530 {
lab=colon_n[21]}
N 6780 -6510 6800 -6510 {
lab=#net43}
N 6780 -6490 6800 -6490 {
lab=#net44}
N 7020 -6490 7040 -6490 {
lab=#net44}
N 7020 -6510 7040 -6510 {
lab=#net43}
N 7020 -6530 7040 -6530 {
lab=colon_n[21]}
N 7020 -6550 7040 -6550 {
lab=col_n[21]}
N 6840 -6410 6840 -6400 {
lab=VSS}
N 6840 -6640 6840 -6630 {
lab=VDD}
N 7180 -6410 7190 -6420 {
lab=row_n[23]}
N 7190 -6620 7190 -6420 {
lab=row_n[23]}
N 7180 -6630 7190 -6620 {
lab=row_n[23]}
N 7180 -6410 7180 -6390 {
lab=row_n[23]}
N 7180 -6650 7180 -6630 {
lab=row_n[23]}
N 7060 -6550 7070 -6560 {
lab=col_n[21]}
N 7070 -6560 7270 -6560 {
lab=col_n[21]}
N 7270 -6560 7280 -6550 {
lab=col_n[21]}
N 7060 -6530 7070 -6540 {
lab=colon_n[21]}
N 7070 -6540 7270 -6540 {
lab=colon_n[21]}
N 7270 -6540 7280 -6530 {
lab=colon_n[21]}
N 7060 -6510 7070 -6520 {
lab=#net43}
N 7070 -6520 7270 -6520 {
lab=#net43}
N 7270 -6520 7280 -6510 {
lab=#net43}
N 7060 -6490 7070 -6500 {
lab=#net44}
N 7070 -6500 7270 -6500 {
lab=#net44}
N 7270 -6500 7280 -6490 {
lab=#net44}
N 7120 -6650 7120 -6630 {
lab=vcom}
N 7160 -6650 7160 -6630 {
lab=ctop}
N 7040 -6550 7060 -6550 {
lab=col_n[21]}
N 7040 -6530 7060 -6530 {
lab=colon_n[21]}
N 7040 -6510 7060 -6510 {
lab=#net43}
N 7040 -6490 7060 -6490 {
lab=#net44}
N 7280 -6490 7300 -6490 {
lab=#net44}
N 7280 -6510 7300 -6510 {
lab=#net43}
N 7280 -6530 7300 -6530 {
lab=colon_n[21]}
N 7280 -6550 7300 -6550 {
lab=col_n[21]}
N 7100 -6410 7100 -6400 {
lab=VSS}
N 7100 -6640 7100 -6630 {
lab=VDD}
N 7440 -6410 7450 -6420 {
lab=row_n[24]}
N 7450 -6620 7450 -6420 {
lab=row_n[24]}
N 7440 -6630 7450 -6620 {
lab=row_n[24]}
N 7440 -6410 7440 -6390 {
lab=row_n[24]}
N 7440 -6650 7440 -6630 {
lab=row_n[24]}
N 7320 -6550 7330 -6560 {
lab=col_n[21]}
N 7330 -6560 7530 -6560 {
lab=col_n[21]}
N 7530 -6560 7540 -6550 {
lab=col_n[21]}
N 7320 -6530 7330 -6540 {
lab=colon_n[21]}
N 7330 -6540 7530 -6540 {
lab=colon_n[21]}
N 7530 -6540 7540 -6530 {
lab=colon_n[21]}
N 7320 -6510 7330 -6520 {
lab=#net43}
N 7330 -6520 7530 -6520 {
lab=#net43}
N 7530 -6520 7540 -6510 {
lab=#net43}
N 7320 -6490 7330 -6500 {
lab=#net44}
N 7330 -6500 7530 -6500 {
lab=#net44}
N 7530 -6500 7540 -6490 {
lab=#net44}
N 7380 -6650 7380 -6630 {
lab=vcom}
N 7420 -6650 7420 -6630 {
lab=ctop}
N 7300 -6550 7320 -6550 {
lab=col_n[21]}
N 7300 -6530 7320 -6530 {
lab=colon_n[21]}
N 7300 -6510 7320 -6510 {
lab=#net43}
N 7300 -6490 7320 -6490 {
lab=#net44}
N 7540 -6490 7560 -6490 {
lab=#net44}
N 7540 -6510 7560 -6510 {
lab=#net43}
N 7540 -6530 7560 -6530 {
lab=colon_n[21]}
N 7540 -6550 7560 -6550 {
lab=col_n[21]}
N 7360 -6410 7360 -6400 {
lab=VSS}
N 7360 -6640 7360 -6630 {
lab=VDD}
N 7700 -6410 7710 -6420 {
lab=row_n[25]}
N 7710 -6620 7710 -6420 {
lab=row_n[25]}
N 7700 -6630 7710 -6620 {
lab=row_n[25]}
N 7700 -6410 7700 -6390 {
lab=row_n[25]}
N 7700 -6650 7700 -6630 {
lab=row_n[25]}
N 7580 -6550 7590 -6560 {
lab=col_n[21]}
N 7590 -6560 7790 -6560 {
lab=col_n[21]}
N 7790 -6560 7800 -6550 {
lab=col_n[21]}
N 7580 -6530 7590 -6540 {
lab=colon_n[21]}
N 7590 -6540 7790 -6540 {
lab=colon_n[21]}
N 7790 -6540 7800 -6530 {
lab=colon_n[21]}
N 7580 -6510 7590 -6520 {
lab=#net43}
N 7590 -6520 7790 -6520 {
lab=#net43}
N 7790 -6520 7800 -6510 {
lab=#net43}
N 7580 -6490 7590 -6500 {
lab=#net44}
N 7590 -6500 7790 -6500 {
lab=#net44}
N 7790 -6500 7800 -6490 {
lab=#net44}
N 7640 -6650 7640 -6630 {
lab=vcom}
N 7680 -6650 7680 -6630 {
lab=ctop}
N 7560 -6550 7580 -6550 {
lab=col_n[21]}
N 7560 -6530 7580 -6530 {
lab=colon_n[21]}
N 7560 -6510 7580 -6510 {
lab=#net43}
N 7560 -6490 7580 -6490 {
lab=#net44}
N 7800 -6490 7820 -6490 {
lab=#net44}
N 7800 -6510 7820 -6510 {
lab=#net43}
N 7800 -6530 7820 -6530 {
lab=colon_n[21]}
N 7800 -6550 7820 -6550 {
lab=col_n[21]}
N 7620 -6410 7620 -6400 {
lab=VSS}
N 7620 -6640 7620 -6630 {
lab=VDD}
N 7960 -6410 7970 -6420 {
lab=row_n[26]}
N 7970 -6620 7970 -6420 {
lab=row_n[26]}
N 7960 -6630 7970 -6620 {
lab=row_n[26]}
N 7960 -6410 7960 -6390 {
lab=row_n[26]}
N 7960 -6650 7960 -6630 {
lab=row_n[26]}
N 7840 -6550 7850 -6560 {
lab=col_n[21]}
N 7850 -6560 8050 -6560 {
lab=col_n[21]}
N 8050 -6560 8060 -6550 {
lab=col_n[21]}
N 7840 -6530 7850 -6540 {
lab=colon_n[21]}
N 7850 -6540 8050 -6540 {
lab=colon_n[21]}
N 8050 -6540 8060 -6530 {
lab=colon_n[21]}
N 7840 -6510 7850 -6520 {
lab=#net43}
N 7850 -6520 8050 -6520 {
lab=#net43}
N 8050 -6520 8060 -6510 {
lab=#net43}
N 7840 -6490 7850 -6500 {
lab=#net44}
N 7850 -6500 8050 -6500 {
lab=#net44}
N 8050 -6500 8060 -6490 {
lab=#net44}
N 7900 -6650 7900 -6630 {
lab=vcom}
N 7940 -6650 7940 -6630 {
lab=ctop}
N 7820 -6550 7840 -6550 {
lab=col_n[21]}
N 7820 -6530 7840 -6530 {
lab=colon_n[21]}
N 7820 -6510 7840 -6510 {
lab=#net43}
N 7820 -6490 7840 -6490 {
lab=#net44}
N 8060 -6490 8080 -6490 {
lab=#net44}
N 8060 -6510 8080 -6510 {
lab=#net43}
N 8060 -6530 8080 -6530 {
lab=colon_n[21]}
N 8060 -6550 8080 -6550 {
lab=col_n[21]}
N 7880 -6410 7880 -6400 {
lab=VSS}
N 7880 -6640 7880 -6630 {
lab=VDD}
N 8220 -6410 8230 -6420 {
lab=row_n[27]}
N 8230 -6620 8230 -6420 {
lab=row_n[27]}
N 8220 -6630 8230 -6620 {
lab=row_n[27]}
N 8220 -6410 8220 -6390 {
lab=row_n[27]}
N 8220 -6650 8220 -6630 {
lab=row_n[27]}
N 8100 -6550 8110 -6560 {
lab=col_n[21]}
N 8110 -6560 8310 -6560 {
lab=col_n[21]}
N 8310 -6560 8320 -6550 {
lab=col_n[21]}
N 8100 -6530 8110 -6540 {
lab=colon_n[21]}
N 8110 -6540 8310 -6540 {
lab=colon_n[21]}
N 8310 -6540 8320 -6530 {
lab=colon_n[21]}
N 8100 -6510 8110 -6520 {
lab=#net43}
N 8110 -6520 8310 -6520 {
lab=#net43}
N 8310 -6520 8320 -6510 {
lab=#net43}
N 8100 -6490 8110 -6500 {
lab=#net44}
N 8110 -6500 8310 -6500 {
lab=#net44}
N 8310 -6500 8320 -6490 {
lab=#net44}
N 8160 -6650 8160 -6630 {
lab=vcom}
N 8200 -6650 8200 -6630 {
lab=ctop}
N 8080 -6550 8100 -6550 {
lab=col_n[21]}
N 8080 -6530 8100 -6530 {
lab=colon_n[21]}
N 8080 -6510 8100 -6510 {
lab=#net43}
N 8080 -6490 8100 -6490 {
lab=#net44}
N 8320 -6490 8340 -6490 {
lab=#net44}
N 8320 -6510 8340 -6510 {
lab=#net43}
N 8320 -6530 8340 -6530 {
lab=colon_n[21]}
N 8320 -6550 8340 -6550 {
lab=col_n[21]}
N 8140 -6410 8140 -6400 {
lab=VSS}
N 8140 -6640 8140 -6630 {
lab=VDD}
N 8480 -6410 8490 -6420 {
lab=row_n[28]}
N 8490 -6620 8490 -6420 {
lab=row_n[28]}
N 8480 -6630 8490 -6620 {
lab=row_n[28]}
N 8480 -6410 8480 -6390 {
lab=row_n[28]}
N 8480 -6650 8480 -6630 {
lab=row_n[28]}
N 8360 -6550 8370 -6560 {
lab=col_n[21]}
N 8370 -6560 8570 -6560 {
lab=col_n[21]}
N 8570 -6560 8580 -6550 {
lab=col_n[21]}
N 8360 -6530 8370 -6540 {
lab=colon_n[21]}
N 8370 -6540 8570 -6540 {
lab=colon_n[21]}
N 8570 -6540 8580 -6530 {
lab=colon_n[21]}
N 8360 -6510 8370 -6520 {
lab=#net43}
N 8370 -6520 8570 -6520 {
lab=#net43}
N 8570 -6520 8580 -6510 {
lab=#net43}
N 8360 -6490 8370 -6500 {
lab=#net44}
N 8370 -6500 8570 -6500 {
lab=#net44}
N 8570 -6500 8580 -6490 {
lab=#net44}
N 8420 -6650 8420 -6630 {
lab=vcom}
N 8460 -6650 8460 -6630 {
lab=ctop}
N 8340 -6550 8360 -6550 {
lab=col_n[21]}
N 8340 -6530 8360 -6530 {
lab=colon_n[21]}
N 8340 -6510 8360 -6510 {
lab=#net43}
N 8340 -6490 8360 -6490 {
lab=#net44}
N 8580 -6490 8600 -6490 {
lab=#net44}
N 8580 -6510 8600 -6510 {
lab=#net43}
N 8580 -6530 8600 -6530 {
lab=colon_n[21]}
N 8580 -6550 8600 -6550 {
lab=col_n[21]}
N 8400 -6410 8400 -6400 {
lab=VSS}
N 8400 -6640 8400 -6630 {
lab=VDD}
N 8740 -6410 8750 -6420 {
lab=row_n[29]}
N 8750 -6620 8750 -6420 {
lab=row_n[29]}
N 8740 -6630 8750 -6620 {
lab=row_n[29]}
N 8740 -6410 8740 -6390 {
lab=row_n[29]}
N 8740 -6650 8740 -6630 {
lab=row_n[29]}
N 8620 -6550 8630 -6560 {
lab=col_n[21]}
N 8630 -6560 8830 -6560 {
lab=col_n[21]}
N 8830 -6560 8840 -6550 {
lab=col_n[21]}
N 8620 -6530 8630 -6540 {
lab=colon_n[21]}
N 8630 -6540 8830 -6540 {
lab=colon_n[21]}
N 8830 -6540 8840 -6530 {
lab=colon_n[21]}
N 8620 -6510 8630 -6520 {
lab=#net43}
N 8630 -6520 8830 -6520 {
lab=#net43}
N 8830 -6520 8840 -6510 {
lab=#net43}
N 8620 -6490 8630 -6500 {
lab=#net44}
N 8630 -6500 8830 -6500 {
lab=#net44}
N 8830 -6500 8840 -6490 {
lab=#net44}
N 8680 -6650 8680 -6630 {
lab=vcom}
N 8720 -6650 8720 -6630 {
lab=ctop}
N 8600 -6550 8620 -6550 {
lab=col_n[21]}
N 8600 -6530 8620 -6530 {
lab=colon_n[21]}
N 8600 -6510 8620 -6510 {
lab=#net43}
N 8600 -6490 8620 -6490 {
lab=#net44}
N 8840 -6490 8860 -6490 {
lab=#net44}
N 8840 -6510 8860 -6510 {
lab=#net43}
N 8840 -6530 8860 -6530 {
lab=colon_n[21]}
N 8840 -6550 8860 -6550 {
lab=col_n[21]}
N 8660 -6410 8660 -6400 {
lab=VSS}
N 8660 -6640 8660 -6630 {
lab=VDD}
N 9000 -6410 9010 -6420 {
lab=row_n[30]}
N 9010 -6620 9010 -6420 {
lab=row_n[30]}
