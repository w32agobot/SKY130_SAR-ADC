v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
T {   Copyright 2022 Manuel Moser

   Licensed under the Apache License, Version 2.0 (the "License");
   you may not use this file except in compliance with the License.
   You may obtain a copy of the License at

       http://www.apache.org/licenses/LICENSE-2.0

   Unless required by applicable law or agreed to in writing, software
   distributed under the License is distributed on an "AS IS" BASIS,
   WITHOUT WARRANTIES OR CONDITIONS OF ANY KIND, either express or implied.
   See the License for the specific language governing permissions and
   limitations under the License.} 0 -240 0 0 0.2 0.2 {}
N 1200 -950 1210 -960 {
lab=row_n[0]}
N 1210 -1160 1210 -960 {
lab=row_n[0]}
N 1200 -1170 1210 -1160 {
lab=row_n[0]}
N 1200 -950 1200 -930 {
lab=row_n[0]}
N 1200 -1190 1200 -1170 {
lab=row_n[0]}
N 1080 -1090 1090 -1100 {
lab=col_n[0]}
N 1090 -1100 1290 -1100 {
lab=col_n[0]}
N 1290 -1100 1300 -1090 {
lab=col_n[0]}
N 1080 -1070 1090 -1080 {
lab=colon_n[0]}
N 1090 -1080 1290 -1080 {
lab=colon_n[0]}
N 1290 -1080 1300 -1070 {
lab=colon_n[0]}
N 1080 -1050 1090 -1060 {
lab=#net1}
N 1090 -1060 1290 -1060 {
lab=#net1}
N 1290 -1060 1300 -1050 {
lab=#net1}
N 1080 -1030 1090 -1040 {
lab=#net2}
N 1090 -1040 1290 -1040 {
lab=#net2}
N 1290 -1040 1300 -1030 {
lab=#net2}
N 1140 -1190 1140 -1170 {
lab=vcom}
N 1180 -1190 1180 -1170 {
lab=ctop}
N 1060 -1090 1080 -1090 {
lab=col_n[0]}
N 1060 -1070 1080 -1070 {
lab=colon_n[0]}
N 1060 -1050 1080 -1050 {
lab=#net1}
N 1060 -1030 1080 -1030 {
lab=#net2}
N 1300 -1030 1320 -1030 {
lab=#net2}
N 1300 -1050 1320 -1050 {
lab=#net1}
N 1300 -1070 1320 -1070 {
lab=colon_n[0]}
N 1300 -1090 1320 -1090 {
lab=col_n[0]}
N 1120 -950 1120 -940 {
lab=VSS}
N 1120 -1180 1120 -1170 {
lab=VDD}
N 1460 -950 1470 -960 {
lab=row_n[1]}
N 1470 -1160 1470 -960 {
lab=row_n[1]}
N 1460 -1170 1470 -1160 {
lab=row_n[1]}
N 1460 -950 1460 -930 {
lab=row_n[1]}
N 1460 -1190 1460 -1170 {
lab=row_n[1]}
N 1340 -1090 1350 -1100 {
lab=col_n[0]}
N 1350 -1100 1550 -1100 {
lab=col_n[0]}
N 1550 -1100 1560 -1090 {
lab=col_n[0]}
N 1340 -1070 1350 -1080 {
lab=colon_n[0]}
N 1350 -1080 1550 -1080 {
lab=colon_n[0]}
N 1550 -1080 1560 -1070 {
lab=colon_n[0]}
N 1340 -1050 1350 -1060 {
lab=#net1}
N 1350 -1060 1550 -1060 {
lab=#net1}
N 1550 -1060 1560 -1050 {
lab=#net1}
N 1340 -1030 1350 -1040 {
lab=#net2}
N 1350 -1040 1550 -1040 {
lab=#net2}
N 1550 -1040 1560 -1030 {
lab=#net2}
N 1400 -1190 1400 -1170 {
lab=vcom}
N 1440 -1190 1440 -1170 {
lab=ctop}
N 1320 -1090 1340 -1090 {
lab=col_n[0]}
N 1320 -1070 1340 -1070 {
lab=colon_n[0]}
N 1320 -1050 1340 -1050 {
lab=#net1}
N 1320 -1030 1340 -1030 {
lab=#net2}
N 1560 -1030 1580 -1030 {
lab=#net2}
N 1560 -1050 1580 -1050 {
lab=#net1}
N 1560 -1070 1580 -1070 {
lab=colon_n[0]}
N 1560 -1090 1580 -1090 {
lab=col_n[0]}
N 1380 -950 1380 -940 {
lab=VSS}
N 1380 -1180 1380 -1170 {
lab=VDD}
N 1720 -950 1730 -960 {
lab=row_n[2]}
N 1730 -1160 1730 -960 {
lab=row_n[2]}
N 1720 -1170 1730 -1160 {
lab=row_n[2]}
N 1720 -950 1720 -930 {
lab=row_n[2]}
N 1720 -1190 1720 -1170 {
lab=row_n[2]}
N 1600 -1090 1610 -1100 {
lab=col_n[0]}
N 1610 -1100 1810 -1100 {
lab=col_n[0]}
N 1810 -1100 1820 -1090 {
lab=col_n[0]}
N 1600 -1070 1610 -1080 {
lab=colon_n[0]}
N 1610 -1080 1810 -1080 {
lab=colon_n[0]}
N 1810 -1080 1820 -1070 {
lab=colon_n[0]}
N 1600 -1050 1610 -1060 {
lab=#net1}
N 1610 -1060 1810 -1060 {
lab=#net1}
N 1810 -1060 1820 -1050 {
lab=#net1}
N 1600 -1030 1610 -1040 {
lab=#net2}
N 1610 -1040 1810 -1040 {
lab=#net2}
N 1810 -1040 1820 -1030 {
lab=#net2}
N 1660 -1190 1660 -1170 {
lab=vcom}
N 1700 -1190 1700 -1170 {
lab=ctop}
N 1580 -1090 1600 -1090 {
lab=col_n[0]}
N 1580 -1070 1600 -1070 {
lab=colon_n[0]}
N 1580 -1050 1600 -1050 {
lab=#net1}
N 1580 -1030 1600 -1030 {
lab=#net2}
N 1820 -1030 1840 -1030 {
lab=#net2}
N 1820 -1050 1840 -1050 {
lab=#net1}
N 1820 -1070 1840 -1070 {
lab=colon_n[0]}
N 1820 -1090 1840 -1090 {
lab=col_n[0]}
N 1640 -950 1640 -940 {
lab=VSS}
N 1640 -1180 1640 -1170 {
lab=VDD}
N 1980 -950 1990 -960 {
lab=row_n[3]}
N 1990 -1160 1990 -960 {
lab=row_n[3]}
N 1980 -1170 1990 -1160 {
lab=row_n[3]}
N 1980 -950 1980 -930 {
lab=row_n[3]}
N 1980 -1190 1980 -1170 {
lab=row_n[3]}
N 1860 -1090 1870 -1100 {
lab=col_n[0]}
N 1870 -1100 2070 -1100 {
lab=col_n[0]}
N 2070 -1100 2080 -1090 {
lab=col_n[0]}
N 1860 -1070 1870 -1080 {
lab=colon_n[0]}
N 1870 -1080 2070 -1080 {
lab=colon_n[0]}
N 2070 -1080 2080 -1070 {
lab=colon_n[0]}
N 1860 -1050 1870 -1060 {
lab=#net1}
N 1870 -1060 2070 -1060 {
lab=#net1}
N 2070 -1060 2080 -1050 {
lab=#net1}
N 1860 -1030 1870 -1040 {
lab=#net2}
N 1870 -1040 2070 -1040 {
lab=#net2}
N 2070 -1040 2080 -1030 {
lab=#net2}
N 1920 -1190 1920 -1170 {
lab=vcom}
N 1960 -1190 1960 -1170 {
lab=ctop}
N 1840 -1090 1860 -1090 {
lab=col_n[0]}
N 1840 -1070 1860 -1070 {
lab=colon_n[0]}
N 1840 -1050 1860 -1050 {
lab=#net1}
N 1840 -1030 1860 -1030 {
lab=#net2}
N 2080 -1030 2100 -1030 {
lab=#net2}
N 2080 -1050 2100 -1050 {
lab=#net1}
N 2080 -1070 2100 -1070 {
lab=colon_n[0]}
N 2080 -1090 2100 -1090 {
lab=col_n[0]}
N 1900 -950 1900 -940 {
lab=VSS}
N 1900 -1180 1900 -1170 {
lab=VDD}
N 2240 -950 2250 -960 {
lab=row_n[4]}
N 2250 -1160 2250 -960 {
lab=row_n[4]}
N 2240 -1170 2250 -1160 {
lab=row_n[4]}
N 2240 -950 2240 -930 {
lab=row_n[4]}
N 2240 -1190 2240 -1170 {
lab=row_n[4]}
N 2120 -1090 2130 -1100 {
lab=col_n[0]}
N 2130 -1100 2330 -1100 {
lab=col_n[0]}
N 2330 -1100 2340 -1090 {
lab=col_n[0]}
N 2120 -1070 2130 -1080 {
lab=colon_n[0]}
N 2130 -1080 2330 -1080 {
lab=colon_n[0]}
N 2330 -1080 2340 -1070 {
lab=colon_n[0]}
N 2120 -1050 2130 -1060 {
lab=#net1}
N 2130 -1060 2330 -1060 {
lab=#net1}
N 2330 -1060 2340 -1050 {
lab=#net1}
N 2120 -1030 2130 -1040 {
lab=#net2}
N 2130 -1040 2330 -1040 {
lab=#net2}
N 2330 -1040 2340 -1030 {
lab=#net2}
N 2180 -1190 2180 -1170 {
lab=vcom}
N 2220 -1190 2220 -1170 {
lab=ctop}
N 2100 -1090 2120 -1090 {
lab=col_n[0]}
N 2100 -1070 2120 -1070 {
lab=colon_n[0]}
N 2100 -1050 2120 -1050 {
lab=#net1}
N 2100 -1030 2120 -1030 {
lab=#net2}
N 2340 -1030 2360 -1030 {
lab=#net2}
N 2340 -1050 2360 -1050 {
lab=#net1}
N 2340 -1070 2360 -1070 {
lab=colon_n[0]}
N 2340 -1090 2360 -1090 {
lab=col_n[0]}
N 2160 -950 2160 -940 {
lab=VSS}
N 2160 -1180 2160 -1170 {
lab=VDD}
N 2500 -950 2510 -960 {
lab=row_n[5]}
N 2510 -1160 2510 -960 {
lab=row_n[5]}
N 2500 -1170 2510 -1160 {
lab=row_n[5]}
N 2500 -950 2500 -930 {
lab=row_n[5]}
N 2500 -1190 2500 -1170 {
lab=row_n[5]}
N 2380 -1090 2390 -1100 {
lab=col_n[0]}
N 2390 -1100 2590 -1100 {
lab=col_n[0]}
N 2590 -1100 2600 -1090 {
lab=col_n[0]}
N 2380 -1070 2390 -1080 {
lab=colon_n[0]}
N 2390 -1080 2590 -1080 {
lab=colon_n[0]}
N 2590 -1080 2600 -1070 {
lab=colon_n[0]}
N 2380 -1050 2390 -1060 {
lab=#net1}
N 2390 -1060 2590 -1060 {
lab=#net1}
N 2590 -1060 2600 -1050 {
lab=#net1}
N 2380 -1030 2390 -1040 {
lab=#net2}
N 2390 -1040 2590 -1040 {
lab=#net2}
N 2590 -1040 2600 -1030 {
lab=#net2}
N 2440 -1190 2440 -1170 {
lab=vcom}
N 2480 -1190 2480 -1170 {
lab=ctop}
N 2360 -1090 2380 -1090 {
lab=col_n[0]}
N 2360 -1070 2380 -1070 {
lab=colon_n[0]}
N 2360 -1050 2380 -1050 {
lab=#net1}
N 2360 -1030 2380 -1030 {
lab=#net2}
N 2600 -1030 2620 -1030 {
lab=#net2}
N 2600 -1050 2620 -1050 {
lab=#net1}
N 2600 -1070 2620 -1070 {
lab=colon_n[0]}
N 2600 -1090 2620 -1090 {
lab=col_n[0]}
N 2420 -950 2420 -940 {
lab=VSS}
N 2420 -1180 2420 -1170 {
lab=VDD}
N 2760 -950 2770 -960 {
lab=row_n[6]}
N 2770 -1160 2770 -960 {
lab=row_n[6]}
N 2760 -1170 2770 -1160 {
lab=row_n[6]}
N 2760 -950 2760 -930 {
lab=row_n[6]}
N 2760 -1190 2760 -1170 {
lab=row_n[6]}
N 2640 -1090 2650 -1100 {
lab=col_n[0]}
N 2650 -1100 2850 -1100 {
lab=col_n[0]}
N 2850 -1100 2860 -1090 {
lab=col_n[0]}
N 2640 -1070 2650 -1080 {
lab=colon_n[0]}
N 2650 -1080 2850 -1080 {
lab=colon_n[0]}
N 2850 -1080 2860 -1070 {
lab=colon_n[0]}
N 2640 -1050 2650 -1060 {
lab=#net1}
N 2650 -1060 2850 -1060 {
lab=#net1}
N 2850 -1060 2860 -1050 {
lab=#net1}
N 2640 -1030 2650 -1040 {
lab=#net2}
N 2650 -1040 2850 -1040 {
lab=#net2}
N 2850 -1040 2860 -1030 {
lab=#net2}
N 2700 -1190 2700 -1170 {
lab=vcom}
N 2740 -1190 2740 -1170 {
lab=ctop}
N 2620 -1090 2640 -1090 {
lab=col_n[0]}
N 2620 -1070 2640 -1070 {
lab=colon_n[0]}
N 2620 -1050 2640 -1050 {
lab=#net1}
N 2620 -1030 2640 -1030 {
lab=#net2}
N 2860 -1030 2880 -1030 {
lab=#net2}
N 2860 -1050 2880 -1050 {
lab=#net1}
N 2860 -1070 2880 -1070 {
lab=colon_n[0]}
N 2860 -1090 2880 -1090 {
lab=col_n[0]}
N 2680 -950 2680 -940 {
lab=VSS}
N 2680 -1180 2680 -1170 {
lab=VDD}
N 3020 -950 3030 -960 {
lab=row_n[7]}
N 3030 -1160 3030 -960 {
lab=row_n[7]}
N 3020 -1170 3030 -1160 {
lab=row_n[7]}
N 3020 -950 3020 -930 {
lab=row_n[7]}
N 3020 -1190 3020 -1170 {
lab=row_n[7]}
N 2900 -1090 2910 -1100 {
lab=col_n[0]}
N 2910 -1100 3110 -1100 {
lab=col_n[0]}
N 3110 -1100 3120 -1090 {
lab=col_n[0]}
N 2900 -1070 2910 -1080 {
lab=colon_n[0]}
N 2910 -1080 3110 -1080 {
lab=colon_n[0]}
N 3110 -1080 3120 -1070 {
lab=colon_n[0]}
N 2900 -1050 2910 -1060 {
lab=#net1}
N 2910 -1060 3110 -1060 {
lab=#net1}
N 3110 -1060 3120 -1050 {
lab=#net1}
N 2900 -1030 2910 -1040 {
lab=#net2}
N 2910 -1040 3110 -1040 {
lab=#net2}
N 3110 -1040 3120 -1030 {
lab=#net2}
N 2960 -1190 2960 -1170 {
lab=vcom}
N 3000 -1190 3000 -1170 {
lab=ctop}
N 2880 -1090 2900 -1090 {
lab=col_n[0]}
N 2880 -1070 2900 -1070 {
lab=colon_n[0]}
N 2880 -1050 2900 -1050 {
lab=#net1}
N 2880 -1030 2900 -1030 {
lab=#net2}
N 3120 -1030 3140 -1030 {
lab=#net2}
N 3120 -1050 3140 -1050 {
lab=#net1}
N 3120 -1070 3140 -1070 {
lab=colon_n[0]}
N 3120 -1090 3140 -1090 {
lab=col_n[0]}
N 2940 -950 2940 -940 {
lab=VSS}
N 2940 -1180 2940 -1170 {
lab=VDD}
N 3280 -950 3290 -960 {
lab=row_n[8]}
N 3290 -1160 3290 -960 {
lab=row_n[8]}
N 3280 -1170 3290 -1160 {
lab=row_n[8]}
N 3280 -950 3280 -930 {
lab=row_n[8]}
N 3280 -1190 3280 -1170 {
lab=row_n[8]}
N 3160 -1090 3170 -1100 {
lab=col_n[0]}
N 3170 -1100 3370 -1100 {
lab=col_n[0]}
N 3370 -1100 3380 -1090 {
lab=col_n[0]}
N 3160 -1070 3170 -1080 {
lab=colon_n[0]}
N 3170 -1080 3370 -1080 {
lab=colon_n[0]}
N 3370 -1080 3380 -1070 {
lab=colon_n[0]}
N 3160 -1050 3170 -1060 {
lab=#net1}
N 3170 -1060 3370 -1060 {
lab=#net1}
N 3370 -1060 3380 -1050 {
lab=#net1}
N 3160 -1030 3170 -1040 {
lab=#net2}
N 3170 -1040 3370 -1040 {
lab=#net2}
N 3370 -1040 3380 -1030 {
lab=#net2}
N 3220 -1190 3220 -1170 {
lab=vcom}
N 3260 -1190 3260 -1170 {
lab=ctop}
N 3140 -1090 3160 -1090 {
lab=col_n[0]}
N 3140 -1070 3160 -1070 {
lab=colon_n[0]}
N 3140 -1050 3160 -1050 {
lab=#net1}
N 3140 -1030 3160 -1030 {
lab=#net2}
N 3380 -1030 3400 -1030 {
lab=#net2}
N 3380 -1050 3400 -1050 {
lab=#net1}
N 3380 -1070 3400 -1070 {
lab=colon_n[0]}
N 3380 -1090 3400 -1090 {
lab=col_n[0]}
N 3200 -950 3200 -940 {
lab=VSS}
N 3200 -1180 3200 -1170 {
lab=VDD}
N 3540 -950 3550 -960 {
lab=row_n[9]}
N 3550 -1160 3550 -960 {
lab=row_n[9]}
N 3540 -1170 3550 -1160 {
lab=row_n[9]}
N 3540 -950 3540 -930 {
lab=row_n[9]}
N 3540 -1190 3540 -1170 {
lab=row_n[9]}
N 3420 -1090 3430 -1100 {
lab=col_n[0]}
N 3430 -1100 3630 -1100 {
lab=col_n[0]}
N 3630 -1100 3640 -1090 {
lab=col_n[0]}
N 3420 -1070 3430 -1080 {
lab=colon_n[0]}
N 3430 -1080 3630 -1080 {
lab=colon_n[0]}
N 3630 -1080 3640 -1070 {
lab=colon_n[0]}
N 3420 -1050 3430 -1060 {
lab=#net1}
N 3430 -1060 3630 -1060 {
lab=#net1}
N 3630 -1060 3640 -1050 {
lab=#net1}
N 3420 -1030 3430 -1040 {
lab=#net2}
N 3430 -1040 3630 -1040 {
lab=#net2}
N 3630 -1040 3640 -1030 {
lab=#net2}
N 3480 -1190 3480 -1170 {
lab=vcom}
N 3520 -1190 3520 -1170 {
lab=ctop}
N 3400 -1090 3420 -1090 {
lab=col_n[0]}
N 3400 -1070 3420 -1070 {
lab=colon_n[0]}
N 3400 -1050 3420 -1050 {
lab=#net1}
N 3400 -1030 3420 -1030 {
lab=#net2}
N 3640 -1030 3660 -1030 {
lab=#net2}
N 3640 -1050 3660 -1050 {
lab=#net1}
N 3640 -1070 3660 -1070 {
lab=colon_n[0]}
N 3640 -1090 3660 -1090 {
lab=col_n[0]}
N 3460 -950 3460 -940 {
lab=VSS}
N 3460 -1180 3460 -1170 {
lab=VDD}
N 3800 -950 3810 -960 {
lab=row_n[10]}
N 3810 -1160 3810 -960 {
lab=row_n[10]}
N 3800 -1170 3810 -1160 {
lab=row_n[10]}
N 3800 -950 3800 -930 {
lab=row_n[10]}
N 3800 -1190 3800 -1170 {
lab=row_n[10]}
N 3680 -1090 3690 -1100 {
lab=col_n[0]}
N 3690 -1100 3890 -1100 {
lab=col_n[0]}
N 3890 -1100 3900 -1090 {
lab=col_n[0]}
N 3680 -1070 3690 -1080 {
lab=colon_n[0]}
N 3690 -1080 3890 -1080 {
lab=colon_n[0]}
N 3890 -1080 3900 -1070 {
lab=colon_n[0]}
N 3680 -1050 3690 -1060 {
lab=#net1}
N 3690 -1060 3890 -1060 {
lab=#net1}
N 3890 -1060 3900 -1050 {
lab=#net1}
N 3680 -1030 3690 -1040 {
lab=#net2}
N 3690 -1040 3890 -1040 {
lab=#net2}
N 3890 -1040 3900 -1030 {
lab=#net2}
N 3740 -1190 3740 -1170 {
lab=vcom}
N 3780 -1190 3780 -1170 {
lab=ctop}
N 3660 -1090 3680 -1090 {
lab=col_n[0]}
N 3660 -1070 3680 -1070 {
lab=colon_n[0]}
N 3660 -1050 3680 -1050 {
lab=#net1}
N 3660 -1030 3680 -1030 {
lab=#net2}
N 3900 -1030 3920 -1030 {
lab=#net2}
N 3900 -1050 3920 -1050 {
lab=#net1}
N 3900 -1070 3920 -1070 {
lab=colon_n[0]}
N 3900 -1090 3920 -1090 {
lab=col_n[0]}
N 3720 -950 3720 -940 {
lab=VSS}
N 3720 -1180 3720 -1170 {
lab=VDD}
N 4060 -950 4070 -960 {
lab=row_n[11]}
N 4070 -1160 4070 -960 {
lab=row_n[11]}
N 4060 -1170 4070 -1160 {
lab=row_n[11]}
N 4060 -950 4060 -930 {
lab=row_n[11]}
N 4060 -1190 4060 -1170 {
lab=row_n[11]}
N 3940 -1090 3950 -1100 {
lab=col_n[0]}
N 3950 -1100 4150 -1100 {
lab=col_n[0]}
N 4150 -1100 4160 -1090 {
lab=col_n[0]}
N 3940 -1070 3950 -1080 {
lab=colon_n[0]}
N 3950 -1080 4150 -1080 {
lab=colon_n[0]}
N 4150 -1080 4160 -1070 {
lab=colon_n[0]}
N 3940 -1050 3950 -1060 {
lab=#net1}
N 3950 -1060 4150 -1060 {
lab=#net1}
N 4150 -1060 4160 -1050 {
lab=#net1}
N 3940 -1030 3950 -1040 {
lab=#net2}
N 3950 -1040 4150 -1040 {
lab=#net2}
N 4150 -1040 4160 -1030 {
lab=#net2}
N 4000 -1190 4000 -1170 {
lab=vcom}
N 4040 -1190 4040 -1170 {
lab=ctop}
N 3920 -1090 3940 -1090 {
lab=col_n[0]}
N 3920 -1070 3940 -1070 {
lab=colon_n[0]}
N 3920 -1050 3940 -1050 {
lab=#net1}
N 3920 -1030 3940 -1030 {
lab=#net2}
N 4160 -1030 4180 -1030 {
lab=#net2}
N 4160 -1050 4180 -1050 {
lab=#net1}
N 4160 -1070 4180 -1070 {
lab=colon_n[0]}
N 4160 -1090 4180 -1090 {
lab=col_n[0]}
N 3980 -950 3980 -940 {
lab=VSS}
N 3980 -1180 3980 -1170 {
lab=VDD}
N 4320 -950 4330 -960 {
lab=row_n[12]}
N 4330 -1160 4330 -960 {
lab=row_n[12]}
N 4320 -1170 4330 -1160 {
lab=row_n[12]}
N 4320 -950 4320 -930 {
lab=row_n[12]}
N 4320 -1190 4320 -1170 {
lab=row_n[12]}
N 4200 -1090 4210 -1100 {
lab=col_n[0]}
N 4210 -1100 4410 -1100 {
lab=col_n[0]}
N 4410 -1100 4420 -1090 {
lab=col_n[0]}
N 4200 -1070 4210 -1080 {
lab=colon_n[0]}
N 4210 -1080 4410 -1080 {
lab=colon_n[0]}
N 4410 -1080 4420 -1070 {
lab=colon_n[0]}
N 4200 -1050 4210 -1060 {
lab=#net1}
N 4210 -1060 4410 -1060 {
lab=#net1}
N 4410 -1060 4420 -1050 {
lab=#net1}
N 4200 -1030 4210 -1040 {
lab=#net2}
N 4210 -1040 4410 -1040 {
lab=#net2}
N 4410 -1040 4420 -1030 {
lab=#net2}
N 4260 -1190 4260 -1170 {
lab=vcom}
N 4300 -1190 4300 -1170 {
lab=ctop}
N 4180 -1090 4200 -1090 {
lab=col_n[0]}
N 4180 -1070 4200 -1070 {
lab=colon_n[0]}
N 4180 -1050 4200 -1050 {
lab=#net1}
N 4180 -1030 4200 -1030 {
lab=#net2}
N 4420 -1030 4440 -1030 {
lab=#net2}
N 4420 -1050 4440 -1050 {
lab=#net1}
N 4420 -1070 4440 -1070 {
lab=colon_n[0]}
N 4420 -1090 4440 -1090 {
lab=col_n[0]}
N 4240 -950 4240 -940 {
lab=VSS}
N 4240 -1180 4240 -1170 {
lab=VDD}
N 4580 -950 4590 -960 {
lab=row_n[13]}
N 4590 -1160 4590 -960 {
lab=row_n[13]}
N 4580 -1170 4590 -1160 {
lab=row_n[13]}
N 4580 -950 4580 -930 {
lab=row_n[13]}
N 4580 -1190 4580 -1170 {
lab=row_n[13]}
N 4460 -1090 4470 -1100 {
lab=col_n[0]}
N 4470 -1100 4670 -1100 {
lab=col_n[0]}
N 4670 -1100 4680 -1090 {
lab=col_n[0]}
N 4460 -1070 4470 -1080 {
lab=colon_n[0]}
N 4470 -1080 4670 -1080 {
lab=colon_n[0]}
N 4670 -1080 4680 -1070 {
lab=colon_n[0]}
N 4460 -1050 4470 -1060 {
lab=#net1}
N 4470 -1060 4670 -1060 {
lab=#net1}
N 4670 -1060 4680 -1050 {
lab=#net1}
N 4460 -1030 4470 -1040 {
lab=#net2}
N 4470 -1040 4670 -1040 {
lab=#net2}
N 4670 -1040 4680 -1030 {
lab=#net2}
N 4520 -1190 4520 -1170 {
lab=vcom}
N 4560 -1190 4560 -1170 {
lab=ctop}
N 4440 -1090 4460 -1090 {
lab=col_n[0]}
N 4440 -1070 4460 -1070 {
lab=colon_n[0]}
N 4440 -1050 4460 -1050 {
lab=#net1}
N 4440 -1030 4460 -1030 {
lab=#net2}
N 4680 -1030 4700 -1030 {
lab=#net2}
N 4680 -1050 4700 -1050 {
lab=#net1}
N 4680 -1070 4700 -1070 {
lab=colon_n[0]}
N 4680 -1090 4700 -1090 {
lab=col_n[0]}
N 4500 -950 4500 -940 {
lab=VSS}
N 4500 -1180 4500 -1170 {
lab=VDD}
N 4840 -950 4850 -960 {
lab=row_n[14]}
N 4850 -1160 4850 -960 {
lab=row_n[14]}
N 4840 -1170 4850 -1160 {
lab=row_n[14]}
N 4840 -950 4840 -930 {
lab=row_n[14]}
N 4840 -1190 4840 -1170 {
lab=row_n[14]}
N 4720 -1090 4730 -1100 {
lab=col_n[0]}
N 4730 -1100 4930 -1100 {
lab=col_n[0]}
N 4930 -1100 4940 -1090 {
lab=col_n[0]}
N 4720 -1070 4730 -1080 {
lab=colon_n[0]}
N 4730 -1080 4930 -1080 {
lab=colon_n[0]}
N 4930 -1080 4940 -1070 {
lab=colon_n[0]}
N 4720 -1050 4730 -1060 {
lab=#net1}
N 4730 -1060 4930 -1060 {
lab=#net1}
N 4930 -1060 4940 -1050 {
lab=#net1}
N 4720 -1030 4730 -1040 {
lab=#net2}
N 4730 -1040 4930 -1040 {
lab=#net2}
N 4930 -1040 4940 -1030 {
lab=#net2}
N 4780 -1190 4780 -1170 {
lab=vcom}
N 4820 -1190 4820 -1170 {
lab=ctop}
N 4700 -1090 4720 -1090 {
lab=col_n[0]}
N 4700 -1070 4720 -1070 {
lab=colon_n[0]}
N 4700 -1050 4720 -1050 {
lab=#net1}
N 4700 -1030 4720 -1030 {
lab=#net2}
N 4940 -1030 4960 -1030 {
lab=#net2}
N 4940 -1050 4960 -1050 {
lab=#net1}
N 4940 -1070 4960 -1070 {
lab=colon_n[0]}
N 4940 -1090 4960 -1090 {
lab=col_n[0]}
N 4760 -950 4760 -940 {
lab=VSS}
N 4760 -1180 4760 -1170 {
lab=VDD}
N 5100 -950 5110 -960 {
lab=row_n[15]}
N 5110 -1160 5110 -960 {
lab=row_n[15]}
N 5100 -1170 5110 -1160 {
lab=row_n[15]}
N 5100 -950 5100 -930 {
lab=row_n[15]}
N 5100 -1190 5100 -1170 {
lab=row_n[15]}
N 4980 -1090 4990 -1100 {
lab=col_n[0]}
N 4990 -1100 5190 -1100 {
lab=col_n[0]}
N 5190 -1100 5200 -1090 {
lab=col_n[0]}
N 4980 -1070 4990 -1080 {
lab=colon_n[0]}
N 4990 -1080 5190 -1080 {
lab=colon_n[0]}
N 5190 -1080 5200 -1070 {
lab=colon_n[0]}
N 4980 -1050 4990 -1060 {
lab=#net1}
N 4990 -1060 5190 -1060 {
lab=#net1}
N 5190 -1060 5200 -1050 {
lab=#net1}
N 4980 -1030 4990 -1040 {
lab=#net2}
N 4990 -1040 5190 -1040 {
lab=#net2}
N 5190 -1040 5200 -1030 {
lab=#net2}
N 5040 -1190 5040 -1170 {
lab=vcom}
N 5080 -1190 5080 -1170 {
lab=ctop}
N 4960 -1090 4980 -1090 {
lab=col_n[0]}
N 4960 -1070 4980 -1070 {
lab=colon_n[0]}
N 4960 -1050 4980 -1050 {
lab=#net1}
N 4960 -1030 4980 -1030 {
lab=#net2}
N 5200 -1030 5220 -1030 {
lab=#net2}
N 5200 -1050 5220 -1050 {
lab=#net1}
N 5200 -1070 5220 -1070 {
lab=colon_n[0]}
N 5200 -1090 5220 -1090 {
lab=col_n[0]}
N 5020 -950 5020 -940 {
lab=VSS}
N 5020 -1180 5020 -1170 {
lab=VDD}
N 5360 -950 5370 -960 {
lab=row_n[16]}
N 5370 -1160 5370 -960 {
lab=row_n[16]}
N 5360 -1170 5370 -1160 {
lab=row_n[16]}
N 5360 -950 5360 -930 {
lab=row_n[16]}
N 5360 -1190 5360 -1170 {
lab=row_n[16]}
N 5240 -1090 5250 -1100 {
lab=col_n[0]}
N 5250 -1100 5450 -1100 {
lab=col_n[0]}
N 5450 -1100 5460 -1090 {
lab=col_n[0]}
N 5240 -1070 5250 -1080 {
lab=colon_n[0]}
N 5250 -1080 5450 -1080 {
lab=colon_n[0]}
N 5450 -1080 5460 -1070 {
lab=colon_n[0]}
N 5240 -1050 5250 -1060 {
lab=#net1}
N 5250 -1060 5450 -1060 {
lab=#net1}
N 5450 -1060 5460 -1050 {
lab=#net1}
N 5240 -1030 5250 -1040 {
lab=#net2}
N 5250 -1040 5450 -1040 {
lab=#net2}
N 5450 -1040 5460 -1030 {
lab=#net2}
N 5300 -1190 5300 -1170 {
lab=vcom}
N 5340 -1190 5340 -1170 {
lab=ctop}
N 5220 -1090 5240 -1090 {
lab=col_n[0]}
N 5220 -1070 5240 -1070 {
lab=colon_n[0]}
N 5220 -1050 5240 -1050 {
lab=#net1}
N 5220 -1030 5240 -1030 {
lab=#net2}
N 5460 -1030 5480 -1030 {
lab=#net2}
N 5460 -1050 5480 -1050 {
lab=#net1}
N 5460 -1070 5480 -1070 {
lab=colon_n[0]}
N 5460 -1090 5480 -1090 {
lab=col_n[0]}
N 5280 -950 5280 -940 {
lab=VSS}
N 5280 -1180 5280 -1170 {
lab=VDD}
N 5620 -950 5630 -960 {
lab=row_n[17]}
N 5630 -1160 5630 -960 {
lab=row_n[17]}
N 5620 -1170 5630 -1160 {
lab=row_n[17]}
N 5620 -950 5620 -930 {
lab=row_n[17]}
N 5620 -1190 5620 -1170 {
lab=row_n[17]}
N 5500 -1090 5510 -1100 {
lab=col_n[0]}
N 5510 -1100 5710 -1100 {
lab=col_n[0]}
N 5710 -1100 5720 -1090 {
lab=col_n[0]}
N 5500 -1070 5510 -1080 {
lab=colon_n[0]}
N 5510 -1080 5710 -1080 {
lab=colon_n[0]}
N 5710 -1080 5720 -1070 {
lab=colon_n[0]}
N 5500 -1050 5510 -1060 {
lab=#net1}
N 5510 -1060 5710 -1060 {
lab=#net1}
N 5710 -1060 5720 -1050 {
lab=#net1}
N 5500 -1030 5510 -1040 {
lab=#net2}
N 5510 -1040 5710 -1040 {
lab=#net2}
N 5710 -1040 5720 -1030 {
lab=#net2}
N 5560 -1190 5560 -1170 {
lab=vcom}
N 5600 -1190 5600 -1170 {
lab=ctop}
N 5480 -1090 5500 -1090 {
lab=col_n[0]}
N 5480 -1070 5500 -1070 {
lab=colon_n[0]}
N 5480 -1050 5500 -1050 {
lab=#net1}
N 5480 -1030 5500 -1030 {
lab=#net2}
N 5720 -1030 5740 -1030 {
lab=#net2}
N 5720 -1050 5740 -1050 {
lab=#net1}
N 5720 -1070 5740 -1070 {
lab=colon_n[0]}
N 5720 -1090 5740 -1090 {
lab=col_n[0]}
N 5540 -950 5540 -940 {
lab=VSS}
N 5540 -1180 5540 -1170 {
lab=VDD}
N 5880 -950 5890 -960 {
lab=row_n[18]}
N 5890 -1160 5890 -960 {
lab=row_n[18]}
N 5880 -1170 5890 -1160 {
lab=row_n[18]}
N 5880 -950 5880 -930 {
lab=row_n[18]}
N 5880 -1190 5880 -1170 {
lab=row_n[18]}
N 5760 -1090 5770 -1100 {
lab=col_n[0]}
N 5770 -1100 5970 -1100 {
lab=col_n[0]}
N 5970 -1100 5980 -1090 {
lab=col_n[0]}
N 5760 -1070 5770 -1080 {
lab=colon_n[0]}
N 5770 -1080 5970 -1080 {
lab=colon_n[0]}
N 5970 -1080 5980 -1070 {
lab=colon_n[0]}
N 5760 -1050 5770 -1060 {
lab=#net1}
N 5770 -1060 5970 -1060 {
lab=#net1}
N 5970 -1060 5980 -1050 {
lab=#net1}
N 5760 -1030 5770 -1040 {
lab=#net2}
N 5770 -1040 5970 -1040 {
lab=#net2}
N 5970 -1040 5980 -1030 {
lab=#net2}
N 5820 -1190 5820 -1170 {
lab=vcom}
N 5860 -1190 5860 -1170 {
lab=ctop}
N 5740 -1090 5760 -1090 {
lab=col_n[0]}
N 5740 -1070 5760 -1070 {
lab=colon_n[0]}
N 5740 -1050 5760 -1050 {
lab=#net1}
N 5740 -1030 5760 -1030 {
lab=#net2}
N 5980 -1030 6000 -1030 {
lab=#net2}
N 5980 -1050 6000 -1050 {
lab=#net1}
N 5980 -1070 6000 -1070 {
lab=colon_n[0]}
N 5980 -1090 6000 -1090 {
lab=col_n[0]}
N 5800 -950 5800 -940 {
lab=VSS}
N 5800 -1180 5800 -1170 {
lab=VDD}
N 6140 -950 6150 -960 {
lab=row_n[19]}
N 6150 -1160 6150 -960 {
lab=row_n[19]}
N 6140 -1170 6150 -1160 {
lab=row_n[19]}
N 6140 -950 6140 -930 {
lab=row_n[19]}
N 6140 -1190 6140 -1170 {
lab=row_n[19]}
N 6020 -1090 6030 -1100 {
lab=col_n[0]}
N 6030 -1100 6230 -1100 {
lab=col_n[0]}
N 6230 -1100 6240 -1090 {
lab=col_n[0]}
N 6020 -1070 6030 -1080 {
lab=colon_n[0]}
N 6030 -1080 6230 -1080 {
lab=colon_n[0]}
N 6230 -1080 6240 -1070 {
lab=colon_n[0]}
N 6020 -1050 6030 -1060 {
lab=#net1}
N 6030 -1060 6230 -1060 {
lab=#net1}
N 6230 -1060 6240 -1050 {
lab=#net1}
N 6020 -1030 6030 -1040 {
lab=#net2}
N 6030 -1040 6230 -1040 {
lab=#net2}
N 6230 -1040 6240 -1030 {
lab=#net2}
N 6080 -1190 6080 -1170 {
lab=vcom}
N 6120 -1190 6120 -1170 {
lab=ctop}
N 6000 -1090 6020 -1090 {
lab=col_n[0]}
N 6000 -1070 6020 -1070 {
lab=colon_n[0]}
N 6000 -1050 6020 -1050 {
lab=#net1}
N 6000 -1030 6020 -1030 {
lab=#net2}
N 6240 -1030 6260 -1030 {
lab=#net2}
N 6240 -1050 6260 -1050 {
lab=#net1}
N 6240 -1070 6260 -1070 {
lab=colon_n[0]}
N 6240 -1090 6260 -1090 {
lab=col_n[0]}
N 6060 -950 6060 -940 {
lab=VSS}
N 6060 -1180 6060 -1170 {
lab=VDD}
N 6400 -950 6410 -960 {
lab=row_n[20]}
N 6410 -1160 6410 -960 {
lab=row_n[20]}
N 6400 -1170 6410 -1160 {
lab=row_n[20]}
N 6400 -950 6400 -930 {
lab=row_n[20]}
N 6400 -1190 6400 -1170 {
lab=row_n[20]}
N 6280 -1090 6290 -1100 {
lab=col_n[0]}
N 6290 -1100 6490 -1100 {
lab=col_n[0]}
N 6490 -1100 6500 -1090 {
lab=col_n[0]}
N 6280 -1070 6290 -1080 {
lab=colon_n[0]}
N 6290 -1080 6490 -1080 {
lab=colon_n[0]}
N 6490 -1080 6500 -1070 {
lab=colon_n[0]}
N 6280 -1050 6290 -1060 {
lab=#net1}
N 6290 -1060 6490 -1060 {
lab=#net1}
N 6490 -1060 6500 -1050 {
lab=#net1}
N 6280 -1030 6290 -1040 {
lab=#net2}
N 6290 -1040 6490 -1040 {
lab=#net2}
N 6490 -1040 6500 -1030 {
lab=#net2}
N 6340 -1190 6340 -1170 {
lab=vcom}
N 6380 -1190 6380 -1170 {
lab=ctop}
N 6260 -1090 6280 -1090 {
lab=col_n[0]}
N 6260 -1070 6280 -1070 {
lab=colon_n[0]}
N 6260 -1050 6280 -1050 {
lab=#net1}
N 6260 -1030 6280 -1030 {
lab=#net2}
N 6500 -1030 6520 -1030 {
lab=#net2}
N 6500 -1050 6520 -1050 {
lab=#net1}
N 6500 -1070 6520 -1070 {
lab=colon_n[0]}
N 6500 -1090 6520 -1090 {
lab=col_n[0]}
N 6320 -950 6320 -940 {
lab=VSS}
N 6320 -1180 6320 -1170 {
lab=VDD}
N 6660 -950 6670 -960 {
lab=row_n[21]}
N 6670 -1160 6670 -960 {
lab=row_n[21]}
N 6660 -1170 6670 -1160 {
lab=row_n[21]}
N 6660 -950 6660 -930 {
lab=row_n[21]}
N 6660 -1190 6660 -1170 {
lab=row_n[21]}
N 6540 -1090 6550 -1100 {
lab=col_n[0]}
N 6550 -1100 6750 -1100 {
lab=col_n[0]}
N 6750 -1100 6760 -1090 {
lab=col_n[0]}
N 6540 -1070 6550 -1080 {
lab=colon_n[0]}
N 6550 -1080 6750 -1080 {
lab=colon_n[0]}
N 6750 -1080 6760 -1070 {
lab=colon_n[0]}
N 6540 -1050 6550 -1060 {
lab=#net1}
N 6550 -1060 6750 -1060 {
lab=#net1}
N 6750 -1060 6760 -1050 {
lab=#net1}
N 6540 -1030 6550 -1040 {
lab=#net2}
N 6550 -1040 6750 -1040 {
lab=#net2}
N 6750 -1040 6760 -1030 {
lab=#net2}
N 6600 -1190 6600 -1170 {
lab=vcom}
N 6640 -1190 6640 -1170 {
lab=ctop}
N 6520 -1090 6540 -1090 {
lab=col_n[0]}
N 6520 -1070 6540 -1070 {
lab=colon_n[0]}
N 6520 -1050 6540 -1050 {
lab=#net1}
N 6520 -1030 6540 -1030 {
lab=#net2}
N 6760 -1030 6780 -1030 {
lab=#net2}
N 6760 -1050 6780 -1050 {
lab=#net1}
N 6760 -1070 6780 -1070 {
lab=colon_n[0]}
N 6760 -1090 6780 -1090 {
lab=col_n[0]}
N 6580 -950 6580 -940 {
lab=VSS}
N 6580 -1180 6580 -1170 {
lab=VDD}
N 6920 -950 6930 -960 {
lab=row_n[22]}
N 6930 -1160 6930 -960 {
lab=row_n[22]}
N 6920 -1170 6930 -1160 {
lab=row_n[22]}
N 6920 -950 6920 -930 {
lab=row_n[22]}
N 6920 -1190 6920 -1170 {
lab=row_n[22]}
N 6800 -1090 6810 -1100 {
lab=col_n[0]}
N 6810 -1100 7010 -1100 {
lab=col_n[0]}
N 7010 -1100 7020 -1090 {
lab=col_n[0]}
N 6800 -1070 6810 -1080 {
lab=colon_n[0]}
N 6810 -1080 7010 -1080 {
lab=colon_n[0]}
N 7010 -1080 7020 -1070 {
lab=colon_n[0]}
N 6800 -1050 6810 -1060 {
lab=#net1}
N 6810 -1060 7010 -1060 {
lab=#net1}
N 7010 -1060 7020 -1050 {
lab=#net1}
N 6800 -1030 6810 -1040 {
lab=#net2}
N 6810 -1040 7010 -1040 {
lab=#net2}
N 7010 -1040 7020 -1030 {
lab=#net2}
N 6860 -1190 6860 -1170 {
lab=vcom}
N 6900 -1190 6900 -1170 {
lab=ctop}
N 6780 -1090 6800 -1090 {
lab=col_n[0]}
N 6780 -1070 6800 -1070 {
lab=colon_n[0]}
N 6780 -1050 6800 -1050 {
lab=#net1}
N 6780 -1030 6800 -1030 {
lab=#net2}
N 7020 -1030 7040 -1030 {
lab=#net2}
N 7020 -1050 7040 -1050 {
lab=#net1}
N 7020 -1070 7040 -1070 {
lab=colon_n[0]}
N 7020 -1090 7040 -1090 {
lab=col_n[0]}
N 6840 -950 6840 -940 {
lab=VSS}
N 6840 -1180 6840 -1170 {
lab=VDD}
N 7180 -950 7190 -960 {
lab=row_n[23]}
N 7190 -1160 7190 -960 {
lab=row_n[23]}
N 7180 -1170 7190 -1160 {
lab=row_n[23]}
N 7180 -950 7180 -930 {
lab=row_n[23]}
N 7180 -1190 7180 -1170 {
lab=row_n[23]}
N 7060 -1090 7070 -1100 {
lab=col_n[0]}
N 7070 -1100 7270 -1100 {
lab=col_n[0]}
N 7270 -1100 7280 -1090 {
lab=col_n[0]}
N 7060 -1070 7070 -1080 {
lab=colon_n[0]}
N 7070 -1080 7270 -1080 {
lab=colon_n[0]}
N 7270 -1080 7280 -1070 {
lab=colon_n[0]}
N 7060 -1050 7070 -1060 {
lab=#net1}
N 7070 -1060 7270 -1060 {
lab=#net1}
N 7270 -1060 7280 -1050 {
lab=#net1}
N 7060 -1030 7070 -1040 {
lab=#net2}
N 7070 -1040 7270 -1040 {
lab=#net2}
N 7270 -1040 7280 -1030 {
lab=#net2}
N 7120 -1190 7120 -1170 {
lab=vcom}
N 7160 -1190 7160 -1170 {
lab=ctop}
N 7040 -1090 7060 -1090 {
lab=col_n[0]}
N 7040 -1070 7060 -1070 {
lab=colon_n[0]}
N 7040 -1050 7060 -1050 {
lab=#net1}
N 7040 -1030 7060 -1030 {
lab=#net2}
N 7280 -1030 7300 -1030 {
lab=#net2}
N 7280 -1050 7300 -1050 {
lab=#net1}
N 7280 -1070 7300 -1070 {
lab=colon_n[0]}
N 7280 -1090 7300 -1090 {
lab=col_n[0]}
N 7100 -950 7100 -940 {
lab=VSS}
N 7100 -1180 7100 -1170 {
lab=VDD}
N 7440 -950 7450 -960 {
lab=row_n[24]}
N 7450 -1160 7450 -960 {
lab=row_n[24]}
N 7440 -1170 7450 -1160 {
lab=row_n[24]}
N 7440 -950 7440 -930 {
lab=row_n[24]}
N 7440 -1190 7440 -1170 {
lab=row_n[24]}
N 7320 -1090 7330 -1100 {
lab=col_n[0]}
N 7330 -1100 7530 -1100 {
lab=col_n[0]}
N 7530 -1100 7540 -1090 {
lab=col_n[0]}
N 7320 -1070 7330 -1080 {
lab=colon_n[0]}
N 7330 -1080 7530 -1080 {
lab=colon_n[0]}
N 7530 -1080 7540 -1070 {
lab=colon_n[0]}
N 7320 -1050 7330 -1060 {
lab=#net1}
N 7330 -1060 7530 -1060 {
lab=#net1}
N 7530 -1060 7540 -1050 {
lab=#net1}
N 7320 -1030 7330 -1040 {
lab=#net2}
N 7330 -1040 7530 -1040 {
lab=#net2}
N 7530 -1040 7540 -1030 {
lab=#net2}
N 7380 -1190 7380 -1170 {
lab=vcom}
N 7420 -1190 7420 -1170 {
lab=ctop}
N 7300 -1090 7320 -1090 {
lab=col_n[0]}
N 7300 -1070 7320 -1070 {
lab=colon_n[0]}
N 7300 -1050 7320 -1050 {
lab=#net1}
N 7300 -1030 7320 -1030 {
lab=#net2}
N 7540 -1030 7560 -1030 {
lab=#net2}
N 7540 -1050 7560 -1050 {
lab=#net1}
N 7540 -1070 7560 -1070 {
lab=colon_n[0]}
N 7540 -1090 7560 -1090 {
lab=col_n[0]}
N 7360 -950 7360 -940 {
lab=VSS}
N 7360 -1180 7360 -1170 {
lab=VDD}
N 7700 -950 7710 -960 {
lab=row_n[25]}
N 7710 -1160 7710 -960 {
lab=row_n[25]}
N 7700 -1170 7710 -1160 {
lab=row_n[25]}
N 7700 -950 7700 -930 {
lab=row_n[25]}
N 7700 -1190 7700 -1170 {
lab=row_n[25]}
N 7580 -1090 7590 -1100 {
lab=col_n[0]}
N 7590 -1100 7790 -1100 {
lab=col_n[0]}
N 7790 -1100 7800 -1090 {
lab=col_n[0]}
N 7580 -1070 7590 -1080 {
lab=colon_n[0]}
N 7590 -1080 7790 -1080 {
lab=colon_n[0]}
N 7790 -1080 7800 -1070 {
lab=colon_n[0]}
N 7580 -1050 7590 -1060 {
lab=#net1}
N 7590 -1060 7790 -1060 {
lab=#net1}
N 7790 -1060 7800 -1050 {
lab=#net1}
N 7580 -1030 7590 -1040 {
lab=#net2}
N 7590 -1040 7790 -1040 {
lab=#net2}
N 7790 -1040 7800 -1030 {
lab=#net2}
N 7640 -1190 7640 -1170 {
lab=vcom}
N 7680 -1190 7680 -1170 {
lab=ctop}
N 7560 -1090 7580 -1090 {
lab=col_n[0]}
N 7560 -1070 7580 -1070 {
lab=colon_n[0]}
N 7560 -1050 7580 -1050 {
lab=#net1}
N 7560 -1030 7580 -1030 {
lab=#net2}
N 7800 -1030 7820 -1030 {
lab=#net2}
N 7800 -1050 7820 -1050 {
lab=#net1}
N 7800 -1070 7820 -1070 {
lab=colon_n[0]}
N 7800 -1090 7820 -1090 {
lab=col_n[0]}
N 7620 -950 7620 -940 {
lab=VSS}
N 7620 -1180 7620 -1170 {
lab=VDD}
N 7960 -950 7970 -960 {
lab=row_n[26]}
N 7970 -1160 7970 -960 {
lab=row_n[26]}
N 7960 -1170 7970 -1160 {
lab=row_n[26]}
N 7960 -950 7960 -930 {
lab=row_n[26]}
N 7960 -1190 7960 -1170 {
lab=row_n[26]}
N 7840 -1090 7850 -1100 {
lab=col_n[0]}
N 7850 -1100 8050 -1100 {
lab=col_n[0]}
N 8050 -1100 8060 -1090 {
lab=col_n[0]}
N 7840 -1070 7850 -1080 {
lab=colon_n[0]}
N 7850 -1080 8050 -1080 {
lab=colon_n[0]}
N 8050 -1080 8060 -1070 {
lab=colon_n[0]}
N 7840 -1050 7850 -1060 {
lab=#net1}
N 7850 -1060 8050 -1060 {
lab=#net1}
N 8050 -1060 8060 -1050 {
lab=#net1}
N 7840 -1030 7850 -1040 {
lab=#net2}
N 7850 -1040 8050 -1040 {
lab=#net2}
N 8050 -1040 8060 -1030 {
lab=#net2}
N 7900 -1190 7900 -1170 {
lab=vcom}
N 7940 -1190 7940 -1170 {
lab=ctop}
N 7820 -1090 7840 -1090 {
lab=col_n[0]}
N 7820 -1070 7840 -1070 {
lab=colon_n[0]}
N 7820 -1050 7840 -1050 {
lab=#net1}
N 7820 -1030 7840 -1030 {
lab=#net2}
N 8060 -1030 8080 -1030 {
lab=#net2}
N 8060 -1050 8080 -1050 {
lab=#net1}
N 8060 -1070 8080 -1070 {
lab=colon_n[0]}
N 8060 -1090 8080 -1090 {
lab=col_n[0]}
N 7880 -950 7880 -940 {
lab=VSS}
N 7880 -1180 7880 -1170 {
lab=VDD}
N 8220 -950 8230 -960 {
lab=row_n[27]}
N 8230 -1160 8230 -960 {
lab=row_n[27]}
N 8220 -1170 8230 -1160 {
lab=row_n[27]}
N 8220 -950 8220 -930 {
lab=row_n[27]}
N 8220 -1190 8220 -1170 {
lab=row_n[27]}
N 8100 -1090 8110 -1100 {
lab=col_n[0]}
N 8110 -1100 8310 -1100 {
lab=col_n[0]}
N 8310 -1100 8320 -1090 {
lab=col_n[0]}
N 8100 -1070 8110 -1080 {
lab=colon_n[0]}
N 8110 -1080 8310 -1080 {
lab=colon_n[0]}
N 8310 -1080 8320 -1070 {
lab=colon_n[0]}
N 8100 -1050 8110 -1060 {
lab=#net1}
N 8110 -1060 8310 -1060 {
lab=#net1}
N 8310 -1060 8320 -1050 {
lab=#net1}
N 8100 -1030 8110 -1040 {
lab=#net2}
N 8110 -1040 8310 -1040 {
lab=#net2}
N 8310 -1040 8320 -1030 {
lab=#net2}
N 8160 -1190 8160 -1170 {
lab=vcom}
N 8200 -1190 8200 -1170 {
lab=ctop}
N 8080 -1090 8100 -1090 {
lab=col_n[0]}
N 8080 -1070 8100 -1070 {
lab=colon_n[0]}
N 8080 -1050 8100 -1050 {
lab=#net1}
N 8080 -1030 8100 -1030 {
lab=#net2}
N 8320 -1030 8340 -1030 {
lab=#net2}
N 8320 -1050 8340 -1050 {
lab=#net1}
N 8320 -1070 8340 -1070 {
lab=colon_n[0]}
N 8320 -1090 8340 -1090 {
lab=col_n[0]}
N 8140 -950 8140 -940 {
lab=VSS}
N 8140 -1180 8140 -1170 {
lab=VDD}
N 8480 -950 8490 -960 {
lab=row_n[28]}
N 8490 -1160 8490 -960 {
lab=row_n[28]}
N 8480 -1170 8490 -1160 {
lab=row_n[28]}
N 8480 -950 8480 -930 {
lab=row_n[28]}
N 8480 -1190 8480 -1170 {
lab=row_n[28]}
N 8360 -1090 8370 -1100 {
lab=col_n[0]}
N 8370 -1100 8570 -1100 {
lab=col_n[0]}
N 8570 -1100 8580 -1090 {
lab=col_n[0]}
N 8360 -1070 8370 -1080 {
lab=colon_n[0]}
N 8370 -1080 8570 -1080 {
lab=colon_n[0]}
N 8570 -1080 8580 -1070 {
lab=colon_n[0]}
N 8360 -1050 8370 -1060 {
lab=#net1}
N 8370 -1060 8570 -1060 {
lab=#net1}
N 8570 -1060 8580 -1050 {
lab=#net1}
N 8360 -1030 8370 -1040 {
lab=#net2}
N 8370 -1040 8570 -1040 {
lab=#net2}
N 8570 -1040 8580 -1030 {
lab=#net2}
N 8420 -1190 8420 -1170 {
lab=vcom}
N 8460 -1190 8460 -1170 {
lab=ctop}
N 8340 -1090 8360 -1090 {
lab=col_n[0]}
N 8340 -1070 8360 -1070 {
lab=colon_n[0]}
N 8340 -1050 8360 -1050 {
lab=#net1}
N 8340 -1030 8360 -1030 {
lab=#net2}
N 8580 -1030 8600 -1030 {
lab=#net2}
N 8580 -1050 8600 -1050 {
lab=#net1}
N 8580 -1070 8600 -1070 {
lab=colon_n[0]}
N 8580 -1090 8600 -1090 {
lab=col_n[0]}
N 8400 -950 8400 -940 {
lab=VSS}
N 8400 -1180 8400 -1170 {
lab=VDD}
N 8740 -950 8750 -960 {
lab=row_n[29]}
N 8750 -1160 8750 -960 {
lab=row_n[29]}
N 8740 -1170 8750 -1160 {
lab=row_n[29]}
N 8740 -950 8740 -930 {
lab=row_n[29]}
N 8740 -1190 8740 -1170 {
lab=row_n[29]}
N 8620 -1090 8630 -1100 {
lab=col_n[0]}
N 8630 -1100 8830 -1100 {
lab=col_n[0]}
N 8830 -1100 8840 -1090 {
lab=col_n[0]}
N 8620 -1070 8630 -1080 {
lab=colon_n[0]}
N 8630 -1080 8830 -1080 {
lab=colon_n[0]}
N 8830 -1080 8840 -1070 {
lab=colon_n[0]}
N 8620 -1050 8630 -1060 {
lab=#net1}
N 8630 -1060 8830 -1060 {
lab=#net1}
N 8830 -1060 8840 -1050 {
lab=#net1}
N 8620 -1030 8630 -1040 {
lab=#net2}
N 8630 -1040 8830 -1040 {
lab=#net2}
N 8830 -1040 8840 -1030 {
lab=#net2}
N 8680 -1190 8680 -1170 {
lab=vcom}
N 8720 -1190 8720 -1170 {
lab=ctop}
N 8600 -1090 8620 -1090 {
lab=col_n[0]}
N 8600 -1070 8620 -1070 {
lab=colon_n[0]}
N 8600 -1050 8620 -1050 {
lab=#net1}
N 8600 -1030 8620 -1030 {
lab=#net2}
N 8840 -1030 8860 -1030 {
lab=#net2}
N 8840 -1050 8860 -1050 {
lab=#net1}
N 8840 -1070 8860 -1070 {
lab=colon_n[0]}
N 8840 -1090 8860 -1090 {
lab=col_n[0]}
N 8660 -950 8660 -940 {
lab=VSS}
N 8660 -1180 8660 -1170 {
lab=VDD}
N 9000 -950 9010 -960 {
lab=row_n[30]}
N 9010 -1160 9010 -960 {
lab=row_n[30]}
N 9000 -1170 9010 -1160 {
lab=row_n[30]}
N 9000 -950 9000 -930 {
lab=row_n[30]}
N 9000 -1190 9000 -1170 {
lab=row_n[30]}
N 8880 -1090 8890 -1100 {
lab=col_n[0]}
N 8890 -1100 9090 -1100 {
lab=col_n[0]}
N 9090 -1100 9100 -1090 {
lab=col_n[0]}
N 8880 -1070 8890 -1080 {
lab=colon_n[0]}
N 8890 -1080 9090 -1080 {
lab=colon_n[0]}
N 9090 -1080 9100 -1070 {
lab=colon_n[0]}
N 8880 -1050 8890 -1060 {
lab=#net1}
N 8890 -1060 9090 -1060 {
lab=#net1}
N 9090 -1060 9100 -1050 {
lab=#net1}
N 8880 -1030 8890 -1040 {
lab=#net2}
N 8890 -1040 9090 -1040 {
lab=#net2}
N 9090 -1040 9100 -1030 {
lab=#net2}
N 8940 -1190 8940 -1170 {
lab=vcom}
N 8980 -1190 8980 -1170 {
lab=ctop}
N 8860 -1090 8880 -1090 {
lab=col_n[0]}
N 8860 -1070 8880 -1070 {
lab=colon_n[0]}
N 8860 -1050 8880 -1050 {
lab=#net1}
N 8860 -1030 8880 -1030 {
lab=#net2}
N 9100 -1030 9120 -1030 {
lab=#net2}
N 9100 -1050 9120 -1050 {
lab=#net1}
N 9100 -1070 9120 -1070 {
lab=colon_n[0]}
N 9100 -1090 9120 -1090 {
lab=col_n[0]}
N 8920 -950 8920 -940 {
lab=VSS}
N 8920 -1180 8920 -1170 {
lab=VDD}
N 9260 -950 9270 -960 {
lab=row_n[31]}
N 9270 -1160 9270 -960 {
lab=row_n[31]}
N 9260 -1170 9270 -1160 {
lab=row_n[31]}
N 9260 -950 9260 -930 {
lab=row_n[31]}
N 9260 -1190 9260 -1170 {
lab=row_n[31]}
N 9140 -1090 9150 -1100 {
lab=col_n[0]}
N 9150 -1100 9350 -1100 {
lab=col_n[0]}
N 9350 -1100 9360 -1090 {
lab=col_n[0]}
N 9140 -1070 9150 -1080 {
lab=colon_n[0]}
N 9150 -1080 9350 -1080 {
lab=colon_n[0]}
N 9350 -1080 9360 -1070 {
lab=colon_n[0]}
N 9140 -1050 9150 -1060 {
lab=#net1}
N 9150 -1060 9350 -1060 {
lab=#net1}
N 9350 -1060 9360 -1050 {
lab=#net1}
N 9140 -1030 9150 -1040 {
lab=#net2}
N 9150 -1040 9350 -1040 {
lab=#net2}
N 9350 -1040 9360 -1030 {
lab=#net2}
N 9200 -1190 9200 -1170 {
lab=vcom}
N 9240 -1190 9240 -1170 {
lab=ctop}
N 9120 -1090 9140 -1090 {
lab=col_n[0]}
N 9120 -1070 9140 -1070 {
lab=colon_n[0]}
N 9120 -1050 9140 -1050 {
lab=#net1}
N 9120 -1030 9140 -1030 {
lab=#net2}
N 9360 -1030 9380 -1030 {
lab=#net2}
N 9360 -1050 9380 -1050 {
lab=#net1}
N 9360 -1070 9380 -1070 {
lab=colon_n[0]}
N 9360 -1090 9380 -1090 {
lab=col_n[0]}
N 9180 -950 9180 -940 {
lab=VSS}
N 9180 -1180 9180 -1170 {
lab=VDD}
N 1200 -1210 1210 -1220 {
lab=row_n[0]}
N 1210 -1420 1210 -1220 {
lab=row_n[0]}
N 1200 -1430 1210 -1420 {
lab=row_n[0]}
N 1200 -1210 1200 -1190 {
lab=row_n[0]}
N 1200 -1450 1200 -1430 {
lab=row_n[0]}
N 1080 -1350 1090 -1360 {
lab=col_n[1]}
N 1090 -1360 1290 -1360 {
lab=col_n[1]}
N 1290 -1360 1300 -1350 {
lab=col_n[1]}
N 1080 -1330 1090 -1340 {
lab=colon_n[1]}
N 1090 -1340 1290 -1340 {
lab=colon_n[1]}
N 1290 -1340 1300 -1330 {
lab=colon_n[1]}
N 1080 -1310 1090 -1320 {
lab=#net3}
N 1090 -1320 1290 -1320 {
lab=#net3}
N 1290 -1320 1300 -1310 {
lab=#net3}
N 1080 -1290 1090 -1300 {
lab=#net4}
N 1090 -1300 1290 -1300 {
lab=#net4}
N 1290 -1300 1300 -1290 {
lab=#net4}
N 1140 -1450 1140 -1430 {
lab=vcom}
N 1180 -1450 1180 -1430 {
lab=ctop}
N 1060 -1350 1080 -1350 {
lab=col_n[1]}
N 1060 -1330 1080 -1330 {
lab=colon_n[1]}
N 1060 -1310 1080 -1310 {
lab=#net3}
N 1060 -1290 1080 -1290 {
lab=#net4}
N 1300 -1290 1320 -1290 {
lab=#net4}
N 1300 -1310 1320 -1310 {
lab=#net3}
N 1300 -1330 1320 -1330 {
lab=colon_n[1]}
N 1300 -1350 1320 -1350 {
lab=col_n[1]}
N 1120 -1210 1120 -1200 {
lab=VSS}
N 1120 -1440 1120 -1430 {
lab=VDD}
N 1460 -1210 1470 -1220 {
lab=row_n[1]}
N 1470 -1420 1470 -1220 {
lab=row_n[1]}
N 1460 -1430 1470 -1420 {
lab=row_n[1]}
N 1460 -1210 1460 -1190 {
lab=row_n[1]}
N 1460 -1450 1460 -1430 {
lab=row_n[1]}
N 1340 -1350 1350 -1360 {
lab=col_n[1]}
N 1350 -1360 1550 -1360 {
lab=col_n[1]}
N 1550 -1360 1560 -1350 {
lab=col_n[1]}
N 1340 -1330 1350 -1340 {
lab=colon_n[1]}
N 1350 -1340 1550 -1340 {
lab=colon_n[1]}
N 1550 -1340 1560 -1330 {
lab=colon_n[1]}
N 1340 -1310 1350 -1320 {
lab=#net3}
N 1350 -1320 1550 -1320 {
lab=#net3}
N 1550 -1320 1560 -1310 {
lab=#net3}
N 1340 -1290 1350 -1300 {
lab=#net4}
N 1350 -1300 1550 -1300 {
lab=#net4}
N 1550 -1300 1560 -1290 {
lab=#net4}
N 1400 -1450 1400 -1430 {
lab=vcom}
N 1440 -1450 1440 -1430 {
lab=ctop}
N 1320 -1350 1340 -1350 {
lab=col_n[1]}
N 1320 -1330 1340 -1330 {
lab=colon_n[1]}
N 1320 -1310 1340 -1310 {
lab=#net3}
N 1320 -1290 1340 -1290 {
lab=#net4}
N 1560 -1290 1580 -1290 {
lab=#net4}
N 1560 -1310 1580 -1310 {
lab=#net3}
N 1560 -1330 1580 -1330 {
lab=colon_n[1]}
N 1560 -1350 1580 -1350 {
lab=col_n[1]}
N 1380 -1210 1380 -1200 {
lab=VSS}
N 1380 -1440 1380 -1430 {
lab=VDD}
N 1720 -1210 1730 -1220 {
lab=row_n[2]}
N 1730 -1420 1730 -1220 {
lab=row_n[2]}
N 1720 -1430 1730 -1420 {
lab=row_n[2]}
N 1720 -1210 1720 -1190 {
lab=row_n[2]}
N 1720 -1450 1720 -1430 {
lab=row_n[2]}
N 1600 -1350 1610 -1360 {
lab=col_n[1]}
N 1610 -1360 1810 -1360 {
lab=col_n[1]}
N 1810 -1360 1820 -1350 {
lab=col_n[1]}
N 1600 -1330 1610 -1340 {
lab=colon_n[1]}
N 1610 -1340 1810 -1340 {
lab=colon_n[1]}
N 1810 -1340 1820 -1330 {
lab=colon_n[1]}
N 1600 -1310 1610 -1320 {
lab=#net3}
N 1610 -1320 1810 -1320 {
lab=#net3}
N 1810 -1320 1820 -1310 {
lab=#net3}
N 1600 -1290 1610 -1300 {
lab=#net4}
N 1610 -1300 1810 -1300 {
lab=#net4}
N 1810 -1300 1820 -1290 {
lab=#net4}
N 1660 -1450 1660 -1430 {
lab=vcom}
N 1700 -1450 1700 -1430 {
lab=ctop}
N 1580 -1350 1600 -1350 {
lab=col_n[1]}
N 1580 -1330 1600 -1330 {
lab=colon_n[1]}
N 1580 -1310 1600 -1310 {
lab=#net3}
N 1580 -1290 1600 -1290 {
lab=#net4}
N 1820 -1290 1840 -1290 {
lab=#net4}
N 1820 -1310 1840 -1310 {
lab=#net3}
N 1820 -1330 1840 -1330 {
lab=colon_n[1]}
N 1820 -1350 1840 -1350 {
lab=col_n[1]}
N 1640 -1210 1640 -1200 {
lab=VSS}
N 1640 -1440 1640 -1430 {
lab=VDD}
N 1980 -1210 1990 -1220 {
lab=row_n[3]}
N 1990 -1420 1990 -1220 {
lab=row_n[3]}
N 1980 -1430 1990 -1420 {
lab=row_n[3]}
N 1980 -1210 1980 -1190 {
lab=row_n[3]}
N 1980 -1450 1980 -1430 {
lab=row_n[3]}
N 1860 -1350 1870 -1360 {
lab=col_n[1]}
N 1870 -1360 2070 -1360 {
lab=col_n[1]}
N 2070 -1360 2080 -1350 {
lab=col_n[1]}
N 1860 -1330 1870 -1340 {
lab=colon_n[1]}
N 1870 -1340 2070 -1340 {
lab=colon_n[1]}
N 2070 -1340 2080 -1330 {
lab=colon_n[1]}
N 1860 -1310 1870 -1320 {
lab=#net3}
N 1870 -1320 2070 -1320 {
lab=#net3}
N 2070 -1320 2080 -1310 {
lab=#net3}
N 1860 -1290 1870 -1300 {
lab=#net4}
N 1870 -1300 2070 -1300 {
lab=#net4}
N 2070 -1300 2080 -1290 {
lab=#net4}
N 1920 -1450 1920 -1430 {
lab=vcom}
N 1960 -1450 1960 -1430 {
lab=ctop}
N 1840 -1350 1860 -1350 {
lab=col_n[1]}
N 1840 -1330 1860 -1330 {
lab=colon_n[1]}
N 1840 -1310 1860 -1310 {
lab=#net3}
N 1840 -1290 1860 -1290 {
lab=#net4}
N 2080 -1290 2100 -1290 {
lab=#net4}
N 2080 -1310 2100 -1310 {
lab=#net3}
N 2080 -1330 2100 -1330 {
lab=colon_n[1]}
N 2080 -1350 2100 -1350 {
lab=col_n[1]}
N 1900 -1210 1900 -1200 {
lab=VSS}
N 1900 -1440 1900 -1430 {
lab=VDD}
N 2240 -1210 2250 -1220 {
lab=row_n[4]}
N 2250 -1420 2250 -1220 {
lab=row_n[4]}
N 2240 -1430 2250 -1420 {
lab=row_n[4]}
N 2240 -1210 2240 -1190 {
lab=row_n[4]}
N 2240 -1450 2240 -1430 {
lab=row_n[4]}
N 2120 -1350 2130 -1360 {
lab=col_n[1]}
N 2130 -1360 2330 -1360 {
lab=col_n[1]}
N 2330 -1360 2340 -1350 {
lab=col_n[1]}
N 2120 -1330 2130 -1340 {
lab=colon_n[1]}
N 2130 -1340 2330 -1340 {
lab=colon_n[1]}
N 2330 -1340 2340 -1330 {
lab=colon_n[1]}
N 2120 -1310 2130 -1320 {
lab=#net3}
N 2130 -1320 2330 -1320 {
lab=#net3}
N 2330 -1320 2340 -1310 {
lab=#net3}
N 2120 -1290 2130 -1300 {
lab=#net4}
N 2130 -1300 2330 -1300 {
lab=#net4}
N 2330 -1300 2340 -1290 {
lab=#net4}
N 2180 -1450 2180 -1430 {
lab=vcom}
N 2220 -1450 2220 -1430 {
lab=ctop}
N 2100 -1350 2120 -1350 {
lab=col_n[1]}
N 2100 -1330 2120 -1330 {
lab=colon_n[1]}
N 2100 -1310 2120 -1310 {
lab=#net3}
N 2100 -1290 2120 -1290 {
lab=#net4}
N 2340 -1290 2360 -1290 {
lab=#net4}
N 2340 -1310 2360 -1310 {
lab=#net3}
N 2340 -1330 2360 -1330 {
lab=colon_n[1]}
N 2340 -1350 2360 -1350 {
lab=col_n[1]}
N 2160 -1210 2160 -1200 {
lab=VSS}
N 2160 -1440 2160 -1430 {
lab=VDD}
N 2500 -1210 2510 -1220 {
lab=row_n[5]}
N 2510 -1420 2510 -1220 {
lab=row_n[5]}
N 2500 -1430 2510 -1420 {
lab=row_n[5]}
N 2500 -1210 2500 -1190 {
lab=row_n[5]}
N 2500 -1450 2500 -1430 {
lab=row_n[5]}
N 2380 -1350 2390 -1360 {
lab=col_n[1]}
N 2390 -1360 2590 -1360 {
lab=col_n[1]}
N 2590 -1360 2600 -1350 {
lab=col_n[1]}
N 2380 -1330 2390 -1340 {
lab=colon_n[1]}
N 2390 -1340 2590 -1340 {
lab=colon_n[1]}
N 2590 -1340 2600 -1330 {
lab=colon_n[1]}
N 2380 -1310 2390 -1320 {
lab=#net3}
N 2390 -1320 2590 -1320 {
lab=#net3}
N 2590 -1320 2600 -1310 {
lab=#net3}
N 2380 -1290 2390 -1300 {
lab=#net4}
N 2390 -1300 2590 -1300 {
lab=#net4}
N 2590 -1300 2600 -1290 {
lab=#net4}
N 2440 -1450 2440 -1430 {
lab=vcom}
N 2480 -1450 2480 -1430 {
lab=ctop}
N 2360 -1350 2380 -1350 {
lab=col_n[1]}
N 2360 -1330 2380 -1330 {
lab=colon_n[1]}
N 2360 -1310 2380 -1310 {
lab=#net3}
N 2360 -1290 2380 -1290 {
lab=#net4}
N 2600 -1290 2620 -1290 {
lab=#net4}
N 2600 -1310 2620 -1310 {
lab=#net3}
N 2600 -1330 2620 -1330 {
lab=colon_n[1]}
N 2600 -1350 2620 -1350 {
lab=col_n[1]}
N 2420 -1210 2420 -1200 {
lab=VSS}
N 2420 -1440 2420 -1430 {
lab=VDD}
N 2760 -1210 2770 -1220 {
lab=row_n[6]}
N 2770 -1420 2770 -1220 {
lab=row_n[6]}
N 2760 -1430 2770 -1420 {
lab=row_n[6]}
N 2760 -1210 2760 -1190 {
lab=row_n[6]}
N 2760 -1450 2760 -1430 {
lab=row_n[6]}
N 2640 -1350 2650 -1360 {
lab=col_n[1]}
N 2650 -1360 2850 -1360 {
lab=col_n[1]}
N 2850 -1360 2860 -1350 {
lab=col_n[1]}
N 2640 -1330 2650 -1340 {
lab=colon_n[1]}
N 2650 -1340 2850 -1340 {
lab=colon_n[1]}
N 2850 -1340 2860 -1330 {
lab=colon_n[1]}
N 2640 -1310 2650 -1320 {
lab=#net3}
N 2650 -1320 2850 -1320 {
lab=#net3}
N 2850 -1320 2860 -1310 {
lab=#net3}
N 2640 -1290 2650 -1300 {
lab=#net4}
N 2650 -1300 2850 -1300 {
lab=#net4}
N 2850 -1300 2860 -1290 {
lab=#net4}
N 2700 -1450 2700 -1430 {
lab=vcom}
N 2740 -1450 2740 -1430 {
lab=ctop}
N 2620 -1350 2640 -1350 {
lab=col_n[1]}
N 2620 -1330 2640 -1330 {
lab=colon_n[1]}
N 2620 -1310 2640 -1310 {
lab=#net3}
N 2620 -1290 2640 -1290 {
lab=#net4}
N 2860 -1290 2880 -1290 {
lab=#net4}
N 2860 -1310 2880 -1310 {
lab=#net3}
N 2860 -1330 2880 -1330 {
lab=colon_n[1]}
N 2860 -1350 2880 -1350 {
lab=col_n[1]}
N 2680 -1210 2680 -1200 {
lab=VSS}
N 2680 -1440 2680 -1430 {
lab=VDD}
N 3020 -1210 3030 -1220 {
lab=row_n[7]}
N 3030 -1420 3030 -1220 {
lab=row_n[7]}
N 3020 -1430 3030 -1420 {
lab=row_n[7]}
N 3020 -1210 3020 -1190 {
lab=row_n[7]}
N 3020 -1450 3020 -1430 {
lab=row_n[7]}
N 2900 -1350 2910 -1360 {
lab=col_n[1]}
N 2910 -1360 3110 -1360 {
lab=col_n[1]}
N 3110 -1360 3120 -1350 {
lab=col_n[1]}
N 2900 -1330 2910 -1340 {
lab=colon_n[1]}
N 2910 -1340 3110 -1340 {
lab=colon_n[1]}
N 3110 -1340 3120 -1330 {
lab=colon_n[1]}
N 2900 -1310 2910 -1320 {
lab=#net3}
N 2910 -1320 3110 -1320 {
lab=#net3}
N 3110 -1320 3120 -1310 {
lab=#net3}
N 2900 -1290 2910 -1300 {
lab=#net4}
N 2910 -1300 3110 -1300 {
lab=#net4}
N 3110 -1300 3120 -1290 {
lab=#net4}
N 2960 -1450 2960 -1430 {
lab=vcom}
N 3000 -1450 3000 -1430 {
lab=ctop}
N 2880 -1350 2900 -1350 {
lab=col_n[1]}
N 2880 -1330 2900 -1330 {
lab=colon_n[1]}
N 2880 -1310 2900 -1310 {
lab=#net3}
N 2880 -1290 2900 -1290 {
lab=#net4}
N 3120 -1290 3140 -1290 {
lab=#net4}
N 3120 -1310 3140 -1310 {
lab=#net3}
N 3120 -1330 3140 -1330 {
lab=colon_n[1]}
N 3120 -1350 3140 -1350 {
lab=col_n[1]}
N 2940 -1210 2940 -1200 {
lab=VSS}
N 2940 -1440 2940 -1430 {
lab=VDD}
N 3280 -1210 3290 -1220 {
lab=row_n[8]}
N 3290 -1420 3290 -1220 {
lab=row_n[8]}
N 3280 -1430 3290 -1420 {
lab=row_n[8]}
N 3280 -1210 3280 -1190 {
lab=row_n[8]}
N 3280 -1450 3280 -1430 {
lab=row_n[8]}
N 3160 -1350 3170 -1360 {
lab=col_n[1]}
N 3170 -1360 3370 -1360 {
lab=col_n[1]}
N 3370 -1360 3380 -1350 {
lab=col_n[1]}
N 3160 -1330 3170 -1340 {
lab=colon_n[1]}
N 3170 -1340 3370 -1340 {
lab=colon_n[1]}
N 3370 -1340 3380 -1330 {
lab=colon_n[1]}
N 3160 -1310 3170 -1320 {
lab=#net3}
N 3170 -1320 3370 -1320 {
lab=#net3}
N 3370 -1320 3380 -1310 {
lab=#net3}
N 3160 -1290 3170 -1300 {
lab=#net4}
N 3170 -1300 3370 -1300 {
lab=#net4}
N 3370 -1300 3380 -1290 {
lab=#net4}
N 3220 -1450 3220 -1430 {
lab=vcom}
N 3260 -1450 3260 -1430 {
lab=ctop}
N 3140 -1350 3160 -1350 {
lab=col_n[1]}
N 3140 -1330 3160 -1330 {
lab=colon_n[1]}
N 3140 -1310 3160 -1310 {
lab=#net3}
N 3140 -1290 3160 -1290 {
lab=#net4}
N 3380 -1290 3400 -1290 {
lab=#net4}
N 3380 -1310 3400 -1310 {
lab=#net3}
N 3380 -1330 3400 -1330 {
lab=colon_n[1]}
N 3380 -1350 3400 -1350 {
lab=col_n[1]}
N 3200 -1210 3200 -1200 {
lab=VSS}
N 3200 -1440 3200 -1430 {
lab=VDD}
N 3540 -1210 3550 -1220 {
lab=row_n[9]}
N 3550 -1420 3550 -1220 {
lab=row_n[9]}
N 3540 -1430 3550 -1420 {
lab=row_n[9]}
N 3540 -1210 3540 -1190 {
lab=row_n[9]}
N 3540 -1450 3540 -1430 {
lab=row_n[9]}
N 3420 -1350 3430 -1360 {
lab=col_n[1]}
N 3430 -1360 3630 -1360 {
lab=col_n[1]}
N 3630 -1360 3640 -1350 {
lab=col_n[1]}
N 3420 -1330 3430 -1340 {
lab=colon_n[1]}
N 3430 -1340 3630 -1340 {
lab=colon_n[1]}
N 3630 -1340 3640 -1330 {
lab=colon_n[1]}
N 3420 -1310 3430 -1320 {
lab=#net3}
N 3430 -1320 3630 -1320 {
lab=#net3}
N 3630 -1320 3640 -1310 {
lab=#net3}
N 3420 -1290 3430 -1300 {
lab=#net4}
N 3430 -1300 3630 -1300 {
lab=#net4}
N 3630 -1300 3640 -1290 {
lab=#net4}
N 3480 -1450 3480 -1430 {
lab=vcom}
N 3520 -1450 3520 -1430 {
lab=ctop}
N 3400 -1350 3420 -1350 {
lab=col_n[1]}
N 3400 -1330 3420 -1330 {
lab=colon_n[1]}
N 3400 -1310 3420 -1310 {
lab=#net3}
N 3400 -1290 3420 -1290 {
lab=#net4}
N 3640 -1290 3660 -1290 {
lab=#net4}
N 3640 -1310 3660 -1310 {
lab=#net3}
N 3640 -1330 3660 -1330 {
lab=colon_n[1]}
N 3640 -1350 3660 -1350 {
lab=col_n[1]}
N 3460 -1210 3460 -1200 {
lab=VSS}
N 3460 -1440 3460 -1430 {
lab=VDD}
N 3800 -1210 3810 -1220 {
lab=row_n[10]}
N 3810 -1420 3810 -1220 {
lab=row_n[10]}
N 3800 -1430 3810 -1420 {
lab=row_n[10]}
N 3800 -1210 3800 -1190 {
lab=row_n[10]}
N 3800 -1450 3800 -1430 {
lab=row_n[10]}
N 3680 -1350 3690 -1360 {
lab=col_n[1]}
N 3690 -1360 3890 -1360 {
lab=col_n[1]}
N 3890 -1360 3900 -1350 {
lab=col_n[1]}
N 3680 -1330 3690 -1340 {
lab=colon_n[1]}
N 3690 -1340 3890 -1340 {
lab=colon_n[1]}
N 3890 -1340 3900 -1330 {
lab=colon_n[1]}
N 3680 -1310 3690 -1320 {
lab=#net3}
N 3690 -1320 3890 -1320 {
lab=#net3}
N 3890 -1320 3900 -1310 {
lab=#net3}
N 3680 -1290 3690 -1300 {
lab=#net4}
N 3690 -1300 3890 -1300 {
lab=#net4}
N 3890 -1300 3900 -1290 {
lab=#net4}
N 3740 -1450 3740 -1430 {
lab=vcom}
N 3780 -1450 3780 -1430 {
lab=ctop}
N 3660 -1350 3680 -1350 {
lab=col_n[1]}
N 3660 -1330 3680 -1330 {
lab=colon_n[1]}
N 3660 -1310 3680 -1310 {
lab=#net3}
N 3660 -1290 3680 -1290 {
lab=#net4}
N 3900 -1290 3920 -1290 {
lab=#net4}
N 3900 -1310 3920 -1310 {
lab=#net3}
N 3900 -1330 3920 -1330 {
lab=colon_n[1]}
N 3900 -1350 3920 -1350 {
lab=col_n[1]}
N 3720 -1210 3720 -1200 {
lab=VSS}
N 3720 -1440 3720 -1430 {
lab=VDD}
N 4060 -1210 4070 -1220 {
lab=row_n[11]}
N 4070 -1420 4070 -1220 {
lab=row_n[11]}
N 4060 -1430 4070 -1420 {
lab=row_n[11]}
N 4060 -1210 4060 -1190 {
lab=row_n[11]}
N 4060 -1450 4060 -1430 {
lab=row_n[11]}
N 3940 -1350 3950 -1360 {
lab=col_n[1]}
N 3950 -1360 4150 -1360 {
lab=col_n[1]}
N 4150 -1360 4160 -1350 {
lab=col_n[1]}
N 3940 -1330 3950 -1340 {
lab=colon_n[1]}
N 3950 -1340 4150 -1340 {
lab=colon_n[1]}
N 4150 -1340 4160 -1330 {
lab=colon_n[1]}
N 3940 -1310 3950 -1320 {
lab=#net3}
N 3950 -1320 4150 -1320 {
lab=#net3}
N 4150 -1320 4160 -1310 {
lab=#net3}
N 3940 -1290 3950 -1300 {
lab=#net4}
N 3950 -1300 4150 -1300 {
lab=#net4}
N 4150 -1300 4160 -1290 {
lab=#net4}
N 4000 -1450 4000 -1430 {
lab=vcom}
N 4040 -1450 4040 -1430 {
lab=ctop}
N 3920 -1350 3940 -1350 {
lab=col_n[1]}
N 3920 -1330 3940 -1330 {
lab=colon_n[1]}
N 3920 -1310 3940 -1310 {
lab=#net3}
N 3920 -1290 3940 -1290 {
lab=#net4}
N 4160 -1290 4180 -1290 {
lab=#net4}
N 4160 -1310 4180 -1310 {
lab=#net3}
N 4160 -1330 4180 -1330 {
lab=colon_n[1]}
N 4160 -1350 4180 -1350 {
lab=col_n[1]}
N 3980 -1210 3980 -1200 {
lab=VSS}
N 3980 -1440 3980 -1430 {
lab=VDD}
N 4320 -1210 4330 -1220 {
lab=row_n[12]}
N 4330 -1420 4330 -1220 {
lab=row_n[12]}
N 4320 -1430 4330 -1420 {
lab=row_n[12]}
N 4320 -1210 4320 -1190 {
lab=row_n[12]}
N 4320 -1450 4320 -1430 {
lab=row_n[12]}
N 4200 -1350 4210 -1360 {
lab=col_n[1]}
N 4210 -1360 4410 -1360 {
lab=col_n[1]}
N 4410 -1360 4420 -1350 {
lab=col_n[1]}
N 4200 -1330 4210 -1340 {
lab=colon_n[1]}
N 4210 -1340 4410 -1340 {
lab=colon_n[1]}
N 4410 -1340 4420 -1330 {
lab=colon_n[1]}
N 4200 -1310 4210 -1320 {
lab=#net3}
N 4210 -1320 4410 -1320 {
lab=#net3}
N 4410 -1320 4420 -1310 {
lab=#net3}
N 4200 -1290 4210 -1300 {
lab=#net4}
N 4210 -1300 4410 -1300 {
lab=#net4}
N 4410 -1300 4420 -1290 {
lab=#net4}
N 4260 -1450 4260 -1430 {
lab=vcom}
N 4300 -1450 4300 -1430 {
lab=ctop}
N 4180 -1350 4200 -1350 {
lab=col_n[1]}
N 4180 -1330 4200 -1330 {
lab=colon_n[1]}
N 4180 -1310 4200 -1310 {
lab=#net3}
N 4180 -1290 4200 -1290 {
lab=#net4}
N 4420 -1290 4440 -1290 {
lab=#net4}
N 4420 -1310 4440 -1310 {
lab=#net3}
N 4420 -1330 4440 -1330 {
lab=colon_n[1]}
N 4420 -1350 4440 -1350 {
lab=col_n[1]}
N 4240 -1210 4240 -1200 {
lab=VSS}
N 4240 -1440 4240 -1430 {
lab=VDD}
N 4580 -1210 4590 -1220 {
lab=row_n[13]}
N 4590 -1420 4590 -1220 {
lab=row_n[13]}
N 4580 -1430 4590 -1420 {
lab=row_n[13]}
N 4580 -1210 4580 -1190 {
lab=row_n[13]}
N 4580 -1450 4580 -1430 {
lab=row_n[13]}
N 4460 -1350 4470 -1360 {
lab=col_n[1]}
N 4470 -1360 4670 -1360 {
lab=col_n[1]}
N 4670 -1360 4680 -1350 {
lab=col_n[1]}
N 4460 -1330 4470 -1340 {
lab=colon_n[1]}
N 4470 -1340 4670 -1340 {
lab=colon_n[1]}
N 4670 -1340 4680 -1330 {
lab=colon_n[1]}
N 4460 -1310 4470 -1320 {
lab=#net3}
N 4470 -1320 4670 -1320 {
lab=#net3}
N 4670 -1320 4680 -1310 {
lab=#net3}
N 4460 -1290 4470 -1300 {
lab=#net4}
N 4470 -1300 4670 -1300 {
lab=#net4}
N 4670 -1300 4680 -1290 {
lab=#net4}
N 4520 -1450 4520 -1430 {
lab=vcom}
N 4560 -1450 4560 -1430 {
lab=ctop}
N 4440 -1350 4460 -1350 {
lab=col_n[1]}
N 4440 -1330 4460 -1330 {
lab=colon_n[1]}
N 4440 -1310 4460 -1310 {
lab=#net3}
N 4440 -1290 4460 -1290 {
lab=#net4}
N 4680 -1290 4700 -1290 {
lab=#net4}
N 4680 -1310 4700 -1310 {
lab=#net3}
N 4680 -1330 4700 -1330 {
lab=colon_n[1]}
N 4680 -1350 4700 -1350 {
lab=col_n[1]}
N 4500 -1210 4500 -1200 {
lab=VSS}
N 4500 -1440 4500 -1430 {
lab=VDD}
N 4840 -1210 4850 -1220 {
lab=row_n[14]}
N 4850 -1420 4850 -1220 {
lab=row_n[14]}
N 4840 -1430 4850 -1420 {
lab=row_n[14]}
N 4840 -1210 4840 -1190 {
lab=row_n[14]}
N 4840 -1450 4840 -1430 {
lab=row_n[14]}
N 4720 -1350 4730 -1360 {
lab=col_n[1]}
N 4730 -1360 4930 -1360 {
lab=col_n[1]}
N 4930 -1360 4940 -1350 {
lab=col_n[1]}
N 4720 -1330 4730 -1340 {
lab=colon_n[1]}
N 4730 -1340 4930 -1340 {
lab=colon_n[1]}
N 4930 -1340 4940 -1330 {
lab=colon_n[1]}
N 4720 -1310 4730 -1320 {
lab=#net3}
N 4730 -1320 4930 -1320 {
lab=#net3}
N 4930 -1320 4940 -1310 {
lab=#net3}
N 4720 -1290 4730 -1300 {
lab=#net4}
N 4730 -1300 4930 -1300 {
lab=#net4}
N 4930 -1300 4940 -1290 {
lab=#net4}
N 4780 -1450 4780 -1430 {
lab=vcom}
N 4820 -1450 4820 -1430 {
lab=ctop}
N 4700 -1350 4720 -1350 {
lab=col_n[1]}
N 4700 -1330 4720 -1330 {
lab=colon_n[1]}
N 4700 -1310 4720 -1310 {
lab=#net3}
N 4700 -1290 4720 -1290 {
lab=#net4}
N 4940 -1290 4960 -1290 {
lab=#net4}
N 4940 -1310 4960 -1310 {
lab=#net3}
N 4940 -1330 4960 -1330 {
lab=colon_n[1]}
N 4940 -1350 4960 -1350 {
lab=col_n[1]}
N 4760 -1210 4760 -1200 {
lab=VSS}
N 4760 -1440 4760 -1430 {
lab=VDD}
N 5100 -1210 5110 -1220 {
lab=row_n[15]}
N 5110 -1420 5110 -1220 {
lab=row_n[15]}
N 5100 -1430 5110 -1420 {
lab=row_n[15]}
N 5100 -1210 5100 -1190 {
lab=row_n[15]}
N 5100 -1450 5100 -1430 {
lab=row_n[15]}
N 4980 -1350 4990 -1360 {
lab=col_n[1]}
N 4990 -1360 5190 -1360 {
lab=col_n[1]}
N 5190 -1360 5200 -1350 {
lab=col_n[1]}
N 4980 -1330 4990 -1340 {
lab=colon_n[1]}
N 4990 -1340 5190 -1340 {
lab=colon_n[1]}
N 5190 -1340 5200 -1330 {
lab=colon_n[1]}
N 4980 -1310 4990 -1320 {
lab=#net3}
N 4990 -1320 5190 -1320 {
lab=#net3}
N 5190 -1320 5200 -1310 {
lab=#net3}
N 4980 -1290 4990 -1300 {
lab=#net4}
N 4990 -1300 5190 -1300 {
lab=#net4}
N 5190 -1300 5200 -1290 {
lab=#net4}
N 5040 -1450 5040 -1430 {
lab=vcom}
N 5080 -1450 5080 -1430 {
lab=ctop}
N 4960 -1350 4980 -1350 {
lab=col_n[1]}
N 4960 -1330 4980 -1330 {
lab=colon_n[1]}
N 4960 -1310 4980 -1310 {
lab=#net3}
N 4960 -1290 4980 -1290 {
lab=#net4}
N 5200 -1290 5220 -1290 {
lab=#net4}
N 5200 -1310 5220 -1310 {
lab=#net3}
N 5200 -1330 5220 -1330 {
lab=colon_n[1]}
N 5200 -1350 5220 -1350 {
lab=col_n[1]}
N 5020 -1210 5020 -1200 {
lab=VSS}
N 5020 -1440 5020 -1430 {
lab=VDD}
N 5360 -1210 5370 -1220 {
lab=row_n[16]}
N 5370 -1420 5370 -1220 {
lab=row_n[16]}
N 5360 -1430 5370 -1420 {
lab=row_n[16]}
N 5360 -1210 5360 -1190 {
lab=row_n[16]}
N 5360 -1450 5360 -1430 {
lab=row_n[16]}
N 5240 -1350 5250 -1360 {
lab=col_n[1]}
N 5250 -1360 5450 -1360 {
lab=col_n[1]}
N 5450 -1360 5460 -1350 {
lab=col_n[1]}
N 5240 -1330 5250 -1340 {
lab=colon_n[1]}
N 5250 -1340 5450 -1340 {
lab=colon_n[1]}
N 5450 -1340 5460 -1330 {
lab=colon_n[1]}
N 5240 -1310 5250 -1320 {
lab=#net3}
N 5250 -1320 5450 -1320 {
lab=#net3}
N 5450 -1320 5460 -1310 {
lab=#net3}
N 5240 -1290 5250 -1300 {
lab=#net4}
N 5250 -1300 5450 -1300 {
lab=#net4}
N 5450 -1300 5460 -1290 {
lab=#net4}
N 5300 -1450 5300 -1430 {
lab=vcom}
N 5340 -1450 5340 -1430 {
lab=ctop}
N 5220 -1350 5240 -1350 {
lab=col_n[1]}
N 5220 -1330 5240 -1330 {
lab=colon_n[1]}
N 5220 -1310 5240 -1310 {
lab=#net3}
N 5220 -1290 5240 -1290 {
lab=#net4}
N 5460 -1290 5480 -1290 {
lab=#net4}
N 5460 -1310 5480 -1310 {
lab=#net3}
N 5460 -1330 5480 -1330 {
lab=colon_n[1]}
N 5460 -1350 5480 -1350 {
lab=col_n[1]}
N 5280 -1210 5280 -1200 {
lab=VSS}
N 5280 -1440 5280 -1430 {
lab=VDD}
N 5620 -1210 5630 -1220 {
lab=row_n[17]}
N 5630 -1420 5630 -1220 {
lab=row_n[17]}
N 5620 -1430 5630 -1420 {
lab=row_n[17]}
N 5620 -1210 5620 -1190 {
lab=row_n[17]}
N 5620 -1450 5620 -1430 {
lab=row_n[17]}
N 5500 -1350 5510 -1360 {
lab=col_n[1]}
N 5510 -1360 5710 -1360 {
lab=col_n[1]}
N 5710 -1360 5720 -1350 {
lab=col_n[1]}
N 5500 -1330 5510 -1340 {
lab=colon_n[1]}
N 5510 -1340 5710 -1340 {
lab=colon_n[1]}
N 5710 -1340 5720 -1330 {
lab=colon_n[1]}
N 5500 -1310 5510 -1320 {
lab=#net3}
N 5510 -1320 5710 -1320 {
lab=#net3}
N 5710 -1320 5720 -1310 {
lab=#net3}
N 5500 -1290 5510 -1300 {
lab=#net4}
N 5510 -1300 5710 -1300 {
lab=#net4}
N 5710 -1300 5720 -1290 {
lab=#net4}
N 5560 -1450 5560 -1430 {
lab=vcom}
N 5600 -1450 5600 -1430 {
lab=ctop}
N 5480 -1350 5500 -1350 {
lab=col_n[1]}
N 5480 -1330 5500 -1330 {
lab=colon_n[1]}
N 5480 -1310 5500 -1310 {
lab=#net3}
N 5480 -1290 5500 -1290 {
lab=#net4}
N 5720 -1290 5740 -1290 {
lab=#net4}
N 5720 -1310 5740 -1310 {
lab=#net3}
N 5720 -1330 5740 -1330 {
lab=colon_n[1]}
N 5720 -1350 5740 -1350 {
lab=col_n[1]}
N 5540 -1210 5540 -1200 {
lab=VSS}
N 5540 -1440 5540 -1430 {
lab=VDD}
N 5880 -1210 5890 -1220 {
lab=row_n[18]}
N 5890 -1420 5890 -1220 {
lab=row_n[18]}
N 5880 -1430 5890 -1420 {
lab=row_n[18]}
N 5880 -1210 5880 -1190 {
lab=row_n[18]}
N 5880 -1450 5880 -1430 {
lab=row_n[18]}
N 5760 -1350 5770 -1360 {
lab=col_n[1]}
N 5770 -1360 5970 -1360 {
lab=col_n[1]}
N 5970 -1360 5980 -1350 {
lab=col_n[1]}
N 5760 -1330 5770 -1340 {
lab=colon_n[1]}
N 5770 -1340 5970 -1340 {
lab=colon_n[1]}
N 5970 -1340 5980 -1330 {
lab=colon_n[1]}
N 5760 -1310 5770 -1320 {
lab=#net3}
N 5770 -1320 5970 -1320 {
lab=#net3}
N 5970 -1320 5980 -1310 {
lab=#net3}
N 5760 -1290 5770 -1300 {
lab=#net4}
N 5770 -1300 5970 -1300 {
lab=#net4}
N 5970 -1300 5980 -1290 {
lab=#net4}
N 5820 -1450 5820 -1430 {
lab=vcom}
N 5860 -1450 5860 -1430 {
lab=ctop}
N 5740 -1350 5760 -1350 {
lab=col_n[1]}
N 5740 -1330 5760 -1330 {
lab=colon_n[1]}
N 5740 -1310 5760 -1310 {
lab=#net3}
N 5740 -1290 5760 -1290 {
lab=#net4}
N 5980 -1290 6000 -1290 {
lab=#net4}
N 5980 -1310 6000 -1310 {
lab=#net3}
N 5980 -1330 6000 -1330 {
lab=colon_n[1]}
N 5980 -1350 6000 -1350 {
lab=col_n[1]}
N 5800 -1210 5800 -1200 {
lab=VSS}
N 5800 -1440 5800 -1430 {
lab=VDD}
N 6140 -1210 6150 -1220 {
lab=row_n[19]}
N 6150 -1420 6150 -1220 {
lab=row_n[19]}
N 6140 -1430 6150 -1420 {
lab=row_n[19]}
N 6140 -1210 6140 -1190 {
lab=row_n[19]}
N 6140 -1450 6140 -1430 {
lab=row_n[19]}
N 6020 -1350 6030 -1360 {
lab=col_n[1]}
N 6030 -1360 6230 -1360 {
lab=col_n[1]}
N 6230 -1360 6240 -1350 {
lab=col_n[1]}
N 6020 -1330 6030 -1340 {
lab=colon_n[1]}
N 6030 -1340 6230 -1340 {
lab=colon_n[1]}
N 6230 -1340 6240 -1330 {
lab=colon_n[1]}
N 6020 -1310 6030 -1320 {
lab=#net3}
N 6030 -1320 6230 -1320 {
lab=#net3}
N 6230 -1320 6240 -1310 {
lab=#net3}
N 6020 -1290 6030 -1300 {
lab=#net4}
N 6030 -1300 6230 -1300 {
lab=#net4}
N 6230 -1300 6240 -1290 {
lab=#net4}
N 6080 -1450 6080 -1430 {
lab=vcom}
N 6120 -1450 6120 -1430 {
lab=ctop}
N 6000 -1350 6020 -1350 {
lab=col_n[1]}
N 6000 -1330 6020 -1330 {
lab=colon_n[1]}
N 6000 -1310 6020 -1310 {
lab=#net3}
N 6000 -1290 6020 -1290 {
lab=#net4}
N 6240 -1290 6260 -1290 {
lab=#net4}
N 6240 -1310 6260 -1310 {
lab=#net3}
N 6240 -1330 6260 -1330 {
lab=colon_n[1]}
N 6240 -1350 6260 -1350 {
lab=col_n[1]}
N 6060 -1210 6060 -1200 {
lab=VSS}
N 6060 -1440 6060 -1430 {
lab=VDD}
N 6400 -1210 6410 -1220 {
lab=row_n[20]}
N 6410 -1420 6410 -1220 {
lab=row_n[20]}
N 6400 -1430 6410 -1420 {
lab=row_n[20]}
N 6400 -1210 6400 -1190 {
lab=row_n[20]}
N 6400 -1450 6400 -1430 {
lab=row_n[20]}
N 6280 -1350 6290 -1360 {
lab=col_n[1]}
N 6290 -1360 6490 -1360 {
lab=col_n[1]}
N 6490 -1360 6500 -1350 {
lab=col_n[1]}
N 6280 -1330 6290 -1340 {
lab=colon_n[1]}
N 6290 -1340 6490 -1340 {
lab=colon_n[1]}
N 6490 -1340 6500 -1330 {
lab=colon_n[1]}
N 6280 -1310 6290 -1320 {
lab=#net3}
N 6290 -1320 6490 -1320 {
lab=#net3}
N 6490 -1320 6500 -1310 {
lab=#net3}
N 6280 -1290 6290 -1300 {
lab=#net4}
N 6290 -1300 6490 -1300 {
lab=#net4}
N 6490 -1300 6500 -1290 {
lab=#net4}
N 6340 -1450 6340 -1430 {
lab=vcom}
N 6380 -1450 6380 -1430 {
lab=ctop}
N 6260 -1350 6280 -1350 {
lab=col_n[1]}
N 6260 -1330 6280 -1330 {
lab=colon_n[1]}
N 6260 -1310 6280 -1310 {
lab=#net3}
N 6260 -1290 6280 -1290 {
lab=#net4}
N 6500 -1290 6520 -1290 {
lab=#net4}
N 6500 -1310 6520 -1310 {
lab=#net3}
N 6500 -1330 6520 -1330 {
lab=colon_n[1]}
N 6500 -1350 6520 -1350 {
lab=col_n[1]}
N 6320 -1210 6320 -1200 {
lab=VSS}
N 6320 -1440 6320 -1430 {
lab=VDD}
N 6660 -1210 6670 -1220 {
lab=row_n[21]}
N 6670 -1420 6670 -1220 {
lab=row_n[21]}
N 6660 -1430 6670 -1420 {
lab=row_n[21]}
N 6660 -1210 6660 -1190 {
lab=row_n[21]}
N 6660 -1450 6660 -1430 {
lab=row_n[21]}
N 6540 -1350 6550 -1360 {
lab=col_n[1]}
N 6550 -1360 6750 -1360 {
lab=col_n[1]}
N 6750 -1360 6760 -1350 {
lab=col_n[1]}
N 6540 -1330 6550 -1340 {
lab=colon_n[1]}
N 6550 -1340 6750 -1340 {
lab=colon_n[1]}
N 6750 -1340 6760 -1330 {
lab=colon_n[1]}
N 6540 -1310 6550 -1320 {
lab=#net3}
N 6550 -1320 6750 -1320 {
lab=#net3}
N 6750 -1320 6760 -1310 {
lab=#net3}
N 6540 -1290 6550 -1300 {
lab=#net4}
N 6550 -1300 6750 -1300 {
lab=#net4}
N 6750 -1300 6760 -1290 {
lab=#net4}
N 6600 -1450 6600 -1430 {
lab=vcom}
N 6640 -1450 6640 -1430 {
lab=ctop}
N 6520 -1350 6540 -1350 {
lab=col_n[1]}
N 6520 -1330 6540 -1330 {
lab=colon_n[1]}
N 6520 -1310 6540 -1310 {
lab=#net3}
N 6520 -1290 6540 -1290 {
lab=#net4}
N 6760 -1290 6780 -1290 {
lab=#net4}
N 6760 -1310 6780 -1310 {
lab=#net3}
N 6760 -1330 6780 -1330 {
lab=colon_n[1]}
N 6760 -1350 6780 -1350 {
lab=col_n[1]}
N 6580 -1210 6580 -1200 {
lab=VSS}
N 6580 -1440 6580 -1430 {
lab=VDD}
N 6920 -1210 6930 -1220 {
lab=row_n[22]}
N 6930 -1420 6930 -1220 {
lab=row_n[22]}
N 6920 -1430 6930 -1420 {
lab=row_n[22]}
N 6920 -1210 6920 -1190 {
lab=row_n[22]}
N 6920 -1450 6920 -1430 {
lab=row_n[22]}
N 6800 -1350 6810 -1360 {
lab=col_n[1]}
N 6810 -1360 7010 -1360 {
lab=col_n[1]}
N 7010 -1360 7020 -1350 {
lab=col_n[1]}
N 6800 -1330 6810 -1340 {
lab=colon_n[1]}
N 6810 -1340 7010 -1340 {
lab=colon_n[1]}
N 7010 -1340 7020 -1330 {
lab=colon_n[1]}
N 6800 -1310 6810 -1320 {
lab=#net3}
N 6810 -1320 7010 -1320 {
lab=#net3}
N 7010 -1320 7020 -1310 {
lab=#net3}
N 6800 -1290 6810 -1300 {
lab=#net4}
N 6810 -1300 7010 -1300 {
lab=#net4}
N 7010 -1300 7020 -1290 {
lab=#net4}
N 6860 -1450 6860 -1430 {
lab=vcom}
N 6900 -1450 6900 -1430 {
lab=ctop}
N 6780 -1350 6800 -1350 {
lab=col_n[1]}
N 6780 -1330 6800 -1330 {
lab=colon_n[1]}
N 6780 -1310 6800 -1310 {
lab=#net3}
N 6780 -1290 6800 -1290 {
lab=#net4}
N 7020 -1290 7040 -1290 {
lab=#net4}
N 7020 -1310 7040 -1310 {
lab=#net3}
N 7020 -1330 7040 -1330 {
lab=colon_n[1]}
N 7020 -1350 7040 -1350 {
lab=col_n[1]}
N 6840 -1210 6840 -1200 {
lab=VSS}
N 6840 -1440 6840 -1430 {
lab=VDD}
N 7180 -1210 7190 -1220 {
lab=row_n[23]}
N 7190 -1420 7190 -1220 {
lab=row_n[23]}
N 7180 -1430 7190 -1420 {
lab=row_n[23]}
N 7180 -1210 7180 -1190 {
lab=row_n[23]}
N 7180 -1450 7180 -1430 {
lab=row_n[23]}
N 7060 -1350 7070 -1360 {
lab=col_n[1]}
N 7070 -1360 7270 -1360 {
lab=col_n[1]}
N 7270 -1360 7280 -1350 {
lab=col_n[1]}
N 7060 -1330 7070 -1340 {
lab=colon_n[1]}
N 7070 -1340 7270 -1340 {
lab=colon_n[1]}
N 7270 -1340 7280 -1330 {
lab=colon_n[1]}
N 7060 -1310 7070 -1320 {
lab=#net3}
N 7070 -1320 7270 -1320 {
lab=#net3}
N 7270 -1320 7280 -1310 {
lab=#net3}
N 7060 -1290 7070 -1300 {
lab=#net4}
N 7070 -1300 7270 -1300 {
lab=#net4}
N 7270 -1300 7280 -1290 {
lab=#net4}
N 7120 -1450 7120 -1430 {
lab=vcom}
N 7160 -1450 7160 -1430 {
lab=ctop}
N 7040 -1350 7060 -1350 {
lab=col_n[1]}
N 7040 -1330 7060 -1330 {
lab=colon_n[1]}
N 7040 -1310 7060 -1310 {
lab=#net3}
N 7040 -1290 7060 -1290 {
lab=#net4}
N 7280 -1290 7300 -1290 {
lab=#net4}
N 7280 -1310 7300 -1310 {
lab=#net3}
N 7280 -1330 7300 -1330 {
lab=colon_n[1]}
N 7280 -1350 7300 -1350 {
lab=col_n[1]}
N 7100 -1210 7100 -1200 {
lab=VSS}
N 7100 -1440 7100 -1430 {
lab=VDD}
N 7440 -1210 7450 -1220 {
lab=row_n[24]}
N 7450 -1420 7450 -1220 {
lab=row_n[24]}
N 7440 -1430 7450 -1420 {
lab=row_n[24]}
N 7440 -1210 7440 -1190 {
lab=row_n[24]}
N 7440 -1450 7440 -1430 {
lab=row_n[24]}
N 7320 -1350 7330 -1360 {
lab=col_n[1]}
N 7330 -1360 7530 -1360 {
lab=col_n[1]}
N 7530 -1360 7540 -1350 {
lab=col_n[1]}
N 7320 -1330 7330 -1340 {
lab=colon_n[1]}
N 7330 -1340 7530 -1340 {
lab=colon_n[1]}
N 7530 -1340 7540 -1330 {
lab=colon_n[1]}
N 7320 -1310 7330 -1320 {
lab=#net3}
N 7330 -1320 7530 -1320 {
lab=#net3}
N 7530 -1320 7540 -1310 {
lab=#net3}
N 7320 -1290 7330 -1300 {
lab=#net4}
N 7330 -1300 7530 -1300 {
lab=#net4}
N 7530 -1300 7540 -1290 {
lab=#net4}
N 7380 -1450 7380 -1430 {
lab=vcom}
N 7420 -1450 7420 -1430 {
lab=ctop}
N 7300 -1350 7320 -1350 {
lab=col_n[1]}
N 7300 -1330 7320 -1330 {
lab=colon_n[1]}
N 7300 -1310 7320 -1310 {
lab=#net3}
N 7300 -1290 7320 -1290 {
lab=#net4}
N 7540 -1290 7560 -1290 {
lab=#net4}
N 7540 -1310 7560 -1310 {
lab=#net3}
N 7540 -1330 7560 -1330 {
lab=colon_n[1]}
N 7540 -1350 7560 -1350 {
lab=col_n[1]}
N 7360 -1210 7360 -1200 {
lab=VSS}
N 7360 -1440 7360 -1430 {
lab=VDD}
N 7700 -1210 7710 -1220 {
lab=row_n[25]}
N 7710 -1420 7710 -1220 {
lab=row_n[25]}
N 7700 -1430 7710 -1420 {
lab=row_n[25]}
N 7700 -1210 7700 -1190 {
lab=row_n[25]}
N 7700 -1450 7700 -1430 {
lab=row_n[25]}
N 7580 -1350 7590 -1360 {
lab=col_n[1]}
N 7590 -1360 7790 -1360 {
lab=col_n[1]}
N 7790 -1360 7800 -1350 {
lab=col_n[1]}
N 7580 -1330 7590 -1340 {
lab=colon_n[1]}
N 7590 -1340 7790 -1340 {
lab=colon_n[1]}
N 7790 -1340 7800 -1330 {
lab=colon_n[1]}
N 7580 -1310 7590 -1320 {
lab=#net3}
N 7590 -1320 7790 -1320 {
lab=#net3}
N 7790 -1320 7800 -1310 {
lab=#net3}
N 7580 -1290 7590 -1300 {
lab=#net4}
N 7590 -1300 7790 -1300 {
lab=#net4}
N 7790 -1300 7800 -1290 {
lab=#net4}
N 7640 -1450 7640 -1430 {
lab=vcom}
N 7680 -1450 7680 -1430 {
lab=ctop}
N 7560 -1350 7580 -1350 {
lab=col_n[1]}
N 7560 -1330 7580 -1330 {
lab=colon_n[1]}
N 7560 -1310 7580 -1310 {
lab=#net3}
N 7560 -1290 7580 -1290 {
lab=#net4}
N 7800 -1290 7820 -1290 {
lab=#net4}
N 7800 -1310 7820 -1310 {
lab=#net3}
N 7800 -1330 7820 -1330 {
lab=colon_n[1]}
N 7800 -1350 7820 -1350 {
lab=col_n[1]}
N 7620 -1210 7620 -1200 {
lab=VSS}
N 7620 -1440 7620 -1430 {
lab=VDD}
N 7960 -1210 7970 -1220 {
lab=row_n[26]}
N 7970 -1420 7970 -1220 {
lab=row_n[26]}
N 7960 -1430 7970 -1420 {
lab=row_n[26]}
N 7960 -1210 7960 -1190 {
lab=row_n[26]}
N 7960 -1450 7960 -1430 {
lab=row_n[26]}
N 7840 -1350 7850 -1360 {
lab=col_n[1]}
N 7850 -1360 8050 -1360 {
lab=col_n[1]}
N 8050 -1360 8060 -1350 {
lab=col_n[1]}
N 7840 -1330 7850 -1340 {
lab=colon_n[1]}
N 7850 -1340 8050 -1340 {
lab=colon_n[1]}
N 8050 -1340 8060 -1330 {
lab=colon_n[1]}
N 7840 -1310 7850 -1320 {
lab=#net3}
N 7850 -1320 8050 -1320 {
lab=#net3}
N 8050 -1320 8060 -1310 {
lab=#net3}
N 7840 -1290 7850 -1300 {
lab=#net4}
N 7850 -1300 8050 -1300 {
lab=#net4}
N 8050 -1300 8060 -1290 {
lab=#net4}
N 7900 -1450 7900 -1430 {
lab=vcom}
N 7940 -1450 7940 -1430 {
lab=ctop}
N 7820 -1350 7840 -1350 {
lab=col_n[1]}
N 7820 -1330 7840 -1330 {
lab=colon_n[1]}
N 7820 -1310 7840 -1310 {
lab=#net3}
N 7820 -1290 7840 -1290 {
lab=#net4}
N 8060 -1290 8080 -1290 {
lab=#net4}
N 8060 -1310 8080 -1310 {
lab=#net3}
N 8060 -1330 8080 -1330 {
lab=colon_n[1]}
N 8060 -1350 8080 -1350 {
lab=col_n[1]}
N 7880 -1210 7880 -1200 {
lab=VSS}
N 7880 -1440 7880 -1430 {
lab=VDD}
N 8220 -1210 8230 -1220 {
lab=row_n[27]}
N 8230 -1420 8230 -1220 {
lab=row_n[27]}
N 8220 -1430 8230 -1420 {
lab=row_n[27]}
N 8220 -1210 8220 -1190 {
lab=row_n[27]}
N 8220 -1450 8220 -1430 {
lab=row_n[27]}
N 8100 -1350 8110 -1360 {
lab=col_n[1]}
N 8110 -1360 8310 -1360 {
lab=col_n[1]}
N 8310 -1360 8320 -1350 {
lab=col_n[1]}
N 8100 -1330 8110 -1340 {
lab=colon_n[1]}
N 8110 -1340 8310 -1340 {
lab=colon_n[1]}
N 8310 -1340 8320 -1330 {
lab=colon_n[1]}
N 8100 -1310 8110 -1320 {
lab=#net3}
N 8110 -1320 8310 -1320 {
lab=#net3}
N 8310 -1320 8320 -1310 {
lab=#net3}
N 8100 -1290 8110 -1300 {
lab=#net4}
N 8110 -1300 8310 -1300 {
lab=#net4}
N 8310 -1300 8320 -1290 {
lab=#net4}
N 8160 -1450 8160 -1430 {
lab=vcom}
N 8200 -1450 8200 -1430 {
lab=ctop}
N 8080 -1350 8100 -1350 {
lab=col_n[1]}
N 8080 -1330 8100 -1330 {
lab=colon_n[1]}
N 8080 -1310 8100 -1310 {
lab=#net3}
N 8080 -1290 8100 -1290 {
lab=#net4}
N 8320 -1290 8340 -1290 {
lab=#net4}
N 8320 -1310 8340 -1310 {
lab=#net3}
N 8320 -1330 8340 -1330 {
lab=colon_n[1]}
N 8320 -1350 8340 -1350 {
lab=col_n[1]}
N 8140 -1210 8140 -1200 {
lab=VSS}
N 8140 -1440 8140 -1430 {
lab=VDD}
N 8480 -1210 8490 -1220 {
lab=row_n[28]}
N 8490 -1420 8490 -1220 {
lab=row_n[28]}
N 8480 -1430 8490 -1420 {
lab=row_n[28]}
N 8480 -1210 8480 -1190 {
lab=row_n[28]}
N 8480 -1450 8480 -1430 {
lab=row_n[28]}
N 8360 -1350 8370 -1360 {
lab=col_n[1]}
N 8370 -1360 8570 -1360 {
lab=col_n[1]}
N 8570 -1360 8580 -1350 {
lab=col_n[1]}
N 8360 -1330 8370 -1340 {
lab=colon_n[1]}
N 8370 -1340 8570 -1340 {
lab=colon_n[1]}
N 8570 -1340 8580 -1330 {
lab=colon_n[1]}
N 8360 -1310 8370 -1320 {
lab=#net3}
N 8370 -1320 8570 -1320 {
lab=#net3}
N 8570 -1320 8580 -1310 {
lab=#net3}
N 8360 -1290 8370 -1300 {
lab=#net4}
N 8370 -1300 8570 -1300 {
lab=#net4}
N 8570 -1300 8580 -1290 {
lab=#net4}
N 8420 -1450 8420 -1430 {
lab=vcom}
N 8460 -1450 8460 -1430 {
lab=ctop}
N 8340 -1350 8360 -1350 {
lab=col_n[1]}
N 8340 -1330 8360 -1330 {
lab=colon_n[1]}
N 8340 -1310 8360 -1310 {
lab=#net3}
N 8340 -1290 8360 -1290 {
lab=#net4}
N 8580 -1290 8600 -1290 {
lab=#net4}
N 8580 -1310 8600 -1310 {
lab=#net3}
N 8580 -1330 8600 -1330 {
lab=colon_n[1]}
N 8580 -1350 8600 -1350 {
lab=col_n[1]}
N 8400 -1210 8400 -1200 {
lab=VSS}
N 8400 -1440 8400 -1430 {
lab=VDD}
N 8740 -1210 8750 -1220 {
lab=row_n[29]}
N 8750 -1420 8750 -1220 {
lab=row_n[29]}
N 8740 -1430 8750 -1420 {
lab=row_n[29]}
N 8740 -1210 8740 -1190 {
lab=row_n[29]}
N 8740 -1450 8740 -1430 {
lab=row_n[29]}
N 8620 -1350 8630 -1360 {
lab=col_n[1]}
N 8630 -1360 8830 -1360 {
lab=col_n[1]}
N 8830 -1360 8840 -1350 {
lab=col_n[1]}
N 8620 -1330 8630 -1340 {
lab=colon_n[1]}
N 8630 -1340 8830 -1340 {
lab=colon_n[1]}
N 8830 -1340 8840 -1330 {
lab=colon_n[1]}
N 8620 -1310 8630 -1320 {
lab=#net3}
N 8630 -1320 8830 -1320 {
lab=#net3}
N 8830 -1320 8840 -1310 {
lab=#net3}
N 8620 -1290 8630 -1300 {
lab=#net4}
N 8630 -1300 8830 -1300 {
lab=#net4}
N 8830 -1300 8840 -1290 {
lab=#net4}
N 8680 -1450 8680 -1430 {
lab=vcom}
N 8720 -1450 8720 -1430 {
lab=ctop}
N 8600 -1350 8620 -1350 {
lab=col_n[1]}
N 8600 -1330 8620 -1330 {
lab=colon_n[1]}
N 8600 -1310 8620 -1310 {
lab=#net3}
N 8600 -1290 8620 -1290 {
lab=#net4}
N 8840 -1290 8860 -1290 {
lab=#net4}
N 8840 -1310 8860 -1310 {
lab=#net3}
N 8840 -1330 8860 -1330 {
lab=colon_n[1]}
N 8840 -1350 8860 -1350 {
lab=col_n[1]}
N 8660 -1210 8660 -1200 {
lab=VSS}
N 8660 -1440 8660 -1430 {
lab=VDD}
N 9000 -1210 9010 -1220 {
lab=row_n[30]}
N 9010 -1420 9010 -1220 {
lab=row_n[30]}
N 9000 -1430 9010 -1420 {
lab=row_n[30]}
N 9000 -1210 9000 -1190 {
lab=row_n[30]}
N 9000 -1450 9000 -1430 {
lab=row_n[30]}
N 8880 -1350 8890 -1360 {
lab=col_n[1]}
N 8890 -1360 9090 -1360 {
lab=col_n[1]}
N 9090 -1360 9100 -1350 {
lab=col_n[1]}
N 8880 -1330 8890 -1340 {
lab=colon_n[1]}
N 8890 -1340 9090 -1340 {
lab=colon_n[1]}
N 9090 -1340 9100 -1330 {
lab=colon_n[1]}
N 8880 -1310 8890 -1320 {
lab=#net3}
N 8890 -1320 9090 -1320 {
lab=#net3}
N 9090 -1320 9100 -1310 {
lab=#net3}
N 8880 -1290 8890 -1300 {
lab=#net4}
N 8890 -1300 9090 -1300 {
lab=#net4}
N 9090 -1300 9100 -1290 {
lab=#net4}
N 8940 -1450 8940 -1430 {
lab=vcom}
N 8980 -1450 8980 -1430 {
lab=ctop}
N 8860 -1350 8880 -1350 {
lab=col_n[1]}
N 8860 -1330 8880 -1330 {
lab=colon_n[1]}
N 8860 -1310 8880 -1310 {
lab=#net3}
N 8860 -1290 8880 -1290 {
lab=#net4}
N 9100 -1290 9120 -1290 {
lab=#net4}
N 9100 -1310 9120 -1310 {
lab=#net3}
N 9100 -1330 9120 -1330 {
lab=colon_n[1]}
N 9100 -1350 9120 -1350 {
lab=col_n[1]}
N 8920 -1210 8920 -1200 {
lab=VSS}
N 8920 -1440 8920 -1430 {
lab=VDD}
N 9260 -1210 9270 -1220 {
lab=row_n[31]}
N 9270 -1420 9270 -1220 {
lab=row_n[31]}
N 9260 -1430 9270 -1420 {
lab=row_n[31]}
N 9260 -1210 9260 -1190 {
lab=row_n[31]}
N 9260 -1450 9260 -1430 {
lab=row_n[31]}
N 9140 -1350 9150 -1360 {
lab=col_n[1]}
N 9150 -1360 9350 -1360 {
lab=col_n[1]}
N 9350 -1360 9360 -1350 {
lab=col_n[1]}
N 9140 -1330 9150 -1340 {
lab=colon_n[1]}
N 9150 -1340 9350 -1340 {
lab=colon_n[1]}
N 9350 -1340 9360 -1330 {
lab=colon_n[1]}
N 9140 -1310 9150 -1320 {
lab=#net3}
N 9150 -1320 9350 -1320 {
lab=#net3}
N 9350 -1320 9360 -1310 {
lab=#net3}
N 9140 -1290 9150 -1300 {
lab=#net4}
N 9150 -1300 9350 -1300 {
lab=#net4}
N 9350 -1300 9360 -1290 {
lab=#net4}
N 9200 -1450 9200 -1430 {
lab=vcom}
N 9240 -1450 9240 -1430 {
lab=ctop}
N 9120 -1350 9140 -1350 {
lab=col_n[1]}
N 9120 -1330 9140 -1330 {
lab=colon_n[1]}
N 9120 -1310 9140 -1310 {
lab=#net3}
N 9120 -1290 9140 -1290 {
lab=#net4}
N 9360 -1290 9380 -1290 {
lab=#net4}
N 9360 -1310 9380 -1310 {
lab=#net3}
N 9360 -1330 9380 -1330 {
lab=colon_n[1]}
N 9360 -1350 9380 -1350 {
lab=col_n[1]}
N 9180 -1210 9180 -1200 {
lab=VSS}
N 9180 -1440 9180 -1430 {
lab=VDD}
N 1200 -1470 1210 -1480 {
lab=row_n[0]}
N 1210 -1680 1210 -1480 {
lab=row_n[0]}
N 1200 -1690 1210 -1680 {
lab=row_n[0]}
N 1200 -1470 1200 -1450 {
lab=row_n[0]}
N 1200 -1710 1200 -1690 {
lab=row_n[0]}
N 1080 -1610 1090 -1620 {
lab=col_n[2]}
N 1090 -1620 1290 -1620 {
lab=col_n[2]}
N 1290 -1620 1300 -1610 {
lab=col_n[2]}
N 1080 -1590 1090 -1600 {
lab=colon_n[2]}
N 1090 -1600 1290 -1600 {
lab=colon_n[2]}
N 1290 -1600 1300 -1590 {
lab=colon_n[2]}
N 1080 -1570 1090 -1580 {
lab=#net5}
N 1090 -1580 1290 -1580 {
lab=#net5}
N 1290 -1580 1300 -1570 {
lab=#net5}
N 1080 -1550 1090 -1560 {
lab=#net6}
N 1090 -1560 1290 -1560 {
lab=#net6}
N 1290 -1560 1300 -1550 {
lab=#net6}
N 1140 -1710 1140 -1690 {
lab=vcom}
N 1180 -1710 1180 -1690 {
lab=ctop}
N 1060 -1610 1080 -1610 {
lab=col_n[2]}
N 1060 -1590 1080 -1590 {
lab=colon_n[2]}
N 1060 -1570 1080 -1570 {
lab=#net5}
N 1060 -1550 1080 -1550 {
lab=#net6}
N 1300 -1550 1320 -1550 {
lab=#net6}
N 1300 -1570 1320 -1570 {
lab=#net5}
N 1300 -1590 1320 -1590 {
lab=colon_n[2]}
N 1300 -1610 1320 -1610 {
lab=col_n[2]}
N 1120 -1470 1120 -1460 {
lab=VSS}
N 1120 -1700 1120 -1690 {
lab=VDD}
N 1460 -1470 1470 -1480 {
lab=row_n[1]}
N 1470 -1680 1470 -1480 {
lab=row_n[1]}
N 1460 -1690 1470 -1680 {
lab=row_n[1]}
N 1460 -1470 1460 -1450 {
lab=row_n[1]}
N 1460 -1710 1460 -1690 {
lab=row_n[1]}
N 1340 -1610 1350 -1620 {
lab=col_n[2]}
N 1350 -1620 1550 -1620 {
lab=col_n[2]}
N 1550 -1620 1560 -1610 {
lab=col_n[2]}
N 1340 -1590 1350 -1600 {
lab=colon_n[2]}
N 1350 -1600 1550 -1600 {
lab=colon_n[2]}
N 1550 -1600 1560 -1590 {
lab=colon_n[2]}
N 1340 -1570 1350 -1580 {
lab=#net5}
N 1350 -1580 1550 -1580 {
lab=#net5}
N 1550 -1580 1560 -1570 {
lab=#net5}
N 1340 -1550 1350 -1560 {
lab=#net6}
N 1350 -1560 1550 -1560 {
lab=#net6}
N 1550 -1560 1560 -1550 {
lab=#net6}
N 1400 -1710 1400 -1690 {
lab=vcom}
N 1440 -1710 1440 -1690 {
lab=ctop}
N 1320 -1610 1340 -1610 {
lab=col_n[2]}
N 1320 -1590 1340 -1590 {
lab=colon_n[2]}
N 1320 -1570 1340 -1570 {
lab=#net5}
N 1320 -1550 1340 -1550 {
lab=#net6}
N 1560 -1550 1580 -1550 {
lab=#net6}
N 1560 -1570 1580 -1570 {
lab=#net5}
N 1560 -1590 1580 -1590 {
lab=colon_n[2]}
N 1560 -1610 1580 -1610 {
lab=col_n[2]}
N 1380 -1470 1380 -1460 {
lab=VSS}
N 1380 -1700 1380 -1690 {
lab=VDD}
N 1720 -1470 1730 -1480 {
lab=row_n[2]}
N 1730 -1680 1730 -1480 {
lab=row_n[2]}
N 1720 -1690 1730 -1680 {
lab=row_n[2]}
N 1720 -1470 1720 -1450 {
lab=row_n[2]}
N 1720 -1710 1720 -1690 {
lab=row_n[2]}
N 1600 -1610 1610 -1620 {
lab=col_n[2]}
N 1610 -1620 1810 -1620 {
lab=col_n[2]}
N 1810 -1620 1820 -1610 {
lab=col_n[2]}
N 1600 -1590 1610 -1600 {
lab=colon_n[2]}
N 1610 -1600 1810 -1600 {
lab=colon_n[2]}
N 1810 -1600 1820 -1590 {
lab=colon_n[2]}
N 1600 -1570 1610 -1580 {
lab=#net5}
N 1610 -1580 1810 -1580 {
lab=#net5}
N 1810 -1580 1820 -1570 {
lab=#net5}
N 1600 -1550 1610 -1560 {
lab=#net6}
N 1610 -1560 1810 -1560 {
lab=#net6}
N 1810 -1560 1820 -1550 {
lab=#net6}
N 1660 -1710 1660 -1690 {
lab=vcom}
N 1700 -1710 1700 -1690 {
lab=ctop}
N 1580 -1610 1600 -1610 {
lab=col_n[2]}
N 1580 -1590 1600 -1590 {
lab=colon_n[2]}
N 1580 -1570 1600 -1570 {
lab=#net5}
N 1580 -1550 1600 -1550 {
lab=#net6}
N 1820 -1550 1840 -1550 {
lab=#net6}
N 1820 -1570 1840 -1570 {
lab=#net5}
N 1820 -1590 1840 -1590 {
lab=colon_n[2]}
N 1820 -1610 1840 -1610 {
lab=col_n[2]}
N 1640 -1470 1640 -1460 {
lab=VSS}
N 1640 -1700 1640 -1690 {
lab=VDD}
N 1980 -1470 1990 -1480 {
lab=row_n[3]}
N 1990 -1680 1990 -1480 {
lab=row_n[3]}
N 1980 -1690 1990 -1680 {
lab=row_n[3]}
N 1980 -1470 1980 -1450 {
lab=row_n[3]}
N 1980 -1710 1980 -1690 {
lab=row_n[3]}
N 1860 -1610 1870 -1620 {
lab=col_n[2]}
N 1870 -1620 2070 -1620 {
lab=col_n[2]}
N 2070 -1620 2080 -1610 {
lab=col_n[2]}
N 1860 -1590 1870 -1600 {
lab=colon_n[2]}
N 1870 -1600 2070 -1600 {
lab=colon_n[2]}
N 2070 -1600 2080 -1590 {
lab=colon_n[2]}
N 1860 -1570 1870 -1580 {
lab=#net5}
N 1870 -1580 2070 -1580 {
lab=#net5}
N 2070 -1580 2080 -1570 {
lab=#net5}
N 1860 -1550 1870 -1560 {
lab=#net6}
N 1870 -1560 2070 -1560 {
lab=#net6}
N 2070 -1560 2080 -1550 {
lab=#net6}
N 1920 -1710 1920 -1690 {
lab=vcom}
N 1960 -1710 1960 -1690 {
lab=ctop}
N 1840 -1610 1860 -1610 {
lab=col_n[2]}
N 1840 -1590 1860 -1590 {
lab=colon_n[2]}
N 1840 -1570 1860 -1570 {
lab=#net5}
N 1840 -1550 1860 -1550 {
lab=#net6}
N 2080 -1550 2100 -1550 {
lab=#net6}
N 2080 -1570 2100 -1570 {
lab=#net5}
N 2080 -1590 2100 -1590 {
lab=colon_n[2]}
N 2080 -1610 2100 -1610 {
lab=col_n[2]}
N 1900 -1470 1900 -1460 {
lab=VSS}
N 1900 -1700 1900 -1690 {
lab=VDD}
N 2240 -1470 2250 -1480 {
lab=row_n[4]}
N 2250 -1680 2250 -1480 {
lab=row_n[4]}
N 2240 -1690 2250 -1680 {
lab=row_n[4]}
N 2240 -1470 2240 -1450 {
lab=row_n[4]}
N 2240 -1710 2240 -1690 {
lab=row_n[4]}
N 2120 -1610 2130 -1620 {
lab=col_n[2]}
N 2130 -1620 2330 -1620 {
lab=col_n[2]}
N 2330 -1620 2340 -1610 {
lab=col_n[2]}
N 2120 -1590 2130 -1600 {
lab=colon_n[2]}
N 2130 -1600 2330 -1600 {
lab=colon_n[2]}
N 2330 -1600 2340 -1590 {
lab=colon_n[2]}
N 2120 -1570 2130 -1580 {
lab=#net5}
N 2130 -1580 2330 -1580 {
lab=#net5}
N 2330 -1580 2340 -1570 {
lab=#net5}
N 2120 -1550 2130 -1560 {
lab=#net6}
N 2130 -1560 2330 -1560 {
lab=#net6}
N 2330 -1560 2340 -1550 {
lab=#net6}
N 2180 -1710 2180 -1690 {
lab=vcom}
N 2220 -1710 2220 -1690 {
lab=ctop}
N 2100 -1610 2120 -1610 {
lab=col_n[2]}
N 2100 -1590 2120 -1590 {
lab=colon_n[2]}
N 2100 -1570 2120 -1570 {
lab=#net5}
N 2100 -1550 2120 -1550 {
lab=#net6}
N 2340 -1550 2360 -1550 {
lab=#net6}
N 2340 -1570 2360 -1570 {
lab=#net5}
N 2340 -1590 2360 -1590 {
lab=colon_n[2]}
N 2340 -1610 2360 -1610 {
lab=col_n[2]}
N 2160 -1470 2160 -1460 {
lab=VSS}
N 2160 -1700 2160 -1690 {
lab=VDD}
N 2500 -1470 2510 -1480 {
lab=row_n[5]}
N 2510 -1680 2510 -1480 {
lab=row_n[5]}
N 2500 -1690 2510 -1680 {
lab=row_n[5]}
N 2500 -1470 2500 -1450 {
lab=row_n[5]}
N 2500 -1710 2500 -1690 {
lab=row_n[5]}
N 2380 -1610 2390 -1620 {
lab=col_n[2]}
N 2390 -1620 2590 -1620 {
lab=col_n[2]}
N 2590 -1620 2600 -1610 {
lab=col_n[2]}
N 2380 -1590 2390 -1600 {
lab=colon_n[2]}
N 2390 -1600 2590 -1600 {
lab=colon_n[2]}
N 2590 -1600 2600 -1590 {
lab=colon_n[2]}
N 2380 -1570 2390 -1580 {
lab=#net5}
N 2390 -1580 2590 -1580 {
lab=#net5}
N 2590 -1580 2600 -1570 {
lab=#net5}
N 2380 -1550 2390 -1560 {
lab=#net6}
N 2390 -1560 2590 -1560 {
lab=#net6}
N 2590 -1560 2600 -1550 {
lab=#net6}
N 2440 -1710 2440 -1690 {
lab=vcom}
N 2480 -1710 2480 -1690 {
lab=ctop}
N 2360 -1610 2380 -1610 {
lab=col_n[2]}
N 2360 -1590 2380 -1590 {
lab=colon_n[2]}
N 2360 -1570 2380 -1570 {
lab=#net5}
N 2360 -1550 2380 -1550 {
lab=#net6}
N 2600 -1550 2620 -1550 {
lab=#net6}
N 2600 -1570 2620 -1570 {
lab=#net5}
N 2600 -1590 2620 -1590 {
lab=colon_n[2]}
N 2600 -1610 2620 -1610 {
lab=col_n[2]}
N 2420 -1470 2420 -1460 {
lab=VSS}
N 2420 -1700 2420 -1690 {
lab=VDD}
N 2760 -1470 2770 -1480 {
lab=row_n[6]}
N 2770 -1680 2770 -1480 {
lab=row_n[6]}
N 2760 -1690 2770 -1680 {
lab=row_n[6]}
N 2760 -1470 2760 -1450 {
lab=row_n[6]}
N 2760 -1710 2760 -1690 {
lab=row_n[6]}
N 2640 -1610 2650 -1620 {
lab=col_n[2]}
N 2650 -1620 2850 -1620 {
lab=col_n[2]}
N 2850 -1620 2860 -1610 {
lab=col_n[2]}
N 2640 -1590 2650 -1600 {
lab=colon_n[2]}
N 2650 -1600 2850 -1600 {
lab=colon_n[2]}
N 2850 -1600 2860 -1590 {
lab=colon_n[2]}
N 2640 -1570 2650 -1580 {
lab=#net5}
N 2650 -1580 2850 -1580 {
lab=#net5}
N 2850 -1580 2860 -1570 {
lab=#net5}
N 2640 -1550 2650 -1560 {
lab=#net6}
N 2650 -1560 2850 -1560 {
lab=#net6}
N 2850 -1560 2860 -1550 {
lab=#net6}
N 2700 -1710 2700 -1690 {
lab=vcom}
N 2740 -1710 2740 -1690 {
lab=ctop}
N 2620 -1610 2640 -1610 {
lab=col_n[2]}
N 2620 -1590 2640 -1590 {
lab=colon_n[2]}
N 2620 -1570 2640 -1570 {
lab=#net5}
N 2620 -1550 2640 -1550 {
lab=#net6}
N 2860 -1550 2880 -1550 {
lab=#net6}
N 2860 -1570 2880 -1570 {
lab=#net5}
N 2860 -1590 2880 -1590 {
lab=colon_n[2]}
N 2860 -1610 2880 -1610 {
lab=col_n[2]}
N 2680 -1470 2680 -1460 {
lab=VSS}
N 2680 -1700 2680 -1690 {
lab=VDD}
N 3020 -1470 3030 -1480 {
lab=row_n[7]}
N 3030 -1680 3030 -1480 {
lab=row_n[7]}
N 3020 -1690 3030 -1680 {
lab=row_n[7]}
N 3020 -1470 3020 -1450 {
lab=row_n[7]}
N 3020 -1710 3020 -1690 {
lab=row_n[7]}
N 2900 -1610 2910 -1620 {
lab=col_n[2]}
N 2910 -1620 3110 -1620 {
lab=col_n[2]}
N 3110 -1620 3120 -1610 {
lab=col_n[2]}
N 2900 -1590 2910 -1600 {
lab=colon_n[2]}
N 2910 -1600 3110 -1600 {
lab=colon_n[2]}
N 3110 -1600 3120 -1590 {
lab=colon_n[2]}
N 2900 -1570 2910 -1580 {
lab=#net5}
N 2910 -1580 3110 -1580 {
lab=#net5}
N 3110 -1580 3120 -1570 {
lab=#net5}
N 2900 -1550 2910 -1560 {
lab=#net6}
N 2910 -1560 3110 -1560 {
lab=#net6}
N 3110 -1560 3120 -1550 {
lab=#net6}
N 2960 -1710 2960 -1690 {
lab=vcom}
N 3000 -1710 3000 -1690 {
lab=ctop}
N 2880 -1610 2900 -1610 {
lab=col_n[2]}
N 2880 -1590 2900 -1590 {
lab=colon_n[2]}
N 2880 -1570 2900 -1570 {
lab=#net5}
N 2880 -1550 2900 -1550 {
lab=#net6}
N 3120 -1550 3140 -1550 {
lab=#net6}
N 3120 -1570 3140 -1570 {
lab=#net5}
N 3120 -1590 3140 -1590 {
lab=colon_n[2]}
N 3120 -1610 3140 -1610 {
lab=col_n[2]}
N 2940 -1470 2940 -1460 {
lab=VSS}
N 2940 -1700 2940 -1690 {
lab=VDD}
N 3280 -1470 3290 -1480 {
lab=row_n[8]}
N 3290 -1680 3290 -1480 {
lab=row_n[8]}
N 3280 -1690 3290 -1680 {
lab=row_n[8]}
N 3280 -1470 3280 -1450 {
lab=row_n[8]}
N 3280 -1710 3280 -1690 {
lab=row_n[8]}
N 3160 -1610 3170 -1620 {
lab=col_n[2]}
N 3170 -1620 3370 -1620 {
lab=col_n[2]}
N 3370 -1620 3380 -1610 {
lab=col_n[2]}
N 3160 -1590 3170 -1600 {
lab=colon_n[2]}
N 3170 -1600 3370 -1600 {
lab=colon_n[2]}
N 3370 -1600 3380 -1590 {
lab=colon_n[2]}
N 3160 -1570 3170 -1580 {
lab=#net5}
N 3170 -1580 3370 -1580 {
lab=#net5}
N 3370 -1580 3380 -1570 {
lab=#net5}
N 3160 -1550 3170 -1560 {
lab=#net6}
N 3170 -1560 3370 -1560 {
lab=#net6}
N 3370 -1560 3380 -1550 {
lab=#net6}
N 3220 -1710 3220 -1690 {
lab=vcom}
N 3260 -1710 3260 -1690 {
lab=ctop}
N 3140 -1610 3160 -1610 {
lab=col_n[2]}
N 3140 -1590 3160 -1590 {
lab=colon_n[2]}
N 3140 -1570 3160 -1570 {
lab=#net5}
N 3140 -1550 3160 -1550 {
lab=#net6}
N 3380 -1550 3400 -1550 {
lab=#net6}
N 3380 -1570 3400 -1570 {
lab=#net5}
N 3380 -1590 3400 -1590 {
lab=colon_n[2]}
N 3380 -1610 3400 -1610 {
lab=col_n[2]}
N 3200 -1470 3200 -1460 {
lab=VSS}
N 3200 -1700 3200 -1690 {
lab=VDD}
N 3540 -1470 3550 -1480 {
lab=row_n[9]}
N 3550 -1680 3550 -1480 {
lab=row_n[9]}
N 3540 -1690 3550 -1680 {
lab=row_n[9]}
N 3540 -1470 3540 -1450 {
lab=row_n[9]}
N 3540 -1710 3540 -1690 {
lab=row_n[9]}
N 3420 -1610 3430 -1620 {
lab=col_n[2]}
N 3430 -1620 3630 -1620 {
lab=col_n[2]}
N 3630 -1620 3640 -1610 {
lab=col_n[2]}
N 3420 -1590 3430 -1600 {
lab=colon_n[2]}
N 3430 -1600 3630 -1600 {
lab=colon_n[2]}
N 3630 -1600 3640 -1590 {
lab=colon_n[2]}
N 3420 -1570 3430 -1580 {
lab=#net5}
N 3430 -1580 3630 -1580 {
lab=#net5}
N 3630 -1580 3640 -1570 {
lab=#net5}
N 3420 -1550 3430 -1560 {
lab=#net6}
N 3430 -1560 3630 -1560 {
lab=#net6}
N 3630 -1560 3640 -1550 {
lab=#net6}
N 3480 -1710 3480 -1690 {
lab=vcom}
N 3520 -1710 3520 -1690 {
lab=ctop}
N 3400 -1610 3420 -1610 {
lab=col_n[2]}
N 3400 -1590 3420 -1590 {
lab=colon_n[2]}
N 3400 -1570 3420 -1570 {
lab=#net5}
N 3400 -1550 3420 -1550 {
lab=#net6}
N 3640 -1550 3660 -1550 {
lab=#net6}
N 3640 -1570 3660 -1570 {
lab=#net5}
N 3640 -1590 3660 -1590 {
lab=colon_n[2]}
N 3640 -1610 3660 -1610 {
lab=col_n[2]}
N 3460 -1470 3460 -1460 {
lab=VSS}
N 3460 -1700 3460 -1690 {
lab=VDD}
N 3800 -1470 3810 -1480 {
lab=row_n[10]}
N 3810 -1680 3810 -1480 {
lab=row_n[10]}
N 3800 -1690 3810 -1680 {
lab=row_n[10]}
N 3800 -1470 3800 -1450 {
lab=row_n[10]}
N 3800 -1710 3800 -1690 {
lab=row_n[10]}
N 3680 -1610 3690 -1620 {
lab=col_n[2]}
N 3690 -1620 3890 -1620 {
lab=col_n[2]}
N 3890 -1620 3900 -1610 {
lab=col_n[2]}
N 3680 -1590 3690 -1600 {
lab=colon_n[2]}
N 3690 -1600 3890 -1600 {
lab=colon_n[2]}
N 3890 -1600 3900 -1590 {
lab=colon_n[2]}
N 3680 -1570 3690 -1580 {
lab=#net5}
N 3690 -1580 3890 -1580 {
lab=#net5}
N 3890 -1580 3900 -1570 {
lab=#net5}
N 3680 -1550 3690 -1560 {
lab=#net6}
N 3690 -1560 3890 -1560 {
lab=#net6}
N 3890 -1560 3900 -1550 {
lab=#net6}
N 3740 -1710 3740 -1690 {
lab=vcom}
N 3780 -1710 3780 -1690 {
lab=ctop}
N 3660 -1610 3680 -1610 {
lab=col_n[2]}
N 3660 -1590 3680 -1590 {
lab=colon_n[2]}
N 3660 -1570 3680 -1570 {
lab=#net5}
N 3660 -1550 3680 -1550 {
lab=#net6}
N 3900 -1550 3920 -1550 {
lab=#net6}
N 3900 -1570 3920 -1570 {
lab=#net5}
N 3900 -1590 3920 -1590 {
lab=colon_n[2]}
N 3900 -1610 3920 -1610 {
lab=col_n[2]}
N 3720 -1470 3720 -1460 {
lab=VSS}
N 3720 -1700 3720 -1690 {
lab=VDD}
N 4060 -1470 4070 -1480 {
lab=row_n[11]}
N 4070 -1680 4070 -1480 {
lab=row_n[11]}
N 4060 -1690 4070 -1680 {
lab=row_n[11]}
N 4060 -1470 4060 -1450 {
lab=row_n[11]}
N 4060 -1710 4060 -1690 {
lab=row_n[11]}
N 3940 -1610 3950 -1620 {
lab=col_n[2]}
N 3950 -1620 4150 -1620 {
lab=col_n[2]}
N 4150 -1620 4160 -1610 {
lab=col_n[2]}
N 3940 -1590 3950 -1600 {
lab=colon_n[2]}
N 3950 -1600 4150 -1600 {
lab=colon_n[2]}
N 4150 -1600 4160 -1590 {
lab=colon_n[2]}
N 3940 -1570 3950 -1580 {
lab=#net5}
N 3950 -1580 4150 -1580 {
lab=#net5}
N 4150 -1580 4160 -1570 {
lab=#net5}
N 3940 -1550 3950 -1560 {
lab=#net6}
N 3950 -1560 4150 -1560 {
lab=#net6}
N 4150 -1560 4160 -1550 {
lab=#net6}
N 4000 -1710 4000 -1690 {
lab=vcom}
N 4040 -1710 4040 -1690 {
lab=ctop}
N 3920 -1610 3940 -1610 {
lab=col_n[2]}
N 3920 -1590 3940 -1590 {
lab=colon_n[2]}
N 3920 -1570 3940 -1570 {
lab=#net5}
N 3920 -1550 3940 -1550 {
lab=#net6}
N 4160 -1550 4180 -1550 {
lab=#net6}
N 4160 -1570 4180 -1570 {
lab=#net5}
N 4160 -1590 4180 -1590 {
lab=colon_n[2]}
N 4160 -1610 4180 -1610 {
lab=col_n[2]}
N 3980 -1470 3980 -1460 {
lab=VSS}
N 3980 -1700 3980 -1690 {
lab=VDD}
N 4320 -1470 4330 -1480 {
lab=row_n[12]}
N 4330 -1680 4330 -1480 {
lab=row_n[12]}
N 4320 -1690 4330 -1680 {
lab=row_n[12]}
N 4320 -1470 4320 -1450 {
lab=row_n[12]}
N 4320 -1710 4320 -1690 {
lab=row_n[12]}
N 4200 -1610 4210 -1620 {
lab=col_n[2]}
N 4210 -1620 4410 -1620 {
lab=col_n[2]}
N 4410 -1620 4420 -1610 {
lab=col_n[2]}
N 4200 -1590 4210 -1600 {
lab=colon_n[2]}
N 4210 -1600 4410 -1600 {
lab=colon_n[2]}
N 4410 -1600 4420 -1590 {
lab=colon_n[2]}
N 4200 -1570 4210 -1580 {
lab=#net5}
N 4210 -1580 4410 -1580 {
lab=#net5}
N 4410 -1580 4420 -1570 {
lab=#net5}
N 4200 -1550 4210 -1560 {
lab=#net6}
N 4210 -1560 4410 -1560 {
lab=#net6}
N 4410 -1560 4420 -1550 {
lab=#net6}
N 4260 -1710 4260 -1690 {
lab=vcom}
N 4300 -1710 4300 -1690 {
lab=ctop}
N 4180 -1610 4200 -1610 {
lab=col_n[2]}
N 4180 -1590 4200 -1590 {
lab=colon_n[2]}
N 4180 -1570 4200 -1570 {
lab=#net5}
N 4180 -1550 4200 -1550 {
lab=#net6}
N 4420 -1550 4440 -1550 {
lab=#net6}
N 4420 -1570 4440 -1570 {
lab=#net5}
N 4420 -1590 4440 -1590 {
lab=colon_n[2]}
N 4420 -1610 4440 -1610 {
lab=col_n[2]}
N 4240 -1470 4240 -1460 {
lab=VSS}
N 4240 -1700 4240 -1690 {
lab=VDD}
N 4580 -1470 4590 -1480 {
lab=row_n[13]}
N 4590 -1680 4590 -1480 {
lab=row_n[13]}
N 4580 -1690 4590 -1680 {
lab=row_n[13]}
N 4580 -1470 4580 -1450 {
lab=row_n[13]}
N 4580 -1710 4580 -1690 {
lab=row_n[13]}
N 4460 -1610 4470 -1620 {
lab=col_n[2]}
N 4470 -1620 4670 -1620 {
lab=col_n[2]}
N 4670 -1620 4680 -1610 {
lab=col_n[2]}
N 4460 -1590 4470 -1600 {
lab=colon_n[2]}
N 4470 -1600 4670 -1600 {
lab=colon_n[2]}
N 4670 -1600 4680 -1590 {
lab=colon_n[2]}
N 4460 -1570 4470 -1580 {
lab=#net5}
N 4470 -1580 4670 -1580 {
lab=#net5}
N 4670 -1580 4680 -1570 {
lab=#net5}
N 4460 -1550 4470 -1560 {
lab=#net6}
N 4470 -1560 4670 -1560 {
lab=#net6}
N 4670 -1560 4680 -1550 {
lab=#net6}
N 4520 -1710 4520 -1690 {
lab=vcom}
N 4560 -1710 4560 -1690 {
lab=ctop}
N 4440 -1610 4460 -1610 {
lab=col_n[2]}
N 4440 -1590 4460 -1590 {
lab=colon_n[2]}
N 4440 -1570 4460 -1570 {
lab=#net5}
N 4440 -1550 4460 -1550 {
lab=#net6}
N 4680 -1550 4700 -1550 {
lab=#net6}
N 4680 -1570 4700 -1570 {
lab=#net5}
N 4680 -1590 4700 -1590 {
lab=colon_n[2]}
N 4680 -1610 4700 -1610 {
lab=col_n[2]}
N 4500 -1470 4500 -1460 {
lab=VSS}
N 4500 -1700 4500 -1690 {
lab=VDD}
N 4840 -1470 4850 -1480 {
lab=row_n[14]}
N 4850 -1680 4850 -1480 {
lab=row_n[14]}
N 4840 -1690 4850 -1680 {
lab=row_n[14]}
N 4840 -1470 4840 -1450 {
lab=row_n[14]}
N 4840 -1710 4840 -1690 {
lab=row_n[14]}
N 4720 -1610 4730 -1620 {
lab=col_n[2]}
N 4730 -1620 4930 -1620 {
lab=col_n[2]}
N 4930 -1620 4940 -1610 {
lab=col_n[2]}
N 4720 -1590 4730 -1600 {
lab=colon_n[2]}
N 4730 -1600 4930 -1600 {
lab=colon_n[2]}
N 4930 -1600 4940 -1590 {
lab=colon_n[2]}
N 4720 -1570 4730 -1580 {
lab=#net5}
N 4730 -1580 4930 -1580 {
lab=#net5}
N 4930 -1580 4940 -1570 {
lab=#net5}
N 4720 -1550 4730 -1560 {
lab=#net6}
N 4730 -1560 4930 -1560 {
lab=#net6}
N 4930 -1560 4940 -1550 {
lab=#net6}
N 4780 -1710 4780 -1690 {
lab=vcom}
N 4820 -1710 4820 -1690 {
lab=ctop}
N 4700 -1610 4720 -1610 {
lab=col_n[2]}
N 4700 -1590 4720 -1590 {
lab=colon_n[2]}
N 4700 -1570 4720 -1570 {
lab=#net5}
N 4700 -1550 4720 -1550 {
lab=#net6}
N 4940 -1550 4960 -1550 {
lab=#net6}
N 4940 -1570 4960 -1570 {
lab=#net5}
N 4940 -1590 4960 -1590 {
lab=colon_n[2]}
N 4940 -1610 4960 -1610 {
lab=col_n[2]}
N 4760 -1470 4760 -1460 {
lab=VSS}
N 4760 -1700 4760 -1690 {
lab=VDD}
N 5100 -1470 5110 -1480 {
lab=row_n[15]}
N 5110 -1680 5110 -1480 {
lab=row_n[15]}
N 5100 -1690 5110 -1680 {
lab=row_n[15]}
N 5100 -1470 5100 -1450 {
lab=row_n[15]}
N 5100 -1710 5100 -1690 {
lab=row_n[15]}
N 4980 -1610 4990 -1620 {
lab=col_n[2]}
N 4990 -1620 5190 -1620 {
lab=col_n[2]}
N 5190 -1620 5200 -1610 {
lab=col_n[2]}
N 4980 -1590 4990 -1600 {
lab=colon_n[2]}
N 4990 -1600 5190 -1600 {
lab=colon_n[2]}
N 5190 -1600 5200 -1590 {
lab=colon_n[2]}
N 4980 -1570 4990 -1580 {
lab=#net5}
N 4990 -1580 5190 -1580 {
lab=#net5}
N 5190 -1580 5200 -1570 {
lab=#net5}
N 4980 -1550 4990 -1560 {
lab=#net6}
N 4990 -1560 5190 -1560 {
lab=#net6}
N 5190 -1560 5200 -1550 {
lab=#net6}
N 5040 -1710 5040 -1690 {
lab=vcom}
N 5080 -1710 5080 -1690 {
lab=ctop}
N 4960 -1610 4980 -1610 {
lab=col_n[2]}
N 4960 -1590 4980 -1590 {
lab=colon_n[2]}
N 4960 -1570 4980 -1570 {
lab=#net5}
N 4960 -1550 4980 -1550 {
lab=#net6}
N 5200 -1550 5220 -1550 {
lab=#net6}
N 5200 -1570 5220 -1570 {
lab=#net5}
N 5200 -1590 5220 -1590 {
lab=colon_n[2]}
N 5200 -1610 5220 -1610 {
lab=col_n[2]}
N 5020 -1470 5020 -1460 {
lab=VSS}
N 5020 -1700 5020 -1690 {
lab=VDD}
N 5360 -1470 5370 -1480 {
lab=row_n[16]}
N 5370 -1680 5370 -1480 {
lab=row_n[16]}
N 5360 -1690 5370 -1680 {
lab=row_n[16]}
N 5360 -1470 5360 -1450 {
lab=row_n[16]}
N 5360 -1710 5360 -1690 {
lab=row_n[16]}
N 5240 -1610 5250 -1620 {
lab=col_n[2]}
N 5250 -1620 5450 -1620 {
lab=col_n[2]}
N 5450 -1620 5460 -1610 {
lab=col_n[2]}
N 5240 -1590 5250 -1600 {
lab=colon_n[2]}
N 5250 -1600 5450 -1600 {
lab=colon_n[2]}
N 5450 -1600 5460 -1590 {
lab=colon_n[2]}
N 5240 -1570 5250 -1580 {
lab=#net5}
N 5250 -1580 5450 -1580 {
lab=#net5}
N 5450 -1580 5460 -1570 {
lab=#net5}
N 5240 -1550 5250 -1560 {
lab=#net6}
N 5250 -1560 5450 -1560 {
lab=#net6}
N 5450 -1560 5460 -1550 {
lab=#net6}
N 5300 -1710 5300 -1690 {
lab=vcom}
N 5340 -1710 5340 -1690 {
lab=ctop}
N 5220 -1610 5240 -1610 {
lab=col_n[2]}
N 5220 -1590 5240 -1590 {
lab=colon_n[2]}
N 5220 -1570 5240 -1570 {
lab=#net5}
N 5220 -1550 5240 -1550 {
lab=#net6}
N 5460 -1550 5480 -1550 {
lab=#net6}
N 5460 -1570 5480 -1570 {
lab=#net5}
N 5460 -1590 5480 -1590 {
lab=colon_n[2]}
N 5460 -1610 5480 -1610 {
lab=col_n[2]}
N 5280 -1470 5280 -1460 {
lab=VSS}
N 5280 -1700 5280 -1690 {
lab=VDD}
N 5620 -1470 5630 -1480 {
lab=row_n[17]}
N 5630 -1680 5630 -1480 {
lab=row_n[17]}
N 5620 -1690 5630 -1680 {
lab=row_n[17]}
N 5620 -1470 5620 -1450 {
lab=row_n[17]}
N 5620 -1710 5620 -1690 {
lab=row_n[17]}
N 5500 -1610 5510 -1620 {
lab=col_n[2]}
N 5510 -1620 5710 -1620 {
lab=col_n[2]}
N 5710 -1620 5720 -1610 {
lab=col_n[2]}
N 5500 -1590 5510 -1600 {
lab=colon_n[2]}
N 5510 -1600 5710 -1600 {
lab=colon_n[2]}
N 5710 -1600 5720 -1590 {
lab=colon_n[2]}
N 5500 -1570 5510 -1580 {
lab=#net5}
N 5510 -1580 5710 -1580 {
lab=#net5}
N 5710 -1580 5720 -1570 {
lab=#net5}
N 5500 -1550 5510 -1560 {
lab=#net6}
N 5510 -1560 5710 -1560 {
lab=#net6}
N 5710 -1560 5720 -1550 {
lab=#net6}
N 5560 -1710 5560 -1690 {
lab=vcom}
N 5600 -1710 5600 -1690 {
lab=ctop}
N 5480 -1610 5500 -1610 {
lab=col_n[2]}
N 5480 -1590 5500 -1590 {
lab=colon_n[2]}
N 5480 -1570 5500 -1570 {
lab=#net5}
N 5480 -1550 5500 -1550 {
lab=#net6}
N 5720 -1550 5740 -1550 {
lab=#net6}
N 5720 -1570 5740 -1570 {
lab=#net5}
N 5720 -1590 5740 -1590 {
lab=colon_n[2]}
N 5720 -1610 5740 -1610 {
lab=col_n[2]}
N 5540 -1470 5540 -1460 {
lab=VSS}
N 5540 -1700 5540 -1690 {
lab=VDD}
N 5880 -1470 5890 -1480 {
lab=row_n[18]}
N 5890 -1680 5890 -1480 {
lab=row_n[18]}
N 5880 -1690 5890 -1680 {
lab=row_n[18]}
N 5880 -1470 5880 -1450 {
lab=row_n[18]}
N 5880 -1710 5880 -1690 {
lab=row_n[18]}
N 5760 -1610 5770 -1620 {
lab=col_n[2]}
N 5770 -1620 5970 -1620 {
lab=col_n[2]}
N 5970 -1620 5980 -1610 {
lab=col_n[2]}
N 5760 -1590 5770 -1600 {
lab=colon_n[2]}
N 5770 -1600 5970 -1600 {
lab=colon_n[2]}
N 5970 -1600 5980 -1590 {
lab=colon_n[2]}
N 5760 -1570 5770 -1580 {
lab=#net5}
N 5770 -1580 5970 -1580 {
lab=#net5}
N 5970 -1580 5980 -1570 {
lab=#net5}
N 5760 -1550 5770 -1560 {
lab=#net6}
N 5770 -1560 5970 -1560 {
lab=#net6}
N 5970 -1560 5980 -1550 {
lab=#net6}
N 5820 -1710 5820 -1690 {
lab=vcom}
N 5860 -1710 5860 -1690 {
lab=ctop}
N 5740 -1610 5760 -1610 {
lab=col_n[2]}
N 5740 -1590 5760 -1590 {
lab=colon_n[2]}
N 5740 -1570 5760 -1570 {
lab=#net5}
N 5740 -1550 5760 -1550 {
lab=#net6}
N 5980 -1550 6000 -1550 {
lab=#net6}
N 5980 -1570 6000 -1570 {
lab=#net5}
N 5980 -1590 6000 -1590 {
lab=colon_n[2]}
N 5980 -1610 6000 -1610 {
lab=col_n[2]}
N 5800 -1470 5800 -1460 {
lab=VSS}
N 5800 -1700 5800 -1690 {
lab=VDD}
N 6140 -1470 6150 -1480 {
lab=row_n[19]}
N 6150 -1680 6150 -1480 {
lab=row_n[19]}
N 6140 -1690 6150 -1680 {
lab=row_n[19]}
N 6140 -1470 6140 -1450 {
lab=row_n[19]}
N 6140 -1710 6140 -1690 {
lab=row_n[19]}
N 6020 -1610 6030 -1620 {
lab=col_n[2]}
N 6030 -1620 6230 -1620 {
lab=col_n[2]}
N 6230 -1620 6240 -1610 {
lab=col_n[2]}
N 6020 -1590 6030 -1600 {
lab=colon_n[2]}
N 6030 -1600 6230 -1600 {
lab=colon_n[2]}
N 6230 -1600 6240 -1590 {
lab=colon_n[2]}
N 6020 -1570 6030 -1580 {
lab=#net5}
N 6030 -1580 6230 -1580 {
lab=#net5}
N 6230 -1580 6240 -1570 {
lab=#net5}
N 6020 -1550 6030 -1560 {
lab=#net6}
N 6030 -1560 6230 -1560 {
lab=#net6}
N 6230 -1560 6240 -1550 {
lab=#net6}
N 6080 -1710 6080 -1690 {
lab=vcom}
N 6120 -1710 6120 -1690 {
lab=ctop}
N 6000 -1610 6020 -1610 {
lab=col_n[2]}
N 6000 -1590 6020 -1590 {
lab=colon_n[2]}
N 6000 -1570 6020 -1570 {
lab=#net5}
N 6000 -1550 6020 -1550 {
lab=#net6}
N 6240 -1550 6260 -1550 {
lab=#net6}
N 6240 -1570 6260 -1570 {
lab=#net5}
N 6240 -1590 6260 -1590 {
lab=colon_n[2]}
N 6240 -1610 6260 -1610 {
lab=col_n[2]}
N 6060 -1470 6060 -1460 {
lab=VSS}
N 6060 -1700 6060 -1690 {
lab=VDD}
N 6400 -1470 6410 -1480 {
lab=row_n[20]}
N 6410 -1680 6410 -1480 {
lab=row_n[20]}
N 6400 -1690 6410 -1680 {
lab=row_n[20]}
N 6400 -1470 6400 -1450 {
lab=row_n[20]}
N 6400 -1710 6400 -1690 {
lab=row_n[20]}
N 6280 -1610 6290 -1620 {
lab=col_n[2]}
N 6290 -1620 6490 -1620 {
lab=col_n[2]}
N 6490 -1620 6500 -1610 {
lab=col_n[2]}
N 6280 -1590 6290 -1600 {
lab=colon_n[2]}
N 6290 -1600 6490 -1600 {
lab=colon_n[2]}
N 6490 -1600 6500 -1590 {
lab=colon_n[2]}
N 6280 -1570 6290 -1580 {
lab=#net5}
N 6290 -1580 6490 -1580 {
lab=#net5}
N 6490 -1580 6500 -1570 {
lab=#net5}
N 6280 -1550 6290 -1560 {
lab=#net6}
N 6290 -1560 6490 -1560 {
lab=#net6}
N 6490 -1560 6500 -1550 {
lab=#net6}
N 6340 -1710 6340 -1690 {
lab=vcom}
N 6380 -1710 6380 -1690 {
lab=ctop}
N 6260 -1610 6280 -1610 {
lab=col_n[2]}
N 6260 -1590 6280 -1590 {
lab=colon_n[2]}
N 6260 -1570 6280 -1570 {
lab=#net5}
N 6260 -1550 6280 -1550 {
lab=#net6}
N 6500 -1550 6520 -1550 {
lab=#net6}
N 6500 -1570 6520 -1570 {
lab=#net5}
N 6500 -1590 6520 -1590 {
lab=colon_n[2]}
N 6500 -1610 6520 -1610 {
lab=col_n[2]}
N 6320 -1470 6320 -1460 {
lab=VSS}
N 6320 -1700 6320 -1690 {
lab=VDD}
N 6660 -1470 6670 -1480 {
lab=row_n[21]}
N 6670 -1680 6670 -1480 {
lab=row_n[21]}
N 6660 -1690 6670 -1680 {
lab=row_n[21]}
N 6660 -1470 6660 -1450 {
lab=row_n[21]}
N 6660 -1710 6660 -1690 {
lab=row_n[21]}
N 6540 -1610 6550 -1620 {
lab=col_n[2]}
N 6550 -1620 6750 -1620 {
lab=col_n[2]}
N 6750 -1620 6760 -1610 {
lab=col_n[2]}
N 6540 -1590 6550 -1600 {
lab=colon_n[2]}
N 6550 -1600 6750 -1600 {
lab=colon_n[2]}
N 6750 -1600 6760 -1590 {
lab=colon_n[2]}
N 6540 -1570 6550 -1580 {
lab=#net5}
N 6550 -1580 6750 -1580 {
lab=#net5}
N 6750 -1580 6760 -1570 {
lab=#net5}
N 6540 -1550 6550 -1560 {
lab=#net6}
N 6550 -1560 6750 -1560 {
lab=#net6}
N 6750 -1560 6760 -1550 {
lab=#net6}
N 6600 -1710 6600 -1690 {
lab=vcom}
N 6640 -1710 6640 -1690 {
lab=ctop}
N 6520 -1610 6540 -1610 {
lab=col_n[2]}
N 6520 -1590 6540 -1590 {
lab=colon_n[2]}
N 6520 -1570 6540 -1570 {
lab=#net5}
N 6520 -1550 6540 -1550 {
lab=#net6}
N 6760 -1550 6780 -1550 {
lab=#net6}
N 6760 -1570 6780 -1570 {
lab=#net5}
N 6760 -1590 6780 -1590 {
lab=colon_n[2]}
N 6760 -1610 6780 -1610 {
lab=col_n[2]}
N 6580 -1470 6580 -1460 {
lab=VSS}
N 6580 -1700 6580 -1690 {
lab=VDD}
N 6920 -1470 6930 -1480 {
lab=row_n[22]}
N 6930 -1680 6930 -1480 {
lab=row_n[22]}
N 6920 -1690 6930 -1680 {
lab=row_n[22]}
N 6920 -1470 6920 -1450 {
lab=row_n[22]}
N 6920 -1710 6920 -1690 {
lab=row_n[22]}
N 6800 -1610 6810 -1620 {
lab=col_n[2]}
N 6810 -1620 7010 -1620 {
lab=col_n[2]}
N 7010 -1620 7020 -1610 {
lab=col_n[2]}
N 6800 -1590 6810 -1600 {
lab=colon_n[2]}
N 6810 -1600 7010 -1600 {
lab=colon_n[2]}
N 7010 -1600 7020 -1590 {
lab=colon_n[2]}
N 6800 -1570 6810 -1580 {
lab=#net5}
N 6810 -1580 7010 -1580 {
lab=#net5}
N 7010 -1580 7020 -1570 {
lab=#net5}
N 6800 -1550 6810 -1560 {
lab=#net6}
N 6810 -1560 7010 -1560 {
lab=#net6}
N 7010 -1560 7020 -1550 {
lab=#net6}
N 6860 -1710 6860 -1690 {
lab=vcom}
N 6900 -1710 6900 -1690 {
lab=ctop}
N 6780 -1610 6800 -1610 {
lab=col_n[2]}
N 6780 -1590 6800 -1590 {
lab=colon_n[2]}
N 6780 -1570 6800 -1570 {
lab=#net5}
N 6780 -1550 6800 -1550 {
lab=#net6}
N 7020 -1550 7040 -1550 {
lab=#net6}
N 7020 -1570 7040 -1570 {
lab=#net5}
N 7020 -1590 7040 -1590 {
lab=colon_n[2]}
N 7020 -1610 7040 -1610 {
lab=col_n[2]}
N 6840 -1470 6840 -1460 {
lab=VSS}
N 6840 -1700 6840 -1690 {
lab=VDD}
N 7180 -1470 7190 -1480 {
lab=row_n[23]}
N 7190 -1680 7190 -1480 {
lab=row_n[23]}
N 7180 -1690 7190 -1680 {
lab=row_n[23]}
N 7180 -1470 7180 -1450 {
lab=row_n[23]}
N 7180 -1710 7180 -1690 {
lab=row_n[23]}
N 7060 -1610 7070 -1620 {
lab=col_n[2]}
N 7070 -1620 7270 -1620 {
lab=col_n[2]}
N 7270 -1620 7280 -1610 {
lab=col_n[2]}
N 7060 -1590 7070 -1600 {
lab=colon_n[2]}
N 7070 -1600 7270 -1600 {
lab=colon_n[2]}
N 7270 -1600 7280 -1590 {
lab=colon_n[2]}
N 7060 -1570 7070 -1580 {
lab=#net5}
N 7070 -1580 7270 -1580 {
lab=#net5}
N 7270 -1580 7280 -1570 {
lab=#net5}
N 7060 -1550 7070 -1560 {
lab=#net6}
N 7070 -1560 7270 -1560 {
lab=#net6}
N 7270 -1560 7280 -1550 {
lab=#net6}
N 7120 -1710 7120 -1690 {
lab=vcom}
N 7160 -1710 7160 -1690 {
lab=ctop}
N 7040 -1610 7060 -1610 {
lab=col_n[2]}
N 7040 -1590 7060 -1590 {
lab=colon_n[2]}
N 7040 -1570 7060 -1570 {
lab=#net5}
N 7040 -1550 7060 -1550 {
lab=#net6}
N 7280 -1550 7300 -1550 {
lab=#net6}
N 7280 -1570 7300 -1570 {
lab=#net5}
N 7280 -1590 7300 -1590 {
lab=colon_n[2]}
N 7280 -1610 7300 -1610 {
lab=col_n[2]}
N 7100 -1470 7100 -1460 {
lab=VSS}
N 7100 -1700 7100 -1690 {
lab=VDD}
N 7440 -1470 7450 -1480 {
lab=row_n[24]}
N 7450 -1680 7450 -1480 {
lab=row_n[24]}
N 7440 -1690 7450 -1680 {
lab=row_n[24]}
N 7440 -1470 7440 -1450 {
lab=row_n[24]}
N 7440 -1710 7440 -1690 {
lab=row_n[24]}
N 7320 -1610 7330 -1620 {
lab=col_n[2]}
N 7330 -1620 7530 -1620 {
lab=col_n[2]}
N 7530 -1620 7540 -1610 {
lab=col_n[2]}
N 7320 -1590 7330 -1600 {
lab=colon_n[2]}
N 7330 -1600 7530 -1600 {
lab=colon_n[2]}
N 7530 -1600 7540 -1590 {
lab=colon_n[2]}
N 7320 -1570 7330 -1580 {
lab=#net5}
N 7330 -1580 7530 -1580 {
lab=#net5}
N 7530 -1580 7540 -1570 {
lab=#net5}
N 7320 -1550 7330 -1560 {
lab=#net6}
N 7330 -1560 7530 -1560 {
lab=#net6}
N 7530 -1560 7540 -1550 {
lab=#net6}
N 7380 -1710 7380 -1690 {
lab=vcom}
N 7420 -1710 7420 -1690 {
lab=ctop}
N 7300 -1610 7320 -1610 {
lab=col_n[2]}
N 7300 -1590 7320 -1590 {
lab=colon_n[2]}
N 7300 -1570 7320 -1570 {
lab=#net5}
N 7300 -1550 7320 -1550 {
lab=#net6}
N 7540 -1550 7560 -1550 {
lab=#net6}
N 7540 -1570 7560 -1570 {
lab=#net5}
N 7540 -1590 7560 -1590 {
lab=colon_n[2]}
N 7540 -1610 7560 -1610 {
lab=col_n[2]}
N 7360 -1470 7360 -1460 {
lab=VSS}
N 7360 -1700 7360 -1690 {
lab=VDD}
N 7700 -1470 7710 -1480 {
lab=row_n[25]}
N 7710 -1680 7710 -1480 {
lab=row_n[25]}
N 7700 -1690 7710 -1680 {
lab=row_n[25]}
N 7700 -1470 7700 -1450 {
lab=row_n[25]}
N 7700 -1710 7700 -1690 {
lab=row_n[25]}
N 7580 -1610 7590 -1620 {
lab=col_n[2]}
N 7590 -1620 7790 -1620 {
lab=col_n[2]}
N 7790 -1620 7800 -1610 {
lab=col_n[2]}
N 7580 -1590 7590 -1600 {
lab=colon_n[2]}
N 7590 -1600 7790 -1600 {
lab=colon_n[2]}
N 7790 -1600 7800 -1590 {
lab=colon_n[2]}
N 7580 -1570 7590 -1580 {
lab=#net5}
N 7590 -1580 7790 -1580 {
lab=#net5}
N 7790 -1580 7800 -1570 {
lab=#net5}
N 7580 -1550 7590 -1560 {
lab=#net6}
N 7590 -1560 7790 -1560 {
lab=#net6}
N 7790 -1560 7800 -1550 {
lab=#net6}
N 7640 -1710 7640 -1690 {
lab=vcom}
N 7680 -1710 7680 -1690 {
lab=ctop}
N 7560 -1610 7580 -1610 {
lab=col_n[2]}
N 7560 -1590 7580 -1590 {
lab=colon_n[2]}
N 7560 -1570 7580 -1570 {
lab=#net5}
N 7560 -1550 7580 -1550 {
lab=#net6}
N 7800 -1550 7820 -1550 {
lab=#net6}
N 7800 -1570 7820 -1570 {
lab=#net5}
N 7800 -1590 7820 -1590 {
lab=colon_n[2]}
N 7800 -1610 7820 -1610 {
lab=col_n[2]}
N 7620 -1470 7620 -1460 {
lab=VSS}
N 7620 -1700 7620 -1690 {
lab=VDD}
N 7960 -1470 7970 -1480 {
lab=row_n[26]}
N 7970 -1680 7970 -1480 {
lab=row_n[26]}
N 7960 -1690 7970 -1680 {
lab=row_n[26]}
N 7960 -1470 7960 -1450 {
lab=row_n[26]}
N 7960 -1710 7960 -1690 {
lab=row_n[26]}
N 7840 -1610 7850 -1620 {
lab=col_n[2]}
N 7850 -1620 8050 -1620 {
lab=col_n[2]}
N 8050 -1620 8060 -1610 {
lab=col_n[2]}
N 7840 -1590 7850 -1600 {
lab=colon_n[2]}
N 7850 -1600 8050 -1600 {
lab=colon_n[2]}
N 8050 -1600 8060 -1590 {
lab=colon_n[2]}
N 7840 -1570 7850 -1580 {
lab=#net5}
N 7850 -1580 8050 -1580 {
lab=#net5}
N 8050 -1580 8060 -1570 {
lab=#net5}
N 7840 -1550 7850 -1560 {
lab=#net6}
N 7850 -1560 8050 -1560 {
lab=#net6}
N 8050 -1560 8060 -1550 {
lab=#net6}
N 7900 -1710 7900 -1690 {
lab=vcom}
N 7940 -1710 7940 -1690 {
lab=ctop}
N 7820 -1610 7840 -1610 {
lab=col_n[2]}
N 7820 -1590 7840 -1590 {
lab=colon_n[2]}
N 7820 -1570 7840 -1570 {
lab=#net5}
N 7820 -1550 7840 -1550 {
lab=#net6}
N 8060 -1550 8080 -1550 {
lab=#net6}
N 8060 -1570 8080 -1570 {
lab=#net5}
N 8060 -1590 8080 -1590 {
lab=colon_n[2]}
N 8060 -1610 8080 -1610 {
lab=col_n[2]}
N 7880 -1470 7880 -1460 {
lab=VSS}
N 7880 -1700 7880 -1690 {
lab=VDD}
N 8220 -1470 8230 -1480 {
lab=row_n[27]}
N 8230 -1680 8230 -1480 {
lab=row_n[27]}
N 8220 -1690 8230 -1680 {
lab=row_n[27]}
N 8220 -1470 8220 -1450 {
lab=row_n[27]}
N 8220 -1710 8220 -1690 {
lab=row_n[27]}
N 8100 -1610 8110 -1620 {
lab=col_n[2]}
N 8110 -1620 8310 -1620 {
lab=col_n[2]}
N 8310 -1620 8320 -1610 {
lab=col_n[2]}
N 8100 -1590 8110 -1600 {
lab=colon_n[2]}
N 8110 -1600 8310 -1600 {
lab=colon_n[2]}
N 8310 -1600 8320 -1590 {
lab=colon_n[2]}
N 8100 -1570 8110 -1580 {
lab=#net5}
N 8110 -1580 8310 -1580 {
lab=#net5}
N 8310 -1580 8320 -1570 {
lab=#net5}
N 8100 -1550 8110 -1560 {
lab=#net6}
N 8110 -1560 8310 -1560 {
lab=#net6}
N 8310 -1560 8320 -1550 {
lab=#net6}
N 8160 -1710 8160 -1690 {
lab=vcom}
N 8200 -1710 8200 -1690 {
lab=ctop}
N 8080 -1610 8100 -1610 {
lab=col_n[2]}
N 8080 -1590 8100 -1590 {
lab=colon_n[2]}
N 8080 -1570 8100 -1570 {
lab=#net5}
N 8080 -1550 8100 -1550 {
lab=#net6}
N 8320 -1550 8340 -1550 {
lab=#net6}
N 8320 -1570 8340 -1570 {
lab=#net5}
N 8320 -1590 8340 -1590 {
lab=colon_n[2]}
N 8320 -1610 8340 -1610 {
lab=col_n[2]}
N 8140 -1470 8140 -1460 {
lab=VSS}
N 8140 -1700 8140 -1690 {
lab=VDD}
N 8480 -1470 8490 -1480 {
lab=row_n[28]}
N 8490 -1680 8490 -1480 {
lab=row_n[28]}
N 8480 -1690 8490 -1680 {
lab=row_n[28]}
N 8480 -1470 8480 -1450 {
lab=row_n[28]}
N 8480 -1710 8480 -1690 {
lab=row_n[28]}
N 8360 -1610 8370 -1620 {
lab=col_n[2]}
N 8370 -1620 8570 -1620 {
lab=col_n[2]}
N 8570 -1620 8580 -1610 {
lab=col_n[2]}
N 8360 -1590 8370 -1600 {
lab=colon_n[2]}
N 8370 -1600 8570 -1600 {
lab=colon_n[2]}
N 8570 -1600 8580 -1590 {
lab=colon_n[2]}
N 8360 -1570 8370 -1580 {
lab=#net5}
N 8370 -1580 8570 -1580 {
lab=#net5}
N 8570 -1580 8580 -1570 {
lab=#net5}
N 8360 -1550 8370 -1560 {
lab=#net6}
N 8370 -1560 8570 -1560 {
lab=#net6}
N 8570 -1560 8580 -1550 {
lab=#net6}
N 8420 -1710 8420 -1690 {
lab=vcom}
N 8460 -1710 8460 -1690 {
lab=ctop}
N 8340 -1610 8360 -1610 {
lab=col_n[2]}
N 8340 -1590 8360 -1590 {
lab=colon_n[2]}
N 8340 -1570 8360 -1570 {
lab=#net5}
N 8340 -1550 8360 -1550 {
lab=#net6}
N 8580 -1550 8600 -1550 {
lab=#net6}
N 8580 -1570 8600 -1570 {
lab=#net5}
N 8580 -1590 8600 -1590 {
lab=colon_n[2]}
N 8580 -1610 8600 -1610 {
lab=col_n[2]}
N 8400 -1470 8400 -1460 {
lab=VSS}
N 8400 -1700 8400 -1690 {
lab=VDD}
N 8740 -1470 8750 -1480 {
lab=row_n[29]}
N 8750 -1680 8750 -1480 {
lab=row_n[29]}
N 8740 -1690 8750 -1680 {
lab=row_n[29]}
N 8740 -1470 8740 -1450 {
lab=row_n[29]}
N 8740 -1710 8740 -1690 {
lab=row_n[29]}
N 8620 -1610 8630 -1620 {
lab=col_n[2]}
N 8630 -1620 8830 -1620 {
lab=col_n[2]}
N 8830 -1620 8840 -1610 {
lab=col_n[2]}
N 8620 -1590 8630 -1600 {
lab=colon_n[2]}
N 8630 -1600 8830 -1600 {
lab=colon_n[2]}
N 8830 -1600 8840 -1590 {
lab=colon_n[2]}
N 8620 -1570 8630 -1580 {
lab=#net5}
N 8630 -1580 8830 -1580 {
lab=#net5}
N 8830 -1580 8840 -1570 {
lab=#net5}
N 8620 -1550 8630 -1560 {
lab=#net6}
N 8630 -1560 8830 -1560 {
lab=#net6}
N 8830 -1560 8840 -1550 {
lab=#net6}
N 8680 -1710 8680 -1690 {
lab=vcom}
N 8720 -1710 8720 -1690 {
lab=ctop}
N 8600 -1610 8620 -1610 {
lab=col_n[2]}
N 8600 -1590 8620 -1590 {
lab=colon_n[2]}
N 8600 -1570 8620 -1570 {
lab=#net5}
N 8600 -1550 8620 -1550 {
lab=#net6}
N 8840 -1550 8860 -1550 {
lab=#net6}
N 8840 -1570 8860 -1570 {
lab=#net5}
N 8840 -1590 8860 -1590 {
lab=colon_n[2]}
N 8840 -1610 8860 -1610 {
lab=col_n[2]}
N 8660 -1470 8660 -1460 {
lab=VSS}
N 8660 -1700 8660 -1690 {
lab=VDD}
N 9000 -1470 9010 -1480 {
lab=row_n[30]}
N 9010 -1680 9010 -1480 {
lab=row_n[30]}
N 9000 -1690 9010 -1680 {
lab=row_n[30]}
N 9000 -1470 9000 -1450 {
lab=row_n[30]}
N 9000 -1710 9000 -1690 {
lab=row_n[30]}
N 8880 -1610 8890 -1620 {
lab=col_n[2]}
N 8890 -1620 9090 -1620 {
lab=col_n[2]}
N 9090 -1620 9100 -1610 {
lab=col_n[2]}
N 8880 -1590 8890 -1600 {
lab=colon_n[2]}
N 8890 -1600 9090 -1600 {
lab=colon_n[2]}
N 9090 -1600 9100 -1590 {
lab=colon_n[2]}
N 8880 -1570 8890 -1580 {
lab=#net5}
N 8890 -1580 9090 -1580 {
lab=#net5}
N 9090 -1580 9100 -1570 {
lab=#net5}
N 8880 -1550 8890 -1560 {
lab=#net6}
N 8890 -1560 9090 -1560 {
lab=#net6}
N 9090 -1560 9100 -1550 {
lab=#net6}
N 8940 -1710 8940 -1690 {
lab=vcom}
N 8980 -1710 8980 -1690 {
lab=ctop}
N 8860 -1610 8880 -1610 {
lab=col_n[2]}
N 8860 -1590 8880 -1590 {
lab=colon_n[2]}
N 8860 -1570 8880 -1570 {
lab=#net5}
N 8860 -1550 8880 -1550 {
lab=#net6}
N 9100 -1550 9120 -1550 {
lab=#net6}
N 9100 -1570 9120 -1570 {
lab=#net5}
N 9100 -1590 9120 -1590 {
lab=colon_n[2]}
N 9100 -1610 9120 -1610 {
lab=col_n[2]}
N 8920 -1470 8920 -1460 {
lab=VSS}
N 8920 -1700 8920 -1690 {
lab=VDD}
N 9260 -1470 9270 -1480 {
lab=row_n[31]}
N 9270 -1680 9270 -1480 {
lab=row_n[31]}
N 9260 -1690 9270 -1680 {
lab=row_n[31]}
N 9260 -1470 9260 -1450 {
lab=row_n[31]}
N 9260 -1710 9260 -1690 {
lab=row_n[31]}
N 9140 -1610 9150 -1620 {
lab=col_n[2]}
N 9150 -1620 9350 -1620 {
lab=col_n[2]}
N 9350 -1620 9360 -1610 {
lab=col_n[2]}
N 9140 -1590 9150 -1600 {
lab=colon_n[2]}
N 9150 -1600 9350 -1600 {
lab=colon_n[2]}
N 9350 -1600 9360 -1590 {
lab=colon_n[2]}
N 9140 -1570 9150 -1580 {
lab=#net5}
N 9150 -1580 9350 -1580 {
lab=#net5}
N 9350 -1580 9360 -1570 {
lab=#net5}
N 9140 -1550 9150 -1560 {
lab=#net6}
N 9150 -1560 9350 -1560 {
lab=#net6}
N 9350 -1560 9360 -1550 {
lab=#net6}
N 9200 -1710 9200 -1690 {
lab=vcom}
N 9240 -1710 9240 -1690 {
lab=ctop}
N 9120 -1610 9140 -1610 {
lab=col_n[2]}
N 9120 -1590 9140 -1590 {
lab=colon_n[2]}
N 9120 -1570 9140 -1570 {
lab=#net5}
N 9120 -1550 9140 -1550 {
lab=#net6}
N 9360 -1550 9380 -1550 {
lab=#net6}
N 9360 -1570 9380 -1570 {
lab=#net5}
N 9360 -1590 9380 -1590 {
lab=colon_n[2]}
N 9360 -1610 9380 -1610 {
lab=col_n[2]}
N 9180 -1470 9180 -1460 {
lab=VSS}
N 9180 -1700 9180 -1690 {
lab=VDD}
N 1200 -1730 1210 -1740 {
lab=row_n[0]}
N 1210 -1940 1210 -1740 {
lab=row_n[0]}
N 1200 -1950 1210 -1940 {
lab=row_n[0]}
N 1200 -1730 1200 -1710 {
lab=row_n[0]}
N 1200 -1970 1200 -1950 {
lab=row_n[0]}
N 1080 -1870 1090 -1880 {
lab=col_n[3]}
N 1090 -1880 1290 -1880 {
lab=col_n[3]}
N 1290 -1880 1300 -1870 {
lab=col_n[3]}
N 1080 -1850 1090 -1860 {
lab=colon_n[3]}
N 1090 -1860 1290 -1860 {
lab=colon_n[3]}
N 1290 -1860 1300 -1850 {
lab=colon_n[3]}
N 1080 -1830 1090 -1840 {
lab=#net7}
N 1090 -1840 1290 -1840 {
lab=#net7}
N 1290 -1840 1300 -1830 {
lab=#net7}
N 1080 -1810 1090 -1820 {
lab=#net8}
N 1090 -1820 1290 -1820 {
lab=#net8}
N 1290 -1820 1300 -1810 {
lab=#net8}
N 1140 -1970 1140 -1950 {
lab=vcom}
N 1180 -1970 1180 -1950 {
lab=ctop}
N 1060 -1870 1080 -1870 {
lab=col_n[3]}
N 1060 -1850 1080 -1850 {
lab=colon_n[3]}
N 1060 -1830 1080 -1830 {
lab=#net7}
N 1060 -1810 1080 -1810 {
lab=#net8}
N 1300 -1810 1320 -1810 {
lab=#net8}
N 1300 -1830 1320 -1830 {
lab=#net7}
N 1300 -1850 1320 -1850 {
lab=colon_n[3]}
N 1300 -1870 1320 -1870 {
lab=col_n[3]}
N 1120 -1730 1120 -1720 {
lab=VSS}
N 1120 -1960 1120 -1950 {
lab=VDD}
N 1460 -1730 1470 -1740 {
lab=row_n[1]}
N 1470 -1940 1470 -1740 {
lab=row_n[1]}
N 1460 -1950 1470 -1940 {
lab=row_n[1]}
N 1460 -1730 1460 -1710 {
lab=row_n[1]}
N 1460 -1970 1460 -1950 {
lab=row_n[1]}
N 1340 -1870 1350 -1880 {
lab=col_n[3]}
N 1350 -1880 1550 -1880 {
lab=col_n[3]}
N 1550 -1880 1560 -1870 {
lab=col_n[3]}
N 1340 -1850 1350 -1860 {
lab=colon_n[3]}
N 1350 -1860 1550 -1860 {
lab=colon_n[3]}
N 1550 -1860 1560 -1850 {
lab=colon_n[3]}
N 1340 -1830 1350 -1840 {
lab=#net7}
N 1350 -1840 1550 -1840 {
lab=#net7}
N 1550 -1840 1560 -1830 {
lab=#net7}
N 1340 -1810 1350 -1820 {
lab=#net8}
N 1350 -1820 1550 -1820 {
lab=#net8}
N 1550 -1820 1560 -1810 {
lab=#net8}
N 1400 -1970 1400 -1950 {
lab=vcom}
N 1440 -1970 1440 -1950 {
lab=ctop}
N 1320 -1870 1340 -1870 {
lab=col_n[3]}
N 1320 -1850 1340 -1850 {
lab=colon_n[3]}
N 1320 -1830 1340 -1830 {
lab=#net7}
N 1320 -1810 1340 -1810 {
lab=#net8}
N 1560 -1810 1580 -1810 {
lab=#net8}
N 1560 -1830 1580 -1830 {
lab=#net7}
N 1560 -1850 1580 -1850 {
lab=colon_n[3]}
N 1560 -1870 1580 -1870 {
lab=col_n[3]}
N 1380 -1730 1380 -1720 {
lab=VSS}
N 1380 -1960 1380 -1950 {
lab=VDD}
N 1720 -1730 1730 -1740 {
lab=row_n[2]}
N 1730 -1940 1730 -1740 {
lab=row_n[2]}
N 1720 -1950 1730 -1940 {
lab=row_n[2]}
N 1720 -1730 1720 -1710 {
lab=row_n[2]}
N 1720 -1970 1720 -1950 {
lab=row_n[2]}
N 1600 -1870 1610 -1880 {
lab=col_n[3]}
N 1610 -1880 1810 -1880 {
lab=col_n[3]}
N 1810 -1880 1820 -1870 {
lab=col_n[3]}
N 1600 -1850 1610 -1860 {
lab=colon_n[3]}
N 1610 -1860 1810 -1860 {
lab=colon_n[3]}
N 1810 -1860 1820 -1850 {
lab=colon_n[3]}
N 1600 -1830 1610 -1840 {
lab=#net7}
N 1610 -1840 1810 -1840 {
lab=#net7}
N 1810 -1840 1820 -1830 {
lab=#net7}
N 1600 -1810 1610 -1820 {
lab=#net8}
N 1610 -1820 1810 -1820 {
lab=#net8}
N 1810 -1820 1820 -1810 {
lab=#net8}
N 1660 -1970 1660 -1950 {
lab=vcom}
N 1700 -1970 1700 -1950 {
lab=ctop}
N 1580 -1870 1600 -1870 {
lab=col_n[3]}
N 1580 -1850 1600 -1850 {
lab=colon_n[3]}
N 1580 -1830 1600 -1830 {
lab=#net7}
N 1580 -1810 1600 -1810 {
lab=#net8}
N 1820 -1810 1840 -1810 {
lab=#net8}
N 1820 -1830 1840 -1830 {
lab=#net7}
N 1820 -1850 1840 -1850 {
lab=colon_n[3]}
N 1820 -1870 1840 -1870 {
lab=col_n[3]}
N 1640 -1730 1640 -1720 {
lab=VSS}
N 1640 -1960 1640 -1950 {
lab=VDD}
N 1980 -1730 1990 -1740 {
lab=row_n[3]}
N 1990 -1940 1990 -1740 {
lab=row_n[3]}
N 1980 -1950 1990 -1940 {
lab=row_n[3]}
N 1980 -1730 1980 -1710 {
lab=row_n[3]}
N 1980 -1970 1980 -1950 {
lab=row_n[3]}
N 1860 -1870 1870 -1880 {
lab=col_n[3]}
N 1870 -1880 2070 -1880 {
lab=col_n[3]}
N 2070 -1880 2080 -1870 {
lab=col_n[3]}
N 1860 -1850 1870 -1860 {
lab=colon_n[3]}
N 1870 -1860 2070 -1860 {
lab=colon_n[3]}
N 2070 -1860 2080 -1850 {
lab=colon_n[3]}
N 1860 -1830 1870 -1840 {
lab=#net7}
N 1870 -1840 2070 -1840 {
lab=#net7}
N 2070 -1840 2080 -1830 {
lab=#net7}
N 1860 -1810 1870 -1820 {
lab=#net8}
N 1870 -1820 2070 -1820 {
lab=#net8}
N 2070 -1820 2080 -1810 {
lab=#net8}
N 1920 -1970 1920 -1950 {
lab=vcom}
N 1960 -1970 1960 -1950 {
lab=ctop}
N 1840 -1870 1860 -1870 {
lab=col_n[3]}
N 1840 -1850 1860 -1850 {
lab=colon_n[3]}
N 1840 -1830 1860 -1830 {
lab=#net7}
N 1840 -1810 1860 -1810 {
lab=#net8}
N 2080 -1810 2100 -1810 {
lab=#net8}
N 2080 -1830 2100 -1830 {
lab=#net7}
N 2080 -1850 2100 -1850 {
lab=colon_n[3]}
N 2080 -1870 2100 -1870 {
lab=col_n[3]}
N 1900 -1730 1900 -1720 {
lab=VSS}
N 1900 -1960 1900 -1950 {
lab=VDD}
N 2240 -1730 2250 -1740 {
lab=row_n[4]}
N 2250 -1940 2250 -1740 {
lab=row_n[4]}
N 2240 -1950 2250 -1940 {
lab=row_n[4]}
N 2240 -1730 2240 -1710 {
lab=row_n[4]}
N 2240 -1970 2240 -1950 {
lab=row_n[4]}
N 2120 -1870 2130 -1880 {
lab=col_n[3]}
N 2130 -1880 2330 -1880 {
lab=col_n[3]}
N 2330 -1880 2340 -1870 {
lab=col_n[3]}
N 2120 -1850 2130 -1860 {
lab=colon_n[3]}
N 2130 -1860 2330 -1860 {
lab=colon_n[3]}
N 2330 -1860 2340 -1850 {
lab=colon_n[3]}
N 2120 -1830 2130 -1840 {
lab=#net7}
N 2130 -1840 2330 -1840 {
lab=#net7}
N 2330 -1840 2340 -1830 {
lab=#net7}
N 2120 -1810 2130 -1820 {
lab=#net8}
N 2130 -1820 2330 -1820 {
lab=#net8}
N 2330 -1820 2340 -1810 {
lab=#net8}
N 2180 -1970 2180 -1950 {
lab=vcom}
N 2220 -1970 2220 -1950 {
lab=ctop}
N 2100 -1870 2120 -1870 {
lab=col_n[3]}
N 2100 -1850 2120 -1850 {
lab=colon_n[3]}
N 2100 -1830 2120 -1830 {
lab=#net7}
N 2100 -1810 2120 -1810 {
lab=#net8}
N 2340 -1810 2360 -1810 {
lab=#net8}
N 2340 -1830 2360 -1830 {
lab=#net7}
N 2340 -1850 2360 -1850 {
lab=colon_n[3]}
N 2340 -1870 2360 -1870 {
lab=col_n[3]}
N 2160 -1730 2160 -1720 {
lab=VSS}
N 2160 -1960 2160 -1950 {
lab=VDD}
N 2500 -1730 2510 -1740 {
lab=row_n[5]}
N 2510 -1940 2510 -1740 {
lab=row_n[5]}
N 2500 -1950 2510 -1940 {
lab=row_n[5]}
N 2500 -1730 2500 -1710 {
lab=row_n[5]}
N 2500 -1970 2500 -1950 {
lab=row_n[5]}
N 2380 -1870 2390 -1880 {
lab=col_n[3]}
N 2390 -1880 2590 -1880 {
lab=col_n[3]}
N 2590 -1880 2600 -1870 {
lab=col_n[3]}
N 2380 -1850 2390 -1860 {
lab=colon_n[3]}
N 2390 -1860 2590 -1860 {
lab=colon_n[3]}
N 2590 -1860 2600 -1850 {
lab=colon_n[3]}
N 2380 -1830 2390 -1840 {
lab=#net7}
N 2390 -1840 2590 -1840 {
lab=#net7}
N 2590 -1840 2600 -1830 {
lab=#net7}
N 2380 -1810 2390 -1820 {
lab=#net8}
N 2390 -1820 2590 -1820 {
lab=#net8}
N 2590 -1820 2600 -1810 {
lab=#net8}
N 2440 -1970 2440 -1950 {
lab=vcom}
N 2480 -1970 2480 -1950 {
lab=ctop}
N 2360 -1870 2380 -1870 {
lab=col_n[3]}
N 2360 -1850 2380 -1850 {
lab=colon_n[3]}
N 2360 -1830 2380 -1830 {
lab=#net7}
N 2360 -1810 2380 -1810 {
lab=#net8}
N 2600 -1810 2620 -1810 {
lab=#net8}
N 2600 -1830 2620 -1830 {
lab=#net7}
N 2600 -1850 2620 -1850 {
lab=colon_n[3]}
N 2600 -1870 2620 -1870 {
lab=col_n[3]}
N 2420 -1730 2420 -1720 {
lab=VSS}
N 2420 -1960 2420 -1950 {
lab=VDD}
N 2760 -1730 2770 -1740 {
lab=row_n[6]}
N 2770 -1940 2770 -1740 {
lab=row_n[6]}
N 2760 -1950 2770 -1940 {
lab=row_n[6]}
N 2760 -1730 2760 -1710 {
lab=row_n[6]}
N 2760 -1970 2760 -1950 {
lab=row_n[6]}
N 2640 -1870 2650 -1880 {
lab=col_n[3]}
N 2650 -1880 2850 -1880 {
lab=col_n[3]}
N 2850 -1880 2860 -1870 {
lab=col_n[3]}
N 2640 -1850 2650 -1860 {
lab=colon_n[3]}
N 2650 -1860 2850 -1860 {
lab=colon_n[3]}
N 2850 -1860 2860 -1850 {
lab=colon_n[3]}
N 2640 -1830 2650 -1840 {
lab=#net7}
N 2650 -1840 2850 -1840 {
lab=#net7}
N 2850 -1840 2860 -1830 {
lab=#net7}
N 2640 -1810 2650 -1820 {
lab=#net8}
N 2650 -1820 2850 -1820 {
lab=#net8}
N 2850 -1820 2860 -1810 {
lab=#net8}
N 2700 -1970 2700 -1950 {
lab=vcom}
N 2740 -1970 2740 -1950 {
lab=ctop}
N 2620 -1870 2640 -1870 {
lab=col_n[3]}
N 2620 -1850 2640 -1850 {
lab=colon_n[3]}
N 2620 -1830 2640 -1830 {
lab=#net7}
N 2620 -1810 2640 -1810 {
lab=#net8}
N 2860 -1810 2880 -1810 {
lab=#net8}
N 2860 -1830 2880 -1830 {
lab=#net7}
N 2860 -1850 2880 -1850 {
lab=colon_n[3]}
N 2860 -1870 2880 -1870 {
lab=col_n[3]}
N 2680 -1730 2680 -1720 {
lab=VSS}
N 2680 -1960 2680 -1950 {
lab=VDD}
N 3020 -1730 3030 -1740 {
lab=row_n[7]}
N 3030 -1940 3030 -1740 {
lab=row_n[7]}
N 3020 -1950 3030 -1940 {
lab=row_n[7]}
N 3020 -1730 3020 -1710 {
lab=row_n[7]}
N 3020 -1970 3020 -1950 {
lab=row_n[7]}
N 2900 -1870 2910 -1880 {
lab=col_n[3]}
N 2910 -1880 3110 -1880 {
lab=col_n[3]}
N 3110 -1880 3120 -1870 {
lab=col_n[3]}
N 2900 -1850 2910 -1860 {
lab=colon_n[3]}
N 2910 -1860 3110 -1860 {
lab=colon_n[3]}
N 3110 -1860 3120 -1850 {
lab=colon_n[3]}
N 2900 -1830 2910 -1840 {
lab=#net7}
N 2910 -1840 3110 -1840 {
lab=#net7}
N 3110 -1840 3120 -1830 {
lab=#net7}
N 2900 -1810 2910 -1820 {
lab=#net8}
N 2910 -1820 3110 -1820 {
lab=#net8}
N 3110 -1820 3120 -1810 {
lab=#net8}
N 2960 -1970 2960 -1950 {
lab=vcom}
N 3000 -1970 3000 -1950 {
lab=ctop}
N 2880 -1870 2900 -1870 {
lab=col_n[3]}
N 2880 -1850 2900 -1850 {
lab=colon_n[3]}
N 2880 -1830 2900 -1830 {
lab=#net7}
N 2880 -1810 2900 -1810 {
lab=#net8}
N 3120 -1810 3140 -1810 {
lab=#net8}
N 3120 -1830 3140 -1830 {
lab=#net7}
N 3120 -1850 3140 -1850 {
lab=colon_n[3]}
N 3120 -1870 3140 -1870 {
lab=col_n[3]}
N 2940 -1730 2940 -1720 {
lab=VSS}
N 2940 -1960 2940 -1950 {
lab=VDD}
N 3280 -1730 3290 -1740 {
lab=row_n[8]}
N 3290 -1940 3290 -1740 {
lab=row_n[8]}
N 3280 -1950 3290 -1940 {
lab=row_n[8]}
N 3280 -1730 3280 -1710 {
lab=row_n[8]}
N 3280 -1970 3280 -1950 {
lab=row_n[8]}
N 3160 -1870 3170 -1880 {
lab=col_n[3]}
N 3170 -1880 3370 -1880 {
lab=col_n[3]}
N 3370 -1880 3380 -1870 {
lab=col_n[3]}
N 3160 -1850 3170 -1860 {
lab=colon_n[3]}
N 3170 -1860 3370 -1860 {
lab=colon_n[3]}
N 3370 -1860 3380 -1850 {
lab=colon_n[3]}
N 3160 -1830 3170 -1840 {
lab=#net7}
N 3170 -1840 3370 -1840 {
lab=#net7}
N 3370 -1840 3380 -1830 {
lab=#net7}
N 3160 -1810 3170 -1820 {
lab=#net8}
N 3170 -1820 3370 -1820 {
lab=#net8}
N 3370 -1820 3380 -1810 {
lab=#net8}
N 3220 -1970 3220 -1950 {
lab=vcom}
N 3260 -1970 3260 -1950 {
lab=ctop}
N 3140 -1870 3160 -1870 {
lab=col_n[3]}
N 3140 -1850 3160 -1850 {
lab=colon_n[3]}
N 3140 -1830 3160 -1830 {
lab=#net7}
N 3140 -1810 3160 -1810 {
lab=#net8}
N 3380 -1810 3400 -1810 {
lab=#net8}
N 3380 -1830 3400 -1830 {
lab=#net7}
N 3380 -1850 3400 -1850 {
lab=colon_n[3]}
N 3380 -1870 3400 -1870 {
lab=col_n[3]}
N 3200 -1730 3200 -1720 {
lab=VSS}
N 3200 -1960 3200 -1950 {
lab=VDD}
N 3540 -1730 3550 -1740 {
lab=row_n[9]}
N 3550 -1940 3550 -1740 {
lab=row_n[9]}
N 3540 -1950 3550 -1940 {
lab=row_n[9]}
N 3540 -1730 3540 -1710 {
lab=row_n[9]}
N 3540 -1970 3540 -1950 {
lab=row_n[9]}
N 3420 -1870 3430 -1880 {
lab=col_n[3]}
N 3430 -1880 3630 -1880 {
lab=col_n[3]}
N 3630 -1880 3640 -1870 {
lab=col_n[3]}
N 3420 -1850 3430 -1860 {
lab=colon_n[3]}
N 3430 -1860 3630 -1860 {
lab=colon_n[3]}
N 3630 -1860 3640 -1850 {
lab=colon_n[3]}
N 3420 -1830 3430 -1840 {
lab=#net7}
N 3430 -1840 3630 -1840 {
lab=#net7}
N 3630 -1840 3640 -1830 {
lab=#net7}
N 3420 -1810 3430 -1820 {
lab=#net8}
N 3430 -1820 3630 -1820 {
lab=#net8}
N 3630 -1820 3640 -1810 {
lab=#net8}
N 3480 -1970 3480 -1950 {
lab=vcom}
N 3520 -1970 3520 -1950 {
lab=ctop}
N 3400 -1870 3420 -1870 {
lab=col_n[3]}
N 3400 -1850 3420 -1850 {
lab=colon_n[3]}
N 3400 -1830 3420 -1830 {
lab=#net7}
N 3400 -1810 3420 -1810 {
lab=#net8}
N 3640 -1810 3660 -1810 {
lab=#net8}
N 3640 -1830 3660 -1830 {
lab=#net7}
N 3640 -1850 3660 -1850 {
lab=colon_n[3]}
N 3640 -1870 3660 -1870 {
lab=col_n[3]}
N 3460 -1730 3460 -1720 {
lab=VSS}
N 3460 -1960 3460 -1950 {
lab=VDD}
N 3800 -1730 3810 -1740 {
lab=row_n[10]}
N 3810 -1940 3810 -1740 {
lab=row_n[10]}
N 3800 -1950 3810 -1940 {
lab=row_n[10]}
N 3800 -1730 3800 -1710 {
lab=row_n[10]}
N 3800 -1970 3800 -1950 {
lab=row_n[10]}
N 3680 -1870 3690 -1880 {
lab=col_n[3]}
N 3690 -1880 3890 -1880 {
lab=col_n[3]}
N 3890 -1880 3900 -1870 {
lab=col_n[3]}
N 3680 -1850 3690 -1860 {
lab=colon_n[3]}
N 3690 -1860 3890 -1860 {
lab=colon_n[3]}
N 3890 -1860 3900 -1850 {
lab=colon_n[3]}
N 3680 -1830 3690 -1840 {
lab=#net7}
N 3690 -1840 3890 -1840 {
lab=#net7}
N 3890 -1840 3900 -1830 {
lab=#net7}
N 3680 -1810 3690 -1820 {
lab=#net8}
N 3690 -1820 3890 -1820 {
lab=#net8}
N 3890 -1820 3900 -1810 {
lab=#net8}
N 3740 -1970 3740 -1950 {
lab=vcom}
N 3780 -1970 3780 -1950 {
lab=ctop}
N 3660 -1870 3680 -1870 {
lab=col_n[3]}
N 3660 -1850 3680 -1850 {
lab=colon_n[3]}
N 3660 -1830 3680 -1830 {
lab=#net7}
N 3660 -1810 3680 -1810 {
lab=#net8}
N 3900 -1810 3920 -1810 {
lab=#net8}
N 3900 -1830 3920 -1830 {
lab=#net7}
N 3900 -1850 3920 -1850 {
lab=colon_n[3]}
N 3900 -1870 3920 -1870 {
lab=col_n[3]}
N 3720 -1730 3720 -1720 {
lab=VSS}
N 3720 -1960 3720 -1950 {
lab=VDD}
N 4060 -1730 4070 -1740 {
lab=row_n[11]}
N 4070 -1940 4070 -1740 {
lab=row_n[11]}
N 4060 -1950 4070 -1940 {
lab=row_n[11]}
N 4060 -1730 4060 -1710 {
lab=row_n[11]}
N 4060 -1970 4060 -1950 {
lab=row_n[11]}
N 3940 -1870 3950 -1880 {
lab=col_n[3]}
N 3950 -1880 4150 -1880 {
lab=col_n[3]}
N 4150 -1880 4160 -1870 {
lab=col_n[3]}
N 3940 -1850 3950 -1860 {
lab=colon_n[3]}
N 3950 -1860 4150 -1860 {
lab=colon_n[3]}
N 4150 -1860 4160 -1850 {
lab=colon_n[3]}
N 3940 -1830 3950 -1840 {
lab=#net7}
N 3950 -1840 4150 -1840 {
lab=#net7}
N 4150 -1840 4160 -1830 {
lab=#net7}
N 3940 -1810 3950 -1820 {
lab=#net8}
N 3950 -1820 4150 -1820 {
lab=#net8}
N 4150 -1820 4160 -1810 {
lab=#net8}
N 4000 -1970 4000 -1950 {
lab=vcom}
N 4040 -1970 4040 -1950 {
lab=ctop}
N 3920 -1870 3940 -1870 {
lab=col_n[3]}
N 3920 -1850 3940 -1850 {
lab=colon_n[3]}
N 3920 -1830 3940 -1830 {
lab=#net7}
N 3920 -1810 3940 -1810 {
lab=#net8}
N 4160 -1810 4180 -1810 {
lab=#net8}
N 4160 -1830 4180 -1830 {
lab=#net7}
N 4160 -1850 4180 -1850 {
lab=colon_n[3]}
N 4160 -1870 4180 -1870 {
lab=col_n[3]}
N 3980 -1730 3980 -1720 {
lab=VSS}
N 3980 -1960 3980 -1950 {
lab=VDD}
N 4320 -1730 4330 -1740 {
lab=row_n[12]}
N 4330 -1940 4330 -1740 {
lab=row_n[12]}
N 4320 -1950 4330 -1940 {
lab=row_n[12]}
N 4320 -1730 4320 -1710 {
lab=row_n[12]}
N 4320 -1970 4320 -1950 {
lab=row_n[12]}
N 4200 -1870 4210 -1880 {
lab=col_n[3]}
N 4210 -1880 4410 -1880 {
lab=col_n[3]}
N 4410 -1880 4420 -1870 {
lab=col_n[3]}
N 4200 -1850 4210 -1860 {
lab=colon_n[3]}
N 4210 -1860 4410 -1860 {
lab=colon_n[3]}
N 4410 -1860 4420 -1850 {
lab=colon_n[3]}
N 4200 -1830 4210 -1840 {
lab=#net7}
N 4210 -1840 4410 -1840 {
lab=#net7}
N 4410 -1840 4420 -1830 {
lab=#net7}
N 4200 -1810 4210 -1820 {
lab=#net8}
N 4210 -1820 4410 -1820 {
lab=#net8}
N 4410 -1820 4420 -1810 {
lab=#net8}
N 4260 -1970 4260 -1950 {
lab=vcom}
N 4300 -1970 4300 -1950 {
lab=ctop}
N 4180 -1870 4200 -1870 {
lab=col_n[3]}
N 4180 -1850 4200 -1850 {
lab=colon_n[3]}
N 4180 -1830 4200 -1830 {
lab=#net7}
N 4180 -1810 4200 -1810 {
lab=#net8}
N 4420 -1810 4440 -1810 {
lab=#net8}
N 4420 -1830 4440 -1830 {
lab=#net7}
N 4420 -1850 4440 -1850 {
lab=colon_n[3]}
N 4420 -1870 4440 -1870 {
lab=col_n[3]}
N 4240 -1730 4240 -1720 {
lab=VSS}
N 4240 -1960 4240 -1950 {
lab=VDD}
N 4580 -1730 4590 -1740 {
lab=row_n[13]}
N 4590 -1940 4590 -1740 {
lab=row_n[13]}
N 4580 -1950 4590 -1940 {
lab=row_n[13]}
N 4580 -1730 4580 -1710 {
lab=row_n[13]}
N 4580 -1970 4580 -1950 {
lab=row_n[13]}
N 4460 -1870 4470 -1880 {
lab=col_n[3]}
N 4470 -1880 4670 -1880 {
lab=col_n[3]}
N 4670 -1880 4680 -1870 {
lab=col_n[3]}
N 4460 -1850 4470 -1860 {
lab=colon_n[3]}
N 4470 -1860 4670 -1860 {
lab=colon_n[3]}
N 4670 -1860 4680 -1850 {
lab=colon_n[3]}
N 4460 -1830 4470 -1840 {
lab=#net7}
N 4470 -1840 4670 -1840 {
lab=#net7}
N 4670 -1840 4680 -1830 {
lab=#net7}
N 4460 -1810 4470 -1820 {
lab=#net8}
N 4470 -1820 4670 -1820 {
lab=#net8}
N 4670 -1820 4680 -1810 {
lab=#net8}
N 4520 -1970 4520 -1950 {
lab=vcom}
N 4560 -1970 4560 -1950 {
lab=ctop}
N 4440 -1870 4460 -1870 {
lab=col_n[3]}
N 4440 -1850 4460 -1850 {
lab=colon_n[3]}
N 4440 -1830 4460 -1830 {
lab=#net7}
N 4440 -1810 4460 -1810 {
lab=#net8}
N 4680 -1810 4700 -1810 {
lab=#net8}
N 4680 -1830 4700 -1830 {
lab=#net7}
N 4680 -1850 4700 -1850 {
lab=colon_n[3]}
N 4680 -1870 4700 -1870 {
lab=col_n[3]}
N 4500 -1730 4500 -1720 {
lab=VSS}
N 4500 -1960 4500 -1950 {
lab=VDD}
N 4840 -1730 4850 -1740 {
lab=row_n[14]}
N 4850 -1940 4850 -1740 {
lab=row_n[14]}
N 4840 -1950 4850 -1940 {
lab=row_n[14]}
N 4840 -1730 4840 -1710 {
lab=row_n[14]}
N 4840 -1970 4840 -1950 {
lab=row_n[14]}
N 4720 -1870 4730 -1880 {
lab=col_n[3]}
N 4730 -1880 4930 -1880 {
lab=col_n[3]}
N 4930 -1880 4940 -1870 {
lab=col_n[3]}
N 4720 -1850 4730 -1860 {
lab=colon_n[3]}
N 4730 -1860 4930 -1860 {
lab=colon_n[3]}
N 4930 -1860 4940 -1850 {
lab=colon_n[3]}
N 4720 -1830 4730 -1840 {
lab=#net7}
N 4730 -1840 4930 -1840 {
lab=#net7}
N 4930 -1840 4940 -1830 {
lab=#net7}
N 4720 -1810 4730 -1820 {
lab=#net8}
N 4730 -1820 4930 -1820 {
lab=#net8}
N 4930 -1820 4940 -1810 {
lab=#net8}
N 4780 -1970 4780 -1950 {
lab=vcom}
N 4820 -1970 4820 -1950 {
lab=ctop}
N 4700 -1870 4720 -1870 {
lab=col_n[3]}
N 4700 -1850 4720 -1850 {
lab=colon_n[3]}
N 4700 -1830 4720 -1830 {
lab=#net7}
N 4700 -1810 4720 -1810 {
lab=#net8}
N 4940 -1810 4960 -1810 {
lab=#net8}
N 4940 -1830 4960 -1830 {
lab=#net7}
N 4940 -1850 4960 -1850 {
lab=colon_n[3]}
N 4940 -1870 4960 -1870 {
lab=col_n[3]}
N 4760 -1730 4760 -1720 {
lab=VSS}
N 4760 -1960 4760 -1950 {
lab=VDD}
N 5100 -1730 5110 -1740 {
lab=row_n[15]}
N 5110 -1940 5110 -1740 {
lab=row_n[15]}
N 5100 -1950 5110 -1940 {
lab=row_n[15]}
N 5100 -1730 5100 -1710 {
lab=row_n[15]}
N 5100 -1970 5100 -1950 {
lab=row_n[15]}
N 4980 -1870 4990 -1880 {
lab=col_n[3]}
N 4990 -1880 5190 -1880 {
lab=col_n[3]}
N 5190 -1880 5200 -1870 {
lab=col_n[3]}
N 4980 -1850 4990 -1860 {
lab=colon_n[3]}
N 4990 -1860 5190 -1860 {
lab=colon_n[3]}
N 5190 -1860 5200 -1850 {
lab=colon_n[3]}
N 4980 -1830 4990 -1840 {
lab=#net7}
N 4990 -1840 5190 -1840 {
lab=#net7}
N 5190 -1840 5200 -1830 {
lab=#net7}
N 4980 -1810 4990 -1820 {
lab=#net8}
N 4990 -1820 5190 -1820 {
lab=#net8}
N 5190 -1820 5200 -1810 {
lab=#net8}
N 5040 -1970 5040 -1950 {
lab=vcom}
N 5080 -1970 5080 -1950 {
lab=ctop}
N 4960 -1870 4980 -1870 {
lab=col_n[3]}
N 4960 -1850 4980 -1850 {
lab=colon_n[3]}
N 4960 -1830 4980 -1830 {
lab=#net7}
N 4960 -1810 4980 -1810 {
lab=#net8}
N 5200 -1810 5220 -1810 {
lab=#net8}
N 5200 -1830 5220 -1830 {
lab=#net7}
N 5200 -1850 5220 -1850 {
lab=colon_n[3]}
N 5200 -1870 5220 -1870 {
lab=col_n[3]}
N 5020 -1730 5020 -1720 {
lab=VSS}
N 5020 -1960 5020 -1950 {
lab=VDD}
N 5360 -1730 5370 -1740 {
lab=row_n[16]}
N 5370 -1940 5370 -1740 {
lab=row_n[16]}
N 5360 -1950 5370 -1940 {
lab=row_n[16]}
N 5360 -1730 5360 -1710 {
lab=row_n[16]}
N 5360 -1970 5360 -1950 {
lab=row_n[16]}
N 5240 -1870 5250 -1880 {
lab=col_n[3]}
N 5250 -1880 5450 -1880 {
lab=col_n[3]}
N 5450 -1880 5460 -1870 {
lab=col_n[3]}
N 5240 -1850 5250 -1860 {
lab=colon_n[3]}
N 5250 -1860 5450 -1860 {
lab=colon_n[3]}
N 5450 -1860 5460 -1850 {
lab=colon_n[3]}
N 5240 -1830 5250 -1840 {
lab=#net7}
N 5250 -1840 5450 -1840 {
lab=#net7}
N 5450 -1840 5460 -1830 {
lab=#net7}
N 5240 -1810 5250 -1820 {
lab=#net8}
N 5250 -1820 5450 -1820 {
lab=#net8}
N 5450 -1820 5460 -1810 {
lab=#net8}
N 5300 -1970 5300 -1950 {
lab=vcom}
N 5340 -1970 5340 -1950 {
lab=ctop}
N 5220 -1870 5240 -1870 {
lab=col_n[3]}
N 5220 -1850 5240 -1850 {
lab=colon_n[3]}
N 5220 -1830 5240 -1830 {
lab=#net7}
N 5220 -1810 5240 -1810 {
lab=#net8}
N 5460 -1810 5480 -1810 {
lab=#net8}
N 5460 -1830 5480 -1830 {
lab=#net7}
N 5460 -1850 5480 -1850 {
lab=colon_n[3]}
N 5460 -1870 5480 -1870 {
lab=col_n[3]}
N 5280 -1730 5280 -1720 {
lab=VSS}
N 5280 -1960 5280 -1950 {
lab=VDD}
N 5620 -1730 5630 -1740 {
lab=row_n[17]}
N 5630 -1940 5630 -1740 {
lab=row_n[17]}
N 5620 -1950 5630 -1940 {
lab=row_n[17]}
N 5620 -1730 5620 -1710 {
lab=row_n[17]}
N 5620 -1970 5620 -1950 {
lab=row_n[17]}
N 5500 -1870 5510 -1880 {
lab=col_n[3]}
N 5510 -1880 5710 -1880 {
lab=col_n[3]}
N 5710 -1880 5720 -1870 {
lab=col_n[3]}
N 5500 -1850 5510 -1860 {
lab=colon_n[3]}
N 5510 -1860 5710 -1860 {
lab=colon_n[3]}
N 5710 -1860 5720 -1850 {
lab=colon_n[3]}
N 5500 -1830 5510 -1840 {
lab=#net7}
N 5510 -1840 5710 -1840 {
lab=#net7}
N 5710 -1840 5720 -1830 {
lab=#net7}
N 5500 -1810 5510 -1820 {
lab=#net8}
N 5510 -1820 5710 -1820 {
lab=#net8}
N 5710 -1820 5720 -1810 {
lab=#net8}
N 5560 -1970 5560 -1950 {
lab=vcom}
N 5600 -1970 5600 -1950 {
lab=ctop}
N 5480 -1870 5500 -1870 {
lab=col_n[3]}
N 5480 -1850 5500 -1850 {
lab=colon_n[3]}
N 5480 -1830 5500 -1830 {
lab=#net7}
N 5480 -1810 5500 -1810 {
lab=#net8}
N 5720 -1810 5740 -1810 {
lab=#net8}
N 5720 -1830 5740 -1830 {
lab=#net7}
N 5720 -1850 5740 -1850 {
lab=colon_n[3]}
N 5720 -1870 5740 -1870 {
lab=col_n[3]}
N 5540 -1730 5540 -1720 {
lab=VSS}
N 5540 -1960 5540 -1950 {
lab=VDD}
N 5880 -1730 5890 -1740 {
lab=row_n[18]}
N 5890 -1940 5890 -1740 {
lab=row_n[18]}
N 5880 -1950 5890 -1940 {
lab=row_n[18]}
N 5880 -1730 5880 -1710 {
lab=row_n[18]}
N 5880 -1970 5880 -1950 {
lab=row_n[18]}
N 5760 -1870 5770 -1880 {
lab=col_n[3]}
N 5770 -1880 5970 -1880 {
lab=col_n[3]}
N 5970 -1880 5980 -1870 {
lab=col_n[3]}
N 5760 -1850 5770 -1860 {
lab=colon_n[3]}
N 5770 -1860 5970 -1860 {
lab=colon_n[3]}
N 5970 -1860 5980 -1850 {
lab=colon_n[3]}
N 5760 -1830 5770 -1840 {
lab=#net7}
N 5770 -1840 5970 -1840 {
lab=#net7}
N 5970 -1840 5980 -1830 {
lab=#net7}
N 5760 -1810 5770 -1820 {
lab=#net8}
N 5770 -1820 5970 -1820 {
lab=#net8}
N 5970 -1820 5980 -1810 {
lab=#net8}
N 5820 -1970 5820 -1950 {
lab=vcom}
N 5860 -1970 5860 -1950 {
lab=ctop}
N 5740 -1870 5760 -1870 {
lab=col_n[3]}
N 5740 -1850 5760 -1850 {
lab=colon_n[3]}
N 5740 -1830 5760 -1830 {
lab=#net7}
N 5740 -1810 5760 -1810 {
lab=#net8}
N 5980 -1810 6000 -1810 {
lab=#net8}
N 5980 -1830 6000 -1830 {
lab=#net7}
N 5980 -1850 6000 -1850 {
lab=colon_n[3]}
N 5980 -1870 6000 -1870 {
lab=col_n[3]}
N 5800 -1730 5800 -1720 {
lab=VSS}
N 5800 -1960 5800 -1950 {
lab=VDD}
N 6140 -1730 6150 -1740 {
lab=row_n[19]}
N 6150 -1940 6150 -1740 {
lab=row_n[19]}
N 6140 -1950 6150 -1940 {
lab=row_n[19]}
N 6140 -1730 6140 -1710 {
lab=row_n[19]}
N 6140 -1970 6140 -1950 {
lab=row_n[19]}
N 6020 -1870 6030 -1880 {
lab=col_n[3]}
N 6030 -1880 6230 -1880 {
lab=col_n[3]}
N 6230 -1880 6240 -1870 {
lab=col_n[3]}
N 6020 -1850 6030 -1860 {
lab=colon_n[3]}
N 6030 -1860 6230 -1860 {
lab=colon_n[3]}
N 6230 -1860 6240 -1850 {
lab=colon_n[3]}
N 6020 -1830 6030 -1840 {
lab=#net7}
N 6030 -1840 6230 -1840 {
lab=#net7}
N 6230 -1840 6240 -1830 {
lab=#net7}
N 6020 -1810 6030 -1820 {
lab=#net8}
N 6030 -1820 6230 -1820 {
lab=#net8}
N 6230 -1820 6240 -1810 {
lab=#net8}
N 6080 -1970 6080 -1950 {
lab=vcom}
N 6120 -1970 6120 -1950 {
lab=ctop}
N 6000 -1870 6020 -1870 {
lab=col_n[3]}
N 6000 -1850 6020 -1850 {
lab=colon_n[3]}
N 6000 -1830 6020 -1830 {
lab=#net7}
N 6000 -1810 6020 -1810 {
lab=#net8}
N 6240 -1810 6260 -1810 {
lab=#net8}
N 6240 -1830 6260 -1830 {
lab=#net7}
N 6240 -1850 6260 -1850 {
lab=colon_n[3]}
N 6240 -1870 6260 -1870 {
lab=col_n[3]}
N 6060 -1730 6060 -1720 {
lab=VSS}
N 6060 -1960 6060 -1950 {
lab=VDD}
N 6400 -1730 6410 -1740 {
lab=row_n[20]}
N 6410 -1940 6410 -1740 {
lab=row_n[20]}
N 6400 -1950 6410 -1940 {
lab=row_n[20]}
N 6400 -1730 6400 -1710 {
lab=row_n[20]}
N 6400 -1970 6400 -1950 {
lab=row_n[20]}
N 6280 -1870 6290 -1880 {
lab=col_n[3]}
N 6290 -1880 6490 -1880 {
lab=col_n[3]}
N 6490 -1880 6500 -1870 {
lab=col_n[3]}
N 6280 -1850 6290 -1860 {
lab=colon_n[3]}
N 6290 -1860 6490 -1860 {
lab=colon_n[3]}
N 6490 -1860 6500 -1850 {
lab=colon_n[3]}
N 6280 -1830 6290 -1840 {
lab=#net7}
N 6290 -1840 6490 -1840 {
lab=#net7}
N 6490 -1840 6500 -1830 {
lab=#net7}
N 6280 -1810 6290 -1820 {
lab=#net8}
N 6290 -1820 6490 -1820 {
lab=#net8}
N 6490 -1820 6500 -1810 {
lab=#net8}
N 6340 -1970 6340 -1950 {
lab=vcom}
N 6380 -1970 6380 -1950 {
lab=ctop}
N 6260 -1870 6280 -1870 {
lab=col_n[3]}
N 6260 -1850 6280 -1850 {
lab=colon_n[3]}
N 6260 -1830 6280 -1830 {
lab=#net7}
N 6260 -1810 6280 -1810 {
lab=#net8}
N 6500 -1810 6520 -1810 {
lab=#net8}
N 6500 -1830 6520 -1830 {
lab=#net7}
N 6500 -1850 6520 -1850 {
lab=colon_n[3]}
N 6500 -1870 6520 -1870 {
lab=col_n[3]}
N 6320 -1730 6320 -1720 {
lab=VSS}
N 6320 -1960 6320 -1950 {
lab=VDD}
N 6660 -1730 6670 -1740 {
lab=row_n[21]}
N 6670 -1940 6670 -1740 {
lab=row_n[21]}
N 6660 -1950 6670 -1940 {
lab=row_n[21]}
N 6660 -1730 6660 -1710 {
lab=row_n[21]}
N 6660 -1970 6660 -1950 {
lab=row_n[21]}
N 6540 -1870 6550 -1880 {
lab=col_n[3]}
N 6550 -1880 6750 -1880 {
lab=col_n[3]}
N 6750 -1880 6760 -1870 {
lab=col_n[3]}
N 6540 -1850 6550 -1860 {
lab=colon_n[3]}
N 6550 -1860 6750 -1860 {
lab=colon_n[3]}
N 6750 -1860 6760 -1850 {
lab=colon_n[3]}
N 6540 -1830 6550 -1840 {
lab=#net7}
N 6550 -1840 6750 -1840 {
lab=#net7}
N 6750 -1840 6760 -1830 {
lab=#net7}
N 6540 -1810 6550 -1820 {
lab=#net8}
N 6550 -1820 6750 -1820 {
lab=#net8}
N 6750 -1820 6760 -1810 {
lab=#net8}
N 6600 -1970 6600 -1950 {
lab=vcom}
N 6640 -1970 6640 -1950 {
lab=ctop}
N 6520 -1870 6540 -1870 {
lab=col_n[3]}
N 6520 -1850 6540 -1850 {
lab=colon_n[3]}
N 6520 -1830 6540 -1830 {
lab=#net7}
N 6520 -1810 6540 -1810 {
lab=#net8}
N 6760 -1810 6780 -1810 {
lab=#net8}
N 6760 -1830 6780 -1830 {
lab=#net7}
N 6760 -1850 6780 -1850 {
lab=colon_n[3]}
N 6760 -1870 6780 -1870 {
lab=col_n[3]}
N 6580 -1730 6580 -1720 {
lab=VSS}
N 6580 -1960 6580 -1950 {
lab=VDD}
N 6920 -1730 6930 -1740 {
lab=row_n[22]}
N 6930 -1940 6930 -1740 {
lab=row_n[22]}
N 6920 -1950 6930 -1940 {
lab=row_n[22]}
N 6920 -1730 6920 -1710 {
lab=row_n[22]}
N 6920 -1970 6920 -1950 {
lab=row_n[22]}
N 6800 -1870 6810 -1880 {
lab=col_n[3]}
N 6810 -1880 7010 -1880 {
lab=col_n[3]}
N 7010 -1880 7020 -1870 {
lab=col_n[3]}
N 6800 -1850 6810 -1860 {
lab=colon_n[3]}
N 6810 -1860 7010 -1860 {
lab=colon_n[3]}
N 7010 -1860 7020 -1850 {
lab=colon_n[3]}
N 6800 -1830 6810 -1840 {
lab=#net7}
N 6810 -1840 7010 -1840 {
lab=#net7}
N 7010 -1840 7020 -1830 {
lab=#net7}
N 6800 -1810 6810 -1820 {
lab=#net8}
N 6810 -1820 7010 -1820 {
lab=#net8}
N 7010 -1820 7020 -1810 {
lab=#net8}
N 6860 -1970 6860 -1950 {
lab=vcom}
N 6900 -1970 6900 -1950 {
lab=ctop}
N 6780 -1870 6800 -1870 {
lab=col_n[3]}
N 6780 -1850 6800 -1850 {
lab=colon_n[3]}
N 6780 -1830 6800 -1830 {
lab=#net7}
N 6780 -1810 6800 -1810 {
lab=#net8}
N 7020 -1810 7040 -1810 {
lab=#net8}
N 7020 -1830 7040 -1830 {
lab=#net7}
N 7020 -1850 7040 -1850 {
lab=colon_n[3]}
N 7020 -1870 7040 -1870 {
lab=col_n[3]}
N 6840 -1730 6840 -1720 {
lab=VSS}
N 6840 -1960 6840 -1950 {
lab=VDD}
N 7180 -1730 7190 -1740 {
lab=row_n[23]}
N 7190 -1940 7190 -1740 {
lab=row_n[23]}
N 7180 -1950 7190 -1940 {
lab=row_n[23]}
N 7180 -1730 7180 -1710 {
lab=row_n[23]}
N 7180 -1970 7180 -1950 {
lab=row_n[23]}
N 7060 -1870 7070 -1880 {
lab=col_n[3]}
N 7070 -1880 7270 -1880 {
lab=col_n[3]}
N 7270 -1880 7280 -1870 {
lab=col_n[3]}
N 7060 -1850 7070 -1860 {
lab=colon_n[3]}
N 7070 -1860 7270 -1860 {
lab=colon_n[3]}
N 7270 -1860 7280 -1850 {
lab=colon_n[3]}
N 7060 -1830 7070 -1840 {
lab=#net7}
N 7070 -1840 7270 -1840 {
lab=#net7}
N 7270 -1840 7280 -1830 {
lab=#net7}
N 7060 -1810 7070 -1820 {
lab=#net8}
N 7070 -1820 7270 -1820 {
lab=#net8}
N 7270 -1820 7280 -1810 {
lab=#net8}
N 7120 -1970 7120 -1950 {
lab=vcom}
N 7160 -1970 7160 -1950 {
lab=ctop}
N 7040 -1870 7060 -1870 {
lab=col_n[3]}
N 7040 -1850 7060 -1850 {
lab=colon_n[3]}
N 7040 -1830 7060 -1830 {
lab=#net7}
N 7040 -1810 7060 -1810 {
lab=#net8}
N 7280 -1810 7300 -1810 {
lab=#net8}
N 7280 -1830 7300 -1830 {
lab=#net7}
N 7280 -1850 7300 -1850 {
lab=colon_n[3]}
N 7280 -1870 7300 -1870 {
lab=col_n[3]}
N 7100 -1730 7100 -1720 {
lab=VSS}
N 7100 -1960 7100 -1950 {
lab=VDD}
N 7440 -1730 7450 -1740 {
lab=row_n[24]}
N 7450 -1940 7450 -1740 {
lab=row_n[24]}
N 7440 -1950 7450 -1940 {
lab=row_n[24]}
N 7440 -1730 7440 -1710 {
lab=row_n[24]}
N 7440 -1970 7440 -1950 {
lab=row_n[24]}
N 7320 -1870 7330 -1880 {
lab=col_n[3]}
N 7330 -1880 7530 -1880 {
lab=col_n[3]}
N 7530 -1880 7540 -1870 {
lab=col_n[3]}
N 7320 -1850 7330 -1860 {
lab=colon_n[3]}
N 7330 -1860 7530 -1860 {
lab=colon_n[3]}
N 7530 -1860 7540 -1850 {
lab=colon_n[3]}
N 7320 -1830 7330 -1840 {
lab=#net7}
N 7330 -1840 7530 -1840 {
lab=#net7}
N 7530 -1840 7540 -1830 {
lab=#net7}
N 7320 -1810 7330 -1820 {
lab=#net8}
N 7330 -1820 7530 -1820 {
lab=#net8}
N 7530 -1820 7540 -1810 {
lab=#net8}
N 7380 -1970 7380 -1950 {
lab=vcom}
N 7420 -1970 7420 -1950 {
lab=ctop}
N 7300 -1870 7320 -1870 {
lab=col_n[3]}
N 7300 -1850 7320 -1850 {
lab=colon_n[3]}
N 7300 -1830 7320 -1830 {
lab=#net7}
N 7300 -1810 7320 -1810 {
lab=#net8}
N 7540 -1810 7560 -1810 {
lab=#net8}
N 7540 -1830 7560 -1830 {
lab=#net7}
N 7540 -1850 7560 -1850 {
lab=colon_n[3]}
N 7540 -1870 7560 -1870 {
lab=col_n[3]}
N 7360 -1730 7360 -1720 {
lab=VSS}
N 7360 -1960 7360 -1950 {
lab=VDD}
N 7700 -1730 7710 -1740 {
lab=row_n[25]}
N 7710 -1940 7710 -1740 {
lab=row_n[25]}
N 7700 -1950 7710 -1940 {
lab=row_n[25]}
N 7700 -1730 7700 -1710 {
lab=row_n[25]}
N 7700 -1970 7700 -1950 {
lab=row_n[25]}
N 7580 -1870 7590 -1880 {
lab=col_n[3]}
N 7590 -1880 7790 -1880 {
lab=col_n[3]}
N 7790 -1880 7800 -1870 {
lab=col_n[3]}
N 7580 -1850 7590 -1860 {
lab=colon_n[3]}
N 7590 -1860 7790 -1860 {
lab=colon_n[3]}
N 7790 -1860 7800 -1850 {
lab=colon_n[3]}
N 7580 -1830 7590 -1840 {
lab=#net7}
N 7590 -1840 7790 -1840 {
lab=#net7}
N 7790 -1840 7800 -1830 {
lab=#net7}
N 7580 -1810 7590 -1820 {
lab=#net8}
N 7590 -1820 7790 -1820 {
lab=#net8}
N 7790 -1820 7800 -1810 {
lab=#net8}
N 7640 -1970 7640 -1950 {
lab=vcom}
N 7680 -1970 7680 -1950 {
lab=ctop}
N 7560 -1870 7580 -1870 {
lab=col_n[3]}
N 7560 -1850 7580 -1850 {
lab=colon_n[3]}
N 7560 -1830 7580 -1830 {
lab=#net7}
N 7560 -1810 7580 -1810 {
lab=#net8}
N 7800 -1810 7820 -1810 {
lab=#net8}
N 7800 -1830 7820 -1830 {
lab=#net7}
N 7800 -1850 7820 -1850 {
lab=colon_n[3]}
N 7800 -1870 7820 -1870 {
lab=col_n[3]}
N 7620 -1730 7620 -1720 {
lab=VSS}
N 7620 -1960 7620 -1950 {
lab=VDD}
N 7960 -1730 7970 -1740 {
lab=row_n[26]}
N 7970 -1940 7970 -1740 {
lab=row_n[26]}
N 7960 -1950 7970 -1940 {
lab=row_n[26]}
N 7960 -1730 7960 -1710 {
lab=row_n[26]}
N 7960 -1970 7960 -1950 {
lab=row_n[26]}
N 7840 -1870 7850 -1880 {
lab=col_n[3]}
N 7850 -1880 8050 -1880 {
lab=col_n[3]}
N 8050 -1880 8060 -1870 {
lab=col_n[3]}
N 7840 -1850 7850 -1860 {
lab=colon_n[3]}
N 7850 -1860 8050 -1860 {
lab=colon_n[3]}
N 8050 -1860 8060 -1850 {
lab=colon_n[3]}
N 7840 -1830 7850 -1840 {
lab=#net7}
N 7850 -1840 8050 -1840 {
lab=#net7}
N 8050 -1840 8060 -1830 {
lab=#net7}
N 7840 -1810 7850 -1820 {
lab=#net8}
N 7850 -1820 8050 -1820 {
lab=#net8}
N 8050 -1820 8060 -1810 {
lab=#net8}
N 7900 -1970 7900 -1950 {
lab=vcom}
N 7940 -1970 7940 -1950 {
lab=ctop}
N 7820 -1870 7840 -1870 {
lab=col_n[3]}
N 7820 -1850 7840 -1850 {
lab=colon_n[3]}
N 7820 -1830 7840 -1830 {
lab=#net7}
N 7820 -1810 7840 -1810 {
lab=#net8}
N 8060 -1810 8080 -1810 {
lab=#net8}
N 8060 -1830 8080 -1830 {
lab=#net7}
N 8060 -1850 8080 -1850 {
lab=colon_n[3]}
N 8060 -1870 8080 -1870 {
lab=col_n[3]}
N 7880 -1730 7880 -1720 {
lab=VSS}
N 7880 -1960 7880 -1950 {
lab=VDD}
N 8220 -1730 8230 -1740 {
lab=row_n[27]}
N 8230 -1940 8230 -1740 {
lab=row_n[27]}
N 8220 -1950 8230 -1940 {
lab=row_n[27]}
N 8220 -1730 8220 -1710 {
lab=row_n[27]}
N 8220 -1970 8220 -1950 {
lab=row_n[27]}
N 8100 -1870 8110 -1880 {
lab=col_n[3]}
N 8110 -1880 8310 -1880 {
lab=col_n[3]}
N 8310 -1880 8320 -1870 {
lab=col_n[3]}
N 8100 -1850 8110 -1860 {
lab=colon_n[3]}
N 8110 -1860 8310 -1860 {
lab=colon_n[3]}
N 8310 -1860 8320 -1850 {
lab=colon_n[3]}
N 8100 -1830 8110 -1840 {
lab=#net7}
N 8110 -1840 8310 -1840 {
lab=#net7}
N 8310 -1840 8320 -1830 {
lab=#net7}
N 8100 -1810 8110 -1820 {
lab=#net8}
N 8110 -1820 8310 -1820 {
lab=#net8}
N 8310 -1820 8320 -1810 {
lab=#net8}
N 8160 -1970 8160 -1950 {
lab=vcom}
N 8200 -1970 8200 -1950 {
lab=ctop}
N 8080 -1870 8100 -1870 {
lab=col_n[3]}
N 8080 -1850 8100 -1850 {
lab=colon_n[3]}
N 8080 -1830 8100 -1830 {
lab=#net7}
N 8080 -1810 8100 -1810 {
lab=#net8}
N 8320 -1810 8340 -1810 {
lab=#net8}
N 8320 -1830 8340 -1830 {
lab=#net7}
N 8320 -1850 8340 -1850 {
lab=colon_n[3]}
N 8320 -1870 8340 -1870 {
lab=col_n[3]}
N 8140 -1730 8140 -1720 {
lab=VSS}
N 8140 -1960 8140 -1950 {
lab=VDD}
N 8480 -1730 8490 -1740 {
lab=row_n[28]}
N 8490 -1940 8490 -1740 {
lab=row_n[28]}
N 8480 -1950 8490 -1940 {
lab=row_n[28]}
N 8480 -1730 8480 -1710 {
lab=row_n[28]}
N 8480 -1970 8480 -1950 {
lab=row_n[28]}
N 8360 -1870 8370 -1880 {
lab=col_n[3]}
N 8370 -1880 8570 -1880 {
lab=col_n[3]}
N 8570 -1880 8580 -1870 {
lab=col_n[3]}
N 8360 -1850 8370 -1860 {
lab=colon_n[3]}
N 8370 -1860 8570 -1860 {
lab=colon_n[3]}
N 8570 -1860 8580 -1850 {
lab=colon_n[3]}
N 8360 -1830 8370 -1840 {
lab=#net7}
N 8370 -1840 8570 -1840 {
lab=#net7}
N 8570 -1840 8580 -1830 {
lab=#net7}
N 8360 -1810 8370 -1820 {
lab=#net8}
N 8370 -1820 8570 -1820 {
lab=#net8}
N 8570 -1820 8580 -1810 {
lab=#net8}
N 8420 -1970 8420 -1950 {
lab=vcom}
N 8460 -1970 8460 -1950 {
lab=ctop}
N 8340 -1870 8360 -1870 {
lab=col_n[3]}
N 8340 -1850 8360 -1850 {
lab=colon_n[3]}
N 8340 -1830 8360 -1830 {
lab=#net7}
N 8340 -1810 8360 -1810 {
lab=#net8}
N 8580 -1810 8600 -1810 {
lab=#net8}
N 8580 -1830 8600 -1830 {
lab=#net7}
N 8580 -1850 8600 -1850 {
lab=colon_n[3]}
N 8580 -1870 8600 -1870 {
lab=col_n[3]}
N 8400 -1730 8400 -1720 {
lab=VSS}
N 8400 -1960 8400 -1950 {
lab=VDD}
N 8740 -1730 8750 -1740 {
lab=row_n[29]}
N 8750 -1940 8750 -1740 {
lab=row_n[29]}
N 8740 -1950 8750 -1940 {
lab=row_n[29]}
N 8740 -1730 8740 -1710 {
lab=row_n[29]}
N 8740 -1970 8740 -1950 {
lab=row_n[29]}
N 8620 -1870 8630 -1880 {
lab=col_n[3]}
N 8630 -1880 8830 -1880 {
lab=col_n[3]}
N 8830 -1880 8840 -1870 {
lab=col_n[3]}
N 8620 -1850 8630 -1860 {
lab=colon_n[3]}
N 8630 -1860 8830 -1860 {
lab=colon_n[3]}
N 8830 -1860 8840 -1850 {
lab=colon_n[3]}
N 8620 -1830 8630 -1840 {
lab=#net7}
N 8630 -1840 8830 -1840 {
lab=#net7}
N 8830 -1840 8840 -1830 {
lab=#net7}
N 8620 -1810 8630 -1820 {
lab=#net8}
N 8630 -1820 8830 -1820 {
lab=#net8}
N 8830 -1820 8840 -1810 {
lab=#net8}
N 8680 -1970 8680 -1950 {
lab=vcom}
N 8720 -1970 8720 -1950 {
lab=ctop}
N 8600 -1870 8620 -1870 {
lab=col_n[3]}
N 8600 -1850 8620 -1850 {
lab=colon_n[3]}
N 8600 -1830 8620 -1830 {
lab=#net7}
N 8600 -1810 8620 -1810 {
lab=#net8}
N 8840 -1810 8860 -1810 {
lab=#net8}
N 8840 -1830 8860 -1830 {
lab=#net7}
N 8840 -1850 8860 -1850 {
lab=colon_n[3]}
N 8840 -1870 8860 -1870 {
lab=col_n[3]}
N 8660 -1730 8660 -1720 {
lab=VSS}
N 8660 -1960 8660 -1950 {
lab=VDD}
N 9000 -1730 9010 -1740 {
lab=row_n[30]}
N 9010 -1940 9010 -1740 {
lab=row_n[30]}
N 9000 -1950 9010 -1940 {
lab=row_n[30]}
N 9000 -1730 9000 -1710 {
lab=row_n[30]}
N 9000 -1970 9000 -1950 {
lab=row_n[30]}
N 8880 -1870 8890 -1880 {
lab=col_n[3]}
N 8890 -1880 9090 -1880 {
lab=col_n[3]}
N 9090 -1880 9100 -1870 {
lab=col_n[3]}
N 8880 -1850 8890 -1860 {
lab=colon_n[3]}
N 8890 -1860 9090 -1860 {
lab=colon_n[3]}
N 9090 -1860 9100 -1850 {
lab=colon_n[3]}
N 8880 -1830 8890 -1840 {
lab=#net7}
N 8890 -1840 9090 -1840 {
lab=#net7}
N 9090 -1840 9100 -1830 {
lab=#net7}
N 8880 -1810 8890 -1820 {
lab=#net8}
N 8890 -1820 9090 -1820 {
lab=#net8}
N 9090 -1820 9100 -1810 {
lab=#net8}
N 8940 -1970 8940 -1950 {
lab=vcom}
N 8980 -1970 8980 -1950 {
lab=ctop}
N 8860 -1870 8880 -1870 {
lab=col_n[3]}
N 8860 -1850 8880 -1850 {
lab=colon_n[3]}
N 8860 -1830 8880 -1830 {
lab=#net7}
N 8860 -1810 8880 -1810 {
lab=#net8}
N 9100 -1810 9120 -1810 {
lab=#net8}
N 9100 -1830 9120 -1830 {
lab=#net7}
N 9100 -1850 9120 -1850 {
lab=colon_n[3]}
N 9100 -1870 9120 -1870 {
lab=col_n[3]}
N 8920 -1730 8920 -1720 {
lab=VSS}
N 8920 -1960 8920 -1950 {
lab=VDD}
N 9260 -1730 9270 -1740 {
lab=row_n[31]}
N 9270 -1940 9270 -1740 {
lab=row_n[31]}
N 9260 -1950 9270 -1940 {
lab=row_n[31]}
N 9260 -1730 9260 -1710 {
lab=row_n[31]}
N 9260 -1970 9260 -1950 {
lab=row_n[31]}
N 9140 -1870 9150 -1880 {
lab=col_n[3]}
N 9150 -1880 9350 -1880 {
lab=col_n[3]}
N 9350 -1880 9360 -1870 {
lab=col_n[3]}
N 9140 -1850 9150 -1860 {
lab=colon_n[3]}
N 9150 -1860 9350 -1860 {
lab=colon_n[3]}
N 9350 -1860 9360 -1850 {
lab=colon_n[3]}
N 9140 -1830 9150 -1840 {
lab=#net7}
N 9150 -1840 9350 -1840 {
lab=#net7}
N 9350 -1840 9360 -1830 {
lab=#net7}
N 9140 -1810 9150 -1820 {
lab=#net8}
N 9150 -1820 9350 -1820 {
lab=#net8}
N 9350 -1820 9360 -1810 {
lab=#net8}
N 9200 -1970 9200 -1950 {
lab=vcom}
N 9240 -1970 9240 -1950 {
lab=ctop}
N 9120 -1870 9140 -1870 {
lab=col_n[3]}
N 9120 -1850 9140 -1850 {
lab=colon_n[3]}
N 9120 -1830 9140 -1830 {
lab=#net7}
N 9120 -1810 9140 -1810 {
lab=#net8}
N 9360 -1810 9380 -1810 {
lab=#net8}
N 9360 -1830 9380 -1830 {
lab=#net7}
N 9360 -1850 9380 -1850 {
lab=colon_n[3]}
N 9360 -1870 9380 -1870 {
lab=col_n[3]}
N 9180 -1730 9180 -1720 {
lab=VSS}
N 9180 -1960 9180 -1950 {
lab=VDD}
N 1200 -1990 1210 -2000 {
lab=row_n[0]}
N 1210 -2200 1210 -2000 {
lab=row_n[0]}
N 1200 -2210 1210 -2200 {
lab=row_n[0]}
N 1200 -1990 1200 -1970 {
lab=row_n[0]}
N 1200 -2230 1200 -2210 {
lab=row_n[0]}
N 1080 -2130 1090 -2140 {
lab=col_n[4]}
N 1090 -2140 1290 -2140 {
lab=col_n[4]}
N 1290 -2140 1300 -2130 {
lab=col_n[4]}
N 1080 -2110 1090 -2120 {
lab=colon_n[4]}
N 1090 -2120 1290 -2120 {
lab=colon_n[4]}
N 1290 -2120 1300 -2110 {
lab=colon_n[4]}
N 1080 -2090 1090 -2100 {
lab=#net9}
N 1090 -2100 1290 -2100 {
lab=#net9}
N 1290 -2100 1300 -2090 {
lab=#net9}
N 1080 -2070 1090 -2080 {
lab=#net10}
N 1090 -2080 1290 -2080 {
lab=#net10}
N 1290 -2080 1300 -2070 {
lab=#net10}
N 1140 -2230 1140 -2210 {
lab=vcom}
N 1180 -2230 1180 -2210 {
lab=ctop}
N 1060 -2130 1080 -2130 {
lab=col_n[4]}
N 1060 -2110 1080 -2110 {
lab=colon_n[4]}
N 1060 -2090 1080 -2090 {
lab=#net9}
N 1060 -2070 1080 -2070 {
lab=#net10}
N 1300 -2070 1320 -2070 {
lab=#net10}
N 1300 -2090 1320 -2090 {
lab=#net9}
N 1300 -2110 1320 -2110 {
lab=colon_n[4]}
N 1300 -2130 1320 -2130 {
lab=col_n[4]}
N 1120 -1990 1120 -1980 {
lab=VSS}
N 1120 -2220 1120 -2210 {
lab=VDD}
N 1460 -1990 1470 -2000 {
lab=row_n[1]}
N 1470 -2200 1470 -2000 {
lab=row_n[1]}
N 1460 -2210 1470 -2200 {
lab=row_n[1]}
N 1460 -1990 1460 -1970 {
lab=row_n[1]}
N 1460 -2230 1460 -2210 {
lab=row_n[1]}
N 1340 -2130 1350 -2140 {
lab=col_n[4]}
N 1350 -2140 1550 -2140 {
lab=col_n[4]}
N 1550 -2140 1560 -2130 {
lab=col_n[4]}
N 1340 -2110 1350 -2120 {
lab=colon_n[4]}
N 1350 -2120 1550 -2120 {
lab=colon_n[4]}
N 1550 -2120 1560 -2110 {
lab=colon_n[4]}
N 1340 -2090 1350 -2100 {
lab=#net9}
N 1350 -2100 1550 -2100 {
lab=#net9}
N 1550 -2100 1560 -2090 {
lab=#net9}
N 1340 -2070 1350 -2080 {
lab=#net10}
N 1350 -2080 1550 -2080 {
lab=#net10}
N 1550 -2080 1560 -2070 {
lab=#net10}
N 1400 -2230 1400 -2210 {
lab=vcom}
N 1440 -2230 1440 -2210 {
lab=ctop}
N 1320 -2130 1340 -2130 {
lab=col_n[4]}
N 1320 -2110 1340 -2110 {
lab=colon_n[4]}
N 1320 -2090 1340 -2090 {
lab=#net9}
N 1320 -2070 1340 -2070 {
lab=#net10}
N 1560 -2070 1580 -2070 {
lab=#net10}
N 1560 -2090 1580 -2090 {
lab=#net9}
N 1560 -2110 1580 -2110 {
lab=colon_n[4]}
N 1560 -2130 1580 -2130 {
lab=col_n[4]}
N 1380 -1990 1380 -1980 {
lab=VSS}
N 1380 -2220 1380 -2210 {
lab=VDD}
N 1720 -1990 1730 -2000 {
lab=row_n[2]}
N 1730 -2200 1730 -2000 {
lab=row_n[2]}
N 1720 -2210 1730 -2200 {
lab=row_n[2]}
N 1720 -1990 1720 -1970 {
lab=row_n[2]}
N 1720 -2230 1720 -2210 {
lab=row_n[2]}
N 1600 -2130 1610 -2140 {
lab=col_n[4]}
N 1610 -2140 1810 -2140 {
lab=col_n[4]}
N 1810 -2140 1820 -2130 {
lab=col_n[4]}
N 1600 -2110 1610 -2120 {
lab=colon_n[4]}
N 1610 -2120 1810 -2120 {
lab=colon_n[4]}
N 1810 -2120 1820 -2110 {
lab=colon_n[4]}
N 1600 -2090 1610 -2100 {
lab=#net9}
N 1610 -2100 1810 -2100 {
lab=#net9}
N 1810 -2100 1820 -2090 {
lab=#net9}
N 1600 -2070 1610 -2080 {
lab=#net10}
N 1610 -2080 1810 -2080 {
lab=#net10}
N 1810 -2080 1820 -2070 {
lab=#net10}
N 1660 -2230 1660 -2210 {
lab=vcom}
N 1700 -2230 1700 -2210 {
lab=ctop}
N 1580 -2130 1600 -2130 {
lab=col_n[4]}
N 1580 -2110 1600 -2110 {
lab=colon_n[4]}
N 1580 -2090 1600 -2090 {
lab=#net9}
N 1580 -2070 1600 -2070 {
lab=#net10}
N 1820 -2070 1840 -2070 {
lab=#net10}
N 1820 -2090 1840 -2090 {
lab=#net9}
N 1820 -2110 1840 -2110 {
lab=colon_n[4]}
N 1820 -2130 1840 -2130 {
lab=col_n[4]}
N 1640 -1990 1640 -1980 {
lab=VSS}
N 1640 -2220 1640 -2210 {
lab=VDD}
N 1980 -1990 1990 -2000 {
lab=row_n[3]}
N 1990 -2200 1990 -2000 {
lab=row_n[3]}
N 1980 -2210 1990 -2200 {
lab=row_n[3]}
N 1980 -1990 1980 -1970 {
lab=row_n[3]}
N 1980 -2230 1980 -2210 {
lab=row_n[3]}
N 1860 -2130 1870 -2140 {
lab=col_n[4]}
N 1870 -2140 2070 -2140 {
lab=col_n[4]}
N 2070 -2140 2080 -2130 {
lab=col_n[4]}
N 1860 -2110 1870 -2120 {
lab=colon_n[4]}
N 1870 -2120 2070 -2120 {
lab=colon_n[4]}
N 2070 -2120 2080 -2110 {
lab=colon_n[4]}
N 1860 -2090 1870 -2100 {
lab=#net9}
N 1870 -2100 2070 -2100 {
lab=#net9}
N 2070 -2100 2080 -2090 {
lab=#net9}
N 1860 -2070 1870 -2080 {
lab=#net10}
N 1870 -2080 2070 -2080 {
lab=#net10}
N 2070 -2080 2080 -2070 {
lab=#net10}
N 1920 -2230 1920 -2210 {
lab=vcom}
N 1960 -2230 1960 -2210 {
lab=ctop}
N 1840 -2130 1860 -2130 {
lab=col_n[4]}
N 1840 -2110 1860 -2110 {
lab=colon_n[4]}
N 1840 -2090 1860 -2090 {
lab=#net9}
N 1840 -2070 1860 -2070 {
lab=#net10}
N 2080 -2070 2100 -2070 {
lab=#net10}
N 2080 -2090 2100 -2090 {
lab=#net9}
N 2080 -2110 2100 -2110 {
lab=colon_n[4]}
N 2080 -2130 2100 -2130 {
lab=col_n[4]}
N 1900 -1990 1900 -1980 {
lab=VSS}
N 1900 -2220 1900 -2210 {
lab=VDD}
N 2240 -1990 2250 -2000 {
lab=row_n[4]}
N 2250 -2200 2250 -2000 {
lab=row_n[4]}
N 2240 -2210 2250 -2200 {
lab=row_n[4]}
N 2240 -1990 2240 -1970 {
lab=row_n[4]}
N 2240 -2230 2240 -2210 {
lab=row_n[4]}
N 2120 -2130 2130 -2140 {
lab=col_n[4]}
N 2130 -2140 2330 -2140 {
lab=col_n[4]}
N 2330 -2140 2340 -2130 {
lab=col_n[4]}
N 2120 -2110 2130 -2120 {
lab=colon_n[4]}
N 2130 -2120 2330 -2120 {
lab=colon_n[4]}
N 2330 -2120 2340 -2110 {
lab=colon_n[4]}
N 2120 -2090 2130 -2100 {
lab=#net9}
N 2130 -2100 2330 -2100 {
lab=#net9}
N 2330 -2100 2340 -2090 {
lab=#net9}
N 2120 -2070 2130 -2080 {
lab=#net10}
N 2130 -2080 2330 -2080 {
lab=#net10}
N 2330 -2080 2340 -2070 {
lab=#net10}
N 2180 -2230 2180 -2210 {
lab=vcom}
N 2220 -2230 2220 -2210 {
lab=ctop}
N 2100 -2130 2120 -2130 {
lab=col_n[4]}
N 2100 -2110 2120 -2110 {
lab=colon_n[4]}
N 2100 -2090 2120 -2090 {
lab=#net9}
N 2100 -2070 2120 -2070 {
lab=#net10}
N 2340 -2070 2360 -2070 {
lab=#net10}
N 2340 -2090 2360 -2090 {
lab=#net9}
N 2340 -2110 2360 -2110 {
lab=colon_n[4]}
N 2340 -2130 2360 -2130 {
lab=col_n[4]}
N 2160 -1990 2160 -1980 {
lab=VSS}
N 2160 -2220 2160 -2210 {
lab=VDD}
N 2500 -1990 2510 -2000 {
lab=row_n[5]}
N 2510 -2200 2510 -2000 {
lab=row_n[5]}
N 2500 -2210 2510 -2200 {
lab=row_n[5]}
N 2500 -1990 2500 -1970 {
lab=row_n[5]}
N 2500 -2230 2500 -2210 {
lab=row_n[5]}
N 2380 -2130 2390 -2140 {
lab=col_n[4]}
N 2390 -2140 2590 -2140 {
lab=col_n[4]}
N 2590 -2140 2600 -2130 {
lab=col_n[4]}
N 2380 -2110 2390 -2120 {
lab=colon_n[4]}
N 2390 -2120 2590 -2120 {
lab=colon_n[4]}
N 2590 -2120 2600 -2110 {
lab=colon_n[4]}
N 2380 -2090 2390 -2100 {
lab=#net9}
N 2390 -2100 2590 -2100 {
lab=#net9}
N 2590 -2100 2600 -2090 {
lab=#net9}
N 2380 -2070 2390 -2080 {
lab=#net10}
N 2390 -2080 2590 -2080 {
lab=#net10}
N 2590 -2080 2600 -2070 {
lab=#net10}
N 2440 -2230 2440 -2210 {
lab=vcom}
N 2480 -2230 2480 -2210 {
lab=ctop}
N 2360 -2130 2380 -2130 {
lab=col_n[4]}
N 2360 -2110 2380 -2110 {
lab=colon_n[4]}
N 2360 -2090 2380 -2090 {
lab=#net9}
N 2360 -2070 2380 -2070 {
lab=#net10}
N 2600 -2070 2620 -2070 {
lab=#net10}
N 2600 -2090 2620 -2090 {
lab=#net9}
N 2600 -2110 2620 -2110 {
lab=colon_n[4]}
N 2600 -2130 2620 -2130 {
lab=col_n[4]}
N 2420 -1990 2420 -1980 {
lab=VSS}
N 2420 -2220 2420 -2210 {
lab=VDD}
N 2760 -1990 2770 -2000 {
lab=row_n[6]}
N 2770 -2200 2770 -2000 {
lab=row_n[6]}
N 2760 -2210 2770 -2200 {
lab=row_n[6]}
N 2760 -1990 2760 -1970 {
lab=row_n[6]}
N 2760 -2230 2760 -2210 {
lab=row_n[6]}
N 2640 -2130 2650 -2140 {
lab=col_n[4]}
N 2650 -2140 2850 -2140 {
lab=col_n[4]}
N 2850 -2140 2860 -2130 {
lab=col_n[4]}
N 2640 -2110 2650 -2120 {
lab=colon_n[4]}
N 2650 -2120 2850 -2120 {
lab=colon_n[4]}
N 2850 -2120 2860 -2110 {
lab=colon_n[4]}
N 2640 -2090 2650 -2100 {
lab=#net9}
N 2650 -2100 2850 -2100 {
lab=#net9}
N 2850 -2100 2860 -2090 {
lab=#net9}
N 2640 -2070 2650 -2080 {
lab=#net10}
N 2650 -2080 2850 -2080 {
lab=#net10}
N 2850 -2080 2860 -2070 {
lab=#net10}
N 2700 -2230 2700 -2210 {
lab=vcom}
N 2740 -2230 2740 -2210 {
lab=ctop}
N 2620 -2130 2640 -2130 {
lab=col_n[4]}
N 2620 -2110 2640 -2110 {
lab=colon_n[4]}
N 2620 -2090 2640 -2090 {
lab=#net9}
N 2620 -2070 2640 -2070 {
lab=#net10}
N 2860 -2070 2880 -2070 {
lab=#net10}
N 2860 -2090 2880 -2090 {
lab=#net9}
N 2860 -2110 2880 -2110 {
lab=colon_n[4]}
N 2860 -2130 2880 -2130 {
lab=col_n[4]}
N 2680 -1990 2680 -1980 {
lab=VSS}
N 2680 -2220 2680 -2210 {
lab=VDD}
N 3020 -1990 3030 -2000 {
lab=row_n[7]}
N 3030 -2200 3030 -2000 {
lab=row_n[7]}
N 3020 -2210 3030 -2200 {
lab=row_n[7]}
N 3020 -1990 3020 -1970 {
lab=row_n[7]}
N 3020 -2230 3020 -2210 {
lab=row_n[7]}
N 2900 -2130 2910 -2140 {
lab=col_n[4]}
N 2910 -2140 3110 -2140 {
lab=col_n[4]}
N 3110 -2140 3120 -2130 {
lab=col_n[4]}
N 2900 -2110 2910 -2120 {
lab=colon_n[4]}
N 2910 -2120 3110 -2120 {
lab=colon_n[4]}
N 3110 -2120 3120 -2110 {
lab=colon_n[4]}
N 2900 -2090 2910 -2100 {
lab=#net9}
N 2910 -2100 3110 -2100 {
lab=#net9}
N 3110 -2100 3120 -2090 {
lab=#net9}
N 2900 -2070 2910 -2080 {
lab=#net10}
N 2910 -2080 3110 -2080 {
lab=#net10}
N 3110 -2080 3120 -2070 {
lab=#net10}
N 2960 -2230 2960 -2210 {
lab=vcom}
N 3000 -2230 3000 -2210 {
lab=ctop}
N 2880 -2130 2900 -2130 {
lab=col_n[4]}
N 2880 -2110 2900 -2110 {
lab=colon_n[4]}
N 2880 -2090 2900 -2090 {
lab=#net9}
N 2880 -2070 2900 -2070 {
lab=#net10}
N 3120 -2070 3140 -2070 {
lab=#net10}
N 3120 -2090 3140 -2090 {
lab=#net9}
N 3120 -2110 3140 -2110 {
lab=colon_n[4]}
N 3120 -2130 3140 -2130 {
lab=col_n[4]}
N 2940 -1990 2940 -1980 {
lab=VSS}
N 2940 -2220 2940 -2210 {
lab=VDD}
N 3280 -1990 3290 -2000 {
lab=row_n[8]}
N 3290 -2200 3290 -2000 {
lab=row_n[8]}
N 3280 -2210 3290 -2200 {
lab=row_n[8]}
N 3280 -1990 3280 -1970 {
lab=row_n[8]}
N 3280 -2230 3280 -2210 {
lab=row_n[8]}
N 3160 -2130 3170 -2140 {
lab=col_n[4]}
N 3170 -2140 3370 -2140 {
lab=col_n[4]}
N 3370 -2140 3380 -2130 {
lab=col_n[4]}
N 3160 -2110 3170 -2120 {
lab=colon_n[4]}
N 3170 -2120 3370 -2120 {
lab=colon_n[4]}
N 3370 -2120 3380 -2110 {
lab=colon_n[4]}
N 3160 -2090 3170 -2100 {
lab=#net9}
N 3170 -2100 3370 -2100 {
lab=#net9}
N 3370 -2100 3380 -2090 {
lab=#net9}
N 3160 -2070 3170 -2080 {
lab=#net10}
N 3170 -2080 3370 -2080 {
lab=#net10}
N 3370 -2080 3380 -2070 {
lab=#net10}
N 3220 -2230 3220 -2210 {
lab=vcom}
N 3260 -2230 3260 -2210 {
lab=ctop}
N 3140 -2130 3160 -2130 {
lab=col_n[4]}
N 3140 -2110 3160 -2110 {
lab=colon_n[4]}
N 3140 -2090 3160 -2090 {
lab=#net9}
N 3140 -2070 3160 -2070 {
lab=#net10}
N 3380 -2070 3400 -2070 {
lab=#net10}
N 3380 -2090 3400 -2090 {
lab=#net9}
N 3380 -2110 3400 -2110 {
lab=colon_n[4]}
N 3380 -2130 3400 -2130 {
lab=col_n[4]}
N 3200 -1990 3200 -1980 {
lab=VSS}
N 3200 -2220 3200 -2210 {
lab=VDD}
N 3540 -1990 3550 -2000 {
lab=row_n[9]}
N 3550 -2200 3550 -2000 {
lab=row_n[9]}
N 3540 -2210 3550 -2200 {
lab=row_n[9]}
N 3540 -1990 3540 -1970 {
lab=row_n[9]}
N 3540 -2230 3540 -2210 {
lab=row_n[9]}
N 3420 -2130 3430 -2140 {
lab=col_n[4]}
N 3430 -2140 3630 -2140 {
lab=col_n[4]}
N 3630 -2140 3640 -2130 {
lab=col_n[4]}
N 3420 -2110 3430 -2120 {
lab=colon_n[4]}
N 3430 -2120 3630 -2120 {
lab=colon_n[4]}
N 3630 -2120 3640 -2110 {
lab=colon_n[4]}
N 3420 -2090 3430 -2100 {
lab=#net9}
N 3430 -2100 3630 -2100 {
lab=#net9}
N 3630 -2100 3640 -2090 {
lab=#net9}
N 3420 -2070 3430 -2080 {
lab=#net10}
N 3430 -2080 3630 -2080 {
lab=#net10}
N 3630 -2080 3640 -2070 {
lab=#net10}
N 3480 -2230 3480 -2210 {
lab=vcom}
N 3520 -2230 3520 -2210 {
lab=ctop}
N 3400 -2130 3420 -2130 {
lab=col_n[4]}
N 3400 -2110 3420 -2110 {
lab=colon_n[4]}
N 3400 -2090 3420 -2090 {
lab=#net9}
N 3400 -2070 3420 -2070 {
lab=#net10}
N 3640 -2070 3660 -2070 {
lab=#net10}
N 3640 -2090 3660 -2090 {
lab=#net9}
N 3640 -2110 3660 -2110 {
lab=colon_n[4]}
N 3640 -2130 3660 -2130 {
lab=col_n[4]}
N 3460 -1990 3460 -1980 {
lab=VSS}
N 3460 -2220 3460 -2210 {
lab=VDD}
N 3800 -1990 3810 -2000 {
lab=row_n[10]}
N 3810 -2200 3810 -2000 {
lab=row_n[10]}
N 3800 -2210 3810 -2200 {
lab=row_n[10]}
N 3800 -1990 3800 -1970 {
lab=row_n[10]}
N 3800 -2230 3800 -2210 {
lab=row_n[10]}
N 3680 -2130 3690 -2140 {
lab=col_n[4]}
N 3690 -2140 3890 -2140 {
lab=col_n[4]}
N 3890 -2140 3900 -2130 {
lab=col_n[4]}
N 3680 -2110 3690 -2120 {
lab=colon_n[4]}
N 3690 -2120 3890 -2120 {
lab=colon_n[4]}
N 3890 -2120 3900 -2110 {
lab=colon_n[4]}
N 3680 -2090 3690 -2100 {
lab=#net9}
N 3690 -2100 3890 -2100 {
lab=#net9}
N 3890 -2100 3900 -2090 {
lab=#net9}
N 3680 -2070 3690 -2080 {
lab=#net10}
N 3690 -2080 3890 -2080 {
lab=#net10}
N 3890 -2080 3900 -2070 {
lab=#net10}
N 3740 -2230 3740 -2210 {
lab=vcom}
N 3780 -2230 3780 -2210 {
lab=ctop}
N 3660 -2130 3680 -2130 {
lab=col_n[4]}
N 3660 -2110 3680 -2110 {
lab=colon_n[4]}
N 3660 -2090 3680 -2090 {
lab=#net9}
N 3660 -2070 3680 -2070 {
lab=#net10}
N 3900 -2070 3920 -2070 {
lab=#net10}
N 3900 -2090 3920 -2090 {
lab=#net9}
N 3900 -2110 3920 -2110 {
lab=colon_n[4]}
N 3900 -2130 3920 -2130 {
lab=col_n[4]}
N 3720 -1990 3720 -1980 {
lab=VSS}
N 3720 -2220 3720 -2210 {
lab=VDD}
N 4060 -1990 4070 -2000 {
lab=row_n[11]}
N 4070 -2200 4070 -2000 {
lab=row_n[11]}
N 4060 -2210 4070 -2200 {
lab=row_n[11]}
N 4060 -1990 4060 -1970 {
lab=row_n[11]}
N 4060 -2230 4060 -2210 {
lab=row_n[11]}
N 3940 -2130 3950 -2140 {
lab=col_n[4]}
N 3950 -2140 4150 -2140 {
lab=col_n[4]}
N 4150 -2140 4160 -2130 {
lab=col_n[4]}
N 3940 -2110 3950 -2120 {
lab=colon_n[4]}
N 3950 -2120 4150 -2120 {
lab=colon_n[4]}
N 4150 -2120 4160 -2110 {
lab=colon_n[4]}
N 3940 -2090 3950 -2100 {
lab=#net9}
N 3950 -2100 4150 -2100 {
lab=#net9}
N 4150 -2100 4160 -2090 {
lab=#net9}
N 3940 -2070 3950 -2080 {
lab=#net10}
N 3950 -2080 4150 -2080 {
lab=#net10}
N 4150 -2080 4160 -2070 {
lab=#net10}
N 4000 -2230 4000 -2210 {
lab=vcom}
N 4040 -2230 4040 -2210 {
lab=ctop}
N 3920 -2130 3940 -2130 {
lab=col_n[4]}
N 3920 -2110 3940 -2110 {
lab=colon_n[4]}
N 3920 -2090 3940 -2090 {
lab=#net9}
N 3920 -2070 3940 -2070 {
lab=#net10}
N 4160 -2070 4180 -2070 {
lab=#net10}
N 4160 -2090 4180 -2090 {
lab=#net9}
N 4160 -2110 4180 -2110 {
lab=colon_n[4]}
N 4160 -2130 4180 -2130 {
lab=col_n[4]}
N 3980 -1990 3980 -1980 {
lab=VSS}
N 3980 -2220 3980 -2210 {
lab=VDD}
N 4320 -1990 4330 -2000 {
lab=row_n[12]}
N 4330 -2200 4330 -2000 {
lab=row_n[12]}
N 4320 -2210 4330 -2200 {
lab=row_n[12]}
N 4320 -1990 4320 -1970 {
lab=row_n[12]}
N 4320 -2230 4320 -2210 {
lab=row_n[12]}
N 4200 -2130 4210 -2140 {
lab=col_n[4]}
N 4210 -2140 4410 -2140 {
lab=col_n[4]}
N 4410 -2140 4420 -2130 {
lab=col_n[4]}
N 4200 -2110 4210 -2120 {
lab=colon_n[4]}
N 4210 -2120 4410 -2120 {
lab=colon_n[4]}
N 4410 -2120 4420 -2110 {
lab=colon_n[4]}
N 4200 -2090 4210 -2100 {
lab=#net9}
N 4210 -2100 4410 -2100 {
lab=#net9}
N 4410 -2100 4420 -2090 {
lab=#net9}
N 4200 -2070 4210 -2080 {
lab=#net10}
N 4210 -2080 4410 -2080 {
lab=#net10}
N 4410 -2080 4420 -2070 {
lab=#net10}
N 4260 -2230 4260 -2210 {
lab=vcom}
N 4300 -2230 4300 -2210 {
lab=ctop}
N 4180 -2130 4200 -2130 {
lab=col_n[4]}
N 4180 -2110 4200 -2110 {
lab=colon_n[4]}
N 4180 -2090 4200 -2090 {
lab=#net9}
N 4180 -2070 4200 -2070 {
lab=#net10}
N 4420 -2070 4440 -2070 {
lab=#net10}
N 4420 -2090 4440 -2090 {
lab=#net9}
N 4420 -2110 4440 -2110 {
lab=colon_n[4]}
N 4420 -2130 4440 -2130 {
lab=col_n[4]}
N 4240 -1990 4240 -1980 {
lab=VSS}
N 4240 -2220 4240 -2210 {
lab=VDD}
N 4580 -1990 4590 -2000 {
lab=row_n[13]}
N 4590 -2200 4590 -2000 {
lab=row_n[13]}
N 4580 -2210 4590 -2200 {
lab=row_n[13]}
N 4580 -1990 4580 -1970 {
lab=row_n[13]}
N 4580 -2230 4580 -2210 {
lab=row_n[13]}
N 4460 -2130 4470 -2140 {
lab=col_n[4]}
N 4470 -2140 4670 -2140 {
lab=col_n[4]}
N 4670 -2140 4680 -2130 {
lab=col_n[4]}
N 4460 -2110 4470 -2120 {
lab=colon_n[4]}
N 4470 -2120 4670 -2120 {
lab=colon_n[4]}
N 4670 -2120 4680 -2110 {
lab=colon_n[4]}
N 4460 -2090 4470 -2100 {
lab=#net9}
N 4470 -2100 4670 -2100 {
lab=#net9}
N 4670 -2100 4680 -2090 {
lab=#net9}
N 4460 -2070 4470 -2080 {
lab=#net10}
N 4470 -2080 4670 -2080 {
lab=#net10}
N 4670 -2080 4680 -2070 {
lab=#net10}
N 4520 -2230 4520 -2210 {
lab=vcom}
N 4560 -2230 4560 -2210 {
lab=ctop}
N 4440 -2130 4460 -2130 {
lab=col_n[4]}
N 4440 -2110 4460 -2110 {
lab=colon_n[4]}
N 4440 -2090 4460 -2090 {
lab=#net9}
N 4440 -2070 4460 -2070 {
lab=#net10}
N 4680 -2070 4700 -2070 {
lab=#net10}
N 4680 -2090 4700 -2090 {
lab=#net9}
N 4680 -2110 4700 -2110 {
lab=colon_n[4]}
N 4680 -2130 4700 -2130 {
lab=col_n[4]}
N 4500 -1990 4500 -1980 {
lab=VSS}
N 4500 -2220 4500 -2210 {
lab=VDD}
N 4840 -1990 4850 -2000 {
lab=row_n[14]}
N 4850 -2200 4850 -2000 {
lab=row_n[14]}
N 4840 -2210 4850 -2200 {
lab=row_n[14]}
N 4840 -1990 4840 -1970 {
lab=row_n[14]}
N 4840 -2230 4840 -2210 {
lab=row_n[14]}
N 4720 -2130 4730 -2140 {
lab=col_n[4]}
N 4730 -2140 4930 -2140 {
lab=col_n[4]}
N 4930 -2140 4940 -2130 {
lab=col_n[4]}
N 4720 -2110 4730 -2120 {
lab=colon_n[4]}
N 4730 -2120 4930 -2120 {
lab=colon_n[4]}
N 4930 -2120 4940 -2110 {
lab=colon_n[4]}
N 4720 -2090 4730 -2100 {
lab=#net9}
N 4730 -2100 4930 -2100 {
lab=#net9}
N 4930 -2100 4940 -2090 {
lab=#net9}
N 4720 -2070 4730 -2080 {
lab=#net10}
N 4730 -2080 4930 -2080 {
lab=#net10}
N 4930 -2080 4940 -2070 {
lab=#net10}
N 4780 -2230 4780 -2210 {
lab=vcom}
N 4820 -2230 4820 -2210 {
lab=ctop}
N 4700 -2130 4720 -2130 {
lab=col_n[4]}
N 4700 -2110 4720 -2110 {
lab=colon_n[4]}
N 4700 -2090 4720 -2090 {
lab=#net9}
N 4700 -2070 4720 -2070 {
lab=#net10}
N 4940 -2070 4960 -2070 {
lab=#net10}
N 4940 -2090 4960 -2090 {
lab=#net9}
N 4940 -2110 4960 -2110 {
lab=colon_n[4]}
N 4940 -2130 4960 -2130 {
lab=col_n[4]}
N 4760 -1990 4760 -1980 {
lab=VSS}
N 4760 -2220 4760 -2210 {
lab=VDD}
N 5100 -1990 5110 -2000 {
lab=row_n[15]}
N 5110 -2200 5110 -2000 {
lab=row_n[15]}
N 5100 -2210 5110 -2200 {
lab=row_n[15]}
N 5100 -1990 5100 -1970 {
lab=row_n[15]}
N 5100 -2230 5100 -2210 {
lab=row_n[15]}
N 4980 -2130 4990 -2140 {
lab=col_n[4]}
N 4990 -2140 5190 -2140 {
lab=col_n[4]}
N 5190 -2140 5200 -2130 {
lab=col_n[4]}
N 4980 -2110 4990 -2120 {
lab=colon_n[4]}
N 4990 -2120 5190 -2120 {
lab=colon_n[4]}
N 5190 -2120 5200 -2110 {
lab=colon_n[4]}
N 4980 -2090 4990 -2100 {
lab=#net9}
N 4990 -2100 5190 -2100 {
lab=#net9}
N 5190 -2100 5200 -2090 {
lab=#net9}
N 4980 -2070 4990 -2080 {
lab=#net10}
N 4990 -2080 5190 -2080 {
lab=#net10}
N 5190 -2080 5200 -2070 {
lab=#net10}
N 5040 -2230 5040 -2210 {
lab=vcom}
N 5080 -2230 5080 -2210 {
lab=ctop}
N 4960 -2130 4980 -2130 {
lab=col_n[4]}
N 4960 -2110 4980 -2110 {
lab=colon_n[4]}
N 4960 -2090 4980 -2090 {
lab=#net9}
N 4960 -2070 4980 -2070 {
lab=#net10}
N 5200 -2070 5220 -2070 {
lab=#net10}
N 5200 -2090 5220 -2090 {
lab=#net9}
N 5200 -2110 5220 -2110 {
lab=colon_n[4]}
N 5200 -2130 5220 -2130 {
lab=col_n[4]}
N 5020 -1990 5020 -1980 {
lab=VSS}
N 5020 -2220 5020 -2210 {
lab=VDD}
N 5360 -1990 5370 -2000 {
lab=row_n[16]}
N 5370 -2200 5370 -2000 {
lab=row_n[16]}
N 5360 -2210 5370 -2200 {
lab=row_n[16]}
N 5360 -1990 5360 -1970 {
lab=row_n[16]}
N 5360 -2230 5360 -2210 {
lab=row_n[16]}
N 5240 -2130 5250 -2140 {
lab=col_n[4]}
N 5250 -2140 5450 -2140 {
lab=col_n[4]}
N 5450 -2140 5460 -2130 {
lab=col_n[4]}
N 5240 -2110 5250 -2120 {
lab=colon_n[4]}
N 5250 -2120 5450 -2120 {
lab=colon_n[4]}
N 5450 -2120 5460 -2110 {
lab=colon_n[4]}
N 5240 -2090 5250 -2100 {
lab=#net9}
N 5250 -2100 5450 -2100 {
lab=#net9}
N 5450 -2100 5460 -2090 {
lab=#net9}
N 5240 -2070 5250 -2080 {
lab=#net10}
N 5250 -2080 5450 -2080 {
lab=#net10}
N 5450 -2080 5460 -2070 {
lab=#net10}
N 5300 -2230 5300 -2210 {
lab=vcom}
N 5340 -2230 5340 -2210 {
lab=ctop}
N 5220 -2130 5240 -2130 {
lab=col_n[4]}
N 5220 -2110 5240 -2110 {
lab=colon_n[4]}
N 5220 -2090 5240 -2090 {
lab=#net9}
N 5220 -2070 5240 -2070 {
lab=#net10}
N 5460 -2070 5480 -2070 {
lab=#net10}
N 5460 -2090 5480 -2090 {
lab=#net9}
N 5460 -2110 5480 -2110 {
lab=colon_n[4]}
N 5460 -2130 5480 -2130 {
lab=col_n[4]}
N 5280 -1990 5280 -1980 {
lab=VSS}
N 5280 -2220 5280 -2210 {
lab=VDD}
N 5620 -1990 5630 -2000 {
lab=row_n[17]}
N 5630 -2200 5630 -2000 {
lab=row_n[17]}
N 5620 -2210 5630 -2200 {
lab=row_n[17]}
N 5620 -1990 5620 -1970 {
lab=row_n[17]}
N 5620 -2230 5620 -2210 {
lab=row_n[17]}
N 5500 -2130 5510 -2140 {
lab=col_n[4]}
N 5510 -2140 5710 -2140 {
lab=col_n[4]}
N 5710 -2140 5720 -2130 {
lab=col_n[4]}
N 5500 -2110 5510 -2120 {
lab=colon_n[4]}
N 5510 -2120 5710 -2120 {
lab=colon_n[4]}
N 5710 -2120 5720 -2110 {
lab=colon_n[4]}
N 5500 -2090 5510 -2100 {
lab=#net9}
N 5510 -2100 5710 -2100 {
lab=#net9}
N 5710 -2100 5720 -2090 {
lab=#net9}
N 5500 -2070 5510 -2080 {
lab=#net10}
N 5510 -2080 5710 -2080 {
lab=#net10}
N 5710 -2080 5720 -2070 {
lab=#net10}
N 5560 -2230 5560 -2210 {
lab=vcom}
N 5600 -2230 5600 -2210 {
lab=ctop}
N 5480 -2130 5500 -2130 {
lab=col_n[4]}
N 5480 -2110 5500 -2110 {
lab=colon_n[4]}
N 5480 -2090 5500 -2090 {
lab=#net9}
N 5480 -2070 5500 -2070 {
lab=#net10}
N 5720 -2070 5740 -2070 {
lab=#net10}
N 5720 -2090 5740 -2090 {
lab=#net9}
N 5720 -2110 5740 -2110 {
lab=colon_n[4]}
N 5720 -2130 5740 -2130 {
lab=col_n[4]}
N 5540 -1990 5540 -1980 {
lab=VSS}
N 5540 -2220 5540 -2210 {
lab=VDD}
N 5880 -1990 5890 -2000 {
lab=row_n[18]}
N 5890 -2200 5890 -2000 {
lab=row_n[18]}
N 5880 -2210 5890 -2200 {
lab=row_n[18]}
N 5880 -1990 5880 -1970 {
lab=row_n[18]}
N 5880 -2230 5880 -2210 {
lab=row_n[18]}
N 5760 -2130 5770 -2140 {
lab=col_n[4]}
N 5770 -2140 5970 -2140 {
lab=col_n[4]}
N 5970 -2140 5980 -2130 {
lab=col_n[4]}
N 5760 -2110 5770 -2120 {
lab=colon_n[4]}
N 5770 -2120 5970 -2120 {
lab=colon_n[4]}
N 5970 -2120 5980 -2110 {
lab=colon_n[4]}
N 5760 -2090 5770 -2100 {
lab=#net9}
N 5770 -2100 5970 -2100 {
lab=#net9}
N 5970 -2100 5980 -2090 {
lab=#net9}
N 5760 -2070 5770 -2080 {
lab=#net10}
N 5770 -2080 5970 -2080 {
lab=#net10}
N 5970 -2080 5980 -2070 {
lab=#net10}
N 5820 -2230 5820 -2210 {
lab=vcom}
N 5860 -2230 5860 -2210 {
lab=ctop}
N 5740 -2130 5760 -2130 {
lab=col_n[4]}
N 5740 -2110 5760 -2110 {
lab=colon_n[4]}
N 5740 -2090 5760 -2090 {
lab=#net9}
N 5740 -2070 5760 -2070 {
lab=#net10}
N 5980 -2070 6000 -2070 {
lab=#net10}
N 5980 -2090 6000 -2090 {
lab=#net9}
N 5980 -2110 6000 -2110 {
lab=colon_n[4]}
N 5980 -2130 6000 -2130 {
lab=col_n[4]}
N 5800 -1990 5800 -1980 {
lab=VSS}
N 5800 -2220 5800 -2210 {
lab=VDD}
N 6140 -1990 6150 -2000 {
lab=row_n[19]}
N 6150 -2200 6150 -2000 {
lab=row_n[19]}
N 6140 -2210 6150 -2200 {
lab=row_n[19]}
N 6140 -1990 6140 -1970 {
lab=row_n[19]}
N 6140 -2230 6140 -2210 {
lab=row_n[19]}
N 6020 -2130 6030 -2140 {
lab=col_n[4]}
N 6030 -2140 6230 -2140 {
lab=col_n[4]}
N 6230 -2140 6240 -2130 {
lab=col_n[4]}
N 6020 -2110 6030 -2120 {
lab=colon_n[4]}
N 6030 -2120 6230 -2120 {
lab=colon_n[4]}
N 6230 -2120 6240 -2110 {
lab=colon_n[4]}
N 6020 -2090 6030 -2100 {
lab=#net9}
N 6030 -2100 6230 -2100 {
lab=#net9}
N 6230 -2100 6240 -2090 {
lab=#net9}
N 6020 -2070 6030 -2080 {
lab=#net10}
N 6030 -2080 6230 -2080 {
lab=#net10}
N 6230 -2080 6240 -2070 {
lab=#net10}
N 6080 -2230 6080 -2210 {
lab=vcom}
N 6120 -2230 6120 -2210 {
lab=ctop}
N 6000 -2130 6020 -2130 {
lab=col_n[4]}
N 6000 -2110 6020 -2110 {
lab=colon_n[4]}
N 6000 -2090 6020 -2090 {
lab=#net9}
N 6000 -2070 6020 -2070 {
lab=#net10}
N 6240 -2070 6260 -2070 {
lab=#net10}
N 6240 -2090 6260 -2090 {
lab=#net9}
N 6240 -2110 6260 -2110 {
lab=colon_n[4]}
N 6240 -2130 6260 -2130 {
lab=col_n[4]}
N 6060 -1990 6060 -1980 {
lab=VSS}
N 6060 -2220 6060 -2210 {
lab=VDD}
N 6400 -1990 6410 -2000 {
lab=row_n[20]}
N 6410 -2200 6410 -2000 {
lab=row_n[20]}
N 6400 -2210 6410 -2200 {
lab=row_n[20]}
N 6400 -1990 6400 -1970 {
lab=row_n[20]}
N 6400 -2230 6400 -2210 {
lab=row_n[20]}
N 6280 -2130 6290 -2140 {
lab=col_n[4]}
N 6290 -2140 6490 -2140 {
lab=col_n[4]}
N 6490 -2140 6500 -2130 {
lab=col_n[4]}
N 6280 -2110 6290 -2120 {
lab=colon_n[4]}
N 6290 -2120 6490 -2120 {
lab=colon_n[4]}
N 6490 -2120 6500 -2110 {
lab=colon_n[4]}
N 6280 -2090 6290 -2100 {
lab=#net9}
N 6290 -2100 6490 -2100 {
lab=#net9}
N 6490 -2100 6500 -2090 {
lab=#net9}
N 6280 -2070 6290 -2080 {
lab=#net10}
N 6290 -2080 6490 -2080 {
lab=#net10}
N 6490 -2080 6500 -2070 {
lab=#net10}
N 6340 -2230 6340 -2210 {
lab=vcom}
N 6380 -2230 6380 -2210 {
lab=ctop}
N 6260 -2130 6280 -2130 {
lab=col_n[4]}
N 6260 -2110 6280 -2110 {
lab=colon_n[4]}
N 6260 -2090 6280 -2090 {
lab=#net9}
N 6260 -2070 6280 -2070 {
lab=#net10}
N 6500 -2070 6520 -2070 {
lab=#net10}
N 6500 -2090 6520 -2090 {
lab=#net9}
N 6500 -2110 6520 -2110 {
lab=colon_n[4]}
N 6500 -2130 6520 -2130 {
lab=col_n[4]}
N 6320 -1990 6320 -1980 {
lab=VSS}
N 6320 -2220 6320 -2210 {
lab=VDD}
N 6660 -1990 6670 -2000 {
lab=row_n[21]}
N 6670 -2200 6670 -2000 {
lab=row_n[21]}
N 6660 -2210 6670 -2200 {
lab=row_n[21]}
N 6660 -1990 6660 -1970 {
lab=row_n[21]}
N 6660 -2230 6660 -2210 {
lab=row_n[21]}
N 6540 -2130 6550 -2140 {
lab=col_n[4]}
N 6550 -2140 6750 -2140 {
lab=col_n[4]}
N 6750 -2140 6760 -2130 {
lab=col_n[4]}
N 6540 -2110 6550 -2120 {
lab=colon_n[4]}
N 6550 -2120 6750 -2120 {
lab=colon_n[4]}
N 6750 -2120 6760 -2110 {
lab=colon_n[4]}
N 6540 -2090 6550 -2100 {
lab=#net9}
N 6550 -2100 6750 -2100 {
lab=#net9}
N 6750 -2100 6760 -2090 {
lab=#net9}
N 6540 -2070 6550 -2080 {
lab=#net10}
N 6550 -2080 6750 -2080 {
lab=#net10}
N 6750 -2080 6760 -2070 {
lab=#net10}
N 6600 -2230 6600 -2210 {
lab=vcom}
N 6640 -2230 6640 -2210 {
lab=ctop}
N 6520 -2130 6540 -2130 {
lab=col_n[4]}
N 6520 -2110 6540 -2110 {
lab=colon_n[4]}
N 6520 -2090 6540 -2090 {
lab=#net9}
N 6520 -2070 6540 -2070 {
lab=#net10}
N 6760 -2070 6780 -2070 {
lab=#net10}
N 6760 -2090 6780 -2090 {
lab=#net9}
N 6760 -2110 6780 -2110 {
lab=colon_n[4]}
N 6760 -2130 6780 -2130 {
lab=col_n[4]}
N 6580 -1990 6580 -1980 {
lab=VSS}
N 6580 -2220 6580 -2210 {
lab=VDD}
N 6920 -1990 6930 -2000 {
lab=row_n[22]}
N 6930 -2200 6930 -2000 {
lab=row_n[22]}
N 6920 -2210 6930 -2200 {
lab=row_n[22]}
N 6920 -1990 6920 -1970 {
lab=row_n[22]}
N 6920 -2230 6920 -2210 {
lab=row_n[22]}
N 6800 -2130 6810 -2140 {
lab=col_n[4]}
N 6810 -2140 7010 -2140 {
lab=col_n[4]}
N 7010 -2140 7020 -2130 {
lab=col_n[4]}
N 6800 -2110 6810 -2120 {
lab=colon_n[4]}
N 6810 -2120 7010 -2120 {
lab=colon_n[4]}
N 7010 -2120 7020 -2110 {
lab=colon_n[4]}
N 6800 -2090 6810 -2100 {
lab=#net9}
N 6810 -2100 7010 -2100 {
lab=#net9}
N 7010 -2100 7020 -2090 {
lab=#net9}
N 6800 -2070 6810 -2080 {
lab=#net10}
N 6810 -2080 7010 -2080 {
lab=#net10}
N 7010 -2080 7020 -2070 {
lab=#net10}
N 6860 -2230 6860 -2210 {
lab=vcom}
N 6900 -2230 6900 -2210 {
lab=ctop}
N 6780 -2130 6800 -2130 {
lab=col_n[4]}
N 6780 -2110 6800 -2110 {
lab=colon_n[4]}
N 6780 -2090 6800 -2090 {
lab=#net9}
N 6780 -2070 6800 -2070 {
lab=#net10}
N 7020 -2070 7040 -2070 {
lab=#net10}
N 7020 -2090 7040 -2090 {
lab=#net9}
N 7020 -2110 7040 -2110 {
lab=colon_n[4]}
N 7020 -2130 7040 -2130 {
lab=col_n[4]}
N 6840 -1990 6840 -1980 {
lab=VSS}
N 6840 -2220 6840 -2210 {
lab=VDD}
N 7180 -1990 7190 -2000 {
lab=row_n[23]}
N 7190 -2200 7190 -2000 {
lab=row_n[23]}
N 7180 -2210 7190 -2200 {
lab=row_n[23]}
N 7180 -1990 7180 -1970 {
lab=row_n[23]}
N 7180 -2230 7180 -2210 {
lab=row_n[23]}
N 7060 -2130 7070 -2140 {
lab=col_n[4]}
N 7070 -2140 7270 -2140 {
lab=col_n[4]}
N 7270 -2140 7280 -2130 {
lab=col_n[4]}
N 7060 -2110 7070 -2120 {
lab=colon_n[4]}
N 7070 -2120 7270 -2120 {
lab=colon_n[4]}
N 7270 -2120 7280 -2110 {
lab=colon_n[4]}
N 7060 -2090 7070 -2100 {
lab=#net9}
N 7070 -2100 7270 -2100 {
lab=#net9}
N 7270 -2100 7280 -2090 {
lab=#net9}
N 7060 -2070 7070 -2080 {
lab=#net10}
N 7070 -2080 7270 -2080 {
lab=#net10}
N 7270 -2080 7280 -2070 {
lab=#net10}
N 7120 -2230 7120 -2210 {
lab=vcom}
N 7160 -2230 7160 -2210 {
lab=ctop}
N 7040 -2130 7060 -2130 {
lab=col_n[4]}
N 7040 -2110 7060 -2110 {
lab=colon_n[4]}
N 7040 -2090 7060 -2090 {
lab=#net9}
N 7040 -2070 7060 -2070 {
lab=#net10}
N 7280 -2070 7300 -2070 {
lab=#net10}
N 7280 -2090 7300 -2090 {
lab=#net9}
N 7280 -2110 7300 -2110 {
lab=colon_n[4]}
N 7280 -2130 7300 -2130 {
lab=col_n[4]}
N 7100 -1990 7100 -1980 {
lab=VSS}
N 7100 -2220 7100 -2210 {
lab=VDD}
N 7440 -1990 7450 -2000 {
lab=row_n[24]}
N 7450 -2200 7450 -2000 {
lab=row_n[24]}
N 7440 -2210 7450 -2200 {
lab=row_n[24]}
N 7440 -1990 7440 -1970 {
lab=row_n[24]}
N 7440 -2230 7440 -2210 {
lab=row_n[24]}
N 7320 -2130 7330 -2140 {
lab=col_n[4]}
N 7330 -2140 7530 -2140 {
lab=col_n[4]}
N 7530 -2140 7540 -2130 {
lab=col_n[4]}
N 7320 -2110 7330 -2120 {
lab=colon_n[4]}
N 7330 -2120 7530 -2120 {
lab=colon_n[4]}
N 7530 -2120 7540 -2110 {
lab=colon_n[4]}
N 7320 -2090 7330 -2100 {
lab=#net9}
N 7330 -2100 7530 -2100 {
lab=#net9}
N 7530 -2100 7540 -2090 {
lab=#net9}
N 7320 -2070 7330 -2080 {
lab=#net10}
N 7330 -2080 7530 -2080 {
lab=#net10}
N 7530 -2080 7540 -2070 {
lab=#net10}
N 7380 -2230 7380 -2210 {
lab=vcom}
N 7420 -2230 7420 -2210 {
lab=ctop}
N 7300 -2130 7320 -2130 {
lab=col_n[4]}
N 7300 -2110 7320 -2110 {
lab=colon_n[4]}
N 7300 -2090 7320 -2090 {
lab=#net9}
N 7300 -2070 7320 -2070 {
lab=#net10}
N 7540 -2070 7560 -2070 {
lab=#net10}
N 7540 -2090 7560 -2090 {
lab=#net9}
N 7540 -2110 7560 -2110 {
lab=colon_n[4]}
N 7540 -2130 7560 -2130 {
lab=col_n[4]}
N 7360 -1990 7360 -1980 {
lab=VSS}
N 7360 -2220 7360 -2210 {
lab=VDD}
N 7700 -1990 7710 -2000 {
lab=row_n[25]}
N 7710 -2200 7710 -2000 {
lab=row_n[25]}
N 7700 -2210 7710 -2200 {
lab=row_n[25]}
N 7700 -1990 7700 -1970 {
lab=row_n[25]}
N 7700 -2230 7700 -2210 {
lab=row_n[25]}
N 7580 -2130 7590 -2140 {
lab=col_n[4]}
N 7590 -2140 7790 -2140 {
lab=col_n[4]}
N 7790 -2140 7800 -2130 {
lab=col_n[4]}
N 7580 -2110 7590 -2120 {
lab=colon_n[4]}
N 7590 -2120 7790 -2120 {
lab=colon_n[4]}
N 7790 -2120 7800 -2110 {
lab=colon_n[4]}
N 7580 -2090 7590 -2100 {
lab=#net9}
N 7590 -2100 7790 -2100 {
lab=#net9}
N 7790 -2100 7800 -2090 {
lab=#net9}
N 7580 -2070 7590 -2080 {
lab=#net10}
N 7590 -2080 7790 -2080 {
lab=#net10}
N 7790 -2080 7800 -2070 {
lab=#net10}
N 7640 -2230 7640 -2210 {
lab=vcom}
N 7680 -2230 7680 -2210 {
lab=ctop}
N 7560 -2130 7580 -2130 {
lab=col_n[4]}
N 7560 -2110 7580 -2110 {
lab=colon_n[4]}
N 7560 -2090 7580 -2090 {
lab=#net9}
N 7560 -2070 7580 -2070 {
lab=#net10}
N 7800 -2070 7820 -2070 {
lab=#net10}
N 7800 -2090 7820 -2090 {
lab=#net9}
N 7800 -2110 7820 -2110 {
lab=colon_n[4]}
N 7800 -2130 7820 -2130 {
lab=col_n[4]}
N 7620 -1990 7620 -1980 {
lab=VSS}
N 7620 -2220 7620 -2210 {
lab=VDD}
N 7960 -1990 7970 -2000 {
lab=row_n[26]}
N 7970 -2200 7970 -2000 {
lab=row_n[26]}
N 7960 -2210 7970 -2200 {
lab=row_n[26]}
N 7960 -1990 7960 -1970 {
lab=row_n[26]}
N 7960 -2230 7960 -2210 {
lab=row_n[26]}
N 7840 -2130 7850 -2140 {
lab=col_n[4]}
N 7850 -2140 8050 -2140 {
lab=col_n[4]}
N 8050 -2140 8060 -2130 {
lab=col_n[4]}
N 7840 -2110 7850 -2120 {
lab=colon_n[4]}
N 7850 -2120 8050 -2120 {
lab=colon_n[4]}
N 8050 -2120 8060 -2110 {
lab=colon_n[4]}
N 7840 -2090 7850 -2100 {
lab=#net9}
N 7850 -2100 8050 -2100 {
lab=#net9}
N 8050 -2100 8060 -2090 {
lab=#net9}
N 7840 -2070 7850 -2080 {
lab=#net10}
N 7850 -2080 8050 -2080 {
lab=#net10}
N 8050 -2080 8060 -2070 {
lab=#net10}
N 7900 -2230 7900 -2210 {
lab=vcom}
N 7940 -2230 7940 -2210 {
lab=ctop}
N 7820 -2130 7840 -2130 {
lab=col_n[4]}
N 7820 -2110 7840 -2110 {
lab=colon_n[4]}
N 7820 -2090 7840 -2090 {
lab=#net9}
N 7820 -2070 7840 -2070 {
lab=#net10}
N 8060 -2070 8080 -2070 {
lab=#net10}
N 8060 -2090 8080 -2090 {
lab=#net9}
N 8060 -2110 8080 -2110 {
lab=colon_n[4]}
N 8060 -2130 8080 -2130 {
lab=col_n[4]}
N 7880 -1990 7880 -1980 {
lab=VSS}
N 7880 -2220 7880 -2210 {
lab=VDD}
N 8220 -1990 8230 -2000 {
lab=row_n[27]}
N 8230 -2200 8230 -2000 {
lab=row_n[27]}
N 8220 -2210 8230 -2200 {
lab=row_n[27]}
N 8220 -1990 8220 -1970 {
lab=row_n[27]}
N 8220 -2230 8220 -2210 {
lab=row_n[27]}
N 8100 -2130 8110 -2140 {
lab=col_n[4]}
N 8110 -2140 8310 -2140 {
lab=col_n[4]}
N 8310 -2140 8320 -2130 {
lab=col_n[4]}
N 8100 -2110 8110 -2120 {
lab=colon_n[4]}
N 8110 -2120 8310 -2120 {
lab=colon_n[4]}
N 8310 -2120 8320 -2110 {
lab=colon_n[4]}
N 8100 -2090 8110 -2100 {
lab=#net9}
N 8110 -2100 8310 -2100 {
lab=#net9}
N 8310 -2100 8320 -2090 {
lab=#net9}
N 8100 -2070 8110 -2080 {
lab=#net10}
N 8110 -2080 8310 -2080 {
lab=#net10}
N 8310 -2080 8320 -2070 {
lab=#net10}
N 8160 -2230 8160 -2210 {
lab=vcom}
N 8200 -2230 8200 -2210 {
lab=ctop}
N 8080 -2130 8100 -2130 {
lab=col_n[4]}
N 8080 -2110 8100 -2110 {
lab=colon_n[4]}
N 8080 -2090 8100 -2090 {
lab=#net9}
N 8080 -2070 8100 -2070 {
lab=#net10}
N 8320 -2070 8340 -2070 {
lab=#net10}
N 8320 -2090 8340 -2090 {
lab=#net9}
N 8320 -2110 8340 -2110 {
lab=colon_n[4]}
N 8320 -2130 8340 -2130 {
lab=col_n[4]}
N 8140 -1990 8140 -1980 {
lab=VSS}
N 8140 -2220 8140 -2210 {
lab=VDD}
N 8480 -1990 8490 -2000 {
lab=row_n[28]}
N 8490 -2200 8490 -2000 {
lab=row_n[28]}
N 8480 -2210 8490 -2200 {
lab=row_n[28]}
N 8480 -1990 8480 -1970 {
lab=row_n[28]}
N 8480 -2230 8480 -2210 {
lab=row_n[28]}
N 8360 -2130 8370 -2140 {
lab=col_n[4]}
N 8370 -2140 8570 -2140 {
lab=col_n[4]}
N 8570 -2140 8580 -2130 {
lab=col_n[4]}
N 8360 -2110 8370 -2120 {
lab=colon_n[4]}
N 8370 -2120 8570 -2120 {
lab=colon_n[4]}
N 8570 -2120 8580 -2110 {
lab=colon_n[4]}
N 8360 -2090 8370 -2100 {
lab=#net9}
N 8370 -2100 8570 -2100 {
lab=#net9}
N 8570 -2100 8580 -2090 {
lab=#net9}
N 8360 -2070 8370 -2080 {
lab=#net10}
N 8370 -2080 8570 -2080 {
lab=#net10}
N 8570 -2080 8580 -2070 {
lab=#net10}
N 8420 -2230 8420 -2210 {
lab=vcom}
N 8460 -2230 8460 -2210 {
lab=ctop}
N 8340 -2130 8360 -2130 {
lab=col_n[4]}
N 8340 -2110 8360 -2110 {
lab=colon_n[4]}
N 8340 -2090 8360 -2090 {
lab=#net9}
N 8340 -2070 8360 -2070 {
lab=#net10}
N 8580 -2070 8600 -2070 {
lab=#net10}
N 8580 -2090 8600 -2090 {
lab=#net9}
N 8580 -2110 8600 -2110 {
lab=colon_n[4]}
N 8580 -2130 8600 -2130 {
lab=col_n[4]}
N 8400 -1990 8400 -1980 {
lab=VSS}
N 8400 -2220 8400 -2210 {
lab=VDD}
N 8740 -1990 8750 -2000 {
lab=row_n[29]}
N 8750 -2200 8750 -2000 {
lab=row_n[29]}
N 8740 -2210 8750 -2200 {
lab=row_n[29]}
N 8740 -1990 8740 -1970 {
lab=row_n[29]}
N 8740 -2230 8740 -2210 {
lab=row_n[29]}
N 8620 -2130 8630 -2140 {
lab=col_n[4]}
N 8630 -2140 8830 -2140 {
lab=col_n[4]}
N 8830 -2140 8840 -2130 {
lab=col_n[4]}
N 8620 -2110 8630 -2120 {
lab=colon_n[4]}
N 8630 -2120 8830 -2120 {
lab=colon_n[4]}
N 8830 -2120 8840 -2110 {
lab=colon_n[4]}
N 8620 -2090 8630 -2100 {
lab=#net9}
N 8630 -2100 8830 -2100 {
lab=#net9}
N 8830 -2100 8840 -2090 {
lab=#net9}
N 8620 -2070 8630 -2080 {
lab=#net10}
N 8630 -2080 8830 -2080 {
lab=#net10}
N 8830 -2080 8840 -2070 {
lab=#net10}
N 8680 -2230 8680 -2210 {
lab=vcom}
N 8720 -2230 8720 -2210 {
lab=ctop}
N 8600 -2130 8620 -2130 {
lab=col_n[4]}
N 8600 -2110 8620 -2110 {
lab=colon_n[4]}
N 8600 -2090 8620 -2090 {
lab=#net9}
N 8600 -2070 8620 -2070 {
lab=#net10}
N 8840 -2070 8860 -2070 {
lab=#net10}
N 8840 -2090 8860 -2090 {
lab=#net9}
N 8840 -2110 8860 -2110 {
lab=colon_n[4]}
N 8840 -2130 8860 -2130 {
lab=col_n[4]}
N 8660 -1990 8660 -1980 {
lab=VSS}
N 8660 -2220 8660 -2210 {
lab=VDD}
N 9000 -1990 9010 -2000 {
lab=row_n[30]}
N 9010 -2200 9010 -2000 {
lab=row_n[30]}
N 9000 -2210 9010 -2200 {
lab=row_n[30]}
N 9000 -1990 9000 -1970 {
lab=row_n[30]}
N 9000 -2230 9000 -2210 {
lab=row_n[30]}
N 8880 -2130 8890 -2140 {
lab=col_n[4]}
N 8890 -2140 9090 -2140 {
lab=col_n[4]}
N 9090 -2140 9100 -2130 {
lab=col_n[4]}
N 8880 -2110 8890 -2120 {
lab=colon_n[4]}
N 8890 -2120 9090 -2120 {
lab=colon_n[4]}
N 9090 -2120 9100 -2110 {
lab=colon_n[4]}
N 8880 -2090 8890 -2100 {
lab=#net9}
N 8890 -2100 9090 -2100 {
lab=#net9}
N 9090 -2100 9100 -2090 {
lab=#net9}
N 8880 -2070 8890 -2080 {
lab=#net10}
N 8890 -2080 9090 -2080 {
lab=#net10}
N 9090 -2080 9100 -2070 {
lab=#net10}
N 8940 -2230 8940 -2210 {
lab=vcom}
N 8980 -2230 8980 -2210 {
lab=ctop}
N 8860 -2130 8880 -2130 {
lab=col_n[4]}
N 8860 -2110 8880 -2110 {
lab=colon_n[4]}
N 8860 -2090 8880 -2090 {
lab=#net9}
N 8860 -2070 8880 -2070 {
lab=#net10}
N 9100 -2070 9120 -2070 {
lab=#net10}
N 9100 -2090 9120 -2090 {
lab=#net9}
N 9100 -2110 9120 -2110 {
lab=colon_n[4]}
N 9100 -2130 9120 -2130 {
lab=col_n[4]}
N 8920 -1990 8920 -1980 {
lab=VSS}
N 8920 -2220 8920 -2210 {
lab=VDD}
N 9260 -1990 9270 -2000 {
lab=row_n[31]}
N 9270 -2200 9270 -2000 {
lab=row_n[31]}
N 9260 -2210 9270 -2200 {
lab=row_n[31]}
N 9260 -1990 9260 -1970 {
lab=row_n[31]}
N 9260 -2230 9260 -2210 {
lab=row_n[31]}
N 9140 -2130 9150 -2140 {
lab=col_n[4]}
N 9150 -2140 9350 -2140 {
lab=col_n[4]}
N 9350 -2140 9360 -2130 {
lab=col_n[4]}
N 9140 -2110 9150 -2120 {
lab=colon_n[4]}
N 9150 -2120 9350 -2120 {
lab=colon_n[4]}
N 9350 -2120 9360 -2110 {
lab=colon_n[4]}
N 9140 -2090 9150 -2100 {
lab=#net9}
N 9150 -2100 9350 -2100 {
lab=#net9}
N 9350 -2100 9360 -2090 {
lab=#net9}
N 9140 -2070 9150 -2080 {
lab=#net10}
N 9150 -2080 9350 -2080 {
lab=#net10}
N 9350 -2080 9360 -2070 {
lab=#net10}
N 9200 -2230 9200 -2210 {
lab=vcom}
N 9240 -2230 9240 -2210 {
lab=ctop}
N 9120 -2130 9140 -2130 {
lab=col_n[4]}
N 9120 -2110 9140 -2110 {
lab=colon_n[4]}
N 9120 -2090 9140 -2090 {
lab=#net9}
N 9120 -2070 9140 -2070 {
lab=#net10}
N 9360 -2070 9380 -2070 {
lab=#net10}
N 9360 -2090 9380 -2090 {
lab=#net9}
N 9360 -2110 9380 -2110 {
lab=colon_n[4]}
N 9360 -2130 9380 -2130 {
lab=col_n[4]}
N 9180 -1990 9180 -1980 {
lab=VSS}
N 9180 -2220 9180 -2210 {
lab=VDD}
N 1200 -2250 1210 -2260 {
lab=row_n[0]}
N 1210 -2460 1210 -2260 {
lab=row_n[0]}
N 1200 -2470 1210 -2460 {
lab=row_n[0]}
N 1200 -2250 1200 -2230 {
lab=row_n[0]}
N 1200 -2490 1200 -2470 {
lab=row_n[0]}
N 1080 -2390 1090 -2400 {
lab=col_n[5]}
N 1090 -2400 1290 -2400 {
lab=col_n[5]}
N 1290 -2400 1300 -2390 {
lab=col_n[5]}
N 1080 -2370 1090 -2380 {
lab=colon_n[5]}
N 1090 -2380 1290 -2380 {
lab=colon_n[5]}
N 1290 -2380 1300 -2370 {
lab=colon_n[5]}
N 1080 -2350 1090 -2360 {
lab=#net11}
N 1090 -2360 1290 -2360 {
lab=#net11}
N 1290 -2360 1300 -2350 {
lab=#net11}
N 1080 -2330 1090 -2340 {
lab=#net12}
N 1090 -2340 1290 -2340 {
lab=#net12}
N 1290 -2340 1300 -2330 {
lab=#net12}
N 1140 -2490 1140 -2470 {
lab=vcom}
N 1180 -2490 1180 -2470 {
lab=ctop}
N 1060 -2390 1080 -2390 {
lab=col_n[5]}
N 1060 -2370 1080 -2370 {
lab=colon_n[5]}
N 1060 -2350 1080 -2350 {
lab=#net11}
N 1060 -2330 1080 -2330 {
lab=#net12}
N 1300 -2330 1320 -2330 {
lab=#net12}
N 1300 -2350 1320 -2350 {
lab=#net11}
N 1300 -2370 1320 -2370 {
lab=colon_n[5]}
N 1300 -2390 1320 -2390 {
lab=col_n[5]}
N 1120 -2250 1120 -2240 {
lab=VSS}
N 1120 -2480 1120 -2470 {
lab=VDD}
N 1460 -2250 1470 -2260 {
lab=row_n[1]}
N 1470 -2460 1470 -2260 {
lab=row_n[1]}
N 1460 -2470 1470 -2460 {
lab=row_n[1]}
N 1460 -2250 1460 -2230 {
lab=row_n[1]}
N 1460 -2490 1460 -2470 {
lab=row_n[1]}
N 1340 -2390 1350 -2400 {
lab=col_n[5]}
N 1350 -2400 1550 -2400 {
lab=col_n[5]}
N 1550 -2400 1560 -2390 {
lab=col_n[5]}
N 1340 -2370 1350 -2380 {
lab=colon_n[5]}
N 1350 -2380 1550 -2380 {
lab=colon_n[5]}
N 1550 -2380 1560 -2370 {
lab=colon_n[5]}
N 1340 -2350 1350 -2360 {
lab=#net11}
N 1350 -2360 1550 -2360 {
lab=#net11}
N 1550 -2360 1560 -2350 {
lab=#net11}
N 1340 -2330 1350 -2340 {
lab=#net12}
N 1350 -2340 1550 -2340 {
lab=#net12}
N 1550 -2340 1560 -2330 {
lab=#net12}
N 1400 -2490 1400 -2470 {
lab=vcom}
N 1440 -2490 1440 -2470 {
lab=ctop}
N 1320 -2390 1340 -2390 {
lab=col_n[5]}
N 1320 -2370 1340 -2370 {
lab=colon_n[5]}
N 1320 -2350 1340 -2350 {
lab=#net11}
N 1320 -2330 1340 -2330 {
lab=#net12}
N 1560 -2330 1580 -2330 {
lab=#net12}
N 1560 -2350 1580 -2350 {
lab=#net11}
N 1560 -2370 1580 -2370 {
lab=colon_n[5]}
N 1560 -2390 1580 -2390 {
lab=col_n[5]}
N 1380 -2250 1380 -2240 {
lab=VSS}
N 1380 -2480 1380 -2470 {
lab=VDD}
N 1720 -2250 1730 -2260 {
lab=row_n[2]}
N 1730 -2460 1730 -2260 {
lab=row_n[2]}
N 1720 -2470 1730 -2460 {
lab=row_n[2]}
N 1720 -2250 1720 -2230 {
lab=row_n[2]}
N 1720 -2490 1720 -2470 {
lab=row_n[2]}
N 1600 -2390 1610 -2400 {
lab=col_n[5]}
N 1610 -2400 1810 -2400 {
lab=col_n[5]}
N 1810 -2400 1820 -2390 {
lab=col_n[5]}
N 1600 -2370 1610 -2380 {
lab=colon_n[5]}
N 1610 -2380 1810 -2380 {
lab=colon_n[5]}
N 1810 -2380 1820 -2370 {
lab=colon_n[5]}
N 1600 -2350 1610 -2360 {
lab=#net11}
N 1610 -2360 1810 -2360 {
lab=#net11}
N 1810 -2360 1820 -2350 {
lab=#net11}
N 1600 -2330 1610 -2340 {
lab=#net12}
N 1610 -2340 1810 -2340 {
lab=#net12}
N 1810 -2340 1820 -2330 {
lab=#net12}
N 1660 -2490 1660 -2470 {
lab=vcom}
N 1700 -2490 1700 -2470 {
lab=ctop}
N 1580 -2390 1600 -2390 {
lab=col_n[5]}
N 1580 -2370 1600 -2370 {
lab=colon_n[5]}
N 1580 -2350 1600 -2350 {
lab=#net11}
N 1580 -2330 1600 -2330 {
lab=#net12}
N 1820 -2330 1840 -2330 {
lab=#net12}
N 1820 -2350 1840 -2350 {
lab=#net11}
N 1820 -2370 1840 -2370 {
lab=colon_n[5]}
N 1820 -2390 1840 -2390 {
lab=col_n[5]}
N 1640 -2250 1640 -2240 {
lab=VSS}
N 1640 -2480 1640 -2470 {
lab=VDD}
N 1980 -2250 1990 -2260 {
lab=row_n[3]}
N 1990 -2460 1990 -2260 {
lab=row_n[3]}
N 1980 -2470 1990 -2460 {
lab=row_n[3]}
N 1980 -2250 1980 -2230 {
lab=row_n[3]}
N 1980 -2490 1980 -2470 {
lab=row_n[3]}
N 1860 -2390 1870 -2400 {
lab=col_n[5]}
N 1870 -2400 2070 -2400 {
lab=col_n[5]}
N 2070 -2400 2080 -2390 {
lab=col_n[5]}
N 1860 -2370 1870 -2380 {
lab=colon_n[5]}
N 1870 -2380 2070 -2380 {
lab=colon_n[5]}
N 2070 -2380 2080 -2370 {
lab=colon_n[5]}
N 1860 -2350 1870 -2360 {
lab=#net11}
N 1870 -2360 2070 -2360 {
lab=#net11}
N 2070 -2360 2080 -2350 {
lab=#net11}
N 1860 -2330 1870 -2340 {
lab=#net12}
N 1870 -2340 2070 -2340 {
lab=#net12}
N 2070 -2340 2080 -2330 {
lab=#net12}
N 1920 -2490 1920 -2470 {
lab=vcom}
N 1960 -2490 1960 -2470 {
lab=ctop}
N 1840 -2390 1860 -2390 {
lab=col_n[5]}
N 1840 -2370 1860 -2370 {
lab=colon_n[5]}
N 1840 -2350 1860 -2350 {
lab=#net11}
N 1840 -2330 1860 -2330 {
lab=#net12}
N 2080 -2330 2100 -2330 {
lab=#net12}
N 2080 -2350 2100 -2350 {
lab=#net11}
N 2080 -2370 2100 -2370 {
lab=colon_n[5]}
N 2080 -2390 2100 -2390 {
lab=col_n[5]}
N 1900 -2250 1900 -2240 {
lab=VSS}
N 1900 -2480 1900 -2470 {
lab=VDD}
N 2240 -2250 2250 -2260 {
lab=row_n[4]}
N 2250 -2460 2250 -2260 {
lab=row_n[4]}
N 2240 -2470 2250 -2460 {
lab=row_n[4]}
N 2240 -2250 2240 -2230 {
lab=row_n[4]}
N 2240 -2490 2240 -2470 {
lab=row_n[4]}
N 2120 -2390 2130 -2400 {
lab=col_n[5]}
N 2130 -2400 2330 -2400 {
lab=col_n[5]}
N 2330 -2400 2340 -2390 {
lab=col_n[5]}
N 2120 -2370 2130 -2380 {
lab=colon_n[5]}
N 2130 -2380 2330 -2380 {
lab=colon_n[5]}
N 2330 -2380 2340 -2370 {
lab=colon_n[5]}
N 2120 -2350 2130 -2360 {
lab=#net11}
N 2130 -2360 2330 -2360 {
lab=#net11}
N 2330 -2360 2340 -2350 {
lab=#net11}
N 2120 -2330 2130 -2340 {
lab=#net12}
N 2130 -2340 2330 -2340 {
lab=#net12}
N 2330 -2340 2340 -2330 {
lab=#net12}
N 2180 -2490 2180 -2470 {
lab=vcom}
N 2220 -2490 2220 -2470 {
lab=ctop}
N 2100 -2390 2120 -2390 {
lab=col_n[5]}
N 2100 -2370 2120 -2370 {
lab=colon_n[5]}
N 2100 -2350 2120 -2350 {
lab=#net11}
N 2100 -2330 2120 -2330 {
lab=#net12}
N 2340 -2330 2360 -2330 {
lab=#net12}
N 2340 -2350 2360 -2350 {
lab=#net11}
N 2340 -2370 2360 -2370 {
lab=colon_n[5]}
N 2340 -2390 2360 -2390 {
lab=col_n[5]}
N 2160 -2250 2160 -2240 {
lab=VSS}
N 2160 -2480 2160 -2470 {
lab=VDD}
N 2500 -2250 2510 -2260 {
lab=row_n[5]}
N 2510 -2460 2510 -2260 {
lab=row_n[5]}
N 2500 -2470 2510 -2460 {
lab=row_n[5]}
N 2500 -2250 2500 -2230 {
lab=row_n[5]}
N 2500 -2490 2500 -2470 {
lab=row_n[5]}
N 2380 -2390 2390 -2400 {
lab=col_n[5]}
N 2390 -2400 2590 -2400 {
lab=col_n[5]}
N 2590 -2400 2600 -2390 {
lab=col_n[5]}
N 2380 -2370 2390 -2380 {
lab=colon_n[5]}
N 2390 -2380 2590 -2380 {
lab=colon_n[5]}
N 2590 -2380 2600 -2370 {
lab=colon_n[5]}
N 2380 -2350 2390 -2360 {
lab=#net11}
N 2390 -2360 2590 -2360 {
lab=#net11}
N 2590 -2360 2600 -2350 {
lab=#net11}
N 2380 -2330 2390 -2340 {
lab=#net12}
N 2390 -2340 2590 -2340 {
lab=#net12}
N 2590 -2340 2600 -2330 {
lab=#net12}
N 2440 -2490 2440 -2470 {
lab=vcom}
N 2480 -2490 2480 -2470 {
lab=ctop}
N 2360 -2390 2380 -2390 {
lab=col_n[5]}
N 2360 -2370 2380 -2370 {
lab=colon_n[5]}
N 2360 -2350 2380 -2350 {
lab=#net11}
N 2360 -2330 2380 -2330 {
lab=#net12}
N 2600 -2330 2620 -2330 {
lab=#net12}
N 2600 -2350 2620 -2350 {
lab=#net11}
N 2600 -2370 2620 -2370 {
lab=colon_n[5]}
N 2600 -2390 2620 -2390 {
lab=col_n[5]}
N 2420 -2250 2420 -2240 {
lab=VSS}
N 2420 -2480 2420 -2470 {
lab=VDD}
N 2760 -2250 2770 -2260 {
lab=row_n[6]}
N 2770 -2460 2770 -2260 {
lab=row_n[6]}
N 2760 -2470 2770 -2460 {
lab=row_n[6]}
N 2760 -2250 2760 -2230 {
lab=row_n[6]}
N 2760 -2490 2760 -2470 {
lab=row_n[6]}
N 2640 -2390 2650 -2400 {
lab=col_n[5]}
N 2650 -2400 2850 -2400 {
lab=col_n[5]}
N 2850 -2400 2860 -2390 {
lab=col_n[5]}
N 2640 -2370 2650 -2380 {
lab=colon_n[5]}
N 2650 -2380 2850 -2380 {
lab=colon_n[5]}
N 2850 -2380 2860 -2370 {
lab=colon_n[5]}
N 2640 -2350 2650 -2360 {
lab=#net11}
N 2650 -2360 2850 -2360 {
lab=#net11}
N 2850 -2360 2860 -2350 {
lab=#net11}
N 2640 -2330 2650 -2340 {
lab=#net12}
N 2650 -2340 2850 -2340 {
lab=#net12}
N 2850 -2340 2860 -2330 {
lab=#net12}
N 2700 -2490 2700 -2470 {
lab=vcom}
N 2740 -2490 2740 -2470 {
lab=ctop}
N 2620 -2390 2640 -2390 {
lab=col_n[5]}
N 2620 -2370 2640 -2370 {
lab=colon_n[5]}
N 2620 -2350 2640 -2350 {
lab=#net11}
N 2620 -2330 2640 -2330 {
lab=#net12}
N 2860 -2330 2880 -2330 {
lab=#net12}
N 2860 -2350 2880 -2350 {
lab=#net11}
N 2860 -2370 2880 -2370 {
lab=colon_n[5]}
N 2860 -2390 2880 -2390 {
lab=col_n[5]}
N 2680 -2250 2680 -2240 {
lab=VSS}
N 2680 -2480 2680 -2470 {
lab=VDD}
N 3020 -2250 3030 -2260 {
lab=row_n[7]}
N 3030 -2460 3030 -2260 {
lab=row_n[7]}
N 3020 -2470 3030 -2460 {
lab=row_n[7]}
N 3020 -2250 3020 -2230 {
lab=row_n[7]}
N 3020 -2490 3020 -2470 {
lab=row_n[7]}
N 2900 -2390 2910 -2400 {
lab=col_n[5]}
N 2910 -2400 3110 -2400 {
lab=col_n[5]}
N 3110 -2400 3120 -2390 {
lab=col_n[5]}
N 2900 -2370 2910 -2380 {
lab=colon_n[5]}
N 2910 -2380 3110 -2380 {
lab=colon_n[5]}
N 3110 -2380 3120 -2370 {
lab=colon_n[5]}
N 2900 -2350 2910 -2360 {
lab=#net11}
N 2910 -2360 3110 -2360 {
lab=#net11}
N 3110 -2360 3120 -2350 {
lab=#net11}
N 2900 -2330 2910 -2340 {
lab=#net12}
N 2910 -2340 3110 -2340 {
lab=#net12}
N 3110 -2340 3120 -2330 {
lab=#net12}
N 2960 -2490 2960 -2470 {
lab=vcom}
N 3000 -2490 3000 -2470 {
lab=ctop}
N 2880 -2390 2900 -2390 {
lab=col_n[5]}
N 2880 -2370 2900 -2370 {
lab=colon_n[5]}
N 2880 -2350 2900 -2350 {
lab=#net11}
N 2880 -2330 2900 -2330 {
lab=#net12}
N 3120 -2330 3140 -2330 {
lab=#net12}
N 3120 -2350 3140 -2350 {
lab=#net11}
N 3120 -2370 3140 -2370 {
lab=colon_n[5]}
N 3120 -2390 3140 -2390 {
lab=col_n[5]}
N 2940 -2250 2940 -2240 {
lab=VSS}
N 2940 -2480 2940 -2470 {
lab=VDD}
N 3280 -2250 3290 -2260 {
lab=row_n[8]}
N 3290 -2460 3290 -2260 {
lab=row_n[8]}
N 3280 -2470 3290 -2460 {
lab=row_n[8]}
N 3280 -2250 3280 -2230 {
lab=row_n[8]}
N 3280 -2490 3280 -2470 {
lab=row_n[8]}
N 3160 -2390 3170 -2400 {
lab=col_n[5]}
N 3170 -2400 3370 -2400 {
lab=col_n[5]}
N 3370 -2400 3380 -2390 {
lab=col_n[5]}
N 3160 -2370 3170 -2380 {
lab=colon_n[5]}
N 3170 -2380 3370 -2380 {
lab=colon_n[5]}
N 3370 -2380 3380 -2370 {
lab=colon_n[5]}
N 3160 -2350 3170 -2360 {
lab=#net11}
N 3170 -2360 3370 -2360 {
lab=#net11}
N 3370 -2360 3380 -2350 {
lab=#net11}
N 3160 -2330 3170 -2340 {
lab=#net12}
N 3170 -2340 3370 -2340 {
lab=#net12}
N 3370 -2340 3380 -2330 {
lab=#net12}
N 3220 -2490 3220 -2470 {
lab=vcom}
N 3260 -2490 3260 -2470 {
lab=ctop}
N 3140 -2390 3160 -2390 {
lab=col_n[5]}
N 3140 -2370 3160 -2370 {
lab=colon_n[5]}
N 3140 -2350 3160 -2350 {
lab=#net11}
N 3140 -2330 3160 -2330 {
lab=#net12}
N 3380 -2330 3400 -2330 {
lab=#net12}
N 3380 -2350 3400 -2350 {
lab=#net11}
N 3380 -2370 3400 -2370 {
lab=colon_n[5]}
N 3380 -2390 3400 -2390 {
lab=col_n[5]}
N 3200 -2250 3200 -2240 {
lab=VSS}
N 3200 -2480 3200 -2470 {
lab=VDD}
N 3540 -2250 3550 -2260 {
lab=row_n[9]}
N 3550 -2460 3550 -2260 {
lab=row_n[9]}
N 3540 -2470 3550 -2460 {
lab=row_n[9]}
N 3540 -2250 3540 -2230 {
lab=row_n[9]}
N 3540 -2490 3540 -2470 {
lab=row_n[9]}
N 3420 -2390 3430 -2400 {
lab=col_n[5]}
N 3430 -2400 3630 -2400 {
lab=col_n[5]}
N 3630 -2400 3640 -2390 {
lab=col_n[5]}
N 3420 -2370 3430 -2380 {
lab=colon_n[5]}
N 3430 -2380 3630 -2380 {
lab=colon_n[5]}
N 3630 -2380 3640 -2370 {
lab=colon_n[5]}
N 3420 -2350 3430 -2360 {
lab=#net11}
N 3430 -2360 3630 -2360 {
lab=#net11}
N 3630 -2360 3640 -2350 {
lab=#net11}
N 3420 -2330 3430 -2340 {
lab=#net12}
N 3430 -2340 3630 -2340 {
lab=#net12}
N 3630 -2340 3640 -2330 {
lab=#net12}
N 3480 -2490 3480 -2470 {
lab=vcom}
N 3520 -2490 3520 -2470 {
lab=ctop}
N 3400 -2390 3420 -2390 {
lab=col_n[5]}
N 3400 -2370 3420 -2370 {
lab=colon_n[5]}
N 3400 -2350 3420 -2350 {
lab=#net11}
N 3400 -2330 3420 -2330 {
lab=#net12}
N 3640 -2330 3660 -2330 {
lab=#net12}
N 3640 -2350 3660 -2350 {
lab=#net11}
N 3640 -2370 3660 -2370 {
lab=colon_n[5]}
N 3640 -2390 3660 -2390 {
lab=col_n[5]}
N 3460 -2250 3460 -2240 {
lab=VSS}
N 3460 -2480 3460 -2470 {
lab=VDD}
N 3800 -2250 3810 -2260 {
lab=row_n[10]}
N 3810 -2460 3810 -2260 {
lab=row_n[10]}
N 3800 -2470 3810 -2460 {
lab=row_n[10]}
N 3800 -2250 3800 -2230 {
lab=row_n[10]}
N 3800 -2490 3800 -2470 {
lab=row_n[10]}
N 3680 -2390 3690 -2400 {
lab=col_n[5]}
N 3690 -2400 3890 -2400 {
lab=col_n[5]}
N 3890 -2400 3900 -2390 {
lab=col_n[5]}
N 3680 -2370 3690 -2380 {
lab=colon_n[5]}
N 3690 -2380 3890 -2380 {
lab=colon_n[5]}
N 3890 -2380 3900 -2370 {
lab=colon_n[5]}
N 3680 -2350 3690 -2360 {
lab=#net11}
N 3690 -2360 3890 -2360 {
lab=#net11}
N 3890 -2360 3900 -2350 {
lab=#net11}
N 3680 -2330 3690 -2340 {
lab=#net12}
N 3690 -2340 3890 -2340 {
lab=#net12}
N 3890 -2340 3900 -2330 {
lab=#net12}
N 3740 -2490 3740 -2470 {
lab=vcom}
N 3780 -2490 3780 -2470 {
lab=ctop}
N 3660 -2390 3680 -2390 {
lab=col_n[5]}
N 3660 -2370 3680 -2370 {
lab=colon_n[5]}
N 3660 -2350 3680 -2350 {
lab=#net11}
N 3660 -2330 3680 -2330 {
lab=#net12}
N 3900 -2330 3920 -2330 {
lab=#net12}
N 3900 -2350 3920 -2350 {
lab=#net11}
N 3900 -2370 3920 -2370 {
lab=colon_n[5]}
N 3900 -2390 3920 -2390 {
lab=col_n[5]}
N 3720 -2250 3720 -2240 {
lab=VSS}
N 3720 -2480 3720 -2470 {
lab=VDD}
N 4060 -2250 4070 -2260 {
lab=row_n[11]}
N 4070 -2460 4070 -2260 {
lab=row_n[11]}
N 4060 -2470 4070 -2460 {
lab=row_n[11]}
N 4060 -2250 4060 -2230 {
lab=row_n[11]}
N 4060 -2490 4060 -2470 {
lab=row_n[11]}
N 3940 -2390 3950 -2400 {
lab=col_n[5]}
N 3950 -2400 4150 -2400 {
lab=col_n[5]}
N 4150 -2400 4160 -2390 {
lab=col_n[5]}
N 3940 -2370 3950 -2380 {
lab=colon_n[5]}
N 3950 -2380 4150 -2380 {
lab=colon_n[5]}
N 4150 -2380 4160 -2370 {
lab=colon_n[5]}
N 3940 -2350 3950 -2360 {
lab=#net11}
N 3950 -2360 4150 -2360 {
lab=#net11}
N 4150 -2360 4160 -2350 {
lab=#net11}
N 3940 -2330 3950 -2340 {
lab=#net12}
N 3950 -2340 4150 -2340 {
lab=#net12}
N 4150 -2340 4160 -2330 {
lab=#net12}
N 4000 -2490 4000 -2470 {
lab=vcom}
N 4040 -2490 4040 -2470 {
lab=ctop}
N 3920 -2390 3940 -2390 {
lab=col_n[5]}
N 3920 -2370 3940 -2370 {
lab=colon_n[5]}
N 3920 -2350 3940 -2350 {
lab=#net11}
N 3920 -2330 3940 -2330 {
lab=#net12}
N 4160 -2330 4180 -2330 {
lab=#net12}
N 4160 -2350 4180 -2350 {
lab=#net11}
N 4160 -2370 4180 -2370 {
lab=colon_n[5]}
N 4160 -2390 4180 -2390 {
lab=col_n[5]}
N 3980 -2250 3980 -2240 {
lab=VSS}
N 3980 -2480 3980 -2470 {
lab=VDD}
N 4320 -2250 4330 -2260 {
lab=row_n[12]}
N 4330 -2460 4330 -2260 {
lab=row_n[12]}
N 4320 -2470 4330 -2460 {
lab=row_n[12]}
N 4320 -2250 4320 -2230 {
lab=row_n[12]}
N 4320 -2490 4320 -2470 {
lab=row_n[12]}
N 4200 -2390 4210 -2400 {
lab=col_n[5]}
N 4210 -2400 4410 -2400 {
lab=col_n[5]}
N 4410 -2400 4420 -2390 {
lab=col_n[5]}
N 4200 -2370 4210 -2380 {
lab=colon_n[5]}
N 4210 -2380 4410 -2380 {
lab=colon_n[5]}
N 4410 -2380 4420 -2370 {
lab=colon_n[5]}
N 4200 -2350 4210 -2360 {
lab=#net11}
N 4210 -2360 4410 -2360 {
lab=#net11}
N 4410 -2360 4420 -2350 {
lab=#net11}
N 4200 -2330 4210 -2340 {
lab=#net12}
N 4210 -2340 4410 -2340 {
lab=#net12}
N 4410 -2340 4420 -2330 {
lab=#net12}
N 4260 -2490 4260 -2470 {
lab=vcom}
N 4300 -2490 4300 -2470 {
lab=ctop}
N 4180 -2390 4200 -2390 {
lab=col_n[5]}
N 4180 -2370 4200 -2370 {
lab=colon_n[5]}
N 4180 -2350 4200 -2350 {
lab=#net11}
N 4180 -2330 4200 -2330 {
lab=#net12}
N 4420 -2330 4440 -2330 {
lab=#net12}
N 4420 -2350 4440 -2350 {
lab=#net11}
N 4420 -2370 4440 -2370 {
lab=colon_n[5]}
N 4420 -2390 4440 -2390 {
lab=col_n[5]}
N 4240 -2250 4240 -2240 {
lab=VSS}
N 4240 -2480 4240 -2470 {
lab=VDD}
N 4580 -2250 4590 -2260 {
lab=row_n[13]}
N 4590 -2460 4590 -2260 {
lab=row_n[13]}
N 4580 -2470 4590 -2460 {
lab=row_n[13]}
N 4580 -2250 4580 -2230 {
lab=row_n[13]}
N 4580 -2490 4580 -2470 {
lab=row_n[13]}
N 4460 -2390 4470 -2400 {
lab=col_n[5]}
N 4470 -2400 4670 -2400 {
lab=col_n[5]}
N 4670 -2400 4680 -2390 {
lab=col_n[5]}
N 4460 -2370 4470 -2380 {
lab=colon_n[5]}
N 4470 -2380 4670 -2380 {
lab=colon_n[5]}
N 4670 -2380 4680 -2370 {
lab=colon_n[5]}
N 4460 -2350 4470 -2360 {
lab=#net11}
N 4470 -2360 4670 -2360 {
lab=#net11}
N 4670 -2360 4680 -2350 {
lab=#net11}
N 4460 -2330 4470 -2340 {
lab=#net12}
N 4470 -2340 4670 -2340 {
lab=#net12}
N 4670 -2340 4680 -2330 {
lab=#net12}
N 4520 -2490 4520 -2470 {
lab=vcom}
N 4560 -2490 4560 -2470 {
lab=ctop}
N 4440 -2390 4460 -2390 {
lab=col_n[5]}
N 4440 -2370 4460 -2370 {
lab=colon_n[5]}
N 4440 -2350 4460 -2350 {
lab=#net11}
N 4440 -2330 4460 -2330 {
lab=#net12}
N 4680 -2330 4700 -2330 {
lab=#net12}
N 4680 -2350 4700 -2350 {
lab=#net11}
N 4680 -2370 4700 -2370 {
lab=colon_n[5]}
N 4680 -2390 4700 -2390 {
lab=col_n[5]}
N 4500 -2250 4500 -2240 {
lab=VSS}
N 4500 -2480 4500 -2470 {
lab=VDD}
N 4840 -2250 4850 -2260 {
lab=row_n[14]}
N 4850 -2460 4850 -2260 {
lab=row_n[14]}
N 4840 -2470 4850 -2460 {
lab=row_n[14]}
N 4840 -2250 4840 -2230 {
lab=row_n[14]}
N 4840 -2490 4840 -2470 {
lab=row_n[14]}
N 4720 -2390 4730 -2400 {
lab=col_n[5]}
N 4730 -2400 4930 -2400 {
lab=col_n[5]}
N 4930 -2400 4940 -2390 {
lab=col_n[5]}
N 4720 -2370 4730 -2380 {
lab=colon_n[5]}
N 4730 -2380 4930 -2380 {
lab=colon_n[5]}
N 4930 -2380 4940 -2370 {
lab=colon_n[5]}
N 4720 -2350 4730 -2360 {
lab=#net11}
N 4730 -2360 4930 -2360 {
lab=#net11}
N 4930 -2360 4940 -2350 {
lab=#net11}
N 4720 -2330 4730 -2340 {
lab=#net12}
N 4730 -2340 4930 -2340 {
lab=#net12}
N 4930 -2340 4940 -2330 {
lab=#net12}
N 4780 -2490 4780 -2470 {
lab=vcom}
N 4820 -2490 4820 -2470 {
lab=ctop}
N 4700 -2390 4720 -2390 {
lab=col_n[5]}
N 4700 -2370 4720 -2370 {
lab=colon_n[5]}
N 4700 -2350 4720 -2350 {
lab=#net11}
N 4700 -2330 4720 -2330 {
lab=#net12}
N 4940 -2330 4960 -2330 {
lab=#net12}
N 4940 -2350 4960 -2350 {
lab=#net11}
N 4940 -2370 4960 -2370 {
lab=colon_n[5]}
N 4940 -2390 4960 -2390 {
lab=col_n[5]}
N 4760 -2250 4760 -2240 {
lab=VSS}
N 4760 -2480 4760 -2470 {
lab=VDD}
N 5100 -2250 5110 -2260 {
lab=row_n[15]}
N 5110 -2460 5110 -2260 {
lab=row_n[15]}
N 5100 -2470 5110 -2460 {
lab=row_n[15]}
N 5100 -2250 5100 -2230 {
lab=row_n[15]}
N 5100 -2490 5100 -2470 {
lab=row_n[15]}
N 4980 -2390 4990 -2400 {
lab=col_n[5]}
N 4990 -2400 5190 -2400 {
lab=col_n[5]}
N 5190 -2400 5200 -2390 {
lab=col_n[5]}
N 4980 -2370 4990 -2380 {
lab=colon_n[5]}
N 4990 -2380 5190 -2380 {
lab=colon_n[5]}
N 5190 -2380 5200 -2370 {
lab=colon_n[5]}
N 4980 -2350 4990 -2360 {
lab=#net11}
N 4990 -2360 5190 -2360 {
lab=#net11}
N 5190 -2360 5200 -2350 {
lab=#net11}
N 4980 -2330 4990 -2340 {
lab=#net12}
N 4990 -2340 5190 -2340 {
lab=#net12}
N 5190 -2340 5200 -2330 {
lab=#net12}
N 5040 -2490 5040 -2470 {
lab=vcom}
N 5080 -2490 5080 -2470 {
lab=ctop}
N 4960 -2390 4980 -2390 {
lab=col_n[5]}
N 4960 -2370 4980 -2370 {
lab=colon_n[5]}
N 4960 -2350 4980 -2350 {
lab=#net11}
N 4960 -2330 4980 -2330 {
lab=#net12}
N 5200 -2330 5220 -2330 {
lab=#net12}
N 5200 -2350 5220 -2350 {
lab=#net11}
N 5200 -2370 5220 -2370 {
lab=colon_n[5]}
N 5200 -2390 5220 -2390 {
lab=col_n[5]}
N 5020 -2250 5020 -2240 {
lab=VSS}
N 5020 -2480 5020 -2470 {
lab=VDD}
N 5360 -2250 5370 -2260 {
lab=row_n[16]}
N 5370 -2460 5370 -2260 {
lab=row_n[16]}
N 5360 -2470 5370 -2460 {
lab=row_n[16]}
N 5360 -2250 5360 -2230 {
lab=row_n[16]}
N 5360 -2490 5360 -2470 {
lab=row_n[16]}
N 5240 -2390 5250 -2400 {
lab=col_n[5]}
N 5250 -2400 5450 -2400 {
lab=col_n[5]}
N 5450 -2400 5460 -2390 {
lab=col_n[5]}
N 5240 -2370 5250 -2380 {
lab=colon_n[5]}
N 5250 -2380 5450 -2380 {
lab=colon_n[5]}
N 5450 -2380 5460 -2370 {
lab=colon_n[5]}
N 5240 -2350 5250 -2360 {
lab=#net11}
N 5250 -2360 5450 -2360 {
lab=#net11}
N 5450 -2360 5460 -2350 {
lab=#net11}
N 5240 -2330 5250 -2340 {
lab=#net12}
N 5250 -2340 5450 -2340 {
lab=#net12}
N 5450 -2340 5460 -2330 {
lab=#net12}
N 5300 -2490 5300 -2470 {
lab=vcom}
N 5340 -2490 5340 -2470 {
lab=ctop}
N 5220 -2390 5240 -2390 {
lab=col_n[5]}
N 5220 -2370 5240 -2370 {
lab=colon_n[5]}
N 5220 -2350 5240 -2350 {
lab=#net11}
N 5220 -2330 5240 -2330 {
lab=#net12}
N 5460 -2330 5480 -2330 {
lab=#net12}
N 5460 -2350 5480 -2350 {
lab=#net11}
N 5460 -2370 5480 -2370 {
lab=colon_n[5]}
N 5460 -2390 5480 -2390 {
lab=col_n[5]}
N 5280 -2250 5280 -2240 {
lab=VSS}
N 5280 -2480 5280 -2470 {
lab=VDD}
N 5620 -2250 5630 -2260 {
lab=row_n[17]}
N 5630 -2460 5630 -2260 {
lab=row_n[17]}
N 5620 -2470 5630 -2460 {
lab=row_n[17]}
N 5620 -2250 5620 -2230 {
lab=row_n[17]}
N 5620 -2490 5620 -2470 {
lab=row_n[17]}
N 5500 -2390 5510 -2400 {
lab=col_n[5]}
N 5510 -2400 5710 -2400 {
lab=col_n[5]}
N 5710 -2400 5720 -2390 {
lab=col_n[5]}
N 5500 -2370 5510 -2380 {
lab=colon_n[5]}
N 5510 -2380 5710 -2380 {
lab=colon_n[5]}
N 5710 -2380 5720 -2370 {
lab=colon_n[5]}
N 5500 -2350 5510 -2360 {
lab=#net11}
N 5510 -2360 5710 -2360 {
lab=#net11}
N 5710 -2360 5720 -2350 {
lab=#net11}
N 5500 -2330 5510 -2340 {
lab=#net12}
N 5510 -2340 5710 -2340 {
lab=#net12}
N 5710 -2340 5720 -2330 {
lab=#net12}
N 5560 -2490 5560 -2470 {
lab=vcom}
N 5600 -2490 5600 -2470 {
lab=ctop}
N 5480 -2390 5500 -2390 {
lab=col_n[5]}
N 5480 -2370 5500 -2370 {
lab=colon_n[5]}
N 5480 -2350 5500 -2350 {
lab=#net11}
N 5480 -2330 5500 -2330 {
lab=#net12}
N 5720 -2330 5740 -2330 {
lab=#net12}
N 5720 -2350 5740 -2350 {
lab=#net11}
N 5720 -2370 5740 -2370 {
lab=colon_n[5]}
N 5720 -2390 5740 -2390 {
lab=col_n[5]}
N 5540 -2250 5540 -2240 {
lab=VSS}
N 5540 -2480 5540 -2470 {
lab=VDD}
N 5880 -2250 5890 -2260 {
lab=row_n[18]}
N 5890 -2460 5890 -2260 {
lab=row_n[18]}
N 5880 -2470 5890 -2460 {
lab=row_n[18]}
N 5880 -2250 5880 -2230 {
lab=row_n[18]}
N 5880 -2490 5880 -2470 {
lab=row_n[18]}
N 5760 -2390 5770 -2400 {
lab=col_n[5]}
N 5770 -2400 5970 -2400 {
lab=col_n[5]}
N 5970 -2400 5980 -2390 {
lab=col_n[5]}
N 5760 -2370 5770 -2380 {
lab=colon_n[5]}
N 5770 -2380 5970 -2380 {
lab=colon_n[5]}
N 5970 -2380 5980 -2370 {
lab=colon_n[5]}
N 5760 -2350 5770 -2360 {
lab=#net11}
N 5770 -2360 5970 -2360 {
lab=#net11}
N 5970 -2360 5980 -2350 {
lab=#net11}
N 5760 -2330 5770 -2340 {
lab=#net12}
N 5770 -2340 5970 -2340 {
lab=#net12}
N 5970 -2340 5980 -2330 {
lab=#net12}
N 5820 -2490 5820 -2470 {
lab=vcom}
N 5860 -2490 5860 -2470 {
lab=ctop}
N 5740 -2390 5760 -2390 {
lab=col_n[5]}
N 5740 -2370 5760 -2370 {
lab=colon_n[5]}
N 5740 -2350 5760 -2350 {
lab=#net11}
N 5740 -2330 5760 -2330 {
lab=#net12}
N 5980 -2330 6000 -2330 {
lab=#net12}
N 5980 -2350 6000 -2350 {
lab=#net11}
N 5980 -2370 6000 -2370 {
lab=colon_n[5]}
N 5980 -2390 6000 -2390 {
lab=col_n[5]}
N 5800 -2250 5800 -2240 {
lab=VSS}
N 5800 -2480 5800 -2470 {
lab=VDD}
N 6140 -2250 6150 -2260 {
lab=row_n[19]}
N 6150 -2460 6150 -2260 {
lab=row_n[19]}
N 6140 -2470 6150 -2460 {
lab=row_n[19]}
N 6140 -2250 6140 -2230 {
lab=row_n[19]}
N 6140 -2490 6140 -2470 {
lab=row_n[19]}
N 6020 -2390 6030 -2400 {
lab=col_n[5]}
N 6030 -2400 6230 -2400 {
lab=col_n[5]}
N 6230 -2400 6240 -2390 {
lab=col_n[5]}
N 6020 -2370 6030 -2380 {
lab=colon_n[5]}
N 6030 -2380 6230 -2380 {
lab=colon_n[5]}
N 6230 -2380 6240 -2370 {
lab=colon_n[5]}
N 6020 -2350 6030 -2360 {
lab=#net11}
N 6030 -2360 6230 -2360 {
lab=#net11}
N 6230 -2360 6240 -2350 {
lab=#net11}
N 6020 -2330 6030 -2340 {
lab=#net12}
N 6030 -2340 6230 -2340 {
lab=#net12}
N 6230 -2340 6240 -2330 {
lab=#net12}
N 6080 -2490 6080 -2470 {
lab=vcom}
N 6120 -2490 6120 -2470 {
lab=ctop}
N 6000 -2390 6020 -2390 {
lab=col_n[5]}
N 6000 -2370 6020 -2370 {
lab=colon_n[5]}
N 6000 -2350 6020 -2350 {
lab=#net11}
N 6000 -2330 6020 -2330 {
lab=#net12}
N 6240 -2330 6260 -2330 {
lab=#net12}
N 6240 -2350 6260 -2350 {
lab=#net11}
N 6240 -2370 6260 -2370 {
lab=colon_n[5]}
N 6240 -2390 6260 -2390 {
lab=col_n[5]}
N 6060 -2250 6060 -2240 {
lab=VSS}
N 6060 -2480 6060 -2470 {
lab=VDD}
N 6400 -2250 6410 -2260 {
lab=row_n[20]}
N 6410 -2460 6410 -2260 {
lab=row_n[20]}
N 6400 -2470 6410 -2460 {
lab=row_n[20]}
N 6400 -2250 6400 -2230 {
lab=row_n[20]}
N 6400 -2490 6400 -2470 {
lab=row_n[20]}
N 6280 -2390 6290 -2400 {
lab=col_n[5]}
N 6290 -2400 6490 -2400 {
lab=col_n[5]}
N 6490 -2400 6500 -2390 {
lab=col_n[5]}
N 6280 -2370 6290 -2380 {
lab=colon_n[5]}
N 6290 -2380 6490 -2380 {
lab=colon_n[5]}
N 6490 -2380 6500 -2370 {
lab=colon_n[5]}
N 6280 -2350 6290 -2360 {
lab=#net11}
N 6290 -2360 6490 -2360 {
lab=#net11}
N 6490 -2360 6500 -2350 {
lab=#net11}
N 6280 -2330 6290 -2340 {
lab=#net12}
N 6290 -2340 6490 -2340 {
lab=#net12}
N 6490 -2340 6500 -2330 {
lab=#net12}
N 6340 -2490 6340 -2470 {
lab=vcom}
N 6380 -2490 6380 -2470 {
lab=ctop}
N 6260 -2390 6280 -2390 {
lab=col_n[5]}
N 6260 -2370 6280 -2370 {
lab=colon_n[5]}
N 6260 -2350 6280 -2350 {
lab=#net11}
N 6260 -2330 6280 -2330 {
lab=#net12}
N 6500 -2330 6520 -2330 {
lab=#net12}
N 6500 -2350 6520 -2350 {
lab=#net11}
N 6500 -2370 6520 -2370 {
lab=colon_n[5]}
N 6500 -2390 6520 -2390 {
lab=col_n[5]}
N 6320 -2250 6320 -2240 {
lab=VSS}
N 6320 -2480 6320 -2470 {
lab=VDD}
N 6660 -2250 6670 -2260 {
lab=row_n[21]}
N 6670 -2460 6670 -2260 {
lab=row_n[21]}
N 6660 -2470 6670 -2460 {
lab=row_n[21]}
N 6660 -2250 6660 -2230 {
lab=row_n[21]}
N 6660 -2490 6660 -2470 {
lab=row_n[21]}
N 6540 -2390 6550 -2400 {
lab=col_n[5]}
N 6550 -2400 6750 -2400 {
lab=col_n[5]}
N 6750 -2400 6760 -2390 {
lab=col_n[5]}
N 6540 -2370 6550 -2380 {
lab=colon_n[5]}
N 6550 -2380 6750 -2380 {
lab=colon_n[5]}
N 6750 -2380 6760 -2370 {
lab=colon_n[5]}
N 6540 -2350 6550 -2360 {
lab=#net11}
N 6550 -2360 6750 -2360 {
lab=#net11}
N 6750 -2360 6760 -2350 {
lab=#net11}
N 6540 -2330 6550 -2340 {
lab=#net12}
N 6550 -2340 6750 -2340 {
lab=#net12}
N 6750 -2340 6760 -2330 {
lab=#net12}
N 6600 -2490 6600 -2470 {
lab=vcom}
N 6640 -2490 6640 -2470 {
lab=ctop}
N 6520 -2390 6540 -2390 {
lab=col_n[5]}
N 6520 -2370 6540 -2370 {
lab=colon_n[5]}
N 6520 -2350 6540 -2350 {
lab=#net11}
N 6520 -2330 6540 -2330 {
lab=#net12}
N 6760 -2330 6780 -2330 {
lab=#net12}
N 6760 -2350 6780 -2350 {
lab=#net11}
N 6760 -2370 6780 -2370 {
lab=colon_n[5]}
N 6760 -2390 6780 -2390 {
lab=col_n[5]}
N 6580 -2250 6580 -2240 {
lab=VSS}
N 6580 -2480 6580 -2470 {
lab=VDD}
N 6920 -2250 6930 -2260 {
lab=row_n[22]}
N 6930 -2460 6930 -2260 {
lab=row_n[22]}
N 6920 -2470 6930 -2460 {
lab=row_n[22]}
N 6920 -2250 6920 -2230 {
lab=row_n[22]}
N 6920 -2490 6920 -2470 {
lab=row_n[22]}
N 6800 -2390 6810 -2400 {
lab=col_n[5]}
N 6810 -2400 7010 -2400 {
lab=col_n[5]}
N 7010 -2400 7020 -2390 {
lab=col_n[5]}
N 6800 -2370 6810 -2380 {
lab=colon_n[5]}
N 6810 -2380 7010 -2380 {
lab=colon_n[5]}
N 7010 -2380 7020 -2370 {
lab=colon_n[5]}
N 6800 -2350 6810 -2360 {
lab=#net11}
N 6810 -2360 7010 -2360 {
lab=#net11}
N 7010 -2360 7020 -2350 {
lab=#net11}
N 6800 -2330 6810 -2340 {
lab=#net12}
N 6810 -2340 7010 -2340 {
lab=#net12}
N 7010 -2340 7020 -2330 {
lab=#net12}
N 6860 -2490 6860 -2470 {
lab=vcom}
N 6900 -2490 6900 -2470 {
lab=ctop}
N 6780 -2390 6800 -2390 {
lab=col_n[5]}
N 6780 -2370 6800 -2370 {
lab=colon_n[5]}
N 6780 -2350 6800 -2350 {
lab=#net11}
N 6780 -2330 6800 -2330 {
lab=#net12}
N 7020 -2330 7040 -2330 {
lab=#net12}
N 7020 -2350 7040 -2350 {
lab=#net11}
N 7020 -2370 7040 -2370 {
lab=colon_n[5]}
N 7020 -2390 7040 -2390 {
lab=col_n[5]}
N 6840 -2250 6840 -2240 {
lab=VSS}
N 6840 -2480 6840 -2470 {
lab=VDD}
N 7180 -2250 7190 -2260 {
lab=row_n[23]}
N 7190 -2460 7190 -2260 {
lab=row_n[23]}
N 7180 -2470 7190 -2460 {
lab=row_n[23]}
N 7180 -2250 7180 -2230 {
lab=row_n[23]}
N 7180 -2490 7180 -2470 {
lab=row_n[23]}
N 7060 -2390 7070 -2400 {
lab=col_n[5]}
N 7070 -2400 7270 -2400 {
lab=col_n[5]}
N 7270 -2400 7280 -2390 {
lab=col_n[5]}
N 7060 -2370 7070 -2380 {
lab=colon_n[5]}
N 7070 -2380 7270 -2380 {
lab=colon_n[5]}
N 7270 -2380 7280 -2370 {
lab=colon_n[5]}
N 7060 -2350 7070 -2360 {
lab=#net11}
N 7070 -2360 7270 -2360 {
lab=#net11}
N 7270 -2360 7280 -2350 {
lab=#net11}
N 7060 -2330 7070 -2340 {
lab=#net12}
N 7070 -2340 7270 -2340 {
lab=#net12}
N 7270 -2340 7280 -2330 {
lab=#net12}
N 7120 -2490 7120 -2470 {
lab=vcom}
N 7160 -2490 7160 -2470 {
lab=ctop}
N 7040 -2390 7060 -2390 {
lab=col_n[5]}
N 7040 -2370 7060 -2370 {
lab=colon_n[5]}
N 7040 -2350 7060 -2350 {
lab=#net11}
N 7040 -2330 7060 -2330 {
lab=#net12}
N 7280 -2330 7300 -2330 {
lab=#net12}
N 7280 -2350 7300 -2350 {
lab=#net11}
N 7280 -2370 7300 -2370 {
lab=colon_n[5]}
N 7280 -2390 7300 -2390 {
lab=col_n[5]}
N 7100 -2250 7100 -2240 {
lab=VSS}
N 7100 -2480 7100 -2470 {
lab=VDD}
N 7440 -2250 7450 -2260 {
lab=row_n[24]}
N 7450 -2460 7450 -2260 {
lab=row_n[24]}
N 7440 -2470 7450 -2460 {
lab=row_n[24]}
N 7440 -2250 7440 -2230 {
lab=row_n[24]}
N 7440 -2490 7440 -2470 {
lab=row_n[24]}
N 7320 -2390 7330 -2400 {
lab=col_n[5]}
N 7330 -2400 7530 -2400 {
lab=col_n[5]}
N 7530 -2400 7540 -2390 {
lab=col_n[5]}
N 7320 -2370 7330 -2380 {
lab=colon_n[5]}
N 7330 -2380 7530 -2380 {
lab=colon_n[5]}
N 7530 -2380 7540 -2370 {
lab=colon_n[5]}
N 7320 -2350 7330 -2360 {
lab=#net11}
N 7330 -2360 7530 -2360 {
lab=#net11}
N 7530 -2360 7540 -2350 {
lab=#net11}
N 7320 -2330 7330 -2340 {
lab=#net12}
N 7330 -2340 7530 -2340 {
lab=#net12}
N 7530 -2340 7540 -2330 {
lab=#net12}
N 7380 -2490 7380 -2470 {
lab=vcom}
N 7420 -2490 7420 -2470 {
lab=ctop}
N 7300 -2390 7320 -2390 {
lab=col_n[5]}
N 7300 -2370 7320 -2370 {
lab=colon_n[5]}
N 7300 -2350 7320 -2350 {
lab=#net11}
N 7300 -2330 7320 -2330 {
lab=#net12}
N 7540 -2330 7560 -2330 {
lab=#net12}
N 7540 -2350 7560 -2350 {
lab=#net11}
N 7540 -2370 7560 -2370 {
lab=colon_n[5]}
N 7540 -2390 7560 -2390 {
lab=col_n[5]}
N 7360 -2250 7360 -2240 {
lab=VSS}
N 7360 -2480 7360 -2470 {
lab=VDD}
N 7700 -2250 7710 -2260 {
lab=row_n[25]}
N 7710 -2460 7710 -2260 {
lab=row_n[25]}
N 7700 -2470 7710 -2460 {
lab=row_n[25]}
N 7700 -2250 7700 -2230 {
lab=row_n[25]}
N 7700 -2490 7700 -2470 {
lab=row_n[25]}
N 7580 -2390 7590 -2400 {
lab=col_n[5]}
N 7590 -2400 7790 -2400 {
lab=col_n[5]}
N 7790 -2400 7800 -2390 {
lab=col_n[5]}
N 7580 -2370 7590 -2380 {
lab=colon_n[5]}
N 7590 -2380 7790 -2380 {
lab=colon_n[5]}
N 7790 -2380 7800 -2370 {
lab=colon_n[5]}
N 7580 -2350 7590 -2360 {
lab=#net11}
N 7590 -2360 7790 -2360 {
lab=#net11}
N 7790 -2360 7800 -2350 {
lab=#net11}
N 7580 -2330 7590 -2340 {
lab=#net12}
N 7590 -2340 7790 -2340 {
lab=#net12}
N 7790 -2340 7800 -2330 {
lab=#net12}
N 7640 -2490 7640 -2470 {
lab=vcom}
N 7680 -2490 7680 -2470 {
lab=ctop}
N 7560 -2390 7580 -2390 {
lab=col_n[5]}
N 7560 -2370 7580 -2370 {
lab=colon_n[5]}
N 7560 -2350 7580 -2350 {
lab=#net11}
N 7560 -2330 7580 -2330 {
lab=#net12}
N 7800 -2330 7820 -2330 {
lab=#net12}
N 7800 -2350 7820 -2350 {
lab=#net11}
N 7800 -2370 7820 -2370 {
lab=colon_n[5]}
N 7800 -2390 7820 -2390 {
lab=col_n[5]}
N 7620 -2250 7620 -2240 {
lab=VSS}
N 7620 -2480 7620 -2470 {
lab=VDD}
N 7960 -2250 7970 -2260 {
lab=row_n[26]}
N 7970 -2460 7970 -2260 {
lab=row_n[26]}
N 7960 -2470 7970 -2460 {
lab=row_n[26]}
N 7960 -2250 7960 -2230 {
lab=row_n[26]}
N 7960 -2490 7960 -2470 {
lab=row_n[26]}
N 7840 -2390 7850 -2400 {
lab=col_n[5]}
N 7850 -2400 8050 -2400 {
lab=col_n[5]}
N 8050 -2400 8060 -2390 {
lab=col_n[5]}
N 7840 -2370 7850 -2380 {
lab=colon_n[5]}
N 7850 -2380 8050 -2380 {
lab=colon_n[5]}
N 8050 -2380 8060 -2370 {
lab=colon_n[5]}
N 7840 -2350 7850 -2360 {
lab=#net11}
N 7850 -2360 8050 -2360 {
lab=#net11}
N 8050 -2360 8060 -2350 {
lab=#net11}
N 7840 -2330 7850 -2340 {
lab=#net12}
N 7850 -2340 8050 -2340 {
lab=#net12}
N 8050 -2340 8060 -2330 {
lab=#net12}
N 7900 -2490 7900 -2470 {
lab=vcom}
N 7940 -2490 7940 -2470 {
lab=ctop}
N 7820 -2390 7840 -2390 {
lab=col_n[5]}
N 7820 -2370 7840 -2370 {
lab=colon_n[5]}
N 7820 -2350 7840 -2350 {
lab=#net11}
N 7820 -2330 7840 -2330 {
lab=#net12}
N 8060 -2330 8080 -2330 {
lab=#net12}
N 8060 -2350 8080 -2350 {
lab=#net11}
N 8060 -2370 8080 -2370 {
lab=colon_n[5]}
N 8060 -2390 8080 -2390 {
lab=col_n[5]}
N 7880 -2250 7880 -2240 {
lab=VSS}
N 7880 -2480 7880 -2470 {
lab=VDD}
N 8220 -2250 8230 -2260 {
lab=row_n[27]}
N 8230 -2460 8230 -2260 {
lab=row_n[27]}
N 8220 -2470 8230 -2460 {
lab=row_n[27]}
N 8220 -2250 8220 -2230 {
lab=row_n[27]}
N 8220 -2490 8220 -2470 {
lab=row_n[27]}
N 8100 -2390 8110 -2400 {
lab=col_n[5]}
N 8110 -2400 8310 -2400 {
lab=col_n[5]}
N 8310 -2400 8320 -2390 {
lab=col_n[5]}
N 8100 -2370 8110 -2380 {
lab=colon_n[5]}
N 8110 -2380 8310 -2380 {
lab=colon_n[5]}
N 8310 -2380 8320 -2370 {
lab=colon_n[5]}
N 8100 -2350 8110 -2360 {
lab=#net11}
N 8110 -2360 8310 -2360 {
lab=#net11}
N 8310 -2360 8320 -2350 {
lab=#net11}
N 8100 -2330 8110 -2340 {
lab=#net12}
N 8110 -2340 8310 -2340 {
lab=#net12}
N 8310 -2340 8320 -2330 {
lab=#net12}
N 8160 -2490 8160 -2470 {
lab=vcom}
N 8200 -2490 8200 -2470 {
lab=ctop}
N 8080 -2390 8100 -2390 {
lab=col_n[5]}
N 8080 -2370 8100 -2370 {
lab=colon_n[5]}
N 8080 -2350 8100 -2350 {
lab=#net11}
N 8080 -2330 8100 -2330 {
lab=#net12}
N 8320 -2330 8340 -2330 {
lab=#net12}
N 8320 -2350 8340 -2350 {
lab=#net11}
N 8320 -2370 8340 -2370 {
lab=colon_n[5]}
N 8320 -2390 8340 -2390 {
lab=col_n[5]}
N 8140 -2250 8140 -2240 {
lab=VSS}
N 8140 -2480 8140 -2470 {
lab=VDD}
N 8480 -2250 8490 -2260 {
lab=row_n[28]}
N 8490 -2460 8490 -2260 {
lab=row_n[28]}
N 8480 -2470 8490 -2460 {
lab=row_n[28]}
N 8480 -2250 8480 -2230 {
lab=row_n[28]}
N 8480 -2490 8480 -2470 {
lab=row_n[28]}
N 8360 -2390 8370 -2400 {
lab=col_n[5]}
N 8370 -2400 8570 -2400 {
lab=col_n[5]}
N 8570 -2400 8580 -2390 {
lab=col_n[5]}
N 8360 -2370 8370 -2380 {
lab=colon_n[5]}
N 8370 -2380 8570 -2380 {
lab=colon_n[5]}
N 8570 -2380 8580 -2370 {
lab=colon_n[5]}
N 8360 -2350 8370 -2360 {
lab=#net11}
N 8370 -2360 8570 -2360 {
lab=#net11}
N 8570 -2360 8580 -2350 {
lab=#net11}
N 8360 -2330 8370 -2340 {
lab=#net12}
N 8370 -2340 8570 -2340 {
lab=#net12}
N 8570 -2340 8580 -2330 {
lab=#net12}
N 8420 -2490 8420 -2470 {
lab=vcom}
N 8460 -2490 8460 -2470 {
lab=ctop}
N 8340 -2390 8360 -2390 {
lab=col_n[5]}
N 8340 -2370 8360 -2370 {
lab=colon_n[5]}
N 8340 -2350 8360 -2350 {
lab=#net11}
N 8340 -2330 8360 -2330 {
lab=#net12}
N 8580 -2330 8600 -2330 {
lab=#net12}
N 8580 -2350 8600 -2350 {
lab=#net11}
N 8580 -2370 8600 -2370 {
lab=colon_n[5]}
N 8580 -2390 8600 -2390 {
lab=col_n[5]}
N 8400 -2250 8400 -2240 {
lab=VSS}
N 8400 -2480 8400 -2470 {
lab=VDD}
N 8740 -2250 8750 -2260 {
lab=row_n[29]}
N 8750 -2460 8750 -2260 {
lab=row_n[29]}
N 8740 -2470 8750 -2460 {
lab=row_n[29]}
N 8740 -2250 8740 -2230 {
lab=row_n[29]}
N 8740 -2490 8740 -2470 {
lab=row_n[29]}
N 8620 -2390 8630 -2400 {
lab=col_n[5]}
N 8630 -2400 8830 -2400 {
lab=col_n[5]}
N 8830 -2400 8840 -2390 {
lab=col_n[5]}
N 8620 -2370 8630 -2380 {
lab=colon_n[5]}
N 8630 -2380 8830 -2380 {
lab=colon_n[5]}
N 8830 -2380 8840 -2370 {
lab=colon_n[5]}
N 8620 -2350 8630 -2360 {
lab=#net11}
N 8630 -2360 8830 -2360 {
lab=#net11}
N 8830 -2360 8840 -2350 {
lab=#net11}
N 8620 -2330 8630 -2340 {
lab=#net12}
N 8630 -2340 8830 -2340 {
lab=#net12}
N 8830 -2340 8840 -2330 {
lab=#net12}
N 8680 -2490 8680 -2470 {
lab=vcom}
N 8720 -2490 8720 -2470 {
lab=ctop}
N 8600 -2390 8620 -2390 {
lab=col_n[5]}
N 8600 -2370 8620 -2370 {
lab=colon_n[5]}
N 8600 -2350 8620 -2350 {
lab=#net11}
N 8600 -2330 8620 -2330 {
lab=#net12}
N 8840 -2330 8860 -2330 {
lab=#net12}
N 8840 -2350 8860 -2350 {
lab=#net11}
N 8840 -2370 8860 -2370 {
lab=colon_n[5]}
N 8840 -2390 8860 -2390 {
lab=col_n[5]}
N 8660 -2250 8660 -2240 {
lab=VSS}
N 8660 -2480 8660 -2470 {
lab=VDD}
N 9000 -2250 9010 -2260 {
lab=row_n[30]}
N 9010 -2460 9010 -2260 {
lab=row_n[30]}
N 9000 -2470 9010 -2460 {
lab=row_n[30]}
N 9000 -2250 9000 -2230 {
lab=row_n[30]}
N 9000 -2490 9000 -2470 {
lab=row_n[30]}
N 8880 -2390 8890 -2400 {
lab=col_n[5]}
N 8890 -2400 9090 -2400 {
lab=col_n[5]}
N 9090 -2400 9100 -2390 {
lab=col_n[5]}
N 8880 -2370 8890 -2380 {
lab=colon_n[5]}
N 8890 -2380 9090 -2380 {
lab=colon_n[5]}
N 9090 -2380 9100 -2370 {
lab=colon_n[5]}
N 8880 -2350 8890 -2360 {
lab=#net11}
N 8890 -2360 9090 -2360 {
lab=#net11}
N 9090 -2360 9100 -2350 {
lab=#net11}
N 8880 -2330 8890 -2340 {
lab=#net12}
N 8890 -2340 9090 -2340 {
lab=#net12}
N 9090 -2340 9100 -2330 {
lab=#net12}
N 8940 -2490 8940 -2470 {
lab=vcom}
N 8980 -2490 8980 -2470 {
lab=ctop}
N 8860 -2390 8880 -2390 {
lab=col_n[5]}
N 8860 -2370 8880 -2370 {
lab=colon_n[5]}
N 8860 -2350 8880 -2350 {
lab=#net11}
N 8860 -2330 8880 -2330 {
lab=#net12}
N 9100 -2330 9120 -2330 {
lab=#net12}
N 9100 -2350 9120 -2350 {
lab=#net11}
N 9100 -2370 9120 -2370 {
lab=colon_n[5]}
N 9100 -2390 9120 -2390 {
lab=col_n[5]}
N 8920 -2250 8920 -2240 {
lab=VSS}
N 8920 -2480 8920 -2470 {
lab=VDD}
N 9260 -2250 9270 -2260 {
lab=row_n[31]}
N 9270 -2460 9270 -2260 {
lab=row_n[31]}
N 9260 -2470 9270 -2460 {
lab=row_n[31]}
N 9260 -2250 9260 -2230 {
lab=row_n[31]}
N 9260 -2490 9260 -2470 {
lab=row_n[31]}
N 9140 -2390 9150 -2400 {
lab=col_n[5]}
N 9150 -2400 9350 -2400 {
lab=col_n[5]}
N 9350 -2400 9360 -2390 {
lab=col_n[5]}
N 9140 -2370 9150 -2380 {
lab=colon_n[5]}
N 9150 -2380 9350 -2380 {
lab=colon_n[5]}
N 9350 -2380 9360 -2370 {
lab=colon_n[5]}
N 9140 -2350 9150 -2360 {
lab=#net11}
N 9150 -2360 9350 -2360 {
lab=#net11}
N 9350 -2360 9360 -2350 {
lab=#net11}
N 9140 -2330 9150 -2340 {
lab=#net12}
N 9150 -2340 9350 -2340 {
lab=#net12}
N 9350 -2340 9360 -2330 {
lab=#net12}
N 9200 -2490 9200 -2470 {
lab=vcom}
N 9240 -2490 9240 -2470 {
lab=ctop}
N 9120 -2390 9140 -2390 {
lab=col_n[5]}
N 9120 -2370 9140 -2370 {
lab=colon_n[5]}
N 9120 -2350 9140 -2350 {
lab=#net11}
N 9120 -2330 9140 -2330 {
lab=#net12}
N 9360 -2330 9380 -2330 {
lab=#net12}
N 9360 -2350 9380 -2350 {
lab=#net11}
N 9360 -2370 9380 -2370 {
lab=colon_n[5]}
N 9360 -2390 9380 -2390 {
lab=col_n[5]}
N 9180 -2250 9180 -2240 {
lab=VSS}
N 9180 -2480 9180 -2470 {
lab=VDD}
N 1200 -2510 1210 -2520 {
lab=row_n[0]}
N 1210 -2720 1210 -2520 {
lab=row_n[0]}
N 1200 -2730 1210 -2720 {
lab=row_n[0]}
N 1200 -2510 1200 -2490 {
lab=row_n[0]}
N 1200 -2750 1200 -2730 {
lab=row_n[0]}
N 1080 -2650 1090 -2660 {
lab=col_n[6]}
N 1090 -2660 1290 -2660 {
lab=col_n[6]}
N 1290 -2660 1300 -2650 {
lab=col_n[6]}
N 1080 -2630 1090 -2640 {
lab=colon_n[6]}
N 1090 -2640 1290 -2640 {
lab=colon_n[6]}
N 1290 -2640 1300 -2630 {
lab=colon_n[6]}
N 1080 -2610 1090 -2620 {
lab=#net13}
N 1090 -2620 1290 -2620 {
lab=#net13}
N 1290 -2620 1300 -2610 {
lab=#net13}
N 1080 -2590 1090 -2600 {
lab=#net14}
N 1090 -2600 1290 -2600 {
lab=#net14}
N 1290 -2600 1300 -2590 {
lab=#net14}
N 1140 -2750 1140 -2730 {
lab=vcom}
N 1180 -2750 1180 -2730 {
lab=ctop}
N 1060 -2650 1080 -2650 {
lab=col_n[6]}
N 1060 -2630 1080 -2630 {
lab=colon_n[6]}
N 1060 -2610 1080 -2610 {
lab=#net13}
N 1060 -2590 1080 -2590 {
lab=#net14}
N 1300 -2590 1320 -2590 {
lab=#net14}
N 1300 -2610 1320 -2610 {
lab=#net13}
N 1300 -2630 1320 -2630 {
lab=colon_n[6]}
N 1300 -2650 1320 -2650 {
lab=col_n[6]}
N 1120 -2510 1120 -2500 {
lab=VSS}
N 1120 -2740 1120 -2730 {
lab=VDD}
N 1460 -2510 1470 -2520 {
lab=row_n[1]}
N 1470 -2720 1470 -2520 {
lab=row_n[1]}
N 1460 -2730 1470 -2720 {
lab=row_n[1]}
N 1460 -2510 1460 -2490 {
lab=row_n[1]}
N 1460 -2750 1460 -2730 {
lab=row_n[1]}
N 1340 -2650 1350 -2660 {
lab=col_n[6]}
N 1350 -2660 1550 -2660 {
lab=col_n[6]}
N 1550 -2660 1560 -2650 {
lab=col_n[6]}
N 1340 -2630 1350 -2640 {
lab=colon_n[6]}
N 1350 -2640 1550 -2640 {
lab=colon_n[6]}
N 1550 -2640 1560 -2630 {
lab=colon_n[6]}
N 1340 -2610 1350 -2620 {
lab=#net13}
N 1350 -2620 1550 -2620 {
lab=#net13}
N 1550 -2620 1560 -2610 {
lab=#net13}
N 1340 -2590 1350 -2600 {
lab=#net14}
N 1350 -2600 1550 -2600 {
lab=#net14}
N 1550 -2600 1560 -2590 {
lab=#net14}
N 1400 -2750 1400 -2730 {
lab=vcom}
N 1440 -2750 1440 -2730 {
lab=ctop}
N 1320 -2650 1340 -2650 {
lab=col_n[6]}
N 1320 -2630 1340 -2630 {
lab=colon_n[6]}
N 1320 -2610 1340 -2610 {
lab=#net13}
N 1320 -2590 1340 -2590 {
lab=#net14}
N 1560 -2590 1580 -2590 {
lab=#net14}
N 1560 -2610 1580 -2610 {
lab=#net13}
N 1560 -2630 1580 -2630 {
lab=colon_n[6]}
N 1560 -2650 1580 -2650 {
lab=col_n[6]}
N 1380 -2510 1380 -2500 {
lab=VSS}
N 1380 -2740 1380 -2730 {
lab=VDD}
N 1720 -2510 1730 -2520 {
lab=row_n[2]}
N 1730 -2720 1730 -2520 {
lab=row_n[2]}
N 1720 -2730 1730 -2720 {
lab=row_n[2]}
N 1720 -2510 1720 -2490 {
lab=row_n[2]}
N 1720 -2750 1720 -2730 {
lab=row_n[2]}
N 1600 -2650 1610 -2660 {
lab=col_n[6]}
N 1610 -2660 1810 -2660 {
lab=col_n[6]}
N 1810 -2660 1820 -2650 {
lab=col_n[6]}
N 1600 -2630 1610 -2640 {
lab=colon_n[6]}
N 1610 -2640 1810 -2640 {
lab=colon_n[6]}
N 1810 -2640 1820 -2630 {
lab=colon_n[6]}
N 1600 -2610 1610 -2620 {
lab=#net13}
N 1610 -2620 1810 -2620 {
lab=#net13}
N 1810 -2620 1820 -2610 {
lab=#net13}
N 1600 -2590 1610 -2600 {
lab=#net14}
N 1610 -2600 1810 -2600 {
lab=#net14}
N 1810 -2600 1820 -2590 {
lab=#net14}
N 1660 -2750 1660 -2730 {
lab=vcom}
N 1700 -2750 1700 -2730 {
lab=ctop}
N 1580 -2650 1600 -2650 {
lab=col_n[6]}
N 1580 -2630 1600 -2630 {
lab=colon_n[6]}
N 1580 -2610 1600 -2610 {
lab=#net13}
N 1580 -2590 1600 -2590 {
lab=#net14}
N 1820 -2590 1840 -2590 {
lab=#net14}
N 1820 -2610 1840 -2610 {
lab=#net13}
N 1820 -2630 1840 -2630 {
lab=colon_n[6]}
N 1820 -2650 1840 -2650 {
lab=col_n[6]}
N 1640 -2510 1640 -2500 {
lab=VSS}
N 1640 -2740 1640 -2730 {
lab=VDD}
N 1980 -2510 1990 -2520 {
lab=row_n[3]}
N 1990 -2720 1990 -2520 {
lab=row_n[3]}
N 1980 -2730 1990 -2720 {
lab=row_n[3]}
N 1980 -2510 1980 -2490 {
lab=row_n[3]}
N 1980 -2750 1980 -2730 {
lab=row_n[3]}
N 1860 -2650 1870 -2660 {
lab=col_n[6]}
N 1870 -2660 2070 -2660 {
lab=col_n[6]}
N 2070 -2660 2080 -2650 {
lab=col_n[6]}
N 1860 -2630 1870 -2640 {
lab=colon_n[6]}
N 1870 -2640 2070 -2640 {
lab=colon_n[6]}
N 2070 -2640 2080 -2630 {
lab=colon_n[6]}
N 1860 -2610 1870 -2620 {
lab=#net13}
N 1870 -2620 2070 -2620 {
lab=#net13}
N 2070 -2620 2080 -2610 {
lab=#net13}
N 1860 -2590 1870 -2600 {
lab=#net14}
N 1870 -2600 2070 -2600 {
lab=#net14}
N 2070 -2600 2080 -2590 {
lab=#net14}
N 1920 -2750 1920 -2730 {
lab=vcom}
N 1960 -2750 1960 -2730 {
lab=ctop}
N 1840 -2650 1860 -2650 {
lab=col_n[6]}
N 1840 -2630 1860 -2630 {
lab=colon_n[6]}
N 1840 -2610 1860 -2610 {
lab=#net13}
N 1840 -2590 1860 -2590 {
lab=#net14}
N 2080 -2590 2100 -2590 {
lab=#net14}
N 2080 -2610 2100 -2610 {
lab=#net13}
N 2080 -2630 2100 -2630 {
lab=colon_n[6]}
N 2080 -2650 2100 -2650 {
lab=col_n[6]}
N 1900 -2510 1900 -2500 {
lab=VSS}
N 1900 -2740 1900 -2730 {
lab=VDD}
N 2240 -2510 2250 -2520 {
lab=row_n[4]}
N 2250 -2720 2250 -2520 {
lab=row_n[4]}
N 2240 -2730 2250 -2720 {
lab=row_n[4]}
N 2240 -2510 2240 -2490 {
lab=row_n[4]}
N 2240 -2750 2240 -2730 {
lab=row_n[4]}
N 2120 -2650 2130 -2660 {
lab=col_n[6]}
N 2130 -2660 2330 -2660 {
lab=col_n[6]}
N 2330 -2660 2340 -2650 {
lab=col_n[6]}
N 2120 -2630 2130 -2640 {
lab=colon_n[6]}
N 2130 -2640 2330 -2640 {
lab=colon_n[6]}
N 2330 -2640 2340 -2630 {
lab=colon_n[6]}
N 2120 -2610 2130 -2620 {
lab=#net13}
N 2130 -2620 2330 -2620 {
lab=#net13}
N 2330 -2620 2340 -2610 {
lab=#net13}
N 2120 -2590 2130 -2600 {
lab=#net14}
N 2130 -2600 2330 -2600 {
lab=#net14}
N 2330 -2600 2340 -2590 {
lab=#net14}
N 2180 -2750 2180 -2730 {
lab=vcom}
N 2220 -2750 2220 -2730 {
lab=ctop}
N 2100 -2650 2120 -2650 {
lab=col_n[6]}
N 2100 -2630 2120 -2630 {
lab=colon_n[6]}
N 2100 -2610 2120 -2610 {
lab=#net13}
N 2100 -2590 2120 -2590 {
lab=#net14}
N 2340 -2590 2360 -2590 {
lab=#net14}
N 2340 -2610 2360 -2610 {
lab=#net13}
N 2340 -2630 2360 -2630 {
lab=colon_n[6]}
N 2340 -2650 2360 -2650 {
lab=col_n[6]}
N 2160 -2510 2160 -2500 {
lab=VSS}
N 2160 -2740 2160 -2730 {
lab=VDD}
N 2500 -2510 2510 -2520 {
lab=row_n[5]}
N 2510 -2720 2510 -2520 {
lab=row_n[5]}
N 2500 -2730 2510 -2720 {
lab=row_n[5]}
N 2500 -2510 2500 -2490 {
lab=row_n[5]}
N 2500 -2750 2500 -2730 {
lab=row_n[5]}
N 2380 -2650 2390 -2660 {
lab=col_n[6]}
N 2390 -2660 2590 -2660 {
lab=col_n[6]}
N 2590 -2660 2600 -2650 {
lab=col_n[6]}
N 2380 -2630 2390 -2640 {
lab=colon_n[6]}
N 2390 -2640 2590 -2640 {
lab=colon_n[6]}
N 2590 -2640 2600 -2630 {
lab=colon_n[6]}
N 2380 -2610 2390 -2620 {
lab=#net13}
N 2390 -2620 2590 -2620 {
lab=#net13}
N 2590 -2620 2600 -2610 {
lab=#net13}
N 2380 -2590 2390 -2600 {
lab=#net14}
N 2390 -2600 2590 -2600 {
lab=#net14}
N 2590 -2600 2600 -2590 {
lab=#net14}
N 2440 -2750 2440 -2730 {
lab=vcom}
N 2480 -2750 2480 -2730 {
lab=ctop}
N 2360 -2650 2380 -2650 {
lab=col_n[6]}
N 2360 -2630 2380 -2630 {
lab=colon_n[6]}
N 2360 -2610 2380 -2610 {
lab=#net13}
N 2360 -2590 2380 -2590 {
lab=#net14}
N 2600 -2590 2620 -2590 {
lab=#net14}
N 2600 -2610 2620 -2610 {
lab=#net13}
N 2600 -2630 2620 -2630 {
lab=colon_n[6]}
N 2600 -2650 2620 -2650 {
lab=col_n[6]}
N 2420 -2510 2420 -2500 {
lab=VSS}
N 2420 -2740 2420 -2730 {
lab=VDD}
N 2760 -2510 2770 -2520 {
lab=row_n[6]}
N 2770 -2720 2770 -2520 {
lab=row_n[6]}
N 2760 -2730 2770 -2720 {
lab=row_n[6]}
N 2760 -2510 2760 -2490 {
lab=row_n[6]}
N 2760 -2750 2760 -2730 {
lab=row_n[6]}
N 2640 -2650 2650 -2660 {
lab=col_n[6]}
N 2650 -2660 2850 -2660 {
lab=col_n[6]}
N 2850 -2660 2860 -2650 {
lab=col_n[6]}
N 2640 -2630 2650 -2640 {
lab=colon_n[6]}
N 2650 -2640 2850 -2640 {
lab=colon_n[6]}
N 2850 -2640 2860 -2630 {
lab=colon_n[6]}
N 2640 -2610 2650 -2620 {
lab=#net13}
N 2650 -2620 2850 -2620 {
lab=#net13}
N 2850 -2620 2860 -2610 {
lab=#net13}
N 2640 -2590 2650 -2600 {
lab=#net14}
N 2650 -2600 2850 -2600 {
lab=#net14}
N 2850 -2600 2860 -2590 {
lab=#net14}
N 2700 -2750 2700 -2730 {
lab=vcom}
N 2740 -2750 2740 -2730 {
lab=ctop}
N 2620 -2650 2640 -2650 {
lab=col_n[6]}
N 2620 -2630 2640 -2630 {
lab=colon_n[6]}
N 2620 -2610 2640 -2610 {
lab=#net13}
N 2620 -2590 2640 -2590 {
lab=#net14}
N 2860 -2590 2880 -2590 {
lab=#net14}
N 2860 -2610 2880 -2610 {
lab=#net13}
N 2860 -2630 2880 -2630 {
lab=colon_n[6]}
N 2860 -2650 2880 -2650 {
lab=col_n[6]}
N 2680 -2510 2680 -2500 {
lab=VSS}
N 2680 -2740 2680 -2730 {
lab=VDD}
N 3020 -2510 3030 -2520 {
lab=row_n[7]}
N 3030 -2720 3030 -2520 {
lab=row_n[7]}
N 3020 -2730 3030 -2720 {
lab=row_n[7]}
N 3020 -2510 3020 -2490 {
lab=row_n[7]}
N 3020 -2750 3020 -2730 {
lab=row_n[7]}
N 2900 -2650 2910 -2660 {
lab=col_n[6]}
N 2910 -2660 3110 -2660 {
lab=col_n[6]}
N 3110 -2660 3120 -2650 {
lab=col_n[6]}
N 2900 -2630 2910 -2640 {
lab=colon_n[6]}
N 2910 -2640 3110 -2640 {
lab=colon_n[6]}
N 3110 -2640 3120 -2630 {
lab=colon_n[6]}
N 2900 -2610 2910 -2620 {
lab=#net13}
N 2910 -2620 3110 -2620 {
lab=#net13}
N 3110 -2620 3120 -2610 {
lab=#net13}
N 2900 -2590 2910 -2600 {
lab=#net14}
N 2910 -2600 3110 -2600 {
lab=#net14}
N 3110 -2600 3120 -2590 {
lab=#net14}
N 2960 -2750 2960 -2730 {
lab=vcom}
N 3000 -2750 3000 -2730 {
lab=ctop}
N 2880 -2650 2900 -2650 {
lab=col_n[6]}
N 2880 -2630 2900 -2630 {
lab=colon_n[6]}
N 2880 -2610 2900 -2610 {
lab=#net13}
N 2880 -2590 2900 -2590 {
lab=#net14}
N 3120 -2590 3140 -2590 {
lab=#net14}
N 3120 -2610 3140 -2610 {
lab=#net13}
N 3120 -2630 3140 -2630 {
lab=colon_n[6]}
N 3120 -2650 3140 -2650 {
lab=col_n[6]}
N 2940 -2510 2940 -2500 {
lab=VSS}
N 2940 -2740 2940 -2730 {
lab=VDD}
N 3280 -2510 3290 -2520 {
lab=row_n[8]}
N 3290 -2720 3290 -2520 {
lab=row_n[8]}
N 3280 -2730 3290 -2720 {
lab=row_n[8]}
N 3280 -2510 3280 -2490 {
lab=row_n[8]}
N 3280 -2750 3280 -2730 {
lab=row_n[8]}
N 3160 -2650 3170 -2660 {
lab=col_n[6]}
N 3170 -2660 3370 -2660 {
lab=col_n[6]}
N 3370 -2660 3380 -2650 {
lab=col_n[6]}
N 3160 -2630 3170 -2640 {
lab=colon_n[6]}
N 3170 -2640 3370 -2640 {
lab=colon_n[6]}
N 3370 -2640 3380 -2630 {
lab=colon_n[6]}
N 3160 -2610 3170 -2620 {
lab=#net13}
N 3170 -2620 3370 -2620 {
lab=#net13}
N 3370 -2620 3380 -2610 {
lab=#net13}
N 3160 -2590 3170 -2600 {
lab=#net14}
N 3170 -2600 3370 -2600 {
lab=#net14}
N 3370 -2600 3380 -2590 {
lab=#net14}
N 3220 -2750 3220 -2730 {
lab=vcom}
N 3260 -2750 3260 -2730 {
lab=ctop}
N 3140 -2650 3160 -2650 {
lab=col_n[6]}
N 3140 -2630 3160 -2630 {
lab=colon_n[6]}
N 3140 -2610 3160 -2610 {
lab=#net13}
N 3140 -2590 3160 -2590 {
lab=#net14}
N 3380 -2590 3400 -2590 {
lab=#net14}
N 3380 -2610 3400 -2610 {
lab=#net13}
N 3380 -2630 3400 -2630 {
lab=colon_n[6]}
N 3380 -2650 3400 -2650 {
lab=col_n[6]}
N 3200 -2510 3200 -2500 {
lab=VSS}
N 3200 -2740 3200 -2730 {
lab=VDD}
N 3540 -2510 3550 -2520 {
lab=row_n[9]}
N 3550 -2720 3550 -2520 {
lab=row_n[9]}
N 3540 -2730 3550 -2720 {
lab=row_n[9]}
N 3540 -2510 3540 -2490 {
lab=row_n[9]}
N 3540 -2750 3540 -2730 {
lab=row_n[9]}
N 3420 -2650 3430 -2660 {
lab=col_n[6]}
N 3430 -2660 3630 -2660 {
lab=col_n[6]}
N 3630 -2660 3640 -2650 {
lab=col_n[6]}
N 3420 -2630 3430 -2640 {
lab=colon_n[6]}
N 3430 -2640 3630 -2640 {
lab=colon_n[6]}
N 3630 -2640 3640 -2630 {
lab=colon_n[6]}
N 3420 -2610 3430 -2620 {
lab=#net13}
N 3430 -2620 3630 -2620 {
lab=#net13}
N 3630 -2620 3640 -2610 {
lab=#net13}
N 3420 -2590 3430 -2600 {
lab=#net14}
N 3430 -2600 3630 -2600 {
lab=#net14}
N 3630 -2600 3640 -2590 {
lab=#net14}
N 3480 -2750 3480 -2730 {
lab=vcom}
N 3520 -2750 3520 -2730 {
lab=ctop}
N 3400 -2650 3420 -2650 {
lab=col_n[6]}
N 3400 -2630 3420 -2630 {
lab=colon_n[6]}
N 3400 -2610 3420 -2610 {
lab=#net13}
N 3400 -2590 3420 -2590 {
lab=#net14}
N 3640 -2590 3660 -2590 {
lab=#net14}
N 3640 -2610 3660 -2610 {
lab=#net13}
N 3640 -2630 3660 -2630 {
lab=colon_n[6]}
N 3640 -2650 3660 -2650 {
lab=col_n[6]}
N 3460 -2510 3460 -2500 {
lab=VSS}
N 3460 -2740 3460 -2730 {
lab=VDD}
N 3800 -2510 3810 -2520 {
lab=row_n[10]}
N 3810 -2720 3810 -2520 {
lab=row_n[10]}
N 3800 -2730 3810 -2720 {
lab=row_n[10]}
N 3800 -2510 3800 -2490 {
lab=row_n[10]}
N 3800 -2750 3800 -2730 {
lab=row_n[10]}
N 3680 -2650 3690 -2660 {
lab=col_n[6]}
N 3690 -2660 3890 -2660 {
lab=col_n[6]}
N 3890 -2660 3900 -2650 {
lab=col_n[6]}
N 3680 -2630 3690 -2640 {
lab=colon_n[6]}
N 3690 -2640 3890 -2640 {
lab=colon_n[6]}
N 3890 -2640 3900 -2630 {
lab=colon_n[6]}
N 3680 -2610 3690 -2620 {
lab=#net13}
N 3690 -2620 3890 -2620 {
lab=#net13}
N 3890 -2620 3900 -2610 {
lab=#net13}
N 3680 -2590 3690 -2600 {
lab=#net14}
N 3690 -2600 3890 -2600 {
lab=#net14}
N 3890 -2600 3900 -2590 {
lab=#net14}
N 3740 -2750 3740 -2730 {
lab=vcom}
N 3780 -2750 3780 -2730 {
lab=ctop}
N 3660 -2650 3680 -2650 {
lab=col_n[6]}
N 3660 -2630 3680 -2630 {
lab=colon_n[6]}
N 3660 -2610 3680 -2610 {
lab=#net13}
N 3660 -2590 3680 -2590 {
lab=#net14}
N 3900 -2590 3920 -2590 {
lab=#net14}
N 3900 -2610 3920 -2610 {
lab=#net13}
N 3900 -2630 3920 -2630 {
lab=colon_n[6]}
N 3900 -2650 3920 -2650 {
lab=col_n[6]}
N 3720 -2510 3720 -2500 {
lab=VSS}
N 3720 -2740 3720 -2730 {
lab=VDD}
N 4060 -2510 4070 -2520 {
lab=row_n[11]}
N 4070 -2720 4070 -2520 {
lab=row_n[11]}
N 4060 -2730 4070 -2720 {
lab=row_n[11]}
N 4060 -2510 4060 -2490 {
lab=row_n[11]}
N 4060 -2750 4060 -2730 {
lab=row_n[11]}
N 3940 -2650 3950 -2660 {
lab=col_n[6]}
N 3950 -2660 4150 -2660 {
lab=col_n[6]}
N 4150 -2660 4160 -2650 {
lab=col_n[6]}
N 3940 -2630 3950 -2640 {
lab=colon_n[6]}
N 3950 -2640 4150 -2640 {
lab=colon_n[6]}
N 4150 -2640 4160 -2630 {
lab=colon_n[6]}
N 3940 -2610 3950 -2620 {
lab=#net13}
N 3950 -2620 4150 -2620 {
lab=#net13}
N 4150 -2620 4160 -2610 {
lab=#net13}
N 3940 -2590 3950 -2600 {
lab=#net14}
N 3950 -2600 4150 -2600 {
lab=#net14}
N 4150 -2600 4160 -2590 {
lab=#net14}
N 4000 -2750 4000 -2730 {
lab=vcom}
N 4040 -2750 4040 -2730 {
lab=ctop}
N 3920 -2650 3940 -2650 {
lab=col_n[6]}
N 3920 -2630 3940 -2630 {
lab=colon_n[6]}
N 3920 -2610 3940 -2610 {
lab=#net13}
N 3920 -2590 3940 -2590 {
lab=#net14}
N 4160 -2590 4180 -2590 {
lab=#net14}
N 4160 -2610 4180 -2610 {
lab=#net13}
N 4160 -2630 4180 -2630 {
lab=colon_n[6]}
N 4160 -2650 4180 -2650 {
lab=col_n[6]}
N 3980 -2510 3980 -2500 {
lab=VSS}
N 3980 -2740 3980 -2730 {
lab=VDD}
N 4320 -2510 4330 -2520 {
lab=row_n[12]}
N 4330 -2720 4330 -2520 {
lab=row_n[12]}
N 4320 -2730 4330 -2720 {
lab=row_n[12]}
N 4320 -2510 4320 -2490 {
lab=row_n[12]}
N 4320 -2750 4320 -2730 {
lab=row_n[12]}
N 4200 -2650 4210 -2660 {
lab=col_n[6]}
N 4210 -2660 4410 -2660 {
lab=col_n[6]}
N 4410 -2660 4420 -2650 {
lab=col_n[6]}
N 4200 -2630 4210 -2640 {
lab=colon_n[6]}
N 4210 -2640 4410 -2640 {
lab=colon_n[6]}
N 4410 -2640 4420 -2630 {
lab=colon_n[6]}
N 4200 -2610 4210 -2620 {
lab=#net13}
N 4210 -2620 4410 -2620 {
lab=#net13}
N 4410 -2620 4420 -2610 {
lab=#net13}
N 4200 -2590 4210 -2600 {
lab=#net14}
N 4210 -2600 4410 -2600 {
lab=#net14}
N 4410 -2600 4420 -2590 {
lab=#net14}
N 4260 -2750 4260 -2730 {
lab=vcom}
N 4300 -2750 4300 -2730 {
lab=ctop}
N 4180 -2650 4200 -2650 {
lab=col_n[6]}
N 4180 -2630 4200 -2630 {
lab=colon_n[6]}
N 4180 -2610 4200 -2610 {
lab=#net13}
N 4180 -2590 4200 -2590 {
lab=#net14}
N 4420 -2590 4440 -2590 {
lab=#net14}
N 4420 -2610 4440 -2610 {
lab=#net13}
N 4420 -2630 4440 -2630 {
lab=colon_n[6]}
N 4420 -2650 4440 -2650 {
lab=col_n[6]}
N 4240 -2510 4240 -2500 {
lab=VSS}
N 4240 -2740 4240 -2730 {
lab=VDD}
N 4580 -2510 4590 -2520 {
lab=row_n[13]}
N 4590 -2720 4590 -2520 {
lab=row_n[13]}
N 4580 -2730 4590 -2720 {
lab=row_n[13]}
N 4580 -2510 4580 -2490 {
lab=row_n[13]}
N 4580 -2750 4580 -2730 {
lab=row_n[13]}
N 4460 -2650 4470 -2660 {
lab=col_n[6]}
N 4470 -2660 4670 -2660 {
lab=col_n[6]}
N 4670 -2660 4680 -2650 {
lab=col_n[6]}
N 4460 -2630 4470 -2640 {
lab=colon_n[6]}
N 4470 -2640 4670 -2640 {
lab=colon_n[6]}
N 4670 -2640 4680 -2630 {
lab=colon_n[6]}
N 4460 -2610 4470 -2620 {
lab=#net13}
N 4470 -2620 4670 -2620 {
lab=#net13}
N 4670 -2620 4680 -2610 {
lab=#net13}
N 4460 -2590 4470 -2600 {
lab=#net14}
N 4470 -2600 4670 -2600 {
lab=#net14}
N 4670 -2600 4680 -2590 {
lab=#net14}
N 4520 -2750 4520 -2730 {
lab=vcom}
N 4560 -2750 4560 -2730 {
lab=ctop}
N 4440 -2650 4460 -2650 {
lab=col_n[6]}
N 4440 -2630 4460 -2630 {
lab=colon_n[6]}
N 4440 -2610 4460 -2610 {
lab=#net13}
N 4440 -2590 4460 -2590 {
lab=#net14}
N 4680 -2590 4700 -2590 {
lab=#net14}
N 4680 -2610 4700 -2610 {
lab=#net13}
N 4680 -2630 4700 -2630 {
lab=colon_n[6]}
N 4680 -2650 4700 -2650 {
lab=col_n[6]}
N 4500 -2510 4500 -2500 {
lab=VSS}
N 4500 -2740 4500 -2730 {
lab=VDD}
N 4840 -2510 4850 -2520 {
lab=row_n[14]}
N 4850 -2720 4850 -2520 {
lab=row_n[14]}
N 4840 -2730 4850 -2720 {
lab=row_n[14]}
N 4840 -2510 4840 -2490 {
lab=row_n[14]}
N 4840 -2750 4840 -2730 {
lab=row_n[14]}
N 4720 -2650 4730 -2660 {
lab=col_n[6]}
N 4730 -2660 4930 -2660 {
lab=col_n[6]}
N 4930 -2660 4940 -2650 {
lab=col_n[6]}
N 4720 -2630 4730 -2640 {
lab=colon_n[6]}
N 4730 -2640 4930 -2640 {
lab=colon_n[6]}
N 4930 -2640 4940 -2630 {
lab=colon_n[6]}
N 4720 -2610 4730 -2620 {
lab=#net13}
N 4730 -2620 4930 -2620 {
lab=#net13}
N 4930 -2620 4940 -2610 {
lab=#net13}
N 4720 -2590 4730 -2600 {
lab=#net14}
N 4730 -2600 4930 -2600 {
lab=#net14}
N 4930 -2600 4940 -2590 {
lab=#net14}
N 4780 -2750 4780 -2730 {
lab=vcom}
N 4820 -2750 4820 -2730 {
lab=ctop}
N 4700 -2650 4720 -2650 {
lab=col_n[6]}
N 4700 -2630 4720 -2630 {
lab=colon_n[6]}
N 4700 -2610 4720 -2610 {
lab=#net13}
N 4700 -2590 4720 -2590 {
lab=#net14}
N 4940 -2590 4960 -2590 {
lab=#net14}
N 4940 -2610 4960 -2610 {
lab=#net13}
N 4940 -2630 4960 -2630 {
lab=colon_n[6]}
N 4940 -2650 4960 -2650 {
lab=col_n[6]}
N 4760 -2510 4760 -2500 {
lab=VSS}
N 4760 -2740 4760 -2730 {
lab=VDD}
N 5100 -2510 5110 -2520 {
lab=row_n[15]}
N 5110 -2720 5110 -2520 {
lab=row_n[15]}
N 5100 -2730 5110 -2720 {
lab=row_n[15]}
N 5100 -2510 5100 -2490 {
lab=row_n[15]}
N 5100 -2750 5100 -2730 {
lab=row_n[15]}
N 4980 -2650 4990 -2660 {
lab=col_n[6]}
N 4990 -2660 5190 -2660 {
lab=col_n[6]}
N 5190 -2660 5200 -2650 {
lab=col_n[6]}
N 4980 -2630 4990 -2640 {
lab=colon_n[6]}
N 4990 -2640 5190 -2640 {
lab=colon_n[6]}
N 5190 -2640 5200 -2630 {
lab=colon_n[6]}
N 4980 -2610 4990 -2620 {
lab=#net13}
N 4990 -2620 5190 -2620 {
lab=#net13}
N 5190 -2620 5200 -2610 {
lab=#net13}
N 4980 -2590 4990 -2600 {
lab=#net14}
N 4990 -2600 5190 -2600 {
lab=#net14}
N 5190 -2600 5200 -2590 {
lab=#net14}
N 5040 -2750 5040 -2730 {
lab=vcom}
N 5080 -2750 5080 -2730 {
lab=ctop}
N 4960 -2650 4980 -2650 {
lab=col_n[6]}
N 4960 -2630 4980 -2630 {
lab=colon_n[6]}
N 4960 -2610 4980 -2610 {
lab=#net13}
N 4960 -2590 4980 -2590 {
lab=#net14}
N 5200 -2590 5220 -2590 {
lab=#net14}
N 5200 -2610 5220 -2610 {
lab=#net13}
N 5200 -2630 5220 -2630 {
lab=colon_n[6]}
N 5200 -2650 5220 -2650 {
lab=col_n[6]}
N 5020 -2510 5020 -2500 {
lab=VSS}
N 5020 -2740 5020 -2730 {
lab=VDD}
N 5360 -2510 5370 -2520 {
lab=row_n[16]}
N 5370 -2720 5370 -2520 {
lab=row_n[16]}
N 5360 -2730 5370 -2720 {
lab=row_n[16]}
N 5360 -2510 5360 -2490 {
lab=row_n[16]}
N 5360 -2750 5360 -2730 {
lab=row_n[16]}
N 5240 -2650 5250 -2660 {
lab=col_n[6]}
N 5250 -2660 5450 -2660 {
lab=col_n[6]}
N 5450 -2660 5460 -2650 {
lab=col_n[6]}
N 5240 -2630 5250 -2640 {
lab=colon_n[6]}
N 5250 -2640 5450 -2640 {
lab=colon_n[6]}
N 5450 -2640 5460 -2630 {
lab=colon_n[6]}
N 5240 -2610 5250 -2620 {
lab=#net13}
N 5250 -2620 5450 -2620 {
lab=#net13}
N 5450 -2620 5460 -2610 {
lab=#net13}
N 5240 -2590 5250 -2600 {
lab=#net14}
N 5250 -2600 5450 -2600 {
lab=#net14}
N 5450 -2600 5460 -2590 {
lab=#net14}
N 5300 -2750 5300 -2730 {
lab=vcom}
N 5340 -2750 5340 -2730 {
lab=ctop}
N 5220 -2650 5240 -2650 {
lab=col_n[6]}
N 5220 -2630 5240 -2630 {
lab=colon_n[6]}
N 5220 -2610 5240 -2610 {
lab=#net13}
N 5220 -2590 5240 -2590 {
lab=#net14}
N 5460 -2590 5480 -2590 {
lab=#net14}
N 5460 -2610 5480 -2610 {
lab=#net13}
N 5460 -2630 5480 -2630 {
lab=colon_n[6]}
N 5460 -2650 5480 -2650 {
lab=col_n[6]}
N 5280 -2510 5280 -2500 {
lab=VSS}
N 5280 -2740 5280 -2730 {
lab=VDD}
N 5620 -2510 5630 -2520 {
lab=row_n[17]}
N 5630 -2720 5630 -2520 {
lab=row_n[17]}
N 5620 -2730 5630 -2720 {
lab=row_n[17]}
N 5620 -2510 5620 -2490 {
lab=row_n[17]}
N 5620 -2750 5620 -2730 {
lab=row_n[17]}
N 5500 -2650 5510 -2660 {
lab=col_n[6]}
N 5510 -2660 5710 -2660 {
lab=col_n[6]}
N 5710 -2660 5720 -2650 {
lab=col_n[6]}
N 5500 -2630 5510 -2640 {
lab=colon_n[6]}
N 5510 -2640 5710 -2640 {
lab=colon_n[6]}
N 5710 -2640 5720 -2630 {
lab=colon_n[6]}
N 5500 -2610 5510 -2620 {
lab=#net13}
N 5510 -2620 5710 -2620 {
lab=#net13}
N 5710 -2620 5720 -2610 {
lab=#net13}
N 5500 -2590 5510 -2600 {
lab=#net14}
N 5510 -2600 5710 -2600 {
lab=#net14}
N 5710 -2600 5720 -2590 {
lab=#net14}
N 5560 -2750 5560 -2730 {
lab=vcom}
N 5600 -2750 5600 -2730 {
lab=ctop}
N 5480 -2650 5500 -2650 {
lab=col_n[6]}
N 5480 -2630 5500 -2630 {
lab=colon_n[6]}
N 5480 -2610 5500 -2610 {
lab=#net13}
N 5480 -2590 5500 -2590 {
lab=#net14}
N 5720 -2590 5740 -2590 {
lab=#net14}
N 5720 -2610 5740 -2610 {
lab=#net13}
N 5720 -2630 5740 -2630 {
lab=colon_n[6]}
N 5720 -2650 5740 -2650 {
lab=col_n[6]}
N 5540 -2510 5540 -2500 {
lab=VSS}
N 5540 -2740 5540 -2730 {
lab=VDD}
N 5880 -2510 5890 -2520 {
lab=row_n[18]}
N 5890 -2720 5890 -2520 {
lab=row_n[18]}
N 5880 -2730 5890 -2720 {
lab=row_n[18]}
N 5880 -2510 5880 -2490 {
lab=row_n[18]}
N 5880 -2750 5880 -2730 {
lab=row_n[18]}
N 5760 -2650 5770 -2660 {
lab=col_n[6]}
N 5770 -2660 5970 -2660 {
lab=col_n[6]}
N 5970 -2660 5980 -2650 {
lab=col_n[6]}
N 5760 -2630 5770 -2640 {
lab=colon_n[6]}
N 5770 -2640 5970 -2640 {
lab=colon_n[6]}
N 5970 -2640 5980 -2630 {
lab=colon_n[6]}
N 5760 -2610 5770 -2620 {
lab=#net13}
N 5770 -2620 5970 -2620 {
lab=#net13}
N 5970 -2620 5980 -2610 {
lab=#net13}
N 5760 -2590 5770 -2600 {
lab=#net14}
N 5770 -2600 5970 -2600 {
lab=#net14}
N 5970 -2600 5980 -2590 {
lab=#net14}
N 5820 -2750 5820 -2730 {
lab=vcom}
N 5860 -2750 5860 -2730 {
lab=ctop}
N 5740 -2650 5760 -2650 {
lab=col_n[6]}
N 5740 -2630 5760 -2630 {
lab=colon_n[6]}
N 5740 -2610 5760 -2610 {
lab=#net13}
N 5740 -2590 5760 -2590 {
lab=#net14}
N 5980 -2590 6000 -2590 {
lab=#net14}
N 5980 -2610 6000 -2610 {
lab=#net13}
N 5980 -2630 6000 -2630 {
lab=colon_n[6]}
N 5980 -2650 6000 -2650 {
lab=col_n[6]}
N 5800 -2510 5800 -2500 {
lab=VSS}
N 5800 -2740 5800 -2730 {
lab=VDD}
N 6140 -2510 6150 -2520 {
lab=row_n[19]}
N 6150 -2720 6150 -2520 {
lab=row_n[19]}
N 6140 -2730 6150 -2720 {
lab=row_n[19]}
N 6140 -2510 6140 -2490 {
lab=row_n[19]}
N 6140 -2750 6140 -2730 {
lab=row_n[19]}
N 6020 -2650 6030 -2660 {
lab=col_n[6]}
N 6030 -2660 6230 -2660 {
lab=col_n[6]}
N 6230 -2660 6240 -2650 {
lab=col_n[6]}
N 6020 -2630 6030 -2640 {
lab=colon_n[6]}
N 6030 -2640 6230 -2640 {
lab=colon_n[6]}
N 6230 -2640 6240 -2630 {
lab=colon_n[6]}
N 6020 -2610 6030 -2620 {
lab=#net13}
N 6030 -2620 6230 -2620 {
lab=#net13}
N 6230 -2620 6240 -2610 {
lab=#net13}
N 6020 -2590 6030 -2600 {
lab=#net14}
N 6030 -2600 6230 -2600 {
lab=#net14}
N 6230 -2600 6240 -2590 {
lab=#net14}
N 6080 -2750 6080 -2730 {
lab=vcom}
N 6120 -2750 6120 -2730 {
lab=ctop}
N 6000 -2650 6020 -2650 {
lab=col_n[6]}
N 6000 -2630 6020 -2630 {
lab=colon_n[6]}
N 6000 -2610 6020 -2610 {
lab=#net13}
N 6000 -2590 6020 -2590 {
lab=#net14}
N 6240 -2590 6260 -2590 {
lab=#net14}
N 6240 -2610 6260 -2610 {
lab=#net13}
N 6240 -2630 6260 -2630 {
lab=colon_n[6]}
N 6240 -2650 6260 -2650 {
lab=col_n[6]}
N 6060 -2510 6060 -2500 {
lab=VSS}
N 6060 -2740 6060 -2730 {
lab=VDD}
N 6400 -2510 6410 -2520 {
lab=row_n[20]}
N 6410 -2720 6410 -2520 {
lab=row_n[20]}
N 6400 -2730 6410 -2720 {
lab=row_n[20]}
N 6400 -2510 6400 -2490 {
lab=row_n[20]}
N 6400 -2750 6400 -2730 {
lab=row_n[20]}
N 6280 -2650 6290 -2660 {
lab=col_n[6]}
N 6290 -2660 6490 -2660 {
lab=col_n[6]}
N 6490 -2660 6500 -2650 {
lab=col_n[6]}
N 6280 -2630 6290 -2640 {
lab=colon_n[6]}
N 6290 -2640 6490 -2640 {
lab=colon_n[6]}
N 6490 -2640 6500 -2630 {
lab=colon_n[6]}
N 6280 -2610 6290 -2620 {
lab=#net13}
N 6290 -2620 6490 -2620 {
lab=#net13}
N 6490 -2620 6500 -2610 {
lab=#net13}
N 6280 -2590 6290 -2600 {
lab=#net14}
N 6290 -2600 6490 -2600 {
lab=#net14}
N 6490 -2600 6500 -2590 {
lab=#net14}
N 6340 -2750 6340 -2730 {
lab=vcom}
N 6380 -2750 6380 -2730 {
lab=ctop}
N 6260 -2650 6280 -2650 {
lab=col_n[6]}
N 6260 -2630 6280 -2630 {
lab=colon_n[6]}
N 6260 -2610 6280 -2610 {
lab=#net13}
N 6260 -2590 6280 -2590 {
lab=#net14}
N 6500 -2590 6520 -2590 {
lab=#net14}
N 6500 -2610 6520 -2610 {
lab=#net13}
N 6500 -2630 6520 -2630 {
lab=colon_n[6]}
N 6500 -2650 6520 -2650 {
lab=col_n[6]}
N 6320 -2510 6320 -2500 {
lab=VSS}
N 6320 -2740 6320 -2730 {
lab=VDD}
N 6660 -2510 6670 -2520 {
lab=row_n[21]}
N 6670 -2720 6670 -2520 {
lab=row_n[21]}
N 6660 -2730 6670 -2720 {
lab=row_n[21]}
N 6660 -2510 6660 -2490 {
lab=row_n[21]}
N 6660 -2750 6660 -2730 {
lab=row_n[21]}
N 6540 -2650 6550 -2660 {
lab=col_n[6]}
N 6550 -2660 6750 -2660 {
lab=col_n[6]}
N 6750 -2660 6760 -2650 {
lab=col_n[6]}
N 6540 -2630 6550 -2640 {
lab=colon_n[6]}
N 6550 -2640 6750 -2640 {
lab=colon_n[6]}
N 6750 -2640 6760 -2630 {
lab=colon_n[6]}
N 6540 -2610 6550 -2620 {
lab=#net13}
N 6550 -2620 6750 -2620 {
lab=#net13}
N 6750 -2620 6760 -2610 {
lab=#net13}
N 6540 -2590 6550 -2600 {
lab=#net14}
N 6550 -2600 6750 -2600 {
lab=#net14}
N 6750 -2600 6760 -2590 {
lab=#net14}
N 6600 -2750 6600 -2730 {
lab=vcom}
N 6640 -2750 6640 -2730 {
lab=ctop}
N 6520 -2650 6540 -2650 {
lab=col_n[6]}
N 6520 -2630 6540 -2630 {
lab=colon_n[6]}
N 6520 -2610 6540 -2610 {
lab=#net13}
N 6520 -2590 6540 -2590 {
lab=#net14}
N 6760 -2590 6780 -2590 {
lab=#net14}
N 6760 -2610 6780 -2610 {
lab=#net13}
N 6760 -2630 6780 -2630 {
lab=colon_n[6]}
N 6760 -2650 6780 -2650 {
lab=col_n[6]}
N 6580 -2510 6580 -2500 {
lab=VSS}
N 6580 -2740 6580 -2730 {
lab=VDD}
N 6920 -2510 6930 -2520 {
lab=row_n[22]}
N 6930 -2720 6930 -2520 {
lab=row_n[22]}
N 6920 -2730 6930 -2720 {
lab=row_n[22]}
N 6920 -2510 6920 -2490 {
lab=row_n[22]}
N 6920 -2750 6920 -2730 {
lab=row_n[22]}
N 6800 -2650 6810 -2660 {
lab=col_n[6]}
N 6810 -2660 7010 -2660 {
lab=col_n[6]}
N 7010 -2660 7020 -2650 {
lab=col_n[6]}
N 6800 -2630 6810 -2640 {
lab=colon_n[6]}
N 6810 -2640 7010 -2640 {
lab=colon_n[6]}
N 7010 -2640 7020 -2630 {
lab=colon_n[6]}
N 6800 -2610 6810 -2620 {
lab=#net13}
N 6810 -2620 7010 -2620 {
lab=#net13}
N 7010 -2620 7020 -2610 {
lab=#net13}
N 6800 -2590 6810 -2600 {
lab=#net14}
N 6810 -2600 7010 -2600 {
lab=#net14}
N 7010 -2600 7020 -2590 {
lab=#net14}
N 6860 -2750 6860 -2730 {
lab=vcom}
N 6900 -2750 6900 -2730 {
lab=ctop}
N 6780 -2650 6800 -2650 {
lab=col_n[6]}
N 6780 -2630 6800 -2630 {
lab=colon_n[6]}
N 6780 -2610 6800 -2610 {
lab=#net13}
N 6780 -2590 6800 -2590 {
lab=#net14}
N 7020 -2590 7040 -2590 {
lab=#net14}
N 7020 -2610 7040 -2610 {
lab=#net13}
N 7020 -2630 7040 -2630 {
lab=colon_n[6]}
N 7020 -2650 7040 -2650 {
lab=col_n[6]}
N 6840 -2510 6840 -2500 {
lab=VSS}
N 6840 -2740 6840 -2730 {
lab=VDD}
N 7180 -2510 7190 -2520 {
lab=row_n[23]}
N 7190 -2720 7190 -2520 {
lab=row_n[23]}
N 7180 -2730 7190 -2720 {
lab=row_n[23]}
N 7180 -2510 7180 -2490 {
lab=row_n[23]}
N 7180 -2750 7180 -2730 {
lab=row_n[23]}
N 7060 -2650 7070 -2660 {
lab=col_n[6]}
N 7070 -2660 7270 -2660 {
lab=col_n[6]}
N 7270 -2660 7280 -2650 {
lab=col_n[6]}
N 7060 -2630 7070 -2640 {
lab=colon_n[6]}
N 7070 -2640 7270 -2640 {
lab=colon_n[6]}
N 7270 -2640 7280 -2630 {
lab=colon_n[6]}
N 7060 -2610 7070 -2620 {
lab=#net13}
N 7070 -2620 7270 -2620 {
lab=#net13}
N 7270 -2620 7280 -2610 {
lab=#net13}
N 7060 -2590 7070 -2600 {
lab=#net14}
N 7070 -2600 7270 -2600 {
lab=#net14}
N 7270 -2600 7280 -2590 {
lab=#net14}
N 7120 -2750 7120 -2730 {
lab=vcom}
N 7160 -2750 7160 -2730 {
lab=ctop}
N 7040 -2650 7060 -2650 {
lab=col_n[6]}
N 7040 -2630 7060 -2630 {
lab=colon_n[6]}
N 7040 -2610 7060 -2610 {
lab=#net13}
N 7040 -2590 7060 -2590 {
lab=#net14}
N 7280 -2590 7300 -2590 {
lab=#net14}
N 7280 -2610 7300 -2610 {
lab=#net13}
N 7280 -2630 7300 -2630 {
lab=colon_n[6]}
N 7280 -2650 7300 -2650 {
lab=col_n[6]}
N 7100 -2510 7100 -2500 {
lab=VSS}
N 7100 -2740 7100 -2730 {
lab=VDD}
N 7440 -2510 7450 -2520 {
lab=row_n[24]}
N 7450 -2720 7450 -2520 {
lab=row_n[24]}
N 7440 -2730 7450 -2720 {
lab=row_n[24]}
N 7440 -2510 7440 -2490 {
lab=row_n[24]}
N 7440 -2750 7440 -2730 {
lab=row_n[24]}
N 7320 -2650 7330 -2660 {
lab=col_n[6]}
N 7330 -2660 7530 -2660 {
lab=col_n[6]}
N 7530 -2660 7540 -2650 {
lab=col_n[6]}
N 7320 -2630 7330 -2640 {
lab=colon_n[6]}
N 7330 -2640 7530 -2640 {
lab=colon_n[6]}
N 7530 -2640 7540 -2630 {
lab=colon_n[6]}
N 7320 -2610 7330 -2620 {
lab=#net13}
N 7330 -2620 7530 -2620 {
lab=#net13}
N 7530 -2620 7540 -2610 {
lab=#net13}
N 7320 -2590 7330 -2600 {
lab=#net14}
N 7330 -2600 7530 -2600 {
lab=#net14}
N 7530 -2600 7540 -2590 {
lab=#net14}
N 7380 -2750 7380 -2730 {
lab=vcom}
N 7420 -2750 7420 -2730 {
lab=ctop}
N 7300 -2650 7320 -2650 {
lab=col_n[6]}
N 7300 -2630 7320 -2630 {
lab=colon_n[6]}
N 7300 -2610 7320 -2610 {
lab=#net13}
N 7300 -2590 7320 -2590 {
lab=#net14}
N 7540 -2590 7560 -2590 {
lab=#net14}
N 7540 -2610 7560 -2610 {
lab=#net13}
N 7540 -2630 7560 -2630 {
lab=colon_n[6]}
N 7540 -2650 7560 -2650 {
lab=col_n[6]}
N 7360 -2510 7360 -2500 {
lab=VSS}
N 7360 -2740 7360 -2730 {
lab=VDD}
N 7700 -2510 7710 -2520 {
lab=row_n[25]}
N 7710 -2720 7710 -2520 {
lab=row_n[25]}
N 7700 -2730 7710 -2720 {
lab=row_n[25]}
N 7700 -2510 7700 -2490 {
lab=row_n[25]}
N 7700 -2750 7700 -2730 {
lab=row_n[25]}
N 7580 -2650 7590 -2660 {
lab=col_n[6]}
N 7590 -2660 7790 -2660 {
lab=col_n[6]}
N 7790 -2660 7800 -2650 {
lab=col_n[6]}
N 7580 -2630 7590 -2640 {
lab=colon_n[6]}
N 7590 -2640 7790 -2640 {
lab=colon_n[6]}
N 7790 -2640 7800 -2630 {
lab=colon_n[6]}
N 7580 -2610 7590 -2620 {
lab=#net13}
N 7590 -2620 7790 -2620 {
lab=#net13}
N 7790 -2620 7800 -2610 {
lab=#net13}
N 7580 -2590 7590 -2600 {
lab=#net14}
N 7590 -2600 7790 -2600 {
lab=#net14}
N 7790 -2600 7800 -2590 {
lab=#net14}
N 7640 -2750 7640 -2730 {
lab=vcom}
N 7680 -2750 7680 -2730 {
lab=ctop}
N 7560 -2650 7580 -2650 {
lab=col_n[6]}
N 7560 -2630 7580 -2630 {
lab=colon_n[6]}
N 7560 -2610 7580 -2610 {
lab=#net13}
N 7560 -2590 7580 -2590 {
lab=#net14}
N 7800 -2590 7820 -2590 {
lab=#net14}
N 7800 -2610 7820 -2610 {
lab=#net13}
N 7800 -2630 7820 -2630 {
lab=colon_n[6]}
N 7800 -2650 7820 -2650 {
lab=col_n[6]}
N 7620 -2510 7620 -2500 {
lab=VSS}
N 7620 -2740 7620 -2730 {
lab=VDD}
N 7960 -2510 7970 -2520 {
lab=row_n[26]}
N 7970 -2720 7970 -2520 {
lab=row_n[26]}
N 7960 -2730 7970 -2720 {
lab=row_n[26]}
N 7960 -2510 7960 -2490 {
lab=row_n[26]}
N 7960 -2750 7960 -2730 {
lab=row_n[26]}
N 7840 -2650 7850 -2660 {
lab=col_n[6]}
N 7850 -2660 8050 -2660 {
lab=col_n[6]}
N 8050 -2660 8060 -2650 {
lab=col_n[6]}
N 7840 -2630 7850 -2640 {
lab=colon_n[6]}
N 7850 -2640 8050 -2640 {
lab=colon_n[6]}
N 8050 -2640 8060 -2630 {
lab=colon_n[6]}
N 7840 -2610 7850 -2620 {
lab=#net13}
N 7850 -2620 8050 -2620 {
lab=#net13}
N 8050 -2620 8060 -2610 {
lab=#net13}
N 7840 -2590 7850 -2600 {
lab=#net14}
N 7850 -2600 8050 -2600 {
lab=#net14}
N 8050 -2600 8060 -2590 {
lab=#net14}
N 7900 -2750 7900 -2730 {
lab=vcom}
N 7940 -2750 7940 -2730 {
lab=ctop}
N 7820 -2650 7840 -2650 {
lab=col_n[6]}
N 7820 -2630 7840 -2630 {
lab=colon_n[6]}
N 7820 -2610 7840 -2610 {
lab=#net13}
N 7820 -2590 7840 -2590 {
lab=#net14}
N 8060 -2590 8080 -2590 {
lab=#net14}
N 8060 -2610 8080 -2610 {
lab=#net13}
N 8060 -2630 8080 -2630 {
lab=colon_n[6]}
N 8060 -2650 8080 -2650 {
lab=col_n[6]}
N 7880 -2510 7880 -2500 {
lab=VSS}
N 7880 -2740 7880 -2730 {
lab=VDD}
N 8220 -2510 8230 -2520 {
lab=row_n[27]}
N 8230 -2720 8230 -2520 {
lab=row_n[27]}
N 8220 -2730 8230 -2720 {
lab=row_n[27]}
N 8220 -2510 8220 -2490 {
lab=row_n[27]}
N 8220 -2750 8220 -2730 {
lab=row_n[27]}
N 8100 -2650 8110 -2660 {
lab=col_n[6]}
N 8110 -2660 8310 -2660 {
lab=col_n[6]}
N 8310 -2660 8320 -2650 {
lab=col_n[6]}
N 8100 -2630 8110 -2640 {
lab=colon_n[6]}
N 8110 -2640 8310 -2640 {
lab=colon_n[6]}
N 8310 -2640 8320 -2630 {
lab=colon_n[6]}
N 8100 -2610 8110 -2620 {
lab=#net13}
N 8110 -2620 8310 -2620 {
lab=#net13}
N 8310 -2620 8320 -2610 {
lab=#net13}
N 8100 -2590 8110 -2600 {
lab=#net14}
N 8110 -2600 8310 -2600 {
lab=#net14}
N 8310 -2600 8320 -2590 {
lab=#net14}
N 8160 -2750 8160 -2730 {
lab=vcom}
N 8200 -2750 8200 -2730 {
lab=ctop}
N 8080 -2650 8100 -2650 {
lab=col_n[6]}
N 8080 -2630 8100 -2630 {
lab=colon_n[6]}
N 8080 -2610 8100 -2610 {
lab=#net13}
N 8080 -2590 8100 -2590 {
lab=#net14}
N 8320 -2590 8340 -2590 {
lab=#net14}
N 8320 -2610 8340 -2610 {
lab=#net13}
N 8320 -2630 8340 -2630 {
lab=colon_n[6]}
N 8320 -2650 8340 -2650 {
lab=col_n[6]}
N 8140 -2510 8140 -2500 {
lab=VSS}
N 8140 -2740 8140 -2730 {
lab=VDD}
N 8480 -2510 8490 -2520 {
lab=row_n[28]}
N 8490 -2720 8490 -2520 {
lab=row_n[28]}
N 8480 -2730 8490 -2720 {
lab=row_n[28]}
N 8480 -2510 8480 -2490 {
lab=row_n[28]}
N 8480 -2750 8480 -2730 {
lab=row_n[28]}
N 8360 -2650 8370 -2660 {
lab=col_n[6]}
N 8370 -2660 8570 -2660 {
lab=col_n[6]}
N 8570 -2660 8580 -2650 {
lab=col_n[6]}
N 8360 -2630 8370 -2640 {
lab=colon_n[6]}
N 8370 -2640 8570 -2640 {
lab=colon_n[6]}
N 8570 -2640 8580 -2630 {
lab=colon_n[6]}
N 8360 -2610 8370 -2620 {
lab=#net13}
N 8370 -2620 8570 -2620 {
lab=#net13}
N 8570 -2620 8580 -2610 {
lab=#net13}
N 8360 -2590 8370 -2600 {
lab=#net14}
N 8370 -2600 8570 -2600 {
lab=#net14}
N 8570 -2600 8580 -2590 {
lab=#net14}
N 8420 -2750 8420 -2730 {
lab=vcom}
N 8460 -2750 8460 -2730 {
lab=ctop}
N 8340 -2650 8360 -2650 {
lab=col_n[6]}
N 8340 -2630 8360 -2630 {
lab=colon_n[6]}
N 8340 -2610 8360 -2610 {
lab=#net13}
N 8340 -2590 8360 -2590 {
lab=#net14}
N 8580 -2590 8600 -2590 {
lab=#net14}
N 8580 -2610 8600 -2610 {
lab=#net13}
N 8580 -2630 8600 -2630 {
lab=colon_n[6]}
N 8580 -2650 8600 -2650 {
lab=col_n[6]}
N 8400 -2510 8400 -2500 {
lab=VSS}
N 8400 -2740 8400 -2730 {
lab=VDD}
N 8740 -2510 8750 -2520 {
lab=row_n[29]}
N 8750 -2720 8750 -2520 {
lab=row_n[29]}
N 8740 -2730 8750 -2720 {
lab=row_n[29]}
N 8740 -2510 8740 -2490 {
lab=row_n[29]}
N 8740 -2750 8740 -2730 {
lab=row_n[29]}
N 8620 -2650 8630 -2660 {
lab=col_n[6]}
N 8630 -2660 8830 -2660 {
lab=col_n[6]}
N 8830 -2660 8840 -2650 {
lab=col_n[6]}
N 8620 -2630 8630 -2640 {
lab=colon_n[6]}
N 8630 -2640 8830 -2640 {
lab=colon_n[6]}
N 8830 -2640 8840 -2630 {
lab=colon_n[6]}
N 8620 -2610 8630 -2620 {
lab=#net13}
N 8630 -2620 8830 -2620 {
lab=#net13}
N 8830 -2620 8840 -2610 {
lab=#net13}
N 8620 -2590 8630 -2600 {
lab=#net14}
N 8630 -2600 8830 -2600 {
lab=#net14}
N 8830 -2600 8840 -2590 {
lab=#net14}
N 8680 -2750 8680 -2730 {
lab=vcom}
N 8720 -2750 8720 -2730 {
lab=ctop}
N 8600 -2650 8620 -2650 {
lab=col_n[6]}
N 8600 -2630 8620 -2630 {
lab=colon_n[6]}
N 8600 -2610 8620 -2610 {
lab=#net13}
N 8600 -2590 8620 -2590 {
lab=#net14}
N 8840 -2590 8860 -2590 {
lab=#net14}
N 8840 -2610 8860 -2610 {
lab=#net13}
N 8840 -2630 8860 -2630 {
lab=colon_n[6]}
N 8840 -2650 8860 -2650 {
lab=col_n[6]}
N 8660 -2510 8660 -2500 {
lab=VSS}
N 8660 -2740 8660 -2730 {
lab=VDD}
N 9000 -2510 9010 -2520 {
lab=row_n[30]}
N 9010 -2720 9010 -2520 {
lab=row_n[30]}
N 9000 -2730 9010 -2720 {
lab=row_n[30]}
N 9000 -2510 9000 -2490 {
lab=row_n[30]}
N 9000 -2750 9000 -2730 {
lab=row_n[30]}
N 8880 -2650 8890 -2660 {
lab=col_n[6]}
N 8890 -2660 9090 -2660 {
lab=col_n[6]}
N 9090 -2660 9100 -2650 {
lab=col_n[6]}
N 8880 -2630 8890 -2640 {
lab=colon_n[6]}
N 8890 -2640 9090 -2640 {
lab=colon_n[6]}
N 9090 -2640 9100 -2630 {
lab=colon_n[6]}
N 8880 -2610 8890 -2620 {
lab=#net13}
N 8890 -2620 9090 -2620 {
lab=#net13}
N 9090 -2620 9100 -2610 {
lab=#net13}
N 8880 -2590 8890 -2600 {
lab=#net14}
N 8890 -2600 9090 -2600 {
lab=#net14}
N 9090 -2600 9100 -2590 {
lab=#net14}
N 8940 -2750 8940 -2730 {
lab=vcom}
N 8980 -2750 8980 -2730 {
lab=ctop}
N 8860 -2650 8880 -2650 {
lab=col_n[6]}
N 8860 -2630 8880 -2630 {
lab=colon_n[6]}
N 8860 -2610 8880 -2610 {
lab=#net13}
N 8860 -2590 8880 -2590 {
lab=#net14}
N 9100 -2590 9120 -2590 {
lab=#net14}
N 9100 -2610 9120 -2610 {
lab=#net13}
N 9100 -2630 9120 -2630 {
lab=colon_n[6]}
N 9100 -2650 9120 -2650 {
lab=col_n[6]}
N 8920 -2510 8920 -2500 {
lab=VSS}
N 8920 -2740 8920 -2730 {
lab=VDD}
N 9260 -2510 9270 -2520 {
lab=row_n[31]}
N 9270 -2720 9270 -2520 {
lab=row_n[31]}
N 9260 -2730 9270 -2720 {
lab=row_n[31]}
N 9260 -2510 9260 -2490 {
lab=row_n[31]}
N 9260 -2750 9260 -2730 {
lab=row_n[31]}
N 9140 -2650 9150 -2660 {
lab=col_n[6]}
N 9150 -2660 9350 -2660 {
lab=col_n[6]}
N 9350 -2660 9360 -2650 {
lab=col_n[6]}
N 9140 -2630 9150 -2640 {
lab=colon_n[6]}
N 9150 -2640 9350 -2640 {
lab=colon_n[6]}
N 9350 -2640 9360 -2630 {
lab=colon_n[6]}
N 9140 -2610 9150 -2620 {
lab=#net13}
N 9150 -2620 9350 -2620 {
lab=#net13}
N 9350 -2620 9360 -2610 {
lab=#net13}
N 9140 -2590 9150 -2600 {
lab=#net14}
N 9150 -2600 9350 -2600 {
lab=#net14}
N 9350 -2600 9360 -2590 {
lab=#net14}
N 9200 -2750 9200 -2730 {
lab=vcom}
N 9240 -2750 9240 -2730 {
lab=ctop}
N 9120 -2650 9140 -2650 {
lab=col_n[6]}
N 9120 -2630 9140 -2630 {
lab=colon_n[6]}
N 9120 -2610 9140 -2610 {
lab=#net13}
N 9120 -2590 9140 -2590 {
lab=#net14}
N 9360 -2590 9380 -2590 {
lab=#net14}
N 9360 -2610 9380 -2610 {
lab=#net13}
N 9360 -2630 9380 -2630 {
lab=colon_n[6]}
N 9360 -2650 9380 -2650 {
lab=col_n[6]}
N 9180 -2510 9180 -2500 {
lab=VSS}
N 9180 -2740 9180 -2730 {
lab=VDD}
N 1200 -2770 1210 -2780 {
lab=row_n[0]}
N 1210 -2980 1210 -2780 {
lab=row_n[0]}
N 1200 -2990 1210 -2980 {
lab=row_n[0]}
N 1200 -2770 1200 -2750 {
lab=row_n[0]}
N 1200 -3010 1200 -2990 {
lab=row_n[0]}
N 1080 -2910 1090 -2920 {
lab=col_n[7]}
N 1090 -2920 1290 -2920 {
lab=col_n[7]}
N 1290 -2920 1300 -2910 {
lab=col_n[7]}
N 1080 -2890 1090 -2900 {
lab=colon_n[7]}
N 1090 -2900 1290 -2900 {
lab=colon_n[7]}
N 1290 -2900 1300 -2890 {
lab=colon_n[7]}
N 1080 -2870 1090 -2880 {
lab=#net15}
N 1090 -2880 1290 -2880 {
lab=#net15}
N 1290 -2880 1300 -2870 {
lab=#net15}
N 1080 -2850 1090 -2860 {
lab=#net16}
N 1090 -2860 1290 -2860 {
lab=#net16}
N 1290 -2860 1300 -2850 {
lab=#net16}
N 1140 -3010 1140 -2990 {
lab=vcom}
N 1180 -3010 1180 -2990 {
lab=ctop}
N 1060 -2910 1080 -2910 {
lab=col_n[7]}
N 1060 -2890 1080 -2890 {
lab=colon_n[7]}
N 1060 -2870 1080 -2870 {
lab=#net15}
N 1060 -2850 1080 -2850 {
lab=#net16}
N 1300 -2850 1320 -2850 {
lab=#net16}
N 1300 -2870 1320 -2870 {
lab=#net15}
N 1300 -2890 1320 -2890 {
lab=colon_n[7]}
N 1300 -2910 1320 -2910 {
lab=col_n[7]}
N 1120 -2770 1120 -2760 {
lab=VSS}
N 1120 -3000 1120 -2990 {
lab=VDD}
N 1460 -2770 1470 -2780 {
lab=row_n[1]}
N 1470 -2980 1470 -2780 {
lab=row_n[1]}
N 1460 -2990 1470 -2980 {
lab=row_n[1]}
N 1460 -2770 1460 -2750 {
lab=row_n[1]}
N 1460 -3010 1460 -2990 {
lab=row_n[1]}
N 1340 -2910 1350 -2920 {
lab=col_n[7]}
N 1350 -2920 1550 -2920 {
lab=col_n[7]}
N 1550 -2920 1560 -2910 {
lab=col_n[7]}
N 1340 -2890 1350 -2900 {
lab=colon_n[7]}
N 1350 -2900 1550 -2900 {
lab=colon_n[7]}
N 1550 -2900 1560 -2890 {
lab=colon_n[7]}
N 1340 -2870 1350 -2880 {
lab=#net15}
N 1350 -2880 1550 -2880 {
lab=#net15}
N 1550 -2880 1560 -2870 {
lab=#net15}
N 1340 -2850 1350 -2860 {
lab=#net16}
N 1350 -2860 1550 -2860 {
lab=#net16}
N 1550 -2860 1560 -2850 {
lab=#net16}
N 1400 -3010 1400 -2990 {
lab=vcom}
N 1440 -3010 1440 -2990 {
lab=ctop}
N 1320 -2910 1340 -2910 {
lab=col_n[7]}
N 1320 -2890 1340 -2890 {
lab=colon_n[7]}
N 1320 -2870 1340 -2870 {
lab=#net15}
N 1320 -2850 1340 -2850 {
lab=#net16}
N 1560 -2850 1580 -2850 {
lab=#net16}
N 1560 -2870 1580 -2870 {
lab=#net15}
N 1560 -2890 1580 -2890 {
lab=colon_n[7]}
N 1560 -2910 1580 -2910 {
lab=col_n[7]}
N 1380 -2770 1380 -2760 {
lab=VSS}
N 1380 -3000 1380 -2990 {
lab=VDD}
N 1720 -2770 1730 -2780 {
lab=row_n[2]}
N 1730 -2980 1730 -2780 {
lab=row_n[2]}
N 1720 -2990 1730 -2980 {
lab=row_n[2]}
N 1720 -2770 1720 -2750 {
lab=row_n[2]}
N 1720 -3010 1720 -2990 {
lab=row_n[2]}
N 1600 -2910 1610 -2920 {
lab=col_n[7]}
N 1610 -2920 1810 -2920 {
lab=col_n[7]}
N 1810 -2920 1820 -2910 {
lab=col_n[7]}
N 1600 -2890 1610 -2900 {
lab=colon_n[7]}
N 1610 -2900 1810 -2900 {
lab=colon_n[7]}
N 1810 -2900 1820 -2890 {
lab=colon_n[7]}
N 1600 -2870 1610 -2880 {
lab=#net15}
N 1610 -2880 1810 -2880 {
lab=#net15}
N 1810 -2880 1820 -2870 {
lab=#net15}
N 1600 -2850 1610 -2860 {
lab=#net16}
N 1610 -2860 1810 -2860 {
lab=#net16}
N 1810 -2860 1820 -2850 {
lab=#net16}
N 1660 -3010 1660 -2990 {
lab=vcom}
N 1700 -3010 1700 -2990 {
lab=ctop}
N 1580 -2910 1600 -2910 {
lab=col_n[7]}
N 1580 -2890 1600 -2890 {
lab=colon_n[7]}
N 1580 -2870 1600 -2870 {
lab=#net15}
N 1580 -2850 1600 -2850 {
lab=#net16}
N 1820 -2850 1840 -2850 {
lab=#net16}
N 1820 -2870 1840 -2870 {
lab=#net15}
N 1820 -2890 1840 -2890 {
lab=colon_n[7]}
N 1820 -2910 1840 -2910 {
lab=col_n[7]}
N 1640 -2770 1640 -2760 {
lab=VSS}
N 1640 -3000 1640 -2990 {
lab=VDD}
N 1980 -2770 1990 -2780 {
lab=row_n[3]}
N 1990 -2980 1990 -2780 {
lab=row_n[3]}
N 1980 -2990 1990 -2980 {
lab=row_n[3]}
N 1980 -2770 1980 -2750 {
lab=row_n[3]}
N 1980 -3010 1980 -2990 {
lab=row_n[3]}
N 1860 -2910 1870 -2920 {
lab=col_n[7]}
N 1870 -2920 2070 -2920 {
lab=col_n[7]}
N 2070 -2920 2080 -2910 {
lab=col_n[7]}
N 1860 -2890 1870 -2900 {
lab=colon_n[7]}
N 1870 -2900 2070 -2900 {
lab=colon_n[7]}
N 2070 -2900 2080 -2890 {
lab=colon_n[7]}
N 1860 -2870 1870 -2880 {
lab=#net15}
N 1870 -2880 2070 -2880 {
lab=#net15}
N 2070 -2880 2080 -2870 {
lab=#net15}
N 1860 -2850 1870 -2860 {
lab=#net16}
N 1870 -2860 2070 -2860 {
lab=#net16}
N 2070 -2860 2080 -2850 {
lab=#net16}
N 1920 -3010 1920 -2990 {
lab=vcom}
N 1960 -3010 1960 -2990 {
lab=ctop}
N 1840 -2910 1860 -2910 {
lab=col_n[7]}
N 1840 -2890 1860 -2890 {
lab=colon_n[7]}
N 1840 -2870 1860 -2870 {
lab=#net15}
N 1840 -2850 1860 -2850 {
lab=#net16}
N 2080 -2850 2100 -2850 {
lab=#net16}
N 2080 -2870 2100 -2870 {
lab=#net15}
N 2080 -2890 2100 -2890 {
lab=colon_n[7]}
N 2080 -2910 2100 -2910 {
lab=col_n[7]}
N 1900 -2770 1900 -2760 {
lab=VSS}
N 1900 -3000 1900 -2990 {
lab=VDD}
N 2240 -2770 2250 -2780 {
lab=row_n[4]}
N 2250 -2980 2250 -2780 {
lab=row_n[4]}
N 2240 -2990 2250 -2980 {
lab=row_n[4]}
N 2240 -2770 2240 -2750 {
lab=row_n[4]}
N 2240 -3010 2240 -2990 {
lab=row_n[4]}
N 2120 -2910 2130 -2920 {
lab=col_n[7]}
N 2130 -2920 2330 -2920 {
lab=col_n[7]}
N 2330 -2920 2340 -2910 {
lab=col_n[7]}
N 2120 -2890 2130 -2900 {
lab=colon_n[7]}
N 2130 -2900 2330 -2900 {
lab=colon_n[7]}
N 2330 -2900 2340 -2890 {
lab=colon_n[7]}
N 2120 -2870 2130 -2880 {
lab=#net15}
N 2130 -2880 2330 -2880 {
lab=#net15}
N 2330 -2880 2340 -2870 {
lab=#net15}
N 2120 -2850 2130 -2860 {
lab=#net16}
N 2130 -2860 2330 -2860 {
lab=#net16}
N 2330 -2860 2340 -2850 {
lab=#net16}
N 2180 -3010 2180 -2990 {
lab=vcom}
N 2220 -3010 2220 -2990 {
lab=ctop}
N 2100 -2910 2120 -2910 {
lab=col_n[7]}
N 2100 -2890 2120 -2890 {
lab=colon_n[7]}
N 2100 -2870 2120 -2870 {
lab=#net15}
N 2100 -2850 2120 -2850 {
lab=#net16}
N 2340 -2850 2360 -2850 {
lab=#net16}
N 2340 -2870 2360 -2870 {
lab=#net15}
N 2340 -2890 2360 -2890 {
lab=colon_n[7]}
N 2340 -2910 2360 -2910 {
lab=col_n[7]}
N 2160 -2770 2160 -2760 {
lab=VSS}
N 2160 -3000 2160 -2990 {
lab=VDD}
N 2500 -2770 2510 -2780 {
lab=row_n[5]}
N 2510 -2980 2510 -2780 {
lab=row_n[5]}
N 2500 -2990 2510 -2980 {
lab=row_n[5]}
N 2500 -2770 2500 -2750 {
lab=row_n[5]}
N 2500 -3010 2500 -2990 {
lab=row_n[5]}
N 2380 -2910 2390 -2920 {
lab=col_n[7]}
N 2390 -2920 2590 -2920 {
lab=col_n[7]}
N 2590 -2920 2600 -2910 {
lab=col_n[7]}
N 2380 -2890 2390 -2900 {
lab=colon_n[7]}
N 2390 -2900 2590 -2900 {
lab=colon_n[7]}
N 2590 -2900 2600 -2890 {
lab=colon_n[7]}
N 2380 -2870 2390 -2880 {
lab=#net15}
N 2390 -2880 2590 -2880 {
lab=#net15}
N 2590 -2880 2600 -2870 {
lab=#net15}
N 2380 -2850 2390 -2860 {
lab=#net16}
N 2390 -2860 2590 -2860 {
lab=#net16}
N 2590 -2860 2600 -2850 {
lab=#net16}
N 2440 -3010 2440 -2990 {
lab=vcom}
N 2480 -3010 2480 -2990 {
lab=ctop}
N 2360 -2910 2380 -2910 {
lab=col_n[7]}
N 2360 -2890 2380 -2890 {
lab=colon_n[7]}
N 2360 -2870 2380 -2870 {
lab=#net15}
N 2360 -2850 2380 -2850 {
lab=#net16}
N 2600 -2850 2620 -2850 {
lab=#net16}
N 2600 -2870 2620 -2870 {
lab=#net15}
N 2600 -2890 2620 -2890 {
lab=colon_n[7]}
N 2600 -2910 2620 -2910 {
lab=col_n[7]}
N 2420 -2770 2420 -2760 {
lab=VSS}
N 2420 -3000 2420 -2990 {
lab=VDD}
N 2760 -2770 2770 -2780 {
lab=row_n[6]}
N 2770 -2980 2770 -2780 {
lab=row_n[6]}
N 2760 -2990 2770 -2980 {
lab=row_n[6]}
N 2760 -2770 2760 -2750 {
lab=row_n[6]}
N 2760 -3010 2760 -2990 {
lab=row_n[6]}
N 2640 -2910 2650 -2920 {
lab=col_n[7]}
N 2650 -2920 2850 -2920 {
lab=col_n[7]}
N 2850 -2920 2860 -2910 {
lab=col_n[7]}
N 2640 -2890 2650 -2900 {
lab=colon_n[7]}
N 2650 -2900 2850 -2900 {
lab=colon_n[7]}
N 2850 -2900 2860 -2890 {
lab=colon_n[7]}
N 2640 -2870 2650 -2880 {
lab=#net15}
N 2650 -2880 2850 -2880 {
lab=#net15}
N 2850 -2880 2860 -2870 {
lab=#net15}
N 2640 -2850 2650 -2860 {
lab=#net16}
N 2650 -2860 2850 -2860 {
lab=#net16}
N 2850 -2860 2860 -2850 {
lab=#net16}
N 2700 -3010 2700 -2990 {
lab=vcom}
N 2740 -3010 2740 -2990 {
lab=ctop}
N 2620 -2910 2640 -2910 {
lab=col_n[7]}
N 2620 -2890 2640 -2890 {
lab=colon_n[7]}
N 2620 -2870 2640 -2870 {
lab=#net15}
N 2620 -2850 2640 -2850 {
lab=#net16}
N 2860 -2850 2880 -2850 {
lab=#net16}
N 2860 -2870 2880 -2870 {
lab=#net15}
N 2860 -2890 2880 -2890 {
lab=colon_n[7]}
N 2860 -2910 2880 -2910 {
lab=col_n[7]}
N 2680 -2770 2680 -2760 {
lab=VSS}
N 2680 -3000 2680 -2990 {
lab=VDD}
N 3020 -2770 3030 -2780 {
lab=row_n[7]}
N 3030 -2980 3030 -2780 {
lab=row_n[7]}
N 3020 -2990 3030 -2980 {
lab=row_n[7]}
N 3020 -2770 3020 -2750 {
lab=row_n[7]}
N 3020 -3010 3020 -2990 {
lab=row_n[7]}
N 2900 -2910 2910 -2920 {
lab=col_n[7]}
N 2910 -2920 3110 -2920 {
lab=col_n[7]}
N 3110 -2920 3120 -2910 {
lab=col_n[7]}
N 2900 -2890 2910 -2900 {
lab=colon_n[7]}
N 2910 -2900 3110 -2900 {
lab=colon_n[7]}
N 3110 -2900 3120 -2890 {
lab=colon_n[7]}
N 2900 -2870 2910 -2880 {
lab=#net15}
N 2910 -2880 3110 -2880 {
lab=#net15}
N 3110 -2880 3120 -2870 {
lab=#net15}
N 2900 -2850 2910 -2860 {
lab=#net16}
N 2910 -2860 3110 -2860 {
lab=#net16}
N 3110 -2860 3120 -2850 {
lab=#net16}
N 2960 -3010 2960 -2990 {
lab=vcom}
N 3000 -3010 3000 -2990 {
lab=ctop}
N 2880 -2910 2900 -2910 {
lab=col_n[7]}
N 2880 -2890 2900 -2890 {
lab=colon_n[7]}
N 2880 -2870 2900 -2870 {
lab=#net15}
N 2880 -2850 2900 -2850 {
lab=#net16}
N 3120 -2850 3140 -2850 {
lab=#net16}
N 3120 -2870 3140 -2870 {
lab=#net15}
N 3120 -2890 3140 -2890 {
lab=colon_n[7]}
N 3120 -2910 3140 -2910 {
lab=col_n[7]}
N 2940 -2770 2940 -2760 {
lab=VSS}
N 2940 -3000 2940 -2990 {
lab=VDD}
N 3280 -2770 3290 -2780 {
lab=row_n[8]}
N 3290 -2980 3290 -2780 {
lab=row_n[8]}
N 3280 -2990 3290 -2980 {
lab=row_n[8]}
N 3280 -2770 3280 -2750 {
lab=row_n[8]}
N 3280 -3010 3280 -2990 {
lab=row_n[8]}
N 3160 -2910 3170 -2920 {
lab=col_n[7]}
N 3170 -2920 3370 -2920 {
lab=col_n[7]}
N 3370 -2920 3380 -2910 {
lab=col_n[7]}
N 3160 -2890 3170 -2900 {
lab=colon_n[7]}
N 3170 -2900 3370 -2900 {
lab=colon_n[7]}
N 3370 -2900 3380 -2890 {
lab=colon_n[7]}
N 3160 -2870 3170 -2880 {
lab=#net15}
N 3170 -2880 3370 -2880 {
lab=#net15}
N 3370 -2880 3380 -2870 {
lab=#net15}
N 3160 -2850 3170 -2860 {
lab=#net16}
N 3170 -2860 3370 -2860 {
lab=#net16}
N 3370 -2860 3380 -2850 {
lab=#net16}
N 3220 -3010 3220 -2990 {
lab=vcom}
N 3260 -3010 3260 -2990 {
lab=ctop}
N 3140 -2910 3160 -2910 {
lab=col_n[7]}
N 3140 -2890 3160 -2890 {
lab=colon_n[7]}
N 3140 -2870 3160 -2870 {
lab=#net15}
N 3140 -2850 3160 -2850 {
lab=#net16}
N 3380 -2850 3400 -2850 {
lab=#net16}
N 3380 -2870 3400 -2870 {
lab=#net15}
N 3380 -2890 3400 -2890 {
lab=colon_n[7]}
N 3380 -2910 3400 -2910 {
lab=col_n[7]}
N 3200 -2770 3200 -2760 {
lab=VSS}
N 3200 -3000 3200 -2990 {
lab=VDD}
N 3540 -2770 3550 -2780 {
lab=row_n[9]}
N 3550 -2980 3550 -2780 {
lab=row_n[9]}
N 3540 -2990 3550 -2980 {
lab=row_n[9]}
N 3540 -2770 3540 -2750 {
lab=row_n[9]}
N 3540 -3010 3540 -2990 {
lab=row_n[9]}
N 3420 -2910 3430 -2920 {
lab=col_n[7]}
N 3430 -2920 3630 -2920 {
lab=col_n[7]}
N 3630 -2920 3640 -2910 {
lab=col_n[7]}
N 3420 -2890 3430 -2900 {
lab=colon_n[7]}
N 3430 -2900 3630 -2900 {
lab=colon_n[7]}
N 3630 -2900 3640 -2890 {
lab=colon_n[7]}
N 3420 -2870 3430 -2880 {
lab=#net15}
N 3430 -2880 3630 -2880 {
lab=#net15}
N 3630 -2880 3640 -2870 {
lab=#net15}
N 3420 -2850 3430 -2860 {
lab=#net16}
N 3430 -2860 3630 -2860 {
lab=#net16}
N 3630 -2860 3640 -2850 {
lab=#net16}
N 3480 -3010 3480 -2990 {
lab=vcom}
N 3520 -3010 3520 -2990 {
lab=ctop}
N 3400 -2910 3420 -2910 {
lab=col_n[7]}
N 3400 -2890 3420 -2890 {
lab=colon_n[7]}
N 3400 -2870 3420 -2870 {
lab=#net15}
N 3400 -2850 3420 -2850 {
lab=#net16}
N 3640 -2850 3660 -2850 {
lab=#net16}
N 3640 -2870 3660 -2870 {
lab=#net15}
N 3640 -2890 3660 -2890 {
lab=colon_n[7]}
N 3640 -2910 3660 -2910 {
lab=col_n[7]}
N 3460 -2770 3460 -2760 {
lab=VSS}
N 3460 -3000 3460 -2990 {
lab=VDD}
N 3800 -2770 3810 -2780 {
lab=row_n[10]}
N 3810 -2980 3810 -2780 {
lab=row_n[10]}
N 3800 -2990 3810 -2980 {
lab=row_n[10]}
N 3800 -2770 3800 -2750 {
lab=row_n[10]}
N 3800 -3010 3800 -2990 {
lab=row_n[10]}
N 3680 -2910 3690 -2920 {
lab=col_n[7]}
N 3690 -2920 3890 -2920 {
lab=col_n[7]}
N 3890 -2920 3900 -2910 {
lab=col_n[7]}
N 3680 -2890 3690 -2900 {
lab=colon_n[7]}
N 3690 -2900 3890 -2900 {
lab=colon_n[7]}
N 3890 -2900 3900 -2890 {
lab=colon_n[7]}
N 3680 -2870 3690 -2880 {
lab=#net15}
N 3690 -2880 3890 -2880 {
lab=#net15}
N 3890 -2880 3900 -2870 {
lab=#net15}
N 3680 -2850 3690 -2860 {
lab=#net16}
N 3690 -2860 3890 -2860 {
lab=#net16}
N 3890 -2860 3900 -2850 {
lab=#net16}
N 3740 -3010 3740 -2990 {
lab=vcom}
N 3780 -3010 3780 -2990 {
lab=ctop}
N 3660 -2910 3680 -2910 {
lab=col_n[7]}
N 3660 -2890 3680 -2890 {
lab=colon_n[7]}
N 3660 -2870 3680 -2870 {
lab=#net15}
N 3660 -2850 3680 -2850 {
lab=#net16}
N 3900 -2850 3920 -2850 {
lab=#net16}
N 3900 -2870 3920 -2870 {
lab=#net15}
N 3900 -2890 3920 -2890 {
lab=colon_n[7]}
N 3900 -2910 3920 -2910 {
lab=col_n[7]}
N 3720 -2770 3720 -2760 {
lab=VSS}
N 3720 -3000 3720 -2990 {
lab=VDD}
N 4060 -2770 4070 -2780 {
lab=row_n[11]}
N 4070 -2980 4070 -2780 {
lab=row_n[11]}
N 4060 -2990 4070 -2980 {
lab=row_n[11]}
N 4060 -2770 4060 -2750 {
lab=row_n[11]}
N 4060 -3010 4060 -2990 {
lab=row_n[11]}
N 3940 -2910 3950 -2920 {
lab=col_n[7]}
N 3950 -2920 4150 -2920 {
lab=col_n[7]}
N 4150 -2920 4160 -2910 {
lab=col_n[7]}
N 3940 -2890 3950 -2900 {
lab=colon_n[7]}
N 3950 -2900 4150 -2900 {
lab=colon_n[7]}
N 4150 -2900 4160 -2890 {
lab=colon_n[7]}
N 3940 -2870 3950 -2880 {
lab=#net15}
N 3950 -2880 4150 -2880 {
lab=#net15}
N 4150 -2880 4160 -2870 {
lab=#net15}
N 3940 -2850 3950 -2860 {
lab=#net16}
N 3950 -2860 4150 -2860 {
lab=#net16}
N 4150 -2860 4160 -2850 {
lab=#net16}
N 4000 -3010 4000 -2990 {
lab=vcom}
N 4040 -3010 4040 -2990 {
lab=ctop}
N 3920 -2910 3940 -2910 {
lab=col_n[7]}
N 3920 -2890 3940 -2890 {
lab=colon_n[7]}
N 3920 -2870 3940 -2870 {
lab=#net15}
N 3920 -2850 3940 -2850 {
lab=#net16}
N 4160 -2850 4180 -2850 {
lab=#net16}
N 4160 -2870 4180 -2870 {
lab=#net15}
N 4160 -2890 4180 -2890 {
lab=colon_n[7]}
N 4160 -2910 4180 -2910 {
lab=col_n[7]}
N 3980 -2770 3980 -2760 {
lab=VSS}
N 3980 -3000 3980 -2990 {
lab=VDD}
N 4320 -2770 4330 -2780 {
lab=row_n[12]}
N 4330 -2980 4330 -2780 {
lab=row_n[12]}
N 4320 -2990 4330 -2980 {
lab=row_n[12]}
N 4320 -2770 4320 -2750 {
lab=row_n[12]}
N 4320 -3010 4320 -2990 {
lab=row_n[12]}
N 4200 -2910 4210 -2920 {
lab=col_n[7]}
N 4210 -2920 4410 -2920 {
lab=col_n[7]}
N 4410 -2920 4420 -2910 {
lab=col_n[7]}
N 4200 -2890 4210 -2900 {
lab=colon_n[7]}
N 4210 -2900 4410 -2900 {
lab=colon_n[7]}
N 4410 -2900 4420 -2890 {
lab=colon_n[7]}
N 4200 -2870 4210 -2880 {
lab=#net15}
N 4210 -2880 4410 -2880 {
lab=#net15}
N 4410 -2880 4420 -2870 {
lab=#net15}
N 4200 -2850 4210 -2860 {
lab=#net16}
N 4210 -2860 4410 -2860 {
lab=#net16}
N 4410 -2860 4420 -2850 {
lab=#net16}
N 4260 -3010 4260 -2990 {
lab=vcom}
N 4300 -3010 4300 -2990 {
lab=ctop}
N 4180 -2910 4200 -2910 {
lab=col_n[7]}
N 4180 -2890 4200 -2890 {
lab=colon_n[7]}
N 4180 -2870 4200 -2870 {
lab=#net15}
N 4180 -2850 4200 -2850 {
lab=#net16}
N 4420 -2850 4440 -2850 {
lab=#net16}
N 4420 -2870 4440 -2870 {
lab=#net15}
N 4420 -2890 4440 -2890 {
lab=colon_n[7]}
N 4420 -2910 4440 -2910 {
lab=col_n[7]}
N 4240 -2770 4240 -2760 {
lab=VSS}
N 4240 -3000 4240 -2990 {
lab=VDD}
N 4580 -2770 4590 -2780 {
lab=row_n[13]}
N 4590 -2980 4590 -2780 {
lab=row_n[13]}
N 4580 -2990 4590 -2980 {
lab=row_n[13]}
N 4580 -2770 4580 -2750 {
lab=row_n[13]}
N 4580 -3010 4580 -2990 {
lab=row_n[13]}
N 4460 -2910 4470 -2920 {
lab=col_n[7]}
N 4470 -2920 4670 -2920 {
lab=col_n[7]}
N 4670 -2920 4680 -2910 {
lab=col_n[7]}
N 4460 -2890 4470 -2900 {
lab=colon_n[7]}
N 4470 -2900 4670 -2900 {
lab=colon_n[7]}
N 4670 -2900 4680 -2890 {
lab=colon_n[7]}
N 4460 -2870 4470 -2880 {
lab=#net15}
N 4470 -2880 4670 -2880 {
lab=#net15}
N 4670 -2880 4680 -2870 {
lab=#net15}
N 4460 -2850 4470 -2860 {
lab=#net16}
N 4470 -2860 4670 -2860 {
lab=#net16}
N 4670 -2860 4680 -2850 {
lab=#net16}
N 4520 -3010 4520 -2990 {
lab=vcom}
N 4560 -3010 4560 -2990 {
lab=ctop}
N 4440 -2910 4460 -2910 {
lab=col_n[7]}
N 4440 -2890 4460 -2890 {
lab=colon_n[7]}
N 4440 -2870 4460 -2870 {
lab=#net15}
N 4440 -2850 4460 -2850 {
lab=#net16}
N 4680 -2850 4700 -2850 {
lab=#net16}
N 4680 -2870 4700 -2870 {
lab=#net15}
N 4680 -2890 4700 -2890 {
lab=colon_n[7]}
N 4680 -2910 4700 -2910 {
lab=col_n[7]}
N 4500 -2770 4500 -2760 {
lab=VSS}
N 4500 -3000 4500 -2990 {
lab=VDD}
N 4840 -2770 4850 -2780 {
lab=row_n[14]}
N 4850 -2980 4850 -2780 {
lab=row_n[14]}
N 4840 -2990 4850 -2980 {
lab=row_n[14]}
N 4840 -2770 4840 -2750 {
lab=row_n[14]}
N 4840 -3010 4840 -2990 {
lab=row_n[14]}
N 4720 -2910 4730 -2920 {
lab=col_n[7]}
N 4730 -2920 4930 -2920 {
lab=col_n[7]}
N 4930 -2920 4940 -2910 {
lab=col_n[7]}
N 4720 -2890 4730 -2900 {
lab=colon_n[7]}
N 4730 -2900 4930 -2900 {
lab=colon_n[7]}
N 4930 -2900 4940 -2890 {
lab=colon_n[7]}
N 4720 -2870 4730 -2880 {
lab=#net15}
N 4730 -2880 4930 -2880 {
lab=#net15}
N 4930 -2880 4940 -2870 {
lab=#net15}
N 4720 -2850 4730 -2860 {
lab=#net16}
N 4730 -2860 4930 -2860 {
lab=#net16}
N 4930 -2860 4940 -2850 {
lab=#net16}
N 4780 -3010 4780 -2990 {
lab=vcom}
N 4820 -3010 4820 -2990 {
lab=ctop}
N 4700 -2910 4720 -2910 {
lab=col_n[7]}
N 4700 -2890 4720 -2890 {
lab=colon_n[7]}
N 4700 -2870 4720 -2870 {
lab=#net15}
N 4700 -2850 4720 -2850 {
lab=#net16}
N 4940 -2850 4960 -2850 {
lab=#net16}
N 4940 -2870 4960 -2870 {
lab=#net15}
N 4940 -2890 4960 -2890 {
lab=colon_n[7]}
N 4940 -2910 4960 -2910 {
lab=col_n[7]}
N 4760 -2770 4760 -2760 {
lab=VSS}
N 4760 -3000 4760 -2990 {
lab=VDD}
N 5100 -2770 5110 -2780 {
lab=row_n[15]}
N 5110 -2980 5110 -2780 {
lab=row_n[15]}
N 5100 -2990 5110 -2980 {
lab=row_n[15]}
N 5100 -2770 5100 -2750 {
lab=row_n[15]}
N 5100 -3010 5100 -2990 {
lab=row_n[15]}
N 4980 -2910 4990 -2920 {
lab=col_n[7]}
N 4990 -2920 5190 -2920 {
lab=col_n[7]}
N 5190 -2920 5200 -2910 {
lab=col_n[7]}
N 4980 -2890 4990 -2900 {
lab=colon_n[7]}
N 4990 -2900 5190 -2900 {
lab=colon_n[7]}
N 5190 -2900 5200 -2890 {
lab=colon_n[7]}
N 4980 -2870 4990 -2880 {
lab=#net15}
N 4990 -2880 5190 -2880 {
lab=#net15}
N 5190 -2880 5200 -2870 {
lab=#net15}
N 4980 -2850 4990 -2860 {
lab=#net16}
N 4990 -2860 5190 -2860 {
lab=#net16}
N 5190 -2860 5200 -2850 {
lab=#net16}
N 5040 -3010 5040 -2990 {
lab=vcom}
N 5080 -3010 5080 -2990 {
lab=ctop}
N 4960 -2910 4980 -2910 {
lab=col_n[7]}
N 4960 -2890 4980 -2890 {
lab=colon_n[7]}
N 4960 -2870 4980 -2870 {
lab=#net15}
N 4960 -2850 4980 -2850 {
lab=#net16}
N 5200 -2850 5220 -2850 {
lab=#net16}
N 5200 -2870 5220 -2870 {
lab=#net15}
N 5200 -2890 5220 -2890 {
lab=colon_n[7]}
N 5200 -2910 5220 -2910 {
lab=col_n[7]}
N 5020 -2770 5020 -2760 {
lab=VSS}
N 5020 -3000 5020 -2990 {
lab=VDD}
N 5360 -2770 5370 -2780 {
lab=row_n[16]}
N 5370 -2980 5370 -2780 {
lab=row_n[16]}
N 5360 -2990 5370 -2980 {
lab=row_n[16]}
N 5360 -2770 5360 -2750 {
lab=row_n[16]}
N 5360 -3010 5360 -2990 {
lab=row_n[16]}
N 5240 -2910 5250 -2920 {
lab=col_n[7]}
N 5250 -2920 5450 -2920 {
lab=col_n[7]}
N 5450 -2920 5460 -2910 {
lab=col_n[7]}
N 5240 -2890 5250 -2900 {
lab=colon_n[7]}
N 5250 -2900 5450 -2900 {
lab=colon_n[7]}
N 5450 -2900 5460 -2890 {
lab=colon_n[7]}
N 5240 -2870 5250 -2880 {
lab=#net15}
N 5250 -2880 5450 -2880 {
lab=#net15}
N 5450 -2880 5460 -2870 {
lab=#net15}
N 5240 -2850 5250 -2860 {
lab=#net16}
N 5250 -2860 5450 -2860 {
lab=#net16}
N 5450 -2860 5460 -2850 {
lab=#net16}
N 5300 -3010 5300 -2990 {
lab=vcom}
N 5340 -3010 5340 -2990 {
lab=ctop}
N 5220 -2910 5240 -2910 {
lab=col_n[7]}
N 5220 -2890 5240 -2890 {
lab=colon_n[7]}
N 5220 -2870 5240 -2870 {
lab=#net15}
N 5220 -2850 5240 -2850 {
lab=#net16}
N 5460 -2850 5480 -2850 {
lab=#net16}
N 5460 -2870 5480 -2870 {
lab=#net15}
N 5460 -2890 5480 -2890 {
lab=colon_n[7]}
N 5460 -2910 5480 -2910 {
lab=col_n[7]}
N 5280 -2770 5280 -2760 {
lab=VSS}
N 5280 -3000 5280 -2990 {
lab=VDD}
N 5620 -2770 5630 -2780 {
lab=row_n[17]}
N 5630 -2980 5630 -2780 {
lab=row_n[17]}
N 5620 -2990 5630 -2980 {
lab=row_n[17]}
N 5620 -2770 5620 -2750 {
lab=row_n[17]}
N 5620 -3010 5620 -2990 {
lab=row_n[17]}
N 5500 -2910 5510 -2920 {
lab=col_n[7]}
N 5510 -2920 5710 -2920 {
lab=col_n[7]}
N 5710 -2920 5720 -2910 {
lab=col_n[7]}
N 5500 -2890 5510 -2900 {
lab=colon_n[7]}
N 5510 -2900 5710 -2900 {
lab=colon_n[7]}
N 5710 -2900 5720 -2890 {
lab=colon_n[7]}
N 5500 -2870 5510 -2880 {
lab=#net15}
N 5510 -2880 5710 -2880 {
lab=#net15}
N 5710 -2880 5720 -2870 {
lab=#net15}
N 5500 -2850 5510 -2860 {
lab=#net16}
N 5510 -2860 5710 -2860 {
lab=#net16}
N 5710 -2860 5720 -2850 {
lab=#net16}
N 5560 -3010 5560 -2990 {
lab=vcom}
N 5600 -3010 5600 -2990 {
lab=ctop}
N 5480 -2910 5500 -2910 {
lab=col_n[7]}
N 5480 -2890 5500 -2890 {
lab=colon_n[7]}
N 5480 -2870 5500 -2870 {
lab=#net15}
N 5480 -2850 5500 -2850 {
lab=#net16}
N 5720 -2850 5740 -2850 {
lab=#net16}
N 5720 -2870 5740 -2870 {
lab=#net15}
N 5720 -2890 5740 -2890 {
lab=colon_n[7]}
N 5720 -2910 5740 -2910 {
lab=col_n[7]}
N 5540 -2770 5540 -2760 {
lab=VSS}
N 5540 -3000 5540 -2990 {
lab=VDD}
N 5880 -2770 5890 -2780 {
lab=row_n[18]}
N 5890 -2980 5890 -2780 {
lab=row_n[18]}
N 5880 -2990 5890 -2980 {
lab=row_n[18]}
N 5880 -2770 5880 -2750 {
lab=row_n[18]}
N 5880 -3010 5880 -2990 {
lab=row_n[18]}
N 5760 -2910 5770 -2920 {
lab=col_n[7]}
N 5770 -2920 5970 -2920 {
lab=col_n[7]}
N 5970 -2920 5980 -2910 {
lab=col_n[7]}
N 5760 -2890 5770 -2900 {
lab=colon_n[7]}
N 5770 -2900 5970 -2900 {
lab=colon_n[7]}
N 5970 -2900 5980 -2890 {
lab=colon_n[7]}
N 5760 -2870 5770 -2880 {
lab=#net15}
N 5770 -2880 5970 -2880 {
lab=#net15}
N 5970 -2880 5980 -2870 {
lab=#net15}
N 5760 -2850 5770 -2860 {
lab=#net16}
N 5770 -2860 5970 -2860 {
lab=#net16}
N 5970 -2860 5980 -2850 {
lab=#net16}
N 5820 -3010 5820 -2990 {
lab=vcom}
N 5860 -3010 5860 -2990 {
lab=ctop}
N 5740 -2910 5760 -2910 {
lab=col_n[7]}
N 5740 -2890 5760 -2890 {
lab=colon_n[7]}
N 5740 -2870 5760 -2870 {
lab=#net15}
N 5740 -2850 5760 -2850 {
lab=#net16}
N 5980 -2850 6000 -2850 {
lab=#net16}
N 5980 -2870 6000 -2870 {
lab=#net15}
N 5980 -2890 6000 -2890 {
lab=colon_n[7]}
N 5980 -2910 6000 -2910 {
lab=col_n[7]}
N 5800 -2770 5800 -2760 {
lab=VSS}
N 5800 -3000 5800 -2990 {
lab=VDD}
N 6140 -2770 6150 -2780 {
lab=row_n[19]}
N 6150 -2980 6150 -2780 {
lab=row_n[19]}
N 6140 -2990 6150 -2980 {
lab=row_n[19]}
N 6140 -2770 6140 -2750 {
lab=row_n[19]}
N 6140 -3010 6140 -2990 {
lab=row_n[19]}
N 6020 -2910 6030 -2920 {
lab=col_n[7]}
N 6030 -2920 6230 -2920 {
lab=col_n[7]}
N 6230 -2920 6240 -2910 {
lab=col_n[7]}
N 6020 -2890 6030 -2900 {
lab=colon_n[7]}
N 6030 -2900 6230 -2900 {
lab=colon_n[7]}
N 6230 -2900 6240 -2890 {
lab=colon_n[7]}
N 6020 -2870 6030 -2880 {
lab=#net15}
N 6030 -2880 6230 -2880 {
lab=#net15}
N 6230 -2880 6240 -2870 {
lab=#net15}
N 6020 -2850 6030 -2860 {
lab=#net16}
N 6030 -2860 6230 -2860 {
lab=#net16}
N 6230 -2860 6240 -2850 {
lab=#net16}
N 6080 -3010 6080 -2990 {
lab=vcom}
N 6120 -3010 6120 -2990 {
lab=ctop}
N 6000 -2910 6020 -2910 {
lab=col_n[7]}
N 6000 -2890 6020 -2890 {
lab=colon_n[7]}
N 6000 -2870 6020 -2870 {
lab=#net15}
N 6000 -2850 6020 -2850 {
lab=#net16}
N 6240 -2850 6260 -2850 {
lab=#net16}
N 6240 -2870 6260 -2870 {
lab=#net15}
N 6240 -2890 6260 -2890 {
lab=colon_n[7]}
N 6240 -2910 6260 -2910 {
lab=col_n[7]}
N 6060 -2770 6060 -2760 {
lab=VSS}
N 6060 -3000 6060 -2990 {
lab=VDD}
N 6400 -2770 6410 -2780 {
lab=row_n[20]}
N 6410 -2980 6410 -2780 {
lab=row_n[20]}
N 6400 -2990 6410 -2980 {
lab=row_n[20]}
N 6400 -2770 6400 -2750 {
lab=row_n[20]}
N 6400 -3010 6400 -2990 {
lab=row_n[20]}
N 6280 -2910 6290 -2920 {
lab=col_n[7]}
N 6290 -2920 6490 -2920 {
lab=col_n[7]}
N 6490 -2920 6500 -2910 {
lab=col_n[7]}
N 6280 -2890 6290 -2900 {
lab=colon_n[7]}
N 6290 -2900 6490 -2900 {
lab=colon_n[7]}
N 6490 -2900 6500 -2890 {
lab=colon_n[7]}
N 6280 -2870 6290 -2880 {
lab=#net15}
N 6290 -2880 6490 -2880 {
lab=#net15}
N 6490 -2880 6500 -2870 {
lab=#net15}
N 6280 -2850 6290 -2860 {
lab=#net16}
N 6290 -2860 6490 -2860 {
lab=#net16}
N 6490 -2860 6500 -2850 {
lab=#net16}
N 6340 -3010 6340 -2990 {
lab=vcom}
N 6380 -3010 6380 -2990 {
lab=ctop}
N 6260 -2910 6280 -2910 {
lab=col_n[7]}
N 6260 -2890 6280 -2890 {
lab=colon_n[7]}
N 6260 -2870 6280 -2870 {
lab=#net15}
N 6260 -2850 6280 -2850 {
lab=#net16}
N 6500 -2850 6520 -2850 {
lab=#net16}
N 6500 -2870 6520 -2870 {
lab=#net15}
N 6500 -2890 6520 -2890 {
lab=colon_n[7]}
N 6500 -2910 6520 -2910 {
lab=col_n[7]}
N 6320 -2770 6320 -2760 {
lab=VSS}
N 6320 -3000 6320 -2990 {
lab=VDD}
N 6660 -2770 6670 -2780 {
lab=row_n[21]}
N 6670 -2980 6670 -2780 {
lab=row_n[21]}
N 6660 -2990 6670 -2980 {
lab=row_n[21]}
N 6660 -2770 6660 -2750 {
lab=row_n[21]}
N 6660 -3010 6660 -2990 {
lab=row_n[21]}
N 6540 -2910 6550 -2920 {
lab=col_n[7]}
N 6550 -2920 6750 -2920 {
lab=col_n[7]}
N 6750 -2920 6760 -2910 {
lab=col_n[7]}
N 6540 -2890 6550 -2900 {
lab=colon_n[7]}
N 6550 -2900 6750 -2900 {
lab=colon_n[7]}
N 6750 -2900 6760 -2890 {
lab=colon_n[7]}
N 6540 -2870 6550 -2880 {
lab=#net15}
N 6550 -2880 6750 -2880 {
lab=#net15}
N 6750 -2880 6760 -2870 {
lab=#net15}
N 6540 -2850 6550 -2860 {
lab=#net16}
N 6550 -2860 6750 -2860 {
lab=#net16}
N 6750 -2860 6760 -2850 {
lab=#net16}
N 6600 -3010 6600 -2990 {
lab=vcom}
N 6640 -3010 6640 -2990 {
lab=ctop}
N 6520 -2910 6540 -2910 {
lab=col_n[7]}
N 6520 -2890 6540 -2890 {
lab=colon_n[7]}
N 6520 -2870 6540 -2870 {
lab=#net15}
N 6520 -2850 6540 -2850 {
lab=#net16}
N 6760 -2850 6780 -2850 {
lab=#net16}
N 6760 -2870 6780 -2870 {
lab=#net15}
N 6760 -2890 6780 -2890 {
lab=colon_n[7]}
N 6760 -2910 6780 -2910 {
lab=col_n[7]}
N 6580 -2770 6580 -2760 {
lab=VSS}
N 6580 -3000 6580 -2990 {
lab=VDD}
N 6920 -2770 6930 -2780 {
lab=row_n[22]}
N 6930 -2980 6930 -2780 {
lab=row_n[22]}
N 6920 -2990 6930 -2980 {
lab=row_n[22]}
N 6920 -2770 6920 -2750 {
lab=row_n[22]}
N 6920 -3010 6920 -2990 {
lab=row_n[22]}
N 6800 -2910 6810 -2920 {
lab=col_n[7]}
N 6810 -2920 7010 -2920 {
lab=col_n[7]}
N 7010 -2920 7020 -2910 {
lab=col_n[7]}
N 6800 -2890 6810 -2900 {
lab=colon_n[7]}
N 6810 -2900 7010 -2900 {
lab=colon_n[7]}
N 7010 -2900 7020 -2890 {
lab=colon_n[7]}
N 6800 -2870 6810 -2880 {
lab=#net15}
N 6810 -2880 7010 -2880 {
lab=#net15}
N 7010 -2880 7020 -2870 {
lab=#net15}
N 6800 -2850 6810 -2860 {
lab=#net16}
N 6810 -2860 7010 -2860 {
lab=#net16}
N 7010 -2860 7020 -2850 {
lab=#net16}
N 6860 -3010 6860 -2990 {
lab=vcom}
N 6900 -3010 6900 -2990 {
lab=ctop}
N 6780 -2910 6800 -2910 {
lab=col_n[7]}
N 6780 -2890 6800 -2890 {
lab=colon_n[7]}
N 6780 -2870 6800 -2870 {
lab=#net15}
N 6780 -2850 6800 -2850 {
lab=#net16}
N 7020 -2850 7040 -2850 {
lab=#net16}
N 7020 -2870 7040 -2870 {
lab=#net15}
N 7020 -2890 7040 -2890 {
lab=colon_n[7]}
N 7020 -2910 7040 -2910 {
lab=col_n[7]}
N 6840 -2770 6840 -2760 {
lab=VSS}
N 6840 -3000 6840 -2990 {
lab=VDD}
N 7180 -2770 7190 -2780 {
lab=row_n[23]}
N 7190 -2980 7190 -2780 {
lab=row_n[23]}
N 7180 -2990 7190 -2980 {
lab=row_n[23]}
N 7180 -2770 7180 -2750 {
lab=row_n[23]}
N 7180 -3010 7180 -2990 {
lab=row_n[23]}
N 7060 -2910 7070 -2920 {
lab=col_n[7]}
N 7070 -2920 7270 -2920 {
lab=col_n[7]}
N 7270 -2920 7280 -2910 {
lab=col_n[7]}
N 7060 -2890 7070 -2900 {
lab=colon_n[7]}
N 7070 -2900 7270 -2900 {
lab=colon_n[7]}
N 7270 -2900 7280 -2890 {
lab=colon_n[7]}
N 7060 -2870 7070 -2880 {
lab=#net15}
N 7070 -2880 7270 -2880 {
lab=#net15}
N 7270 -2880 7280 -2870 {
lab=#net15}
N 7060 -2850 7070 -2860 {
lab=#net16}
N 7070 -2860 7270 -2860 {
lab=#net16}
N 7270 -2860 7280 -2850 {
lab=#net16}
N 7120 -3010 7120 -2990 {
lab=vcom}
N 7160 -3010 7160 -2990 {
lab=ctop}
N 7040 -2910 7060 -2910 {
lab=col_n[7]}
N 7040 -2890 7060 -2890 {
lab=colon_n[7]}
N 7040 -2870 7060 -2870 {
lab=#net15}
N 7040 -2850 7060 -2850 {
lab=#net16}
N 7280 -2850 7300 -2850 {
lab=#net16}
N 7280 -2870 7300 -2870 {
lab=#net15}
N 7280 -2890 7300 -2890 {
lab=colon_n[7]}
N 7280 -2910 7300 -2910 {
lab=col_n[7]}
N 7100 -2770 7100 -2760 {
lab=VSS}
N 7100 -3000 7100 -2990 {
lab=VDD}
N 7440 -2770 7450 -2780 {
lab=row_n[24]}
N 7450 -2980 7450 -2780 {
lab=row_n[24]}
N 7440 -2990 7450 -2980 {
lab=row_n[24]}
N 7440 -2770 7440 -2750 {
lab=row_n[24]}
N 7440 -3010 7440 -2990 {
lab=row_n[24]}
N 7320 -2910 7330 -2920 {
lab=col_n[7]}
N 7330 -2920 7530 -2920 {
lab=col_n[7]}
N 7530 -2920 7540 -2910 {
lab=col_n[7]}
N 7320 -2890 7330 -2900 {
lab=colon_n[7]}
N 7330 -2900 7530 -2900 {
lab=colon_n[7]}
N 7530 -2900 7540 -2890 {
lab=colon_n[7]}
N 7320 -2870 7330 -2880 {
lab=#net15}
N 7330 -2880 7530 -2880 {
lab=#net15}
N 7530 -2880 7540 -2870 {
lab=#net15}
N 7320 -2850 7330 -2860 {
lab=#net16}
N 7330 -2860 7530 -2860 {
lab=#net16}
N 7530 -2860 7540 -2850 {
lab=#net16}
N 7380 -3010 7380 -2990 {
lab=vcom}
N 7420 -3010 7420 -2990 {
lab=ctop}
N 7300 -2910 7320 -2910 {
lab=col_n[7]}
N 7300 -2890 7320 -2890 {
lab=colon_n[7]}
N 7300 -2870 7320 -2870 {
lab=#net15}
N 7300 -2850 7320 -2850 {
lab=#net16}
N 7540 -2850 7560 -2850 {
lab=#net16}
N 7540 -2870 7560 -2870 {
lab=#net15}
N 7540 -2890 7560 -2890 {
lab=colon_n[7]}
N 7540 -2910 7560 -2910 {
lab=col_n[7]}
N 7360 -2770 7360 -2760 {
lab=VSS}
N 7360 -3000 7360 -2990 {
lab=VDD}
N 7700 -2770 7710 -2780 {
lab=row_n[25]}
N 7710 -2980 7710 -2780 {
lab=row_n[25]}
N 7700 -2990 7710 -2980 {
lab=row_n[25]}
N 7700 -2770 7700 -2750 {
lab=row_n[25]}
N 7700 -3010 7700 -2990 {
lab=row_n[25]}
N 7580 -2910 7590 -2920 {
lab=col_n[7]}
N 7590 -2920 7790 -2920 {
lab=col_n[7]}
N 7790 -2920 7800 -2910 {
lab=col_n[7]}
N 7580 -2890 7590 -2900 {
lab=colon_n[7]}
N 7590 -2900 7790 -2900 {
lab=colon_n[7]}
N 7790 -2900 7800 -2890 {
lab=colon_n[7]}
N 7580 -2870 7590 -2880 {
lab=#net15}
N 7590 -2880 7790 -2880 {
lab=#net15}
N 7790 -2880 7800 -2870 {
lab=#net15}
N 7580 -2850 7590 -2860 {
lab=#net16}
N 7590 -2860 7790 -2860 {
lab=#net16}
N 7790 -2860 7800 -2850 {
lab=#net16}
N 7640 -3010 7640 -2990 {
lab=vcom}
N 7680 -3010 7680 -2990 {
lab=ctop}
N 7560 -2910 7580 -2910 {
lab=col_n[7]}
N 7560 -2890 7580 -2890 {
lab=colon_n[7]}
N 7560 -2870 7580 -2870 {
lab=#net15}
N 7560 -2850 7580 -2850 {
lab=#net16}
N 7800 -2850 7820 -2850 {
lab=#net16}
N 7800 -2870 7820 -2870 {
lab=#net15}
N 7800 -2890 7820 -2890 {
lab=colon_n[7]}
N 7800 -2910 7820 -2910 {
lab=col_n[7]}
N 7620 -2770 7620 -2760 {
lab=VSS}
N 7620 -3000 7620 -2990 {
lab=VDD}
N 7960 -2770 7970 -2780 {
lab=row_n[26]}
N 7970 -2980 7970 -2780 {
lab=row_n[26]}
N 7960 -2990 7970 -2980 {
lab=row_n[26]}
N 7960 -2770 7960 -2750 {
lab=row_n[26]}
N 7960 -3010 7960 -2990 {
lab=row_n[26]}
N 7840 -2910 7850 -2920 {
lab=col_n[7]}
N 7850 -2920 8050 -2920 {
lab=col_n[7]}
N 8050 -2920 8060 -2910 {
lab=col_n[7]}
N 7840 -2890 7850 -2900 {
lab=colon_n[7]}
N 7850 -2900 8050 -2900 {
lab=colon_n[7]}
N 8050 -2900 8060 -2890 {
lab=colon_n[7]}
N 7840 -2870 7850 -2880 {
lab=#net15}
N 7850 -2880 8050 -2880 {
lab=#net15}
N 8050 -2880 8060 -2870 {
lab=#net15}
N 7840 -2850 7850 -2860 {
lab=#net16}
N 7850 -2860 8050 -2860 {
lab=#net16}
N 8050 -2860 8060 -2850 {
lab=#net16}
N 7900 -3010 7900 -2990 {
lab=vcom}
N 7940 -3010 7940 -2990 {
lab=ctop}
N 7820 -2910 7840 -2910 {
lab=col_n[7]}
N 7820 -2890 7840 -2890 {
lab=colon_n[7]}
N 7820 -2870 7840 -2870 {
lab=#net15}
N 7820 -2850 7840 -2850 {
lab=#net16}
N 8060 -2850 8080 -2850 {
lab=#net16}
N 8060 -2870 8080 -2870 {
lab=#net15}
N 8060 -2890 8080 -2890 {
lab=colon_n[7]}
N 8060 -2910 8080 -2910 {
lab=col_n[7]}
N 7880 -2770 7880 -2760 {
lab=VSS}
N 7880 -3000 7880 -2990 {
lab=VDD}
N 8220 -2770 8230 -2780 {
lab=row_n[27]}
N 8230 -2980 8230 -2780 {
lab=row_n[27]}
N 8220 -2990 8230 -2980 {
lab=row_n[27]}
N 8220 -2770 8220 -2750 {
lab=row_n[27]}
N 8220 -3010 8220 -2990 {
lab=row_n[27]}
N 8100 -2910 8110 -2920 {
lab=col_n[7]}
N 8110 -2920 8310 -2920 {
lab=col_n[7]}
N 8310 -2920 8320 -2910 {
lab=col_n[7]}
N 8100 -2890 8110 -2900 {
lab=colon_n[7]}
N 8110 -2900 8310 -2900 {
lab=colon_n[7]}
N 8310 -2900 8320 -2890 {
lab=colon_n[7]}
N 8100 -2870 8110 -2880 {
lab=#net15}
N 8110 -2880 8310 -2880 {
lab=#net15}
N 8310 -2880 8320 -2870 {
lab=#net15}
N 8100 -2850 8110 -2860 {
lab=#net16}
N 8110 -2860 8310 -2860 {
lab=#net16}
N 8310 -2860 8320 -2850 {
lab=#net16}
N 8160 -3010 8160 -2990 {
lab=vcom}
N 8200 -3010 8200 -2990 {
lab=ctop}
N 8080 -2910 8100 -2910 {
lab=col_n[7]}
N 8080 -2890 8100 -2890 {
lab=colon_n[7]}
N 8080 -2870 8100 -2870 {
lab=#net15}
N 8080 -2850 8100 -2850 {
lab=#net16}
N 8320 -2850 8340 -2850 {
lab=#net16}
N 8320 -2870 8340 -2870 {
lab=#net15}
N 8320 -2890 8340 -2890 {
lab=colon_n[7]}
N 8320 -2910 8340 -2910 {
lab=col_n[7]}
N 8140 -2770 8140 -2760 {
lab=VSS}
N 8140 -3000 8140 -2990 {
lab=VDD}
N 8480 -2770 8490 -2780 {
lab=row_n[28]}
N 8490 -2980 8490 -2780 {
lab=row_n[28]}
N 8480 -2990 8490 -2980 {
lab=row_n[28]}
N 8480 -2770 8480 -2750 {
lab=row_n[28]}
N 8480 -3010 8480 -2990 {
lab=row_n[28]}
N 8360 -2910 8370 -2920 {
lab=col_n[7]}
N 8370 -2920 8570 -2920 {
lab=col_n[7]}
N 8570 -2920 8580 -2910 {
lab=col_n[7]}
N 8360 -2890 8370 -2900 {
lab=colon_n[7]}
N 8370 -2900 8570 -2900 {
lab=colon_n[7]}
N 8570 -2900 8580 -2890 {
lab=colon_n[7]}
N 8360 -2870 8370 -2880 {
lab=#net15}
N 8370 -2880 8570 -2880 {
lab=#net15}
N 8570 -2880 8580 -2870 {
lab=#net15}
N 8360 -2850 8370 -2860 {
lab=#net16}
N 8370 -2860 8570 -2860 {
lab=#net16}
N 8570 -2860 8580 -2850 {
lab=#net16}
N 8420 -3010 8420 -2990 {
lab=vcom}
N 8460 -3010 8460 -2990 {
lab=ctop}
N 8340 -2910 8360 -2910 {
lab=col_n[7]}
N 8340 -2890 8360 -2890 {
lab=colon_n[7]}
N 8340 -2870 8360 -2870 {
lab=#net15}
N 8340 -2850 8360 -2850 {
lab=#net16}
N 8580 -2850 8600 -2850 {
lab=#net16}
N 8580 -2870 8600 -2870 {
lab=#net15}
N 8580 -2890 8600 -2890 {
lab=colon_n[7]}
N 8580 -2910 8600 -2910 {
lab=col_n[7]}
N 8400 -2770 8400 -2760 {
lab=VSS}
N 8400 -3000 8400 -2990 {
lab=VDD}
N 8740 -2770 8750 -2780 {
lab=row_n[29]}
N 8750 -2980 8750 -2780 {
lab=row_n[29]}
N 8740 -2990 8750 -2980 {
lab=row_n[29]}
N 8740 -2770 8740 -2750 {
lab=row_n[29]}
N 8740 -3010 8740 -2990 {
lab=row_n[29]}
N 8620 -2910 8630 -2920 {
lab=col_n[7]}
N 8630 -2920 8830 -2920 {
lab=col_n[7]}
N 8830 -2920 8840 -2910 {
lab=col_n[7]}
N 8620 -2890 8630 -2900 {
lab=colon_n[7]}
N 8630 -2900 8830 -2900 {
lab=colon_n[7]}
N 8830 -2900 8840 -2890 {
lab=colon_n[7]}
N 8620 -2870 8630 -2880 {
lab=#net15}
N 8630 -2880 8830 -2880 {
lab=#net15}
N 8830 -2880 8840 -2870 {
lab=#net15}
N 8620 -2850 8630 -2860 {
lab=#net16}
N 8630 -2860 8830 -2860 {
lab=#net16}
N 8830 -2860 8840 -2850 {
lab=#net16}
N 8680 -3010 8680 -2990 {
lab=vcom}
N 8720 -3010 8720 -2990 {
lab=ctop}
N 8600 -2910 8620 -2910 {
lab=col_n[7]}
N 8600 -2890 8620 -2890 {
lab=colon_n[7]}
N 8600 -2870 8620 -2870 {
lab=#net15}
N 8600 -2850 8620 -2850 {
lab=#net16}
N 8840 -2850 8860 -2850 {
lab=#net16}
N 8840 -2870 8860 -2870 {
lab=#net15}
N 8840 -2890 8860 -2890 {
lab=colon_n[7]}
N 8840 -2910 8860 -2910 {
lab=col_n[7]}
N 8660 -2770 8660 -2760 {
lab=VSS}
N 8660 -3000 8660 -2990 {
lab=VDD}
N 9000 -2770 9010 -2780 {
lab=row_n[30]}
N 9010 -2980 9010 -2780 {
lab=row_n[30]}
N 9000 -2990 9010 -2980 {
lab=row_n[30]}
N 9000 -2770 9000 -2750 {
lab=row_n[30]}
N 9000 -3010 9000 -2990 {
lab=row_n[30]}
N 8880 -2910 8890 -2920 {
lab=col_n[7]}
N 8890 -2920 9090 -2920 {
lab=col_n[7]}
N 9090 -2920 9100 -2910 {
lab=col_n[7]}
N 8880 -2890 8890 -2900 {
lab=colon_n[7]}
N 8890 -2900 9090 -2900 {
lab=colon_n[7]}
N 9090 -2900 9100 -2890 {
lab=colon_n[7]}
N 8880 -2870 8890 -2880 {
lab=#net15}
N 8890 -2880 9090 -2880 {
lab=#net15}
N 9090 -2880 9100 -2870 {
lab=#net15}
N 8880 -2850 8890 -2860 {
lab=#net16}
N 8890 -2860 9090 -2860 {
lab=#net16}
N 9090 -2860 9100 -2850 {
lab=#net16}
N 8940 -3010 8940 -2990 {
lab=vcom}
N 8980 -3010 8980 -2990 {
lab=ctop}
N 8860 -2910 8880 -2910 {
lab=col_n[7]}
N 8860 -2890 8880 -2890 {
lab=colon_n[7]}
N 8860 -2870 8880 -2870 {
lab=#net15}
N 8860 -2850 8880 -2850 {
lab=#net16}
N 9100 -2850 9120 -2850 {
lab=#net16}
N 9100 -2870 9120 -2870 {
lab=#net15}
N 9100 -2890 9120 -2890 {
lab=colon_n[7]}
N 9100 -2910 9120 -2910 {
lab=col_n[7]}
N 8920 -2770 8920 -2760 {
lab=VSS}
N 8920 -3000 8920 -2990 {
lab=VDD}
N 9260 -2770 9270 -2780 {
lab=row_n[31]}
N 9270 -2980 9270 -2780 {
lab=row_n[31]}
N 9260 -2990 9270 -2980 {
lab=row_n[31]}
N 9260 -2770 9260 -2750 {
lab=row_n[31]}
N 9260 -3010 9260 -2990 {
lab=row_n[31]}
N 9140 -2910 9150 -2920 {
lab=col_n[7]}
N 9150 -2920 9350 -2920 {
lab=col_n[7]}
N 9350 -2920 9360 -2910 {
lab=col_n[7]}
N 9140 -2890 9150 -2900 {
lab=colon_n[7]}
N 9150 -2900 9350 -2900 {
lab=colon_n[7]}
N 9350 -2900 9360 -2890 {
lab=colon_n[7]}
N 9140 -2870 9150 -2880 {
lab=#net15}
N 9150 -2880 9350 -2880 {
lab=#net15}
N 9350 -2880 9360 -2870 {
lab=#net15}
N 9140 -2850 9150 -2860 {
lab=#net16}
N 9150 -2860 9350 -2860 {
lab=#net16}
N 9350 -2860 9360 -2850 {
lab=#net16}
N 9200 -3010 9200 -2990 {
lab=vcom}
N 9240 -3010 9240 -2990 {
lab=ctop}
N 9120 -2910 9140 -2910 {
lab=col_n[7]}
N 9120 -2890 9140 -2890 {
lab=colon_n[7]}
N 9120 -2870 9140 -2870 {
lab=#net15}
N 9120 -2850 9140 -2850 {
lab=#net16}
N 9360 -2850 9380 -2850 {
lab=#net16}
N 9360 -2870 9380 -2870 {
lab=#net15}
N 9360 -2890 9380 -2890 {
lab=colon_n[7]}
N 9360 -2910 9380 -2910 {
lab=col_n[7]}
N 9180 -2770 9180 -2760 {
lab=VSS}
N 9180 -3000 9180 -2990 {
lab=VDD}
N 1200 -3030 1210 -3040 {
lab=row_n[0]}
N 1210 -3240 1210 -3040 {
lab=row_n[0]}
N 1200 -3250 1210 -3240 {
lab=row_n[0]}
N 1200 -3030 1200 -3010 {
lab=row_n[0]}
N 1200 -3270 1200 -3250 {
lab=row_n[0]}
N 1080 -3170 1090 -3180 {
lab=col_n[8]}
N 1090 -3180 1290 -3180 {
lab=col_n[8]}
N 1290 -3180 1300 -3170 {
lab=col_n[8]}
N 1080 -3150 1090 -3160 {
lab=colon_n[8]}
N 1090 -3160 1290 -3160 {
lab=colon_n[8]}
N 1290 -3160 1300 -3150 {
lab=colon_n[8]}
N 1080 -3130 1090 -3140 {
lab=#net17}
N 1090 -3140 1290 -3140 {
lab=#net17}
N 1290 -3140 1300 -3130 {
lab=#net17}
N 1080 -3110 1090 -3120 {
lab=#net18}
N 1090 -3120 1290 -3120 {
lab=#net18}
N 1290 -3120 1300 -3110 {
lab=#net18}
N 1140 -3270 1140 -3250 {
lab=vcom}
N 1180 -3270 1180 -3250 {
lab=ctop}
N 1060 -3170 1080 -3170 {
lab=col_n[8]}
N 1060 -3150 1080 -3150 {
lab=colon_n[8]}
N 1060 -3130 1080 -3130 {
lab=#net17}
N 1060 -3110 1080 -3110 {
lab=#net18}
N 1300 -3110 1320 -3110 {
lab=#net18}
N 1300 -3130 1320 -3130 {
lab=#net17}
N 1300 -3150 1320 -3150 {
lab=colon_n[8]}
N 1300 -3170 1320 -3170 {
lab=col_n[8]}
N 1120 -3030 1120 -3020 {
lab=VSS}
N 1120 -3260 1120 -3250 {
lab=VDD}
N 1460 -3030 1470 -3040 {
lab=row_n[1]}
N 1470 -3240 1470 -3040 {
lab=row_n[1]}
N 1460 -3250 1470 -3240 {
lab=row_n[1]}
N 1460 -3030 1460 -3010 {
lab=row_n[1]}
N 1460 -3270 1460 -3250 {
lab=row_n[1]}
N 1340 -3170 1350 -3180 {
lab=col_n[8]}
N 1350 -3180 1550 -3180 {
lab=col_n[8]}
N 1550 -3180 1560 -3170 {
lab=col_n[8]}
N 1340 -3150 1350 -3160 {
lab=colon_n[8]}
N 1350 -3160 1550 -3160 {
lab=colon_n[8]}
N 1550 -3160 1560 -3150 {
lab=colon_n[8]}
N 1340 -3130 1350 -3140 {
lab=#net17}
N 1350 -3140 1550 -3140 {
lab=#net17}
N 1550 -3140 1560 -3130 {
lab=#net17}
N 1340 -3110 1350 -3120 {
lab=#net18}
N 1350 -3120 1550 -3120 {
lab=#net18}
N 1550 -3120 1560 -3110 {
lab=#net18}
N 1400 -3270 1400 -3250 {
lab=vcom}
N 1440 -3270 1440 -3250 {
lab=ctop}
N 1320 -3170 1340 -3170 {
lab=col_n[8]}
N 1320 -3150 1340 -3150 {
lab=colon_n[8]}
N 1320 -3130 1340 -3130 {
lab=#net17}
N 1320 -3110 1340 -3110 {
lab=#net18}
N 1560 -3110 1580 -3110 {
lab=#net18}
N 1560 -3130 1580 -3130 {
lab=#net17}
N 1560 -3150 1580 -3150 {
lab=colon_n[8]}
N 1560 -3170 1580 -3170 {
lab=col_n[8]}
N 1380 -3030 1380 -3020 {
lab=VSS}
N 1380 -3260 1380 -3250 {
lab=VDD}
N 1720 -3030 1730 -3040 {
lab=row_n[2]}
N 1730 -3240 1730 -3040 {
lab=row_n[2]}
N 1720 -3250 1730 -3240 {
lab=row_n[2]}
N 1720 -3030 1720 -3010 {
lab=row_n[2]}
N 1720 -3270 1720 -3250 {
lab=row_n[2]}
N 1600 -3170 1610 -3180 {
lab=col_n[8]}
N 1610 -3180 1810 -3180 {
lab=col_n[8]}
N 1810 -3180 1820 -3170 {
lab=col_n[8]}
N 1600 -3150 1610 -3160 {
lab=colon_n[8]}
N 1610 -3160 1810 -3160 {
lab=colon_n[8]}
N 1810 -3160 1820 -3150 {
lab=colon_n[8]}
N 1600 -3130 1610 -3140 {
lab=#net17}
N 1610 -3140 1810 -3140 {
lab=#net17}
N 1810 -3140 1820 -3130 {
lab=#net17}
N 1600 -3110 1610 -3120 {
lab=#net18}
N 1610 -3120 1810 -3120 {
lab=#net18}
N 1810 -3120 1820 -3110 {
lab=#net18}
N 1660 -3270 1660 -3250 {
lab=vcom}
N 1700 -3270 1700 -3250 {
lab=ctop}
N 1580 -3170 1600 -3170 {
lab=col_n[8]}
N 1580 -3150 1600 -3150 {
lab=colon_n[8]}
N 1580 -3130 1600 -3130 {
lab=#net17}
N 1580 -3110 1600 -3110 {
lab=#net18}
N 1820 -3110 1840 -3110 {
lab=#net18}
N 1820 -3130 1840 -3130 {
lab=#net17}
N 1820 -3150 1840 -3150 {
lab=colon_n[8]}
N 1820 -3170 1840 -3170 {
lab=col_n[8]}
N 1640 -3030 1640 -3020 {
lab=VSS}
N 1640 -3260 1640 -3250 {
lab=VDD}
N 1980 -3030 1990 -3040 {
lab=row_n[3]}
N 1990 -3240 1990 -3040 {
lab=row_n[3]}
N 1980 -3250 1990 -3240 {
lab=row_n[3]}
N 1980 -3030 1980 -3010 {
lab=row_n[3]}
N 1980 -3270 1980 -3250 {
lab=row_n[3]}
N 1860 -3170 1870 -3180 {
lab=col_n[8]}
N 1870 -3180 2070 -3180 {
lab=col_n[8]}
N 2070 -3180 2080 -3170 {
lab=col_n[8]}
N 1860 -3150 1870 -3160 {
lab=colon_n[8]}
N 1870 -3160 2070 -3160 {
lab=colon_n[8]}
N 2070 -3160 2080 -3150 {
lab=colon_n[8]}
N 1860 -3130 1870 -3140 {
lab=#net17}
N 1870 -3140 2070 -3140 {
lab=#net17}
N 2070 -3140 2080 -3130 {
lab=#net17}
N 1860 -3110 1870 -3120 {
lab=#net18}
N 1870 -3120 2070 -3120 {
lab=#net18}
N 2070 -3120 2080 -3110 {
lab=#net18}
N 1920 -3270 1920 -3250 {
lab=vcom}
N 1960 -3270 1960 -3250 {
lab=ctop}
N 1840 -3170 1860 -3170 {
lab=col_n[8]}
N 1840 -3150 1860 -3150 {
lab=colon_n[8]}
N 1840 -3130 1860 -3130 {
lab=#net17}
N 1840 -3110 1860 -3110 {
lab=#net18}
N 2080 -3110 2100 -3110 {
lab=#net18}
N 2080 -3130 2100 -3130 {
lab=#net17}
N 2080 -3150 2100 -3150 {
lab=colon_n[8]}
N 2080 -3170 2100 -3170 {
lab=col_n[8]}
N 1900 -3030 1900 -3020 {
lab=VSS}
N 1900 -3260 1900 -3250 {
lab=VDD}
N 2240 -3030 2250 -3040 {
lab=row_n[4]}
N 2250 -3240 2250 -3040 {
lab=row_n[4]}
N 2240 -3250 2250 -3240 {
lab=row_n[4]}
N 2240 -3030 2240 -3010 {
lab=row_n[4]}
N 2240 -3270 2240 -3250 {
lab=row_n[4]}
N 2120 -3170 2130 -3180 {
lab=col_n[8]}
N 2130 -3180 2330 -3180 {
lab=col_n[8]}
N 2330 -3180 2340 -3170 {
lab=col_n[8]}
N 2120 -3150 2130 -3160 {
lab=colon_n[8]}
N 2130 -3160 2330 -3160 {
lab=colon_n[8]}
N 2330 -3160 2340 -3150 {
lab=colon_n[8]}
N 2120 -3130 2130 -3140 {
lab=#net17}
N 2130 -3140 2330 -3140 {
lab=#net17}
N 2330 -3140 2340 -3130 {
lab=#net17}
N 2120 -3110 2130 -3120 {
lab=#net18}
N 2130 -3120 2330 -3120 {
lab=#net18}
N 2330 -3120 2340 -3110 {
lab=#net18}
N 2180 -3270 2180 -3250 {
lab=vcom}
N 2220 -3270 2220 -3250 {
lab=ctop}
N 2100 -3170 2120 -3170 {
lab=col_n[8]}
N 2100 -3150 2120 -3150 {
lab=colon_n[8]}
N 2100 -3130 2120 -3130 {
lab=#net17}
N 2100 -3110 2120 -3110 {
lab=#net18}
N 2340 -3110 2360 -3110 {
lab=#net18}
N 2340 -3130 2360 -3130 {
lab=#net17}
N 2340 -3150 2360 -3150 {
lab=colon_n[8]}
N 2340 -3170 2360 -3170 {
lab=col_n[8]}
N 2160 -3030 2160 -3020 {
lab=VSS}
N 2160 -3260 2160 -3250 {
lab=VDD}
N 2500 -3030 2510 -3040 {
lab=row_n[5]}
N 2510 -3240 2510 -3040 {
lab=row_n[5]}
N 2500 -3250 2510 -3240 {
lab=row_n[5]}
N 2500 -3030 2500 -3010 {
lab=row_n[5]}
N 2500 -3270 2500 -3250 {
lab=row_n[5]}
N 2380 -3170 2390 -3180 {
lab=col_n[8]}
N 2390 -3180 2590 -3180 {
lab=col_n[8]}
N 2590 -3180 2600 -3170 {
lab=col_n[8]}
N 2380 -3150 2390 -3160 {
lab=colon_n[8]}
N 2390 -3160 2590 -3160 {
lab=colon_n[8]}
N 2590 -3160 2600 -3150 {
lab=colon_n[8]}
N 2380 -3130 2390 -3140 {
lab=#net17}
N 2390 -3140 2590 -3140 {
lab=#net17}
N 2590 -3140 2600 -3130 {
lab=#net17}
N 2380 -3110 2390 -3120 {
lab=#net18}
N 2390 -3120 2590 -3120 {
lab=#net18}
N 2590 -3120 2600 -3110 {
lab=#net18}
N 2440 -3270 2440 -3250 {
lab=vcom}
N 2480 -3270 2480 -3250 {
lab=ctop}
N 2360 -3170 2380 -3170 {
lab=col_n[8]}
N 2360 -3150 2380 -3150 {
lab=colon_n[8]}
N 2360 -3130 2380 -3130 {
lab=#net17}
N 2360 -3110 2380 -3110 {
lab=#net18}
N 2600 -3110 2620 -3110 {
lab=#net18}
N 2600 -3130 2620 -3130 {
lab=#net17}
N 2600 -3150 2620 -3150 {
lab=colon_n[8]}
N 2600 -3170 2620 -3170 {
lab=col_n[8]}
N 2420 -3030 2420 -3020 {
lab=VSS}
N 2420 -3260 2420 -3250 {
lab=VDD}
N 2760 -3030 2770 -3040 {
lab=row_n[6]}
N 2770 -3240 2770 -3040 {
lab=row_n[6]}
N 2760 -3250 2770 -3240 {
lab=row_n[6]}
N 2760 -3030 2760 -3010 {
lab=row_n[6]}
N 2760 -3270 2760 -3250 {
lab=row_n[6]}
N 2640 -3170 2650 -3180 {
lab=col_n[8]}
N 2650 -3180 2850 -3180 {
lab=col_n[8]}
N 2850 -3180 2860 -3170 {
lab=col_n[8]}
N 2640 -3150 2650 -3160 {
lab=colon_n[8]}
N 2650 -3160 2850 -3160 {
lab=colon_n[8]}
N 2850 -3160 2860 -3150 {
lab=colon_n[8]}
N 2640 -3130 2650 -3140 {
lab=#net17}
N 2650 -3140 2850 -3140 {
lab=#net17}
N 2850 -3140 2860 -3130 {
lab=#net17}
N 2640 -3110 2650 -3120 {
lab=#net18}
N 2650 -3120 2850 -3120 {
lab=#net18}
N 2850 -3120 2860 -3110 {
lab=#net18}
N 2700 -3270 2700 -3250 {
lab=vcom}
N 2740 -3270 2740 -3250 {
lab=ctop}
N 2620 -3170 2640 -3170 {
lab=col_n[8]}
N 2620 -3150 2640 -3150 {
lab=colon_n[8]}
N 2620 -3130 2640 -3130 {
lab=#net17}
N 2620 -3110 2640 -3110 {
lab=#net18}
N 2860 -3110 2880 -3110 {
lab=#net18}
N 2860 -3130 2880 -3130 {
lab=#net17}
N 2860 -3150 2880 -3150 {
lab=colon_n[8]}
N 2860 -3170 2880 -3170 {
lab=col_n[8]}
N 2680 -3030 2680 -3020 {
lab=VSS}
N 2680 -3260 2680 -3250 {
lab=VDD}
N 3020 -3030 3030 -3040 {
lab=row_n[7]}
N 3030 -3240 3030 -3040 {
lab=row_n[7]}
N 3020 -3250 3030 -3240 {
lab=row_n[7]}
N 3020 -3030 3020 -3010 {
lab=row_n[7]}
N 3020 -3270 3020 -3250 {
lab=row_n[7]}
N 2900 -3170 2910 -3180 {
lab=col_n[8]}
N 2910 -3180 3110 -3180 {
lab=col_n[8]}
N 3110 -3180 3120 -3170 {
lab=col_n[8]}
N 2900 -3150 2910 -3160 {
lab=colon_n[8]}
N 2910 -3160 3110 -3160 {
lab=colon_n[8]}
N 3110 -3160 3120 -3150 {
lab=colon_n[8]}
N 2900 -3130 2910 -3140 {
lab=#net17}
N 2910 -3140 3110 -3140 {
lab=#net17}
N 3110 -3140 3120 -3130 {
lab=#net17}
N 2900 -3110 2910 -3120 {
lab=#net18}
N 2910 -3120 3110 -3120 {
lab=#net18}
N 3110 -3120 3120 -3110 {
lab=#net18}
N 2960 -3270 2960 -3250 {
lab=vcom}
N 3000 -3270 3000 -3250 {
lab=ctop}
N 2880 -3170 2900 -3170 {
lab=col_n[8]}
N 2880 -3150 2900 -3150 {
lab=colon_n[8]}
N 2880 -3130 2900 -3130 {
lab=#net17}
N 2880 -3110 2900 -3110 {
lab=#net18}
N 3120 -3110 3140 -3110 {
lab=#net18}
N 3120 -3130 3140 -3130 {
lab=#net17}
N 3120 -3150 3140 -3150 {
lab=colon_n[8]}
N 3120 -3170 3140 -3170 {
lab=col_n[8]}
N 2940 -3030 2940 -3020 {
lab=VSS}
N 2940 -3260 2940 -3250 {
lab=VDD}
N 3280 -3030 3290 -3040 {
lab=row_n[8]}
N 3290 -3240 3290 -3040 {
lab=row_n[8]}
N 3280 -3250 3290 -3240 {
lab=row_n[8]}
N 3280 -3030 3280 -3010 {
lab=row_n[8]}
N 3280 -3270 3280 -3250 {
lab=row_n[8]}
N 3160 -3170 3170 -3180 {
lab=col_n[8]}
N 3170 -3180 3370 -3180 {
lab=col_n[8]}
N 3370 -3180 3380 -3170 {
lab=col_n[8]}
N 3160 -3150 3170 -3160 {
lab=colon_n[8]}
N 3170 -3160 3370 -3160 {
lab=colon_n[8]}
N 3370 -3160 3380 -3150 {
lab=colon_n[8]}
N 3160 -3130 3170 -3140 {
lab=#net17}
N 3170 -3140 3370 -3140 {
lab=#net17}
N 3370 -3140 3380 -3130 {
lab=#net17}
N 3160 -3110 3170 -3120 {
lab=#net18}
N 3170 -3120 3370 -3120 {
lab=#net18}
N 3370 -3120 3380 -3110 {
lab=#net18}
N 3220 -3270 3220 -3250 {
lab=vcom}
N 3260 -3270 3260 -3250 {
lab=ctop}
N 3140 -3170 3160 -3170 {
lab=col_n[8]}
N 3140 -3150 3160 -3150 {
lab=colon_n[8]}
N 3140 -3130 3160 -3130 {
lab=#net17}
N 3140 -3110 3160 -3110 {
lab=#net18}
N 3380 -3110 3400 -3110 {
lab=#net18}
N 3380 -3130 3400 -3130 {
lab=#net17}
N 3380 -3150 3400 -3150 {
lab=colon_n[8]}
N 3380 -3170 3400 -3170 {
lab=col_n[8]}
N 3200 -3030 3200 -3020 {
lab=VSS}
N 3200 -3260 3200 -3250 {
lab=VDD}
N 3540 -3030 3550 -3040 {
lab=row_n[9]}
N 3550 -3240 3550 -3040 {
lab=row_n[9]}
N 3540 -3250 3550 -3240 {
lab=row_n[9]}
N 3540 -3030 3540 -3010 {
lab=row_n[9]}
N 3540 -3270 3540 -3250 {
lab=row_n[9]}
N 3420 -3170 3430 -3180 {
lab=col_n[8]}
N 3430 -3180 3630 -3180 {
lab=col_n[8]}
N 3630 -3180 3640 -3170 {
lab=col_n[8]}
N 3420 -3150 3430 -3160 {
lab=colon_n[8]}
N 3430 -3160 3630 -3160 {
lab=colon_n[8]}
N 3630 -3160 3640 -3150 {
lab=colon_n[8]}
N 3420 -3130 3430 -3140 {
lab=#net17}
N 3430 -3140 3630 -3140 {
lab=#net17}
N 3630 -3140 3640 -3130 {
lab=#net17}
N 3420 -3110 3430 -3120 {
lab=#net18}
N 3430 -3120 3630 -3120 {
lab=#net18}
N 3630 -3120 3640 -3110 {
lab=#net18}
N 3480 -3270 3480 -3250 {
lab=vcom}
N 3520 -3270 3520 -3250 {
lab=ctop}
N 3400 -3170 3420 -3170 {
lab=col_n[8]}
N 3400 -3150 3420 -3150 {
lab=colon_n[8]}
N 3400 -3130 3420 -3130 {
lab=#net17}
N 3400 -3110 3420 -3110 {
lab=#net18}
N 3640 -3110 3660 -3110 {
lab=#net18}
N 3640 -3130 3660 -3130 {
lab=#net17}
N 3640 -3150 3660 -3150 {
lab=colon_n[8]}
N 3640 -3170 3660 -3170 {
lab=col_n[8]}
N 3460 -3030 3460 -3020 {
lab=VSS}
N 3460 -3260 3460 -3250 {
lab=VDD}
N 3800 -3030 3810 -3040 {
lab=row_n[10]}
N 3810 -3240 3810 -3040 {
lab=row_n[10]}
N 3800 -3250 3810 -3240 {
lab=row_n[10]}
N 3800 -3030 3800 -3010 {
lab=row_n[10]}
N 3800 -3270 3800 -3250 {
lab=row_n[10]}
N 3680 -3170 3690 -3180 {
lab=col_n[8]}
N 3690 -3180 3890 -3180 {
lab=col_n[8]}
N 3890 -3180 3900 -3170 {
lab=col_n[8]}
N 3680 -3150 3690 -3160 {
lab=colon_n[8]}
N 3690 -3160 3890 -3160 {
lab=colon_n[8]}
N 3890 -3160 3900 -3150 {
lab=colon_n[8]}
N 3680 -3130 3690 -3140 {
lab=#net17}
N 3690 -3140 3890 -3140 {
lab=#net17}
N 3890 -3140 3900 -3130 {
lab=#net17}
N 3680 -3110 3690 -3120 {
lab=#net18}
N 3690 -3120 3890 -3120 {
lab=#net18}
N 3890 -3120 3900 -3110 {
lab=#net18}
N 3740 -3270 3740 -3250 {
lab=vcom}
N 3780 -3270 3780 -3250 {
lab=ctop}
N 3660 -3170 3680 -3170 {
lab=col_n[8]}
N 3660 -3150 3680 -3150 {
lab=colon_n[8]}
N 3660 -3130 3680 -3130 {
lab=#net17}
N 3660 -3110 3680 -3110 {
lab=#net18}
N 3900 -3110 3920 -3110 {
lab=#net18}
N 3900 -3130 3920 -3130 {
lab=#net17}
N 3900 -3150 3920 -3150 {
lab=colon_n[8]}
N 3900 -3170 3920 -3170 {
lab=col_n[8]}
N 3720 -3030 3720 -3020 {
lab=VSS}
N 3720 -3260 3720 -3250 {
lab=VDD}
N 4060 -3030 4070 -3040 {
lab=row_n[11]}
N 4070 -3240 4070 -3040 {
lab=row_n[11]}
N 4060 -3250 4070 -3240 {
lab=row_n[11]}
N 4060 -3030 4060 -3010 {
lab=row_n[11]}
N 4060 -3270 4060 -3250 {
lab=row_n[11]}
N 3940 -3170 3950 -3180 {
lab=col_n[8]}
N 3950 -3180 4150 -3180 {
lab=col_n[8]}
N 4150 -3180 4160 -3170 {
lab=col_n[8]}
N 3940 -3150 3950 -3160 {
lab=colon_n[8]}
N 3950 -3160 4150 -3160 {
lab=colon_n[8]}
N 4150 -3160 4160 -3150 {
lab=colon_n[8]}
N 3940 -3130 3950 -3140 {
lab=#net17}
N 3950 -3140 4150 -3140 {
lab=#net17}
N 4150 -3140 4160 -3130 {
lab=#net17}
N 3940 -3110 3950 -3120 {
lab=#net18}
N 3950 -3120 4150 -3120 {
lab=#net18}
N 4150 -3120 4160 -3110 {
lab=#net18}
N 4000 -3270 4000 -3250 {
lab=vcom}
N 4040 -3270 4040 -3250 {
lab=ctop}
N 3920 -3170 3940 -3170 {
lab=col_n[8]}
N 3920 -3150 3940 -3150 {
lab=colon_n[8]}
N 3920 -3130 3940 -3130 {
lab=#net17}
N 3920 -3110 3940 -3110 {
lab=#net18}
N 4160 -3110 4180 -3110 {
lab=#net18}
N 4160 -3130 4180 -3130 {
lab=#net17}
N 4160 -3150 4180 -3150 {
lab=colon_n[8]}
N 4160 -3170 4180 -3170 {
lab=col_n[8]}
N 3980 -3030 3980 -3020 {
lab=VSS}
N 3980 -3260 3980 -3250 {
lab=VDD}
N 4320 -3030 4330 -3040 {
lab=row_n[12]}
N 4330 -3240 4330 -3040 {
lab=row_n[12]}
N 4320 -3250 4330 -3240 {
lab=row_n[12]}
N 4320 -3030 4320 -3010 {
lab=row_n[12]}
N 4320 -3270 4320 -3250 {
lab=row_n[12]}
N 4200 -3170 4210 -3180 {
lab=col_n[8]}
N 4210 -3180 4410 -3180 {
lab=col_n[8]}
N 4410 -3180 4420 -3170 {
lab=col_n[8]}
N 4200 -3150 4210 -3160 {
lab=colon_n[8]}
N 4210 -3160 4410 -3160 {
lab=colon_n[8]}
N 4410 -3160 4420 -3150 {
lab=colon_n[8]}
N 4200 -3130 4210 -3140 {
lab=#net17}
N 4210 -3140 4410 -3140 {
lab=#net17}
N 4410 -3140 4420 -3130 {
lab=#net17}
N 4200 -3110 4210 -3120 {
lab=#net18}
N 4210 -3120 4410 -3120 {
lab=#net18}
N 4410 -3120 4420 -3110 {
lab=#net18}
N 4260 -3270 4260 -3250 {
lab=vcom}
N 4300 -3270 4300 -3250 {
lab=ctop}
N 4180 -3170 4200 -3170 {
lab=col_n[8]}
N 4180 -3150 4200 -3150 {
lab=colon_n[8]}
N 4180 -3130 4200 -3130 {
lab=#net17}
N 4180 -3110 4200 -3110 {
lab=#net18}
N 4420 -3110 4440 -3110 {
lab=#net18}
N 4420 -3130 4440 -3130 {
lab=#net17}
N 4420 -3150 4440 -3150 {
lab=colon_n[8]}
N 4420 -3170 4440 -3170 {
lab=col_n[8]}
N 4240 -3030 4240 -3020 {
lab=VSS}
N 4240 -3260 4240 -3250 {
lab=VDD}
N 4580 -3030 4590 -3040 {
lab=row_n[13]}
N 4590 -3240 4590 -3040 {
lab=row_n[13]}
N 4580 -3250 4590 -3240 {
lab=row_n[13]}
N 4580 -3030 4580 -3010 {
lab=row_n[13]}
N 4580 -3270 4580 -3250 {
lab=row_n[13]}
N 4460 -3170 4470 -3180 {
lab=col_n[8]}
N 4470 -3180 4670 -3180 {
lab=col_n[8]}
N 4670 -3180 4680 -3170 {
lab=col_n[8]}
N 4460 -3150 4470 -3160 {
lab=colon_n[8]}
N 4470 -3160 4670 -3160 {
lab=colon_n[8]}
N 4670 -3160 4680 -3150 {
lab=colon_n[8]}
N 4460 -3130 4470 -3140 {
lab=#net17}
N 4470 -3140 4670 -3140 {
lab=#net17}
N 4670 -3140 4680 -3130 {
lab=#net17}
N 4460 -3110 4470 -3120 {
lab=#net18}
N 4470 -3120 4670 -3120 {
lab=#net18}
N 4670 -3120 4680 -3110 {
lab=#net18}
N 4520 -3270 4520 -3250 {
lab=vcom}
N 4560 -3270 4560 -3250 {
lab=ctop}
N 4440 -3170 4460 -3170 {
lab=col_n[8]}
N 4440 -3150 4460 -3150 {
lab=colon_n[8]}
N 4440 -3130 4460 -3130 {
lab=#net17}
N 4440 -3110 4460 -3110 {
lab=#net18}
N 4680 -3110 4700 -3110 {
lab=#net18}
N 4680 -3130 4700 -3130 {
lab=#net17}
N 4680 -3150 4700 -3150 {
lab=colon_n[8]}
N 4680 -3170 4700 -3170 {
lab=col_n[8]}
N 4500 -3030 4500 -3020 {
lab=VSS}
N 4500 -3260 4500 -3250 {
lab=VDD}
N 4840 -3030 4850 -3040 {
lab=row_n[14]}
N 4850 -3240 4850 -3040 {
lab=row_n[14]}
N 4840 -3250 4850 -3240 {
lab=row_n[14]}
N 4840 -3030 4840 -3010 {
lab=row_n[14]}
N 4840 -3270 4840 -3250 {
lab=row_n[14]}
N 4720 -3170 4730 -3180 {
lab=col_n[8]}
N 4730 -3180 4930 -3180 {
lab=col_n[8]}
N 4930 -3180 4940 -3170 {
lab=col_n[8]}
N 4720 -3150 4730 -3160 {
lab=colon_n[8]}
N 4730 -3160 4930 -3160 {
lab=colon_n[8]}
N 4930 -3160 4940 -3150 {
lab=colon_n[8]}
N 4720 -3130 4730 -3140 {
lab=#net17}
N 4730 -3140 4930 -3140 {
lab=#net17}
N 4930 -3140 4940 -3130 {
lab=#net17}
N 4720 -3110 4730 -3120 {
lab=#net18}
N 4730 -3120 4930 -3120 {
lab=#net18}
N 4930 -3120 4940 -3110 {
lab=#net18}
N 4780 -3270 4780 -3250 {
lab=vcom}
N 4820 -3270 4820 -3250 {
lab=ctop}
N 4700 -3170 4720 -3170 {
lab=col_n[8]}
N 4700 -3150 4720 -3150 {
lab=colon_n[8]}
N 4700 -3130 4720 -3130 {
lab=#net17}
N 4700 -3110 4720 -3110 {
lab=#net18}
N 4940 -3110 4960 -3110 {
lab=#net18}
N 4940 -3130 4960 -3130 {
lab=#net17}
N 4940 -3150 4960 -3150 {
lab=colon_n[8]}
N 4940 -3170 4960 -3170 {
lab=col_n[8]}
N 4760 -3030 4760 -3020 {
lab=VSS}
N 4760 -3260 4760 -3250 {
lab=VDD}
N 5100 -3030 5110 -3040 {
lab=row_n[15]}
N 5110 -3240 5110 -3040 {
lab=row_n[15]}
N 5100 -3250 5110 -3240 {
lab=row_n[15]}
N 5100 -3030 5100 -3010 {
lab=row_n[15]}
N 5100 -3270 5100 -3250 {
lab=row_n[15]}
N 4980 -3170 4990 -3180 {
lab=col_n[8]}
N 4990 -3180 5190 -3180 {
lab=col_n[8]}
N 5190 -3180 5200 -3170 {
lab=col_n[8]}
N 4980 -3150 4990 -3160 {
lab=colon_n[8]}
N 4990 -3160 5190 -3160 {
lab=colon_n[8]}
N 5190 -3160 5200 -3150 {
lab=colon_n[8]}
N 4980 -3130 4990 -3140 {
lab=#net17}
N 4990 -3140 5190 -3140 {
lab=#net17}
N 5190 -3140 5200 -3130 {
lab=#net17}
N 4980 -3110 4990 -3120 {
lab=#net18}
N 4990 -3120 5190 -3120 {
lab=#net18}
N 5190 -3120 5200 -3110 {
lab=#net18}
N 5040 -3270 5040 -3250 {
lab=vcom}
N 5080 -3270 5080 -3250 {
lab=ctop}
N 4960 -3170 4980 -3170 {
lab=col_n[8]}
N 4960 -3150 4980 -3150 {
lab=colon_n[8]}
N 4960 -3130 4980 -3130 {
lab=#net17}
N 4960 -3110 4980 -3110 {
lab=#net18}
N 5200 -3110 5220 -3110 {
lab=#net18}
N 5200 -3130 5220 -3130 {
lab=#net17}
N 5200 -3150 5220 -3150 {
lab=colon_n[8]}
N 5200 -3170 5220 -3170 {
lab=col_n[8]}
N 5020 -3030 5020 -3020 {
lab=VSS}
N 5020 -3260 5020 -3250 {
lab=VDD}
N 5360 -3030 5370 -3040 {
lab=row_n[16]}
N 5370 -3240 5370 -3040 {
lab=row_n[16]}
N 5360 -3250 5370 -3240 {
lab=row_n[16]}
N 5360 -3030 5360 -3010 {
lab=row_n[16]}
N 5360 -3270 5360 -3250 {
lab=row_n[16]}
N 5240 -3170 5250 -3180 {
lab=col_n[8]}
N 5250 -3180 5450 -3180 {
lab=col_n[8]}
N 5450 -3180 5460 -3170 {
lab=col_n[8]}
N 5240 -3150 5250 -3160 {
lab=colon_n[8]}
N 5250 -3160 5450 -3160 {
lab=colon_n[8]}
N 5450 -3160 5460 -3150 {
lab=colon_n[8]}
N 5240 -3130 5250 -3140 {
lab=#net17}
N 5250 -3140 5450 -3140 {
lab=#net17}
N 5450 -3140 5460 -3130 {
lab=#net17}
N 5240 -3110 5250 -3120 {
lab=#net18}
N 5250 -3120 5450 -3120 {
lab=#net18}
N 5450 -3120 5460 -3110 {
lab=#net18}
N 5300 -3270 5300 -3250 {
lab=vcom}
N 5340 -3270 5340 -3250 {
lab=ctop}
N 5220 -3170 5240 -3170 {
lab=col_n[8]}
N 5220 -3150 5240 -3150 {
lab=colon_n[8]}
N 5220 -3130 5240 -3130 {
lab=#net17}
N 5220 -3110 5240 -3110 {
lab=#net18}
N 5460 -3110 5480 -3110 {
lab=#net18}
N 5460 -3130 5480 -3130 {
lab=#net17}
N 5460 -3150 5480 -3150 {
lab=colon_n[8]}
N 5460 -3170 5480 -3170 {
lab=col_n[8]}
N 5280 -3030 5280 -3020 {
lab=VSS}
N 5280 -3260 5280 -3250 {
lab=VDD}
N 5620 -3030 5630 -3040 {
lab=row_n[17]}
N 5630 -3240 5630 -3040 {
lab=row_n[17]}
N 5620 -3250 5630 -3240 {
lab=row_n[17]}
N 5620 -3030 5620 -3010 {
lab=row_n[17]}
N 5620 -3270 5620 -3250 {
lab=row_n[17]}
N 5500 -3170 5510 -3180 {
lab=col_n[8]}
N 5510 -3180 5710 -3180 {
lab=col_n[8]}
N 5710 -3180 5720 -3170 {
lab=col_n[8]}
N 5500 -3150 5510 -3160 {
lab=colon_n[8]}
N 5510 -3160 5710 -3160 {
lab=colon_n[8]}
N 5710 -3160 5720 -3150 {
lab=colon_n[8]}
N 5500 -3130 5510 -3140 {
lab=#net17}
N 5510 -3140 5710 -3140 {
lab=#net17}
N 5710 -3140 5720 -3130 {
lab=#net17}
N 5500 -3110 5510 -3120 {
lab=#net18}
N 5510 -3120 5710 -3120 {
lab=#net18}
N 5710 -3120 5720 -3110 {
lab=#net18}
N 5560 -3270 5560 -3250 {
lab=vcom}
N 5600 -3270 5600 -3250 {
lab=ctop}
N 5480 -3170 5500 -3170 {
lab=col_n[8]}
N 5480 -3150 5500 -3150 {
lab=colon_n[8]}
N 5480 -3130 5500 -3130 {
lab=#net17}
N 5480 -3110 5500 -3110 {
lab=#net18}
N 5720 -3110 5740 -3110 {
lab=#net18}
N 5720 -3130 5740 -3130 {
lab=#net17}
N 5720 -3150 5740 -3150 {
lab=colon_n[8]}
N 5720 -3170 5740 -3170 {
lab=col_n[8]}
N 5540 -3030 5540 -3020 {
lab=VSS}
N 5540 -3260 5540 -3250 {
lab=VDD}
N 5880 -3030 5890 -3040 {
lab=row_n[18]}
N 5890 -3240 5890 -3040 {
lab=row_n[18]}
N 5880 -3250 5890 -3240 {
lab=row_n[18]}
N 5880 -3030 5880 -3010 {
lab=row_n[18]}
N 5880 -3270 5880 -3250 {
lab=row_n[18]}
N 5760 -3170 5770 -3180 {
lab=col_n[8]}
N 5770 -3180 5970 -3180 {
lab=col_n[8]}
N 5970 -3180 5980 -3170 {
lab=col_n[8]}
N 5760 -3150 5770 -3160 {
lab=colon_n[8]}
N 5770 -3160 5970 -3160 {
lab=colon_n[8]}
N 5970 -3160 5980 -3150 {
lab=colon_n[8]}
N 5760 -3130 5770 -3140 {
lab=#net17}
N 5770 -3140 5970 -3140 {
lab=#net17}
N 5970 -3140 5980 -3130 {
lab=#net17}
N 5760 -3110 5770 -3120 {
lab=#net18}
N 5770 -3120 5970 -3120 {
lab=#net18}
N 5970 -3120 5980 -3110 {
lab=#net18}
N 5820 -3270 5820 -3250 {
lab=vcom}
N 5860 -3270 5860 -3250 {
lab=ctop}
N 5740 -3170 5760 -3170 {
lab=col_n[8]}
N 5740 -3150 5760 -3150 {
lab=colon_n[8]}
N 5740 -3130 5760 -3130 {
lab=#net17}
N 5740 -3110 5760 -3110 {
lab=#net18}
N 5980 -3110 6000 -3110 {
lab=#net18}
N 5980 -3130 6000 -3130 {
lab=#net17}
N 5980 -3150 6000 -3150 {
lab=colon_n[8]}
N 5980 -3170 6000 -3170 {
lab=col_n[8]}
N 5800 -3030 5800 -3020 {
lab=VSS}
N 5800 -3260 5800 -3250 {
lab=VDD}
N 6140 -3030 6150 -3040 {
lab=row_n[19]}
N 6150 -3240 6150 -3040 {
lab=row_n[19]}
N 6140 -3250 6150 -3240 {
lab=row_n[19]}
N 6140 -3030 6140 -3010 {
lab=row_n[19]}
N 6140 -3270 6140 -3250 {
lab=row_n[19]}
N 6020 -3170 6030 -3180 {
lab=col_n[8]}
N 6030 -3180 6230 -3180 {
lab=col_n[8]}
N 6230 -3180 6240 -3170 {
lab=col_n[8]}
N 6020 -3150 6030 -3160 {
lab=colon_n[8]}
N 6030 -3160 6230 -3160 {
lab=colon_n[8]}
N 6230 -3160 6240 -3150 {
lab=colon_n[8]}
N 6020 -3130 6030 -3140 {
lab=#net17}
N 6030 -3140 6230 -3140 {
lab=#net17}
N 6230 -3140 6240 -3130 {
lab=#net17}
N 6020 -3110 6030 -3120 {
lab=#net18}
N 6030 -3120 6230 -3120 {
lab=#net18}
N 6230 -3120 6240 -3110 {
lab=#net18}
N 6080 -3270 6080 -3250 {
lab=vcom}
N 6120 -3270 6120 -3250 {
lab=ctop}
N 6000 -3170 6020 -3170 {
lab=col_n[8]}
N 6000 -3150 6020 -3150 {
lab=colon_n[8]}
N 6000 -3130 6020 -3130 {
lab=#net17}
N 6000 -3110 6020 -3110 {
lab=#net18}
N 6240 -3110 6260 -3110 {
lab=#net18}
N 6240 -3130 6260 -3130 {
lab=#net17}
N 6240 -3150 6260 -3150 {
lab=colon_n[8]}
N 6240 -3170 6260 -3170 {
lab=col_n[8]}
N 6060 -3030 6060 -3020 {
lab=VSS}
N 6060 -3260 6060 -3250 {
lab=VDD}
N 6400 -3030 6410 -3040 {
lab=row_n[20]}
N 6410 -3240 6410 -3040 {
lab=row_n[20]}
N 6400 -3250 6410 -3240 {
lab=row_n[20]}
N 6400 -3030 6400 -3010 {
lab=row_n[20]}
N 6400 -3270 6400 -3250 {
lab=row_n[20]}
N 6280 -3170 6290 -3180 {
lab=col_n[8]}
N 6290 -3180 6490 -3180 {
lab=col_n[8]}
N 6490 -3180 6500 -3170 {
lab=col_n[8]}
N 6280 -3150 6290 -3160 {
lab=colon_n[8]}
N 6290 -3160 6490 -3160 {
lab=colon_n[8]}
N 6490 -3160 6500 -3150 {
lab=colon_n[8]}
N 6280 -3130 6290 -3140 {
lab=#net17}
N 6290 -3140 6490 -3140 {
lab=#net17}
N 6490 -3140 6500 -3130 {
lab=#net17}
N 6280 -3110 6290 -3120 {
lab=#net18}
N 6290 -3120 6490 -3120 {
lab=#net18}
N 6490 -3120 6500 -3110 {
lab=#net18}
N 6340 -3270 6340 -3250 {
lab=vcom}
N 6380 -3270 6380 -3250 {
lab=ctop}
N 6260 -3170 6280 -3170 {
lab=col_n[8]}
N 6260 -3150 6280 -3150 {
lab=colon_n[8]}
N 6260 -3130 6280 -3130 {
lab=#net17}
N 6260 -3110 6280 -3110 {
lab=#net18}
N 6500 -3110 6520 -3110 {
lab=#net18}
N 6500 -3130 6520 -3130 {
lab=#net17}
N 6500 -3150 6520 -3150 {
lab=colon_n[8]}
N 6500 -3170 6520 -3170 {
lab=col_n[8]}
N 6320 -3030 6320 -3020 {
lab=VSS}
N 6320 -3260 6320 -3250 {
lab=VDD}
N 6660 -3030 6670 -3040 {
lab=row_n[21]}
N 6670 -3240 6670 -3040 {
lab=row_n[21]}
N 6660 -3250 6670 -3240 {
lab=row_n[21]}
N 6660 -3030 6660 -3010 {
lab=row_n[21]}
N 6660 -3270 6660 -3250 {
lab=row_n[21]}
N 6540 -3170 6550 -3180 {
lab=col_n[8]}
N 6550 -3180 6750 -3180 {
lab=col_n[8]}
N 6750 -3180 6760 -3170 {
lab=col_n[8]}
N 6540 -3150 6550 -3160 {
lab=colon_n[8]}
N 6550 -3160 6750 -3160 {
lab=colon_n[8]}
N 6750 -3160 6760 -3150 {
lab=colon_n[8]}
N 6540 -3130 6550 -3140 {
lab=#net17}
N 6550 -3140 6750 -3140 {
lab=#net17}
N 6750 -3140 6760 -3130 {
lab=#net17}
N 6540 -3110 6550 -3120 {
lab=#net18}
N 6550 -3120 6750 -3120 {
lab=#net18}
N 6750 -3120 6760 -3110 {
lab=#net18}
N 6600 -3270 6600 -3250 {
lab=vcom}
N 6640 -3270 6640 -3250 {
lab=ctop}
N 6520 -3170 6540 -3170 {
lab=col_n[8]}
N 6520 -3150 6540 -3150 {
lab=colon_n[8]}
N 6520 -3130 6540 -3130 {
lab=#net17}
N 6520 -3110 6540 -3110 {
lab=#net18}
N 6760 -3110 6780 -3110 {
lab=#net18}
N 6760 -3130 6780 -3130 {
lab=#net17}
N 6760 -3150 6780 -3150 {
lab=colon_n[8]}
N 6760 -3170 6780 -3170 {
lab=col_n[8]}
N 6580 -3030 6580 -3020 {
lab=VSS}
N 6580 -3260 6580 -3250 {
lab=VDD}
N 6920 -3030 6930 -3040 {
lab=row_n[22]}
N 6930 -3240 6930 -3040 {
lab=row_n[22]}
N 6920 -3250 6930 -3240 {
lab=row_n[22]}
N 6920 -3030 6920 -3010 {
lab=row_n[22]}
N 6920 -3270 6920 -3250 {
lab=row_n[22]}
N 6800 -3170 6810 -3180 {
lab=col_n[8]}
N 6810 -3180 7010 -3180 {
lab=col_n[8]}
N 7010 -3180 7020 -3170 {
lab=col_n[8]}
N 6800 -3150 6810 -3160 {
lab=colon_n[8]}
N 6810 -3160 7010 -3160 {
lab=colon_n[8]}
N 7010 -3160 7020 -3150 {
lab=colon_n[8]}
N 6800 -3130 6810 -3140 {
lab=#net17}
N 6810 -3140 7010 -3140 {
lab=#net17}
N 7010 -3140 7020 -3130 {
lab=#net17}
N 6800 -3110 6810 -3120 {
lab=#net18}
N 6810 -3120 7010 -3120 {
lab=#net18}
N 7010 -3120 7020 -3110 {
lab=#net18}
N 6860 -3270 6860 -3250 {
lab=vcom}
N 6900 -3270 6900 -3250 {
lab=ctop}
N 6780 -3170 6800 -3170 {
lab=col_n[8]}
N 6780 -3150 6800 -3150 {
lab=colon_n[8]}
N 6780 -3130 6800 -3130 {
lab=#net17}
N 6780 -3110 6800 -3110 {
lab=#net18}
N 7020 -3110 7040 -3110 {
lab=#net18}
N 7020 -3130 7040 -3130 {
lab=#net17}
N 7020 -3150 7040 -3150 {
lab=colon_n[8]}
N 7020 -3170 7040 -3170 {
lab=col_n[8]}
N 6840 -3030 6840 -3020 {
lab=VSS}
N 6840 -3260 6840 -3250 {
lab=VDD}
N 7180 -3030 7190 -3040 {
lab=row_n[23]}
N 7190 -3240 7190 -3040 {
lab=row_n[23]}
N 7180 -3250 7190 -3240 {
lab=row_n[23]}
N 7180 -3030 7180 -3010 {
lab=row_n[23]}
N 7180 -3270 7180 -3250 {
lab=row_n[23]}
N 7060 -3170 7070 -3180 {
lab=col_n[8]}
N 7070 -3180 7270 -3180 {
lab=col_n[8]}
N 7270 -3180 7280 -3170 {
lab=col_n[8]}
N 7060 -3150 7070 -3160 {
lab=colon_n[8]}
N 7070 -3160 7270 -3160 {
lab=colon_n[8]}
N 7270 -3160 7280 -3150 {
lab=colon_n[8]}
N 7060 -3130 7070 -3140 {
lab=#net17}
N 7070 -3140 7270 -3140 {
lab=#net17}
N 7270 -3140 7280 -3130 {
lab=#net17}
N 7060 -3110 7070 -3120 {
lab=#net18}
N 7070 -3120 7270 -3120 {
lab=#net18}
N 7270 -3120 7280 -3110 {
lab=#net18}
N 7120 -3270 7120 -3250 {
lab=vcom}
N 7160 -3270 7160 -3250 {
lab=ctop}
N 7040 -3170 7060 -3170 {
lab=col_n[8]}
N 7040 -3150 7060 -3150 {
lab=colon_n[8]}
N 7040 -3130 7060 -3130 {
lab=#net17}
N 7040 -3110 7060 -3110 {
lab=#net18}
N 7280 -3110 7300 -3110 {
lab=#net18}
N 7280 -3130 7300 -3130 {
lab=#net17}
N 7280 -3150 7300 -3150 {
lab=colon_n[8]}
N 7280 -3170 7300 -3170 {
lab=col_n[8]}
N 7100 -3030 7100 -3020 {
lab=VSS}
N 7100 -3260 7100 -3250 {
lab=VDD}
N 7440 -3030 7450 -3040 {
lab=row_n[24]}
N 7450 -3240 7450 -3040 {
lab=row_n[24]}
N 7440 -3250 7450 -3240 {
lab=row_n[24]}
N 7440 -3030 7440 -3010 {
lab=row_n[24]}
N 7440 -3270 7440 -3250 {
lab=row_n[24]}
N 7320 -3170 7330 -3180 {
lab=col_n[8]}
N 7330 -3180 7530 -3180 {
lab=col_n[8]}
N 7530 -3180 7540 -3170 {
lab=col_n[8]}
N 7320 -3150 7330 -3160 {
lab=colon_n[8]}
N 7330 -3160 7530 -3160 {
lab=colon_n[8]}
N 7530 -3160 7540 -3150 {
lab=colon_n[8]}
N 7320 -3130 7330 -3140 {
lab=#net17}
N 7330 -3140 7530 -3140 {
lab=#net17}
N 7530 -3140 7540 -3130 {
lab=#net17}
N 7320 -3110 7330 -3120 {
lab=#net18}
N 7330 -3120 7530 -3120 {
lab=#net18}
N 7530 -3120 7540 -3110 {
lab=#net18}
N 7380 -3270 7380 -3250 {
lab=vcom}
N 7420 -3270 7420 -3250 {
lab=ctop}
N 7300 -3170 7320 -3170 {
lab=col_n[8]}
N 7300 -3150 7320 -3150 {
lab=colon_n[8]}
N 7300 -3130 7320 -3130 {
lab=#net17}
N 7300 -3110 7320 -3110 {
lab=#net18}
N 7540 -3110 7560 -3110 {
lab=#net18}
N 7540 -3130 7560 -3130 {
lab=#net17}
N 7540 -3150 7560 -3150 {
lab=colon_n[8]}
N 7540 -3170 7560 -3170 {
lab=col_n[8]}
N 7360 -3030 7360 -3020 {
lab=VSS}
N 7360 -3260 7360 -3250 {
lab=VDD}
N 7700 -3030 7710 -3040 {
lab=row_n[25]}
N 7710 -3240 7710 -3040 {
lab=row_n[25]}
N 7700 -3250 7710 -3240 {
lab=row_n[25]}
N 7700 -3030 7700 -3010 {
lab=row_n[25]}
N 7700 -3270 7700 -3250 {
lab=row_n[25]}
N 7580 -3170 7590 -3180 {
lab=col_n[8]}
N 7590 -3180 7790 -3180 {
lab=col_n[8]}
N 7790 -3180 7800 -3170 {
lab=col_n[8]}
N 7580 -3150 7590 -3160 {
lab=colon_n[8]}
N 7590 -3160 7790 -3160 {
lab=colon_n[8]}
N 7790 -3160 7800 -3150 {
lab=colon_n[8]}
N 7580 -3130 7590 -3140 {
lab=#net17}
N 7590 -3140 7790 -3140 {
lab=#net17}
N 7790 -3140 7800 -3130 {
lab=#net17}
N 7580 -3110 7590 -3120 {
lab=#net18}
N 7590 -3120 7790 -3120 {
lab=#net18}
N 7790 -3120 7800 -3110 {
lab=#net18}
N 7640 -3270 7640 -3250 {
lab=vcom}
N 7680 -3270 7680 -3250 {
lab=ctop}
N 7560 -3170 7580 -3170 {
lab=col_n[8]}
N 7560 -3150 7580 -3150 {
lab=colon_n[8]}
N 7560 -3130 7580 -3130 {
lab=#net17}
N 7560 -3110 7580 -3110 {
lab=#net18}
N 7800 -3110 7820 -3110 {
lab=#net18}
N 7800 -3130 7820 -3130 {
lab=#net17}
N 7800 -3150 7820 -3150 {
lab=colon_n[8]}
N 7800 -3170 7820 -3170 {
lab=col_n[8]}
N 7620 -3030 7620 -3020 {
lab=VSS}
N 7620 -3260 7620 -3250 {
lab=VDD}
N 7960 -3030 7970 -3040 {
lab=row_n[26]}
N 7970 -3240 7970 -3040 {
lab=row_n[26]}
N 7960 -3250 7970 -3240 {
lab=row_n[26]}
N 7960 -3030 7960 -3010 {
lab=row_n[26]}
N 7960 -3270 7960 -3250 {
lab=row_n[26]}
N 7840 -3170 7850 -3180 {
lab=col_n[8]}
N 7850 -3180 8050 -3180 {
lab=col_n[8]}
N 8050 -3180 8060 -3170 {
lab=col_n[8]}
N 7840 -3150 7850 -3160 {
lab=colon_n[8]}
N 7850 -3160 8050 -3160 {
lab=colon_n[8]}
N 8050 -3160 8060 -3150 {
lab=colon_n[8]}
N 7840 -3130 7850 -3140 {
lab=#net17}
N 7850 -3140 8050 -3140 {
lab=#net17}
N 8050 -3140 8060 -3130 {
lab=#net17}
N 7840 -3110 7850 -3120 {
lab=#net18}
N 7850 -3120 8050 -3120 {
lab=#net18}
N 8050 -3120 8060 -3110 {
lab=#net18}
N 7900 -3270 7900 -3250 {
lab=vcom}
N 7940 -3270 7940 -3250 {
lab=ctop}
N 7820 -3170 7840 -3170 {
lab=col_n[8]}
N 7820 -3150 7840 -3150 {
lab=colon_n[8]}
N 7820 -3130 7840 -3130 {
lab=#net17}
N 7820 -3110 7840 -3110 {
lab=#net18}
N 8060 -3110 8080 -3110 {
lab=#net18}
N 8060 -3130 8080 -3130 {
lab=#net17}
N 8060 -3150 8080 -3150 {
lab=colon_n[8]}
N 8060 -3170 8080 -3170 {
lab=col_n[8]}
N 7880 -3030 7880 -3020 {
lab=VSS}
N 7880 -3260 7880 -3250 {
lab=VDD}
N 8220 -3030 8230 -3040 {
lab=row_n[27]}
N 8230 -3240 8230 -3040 {
lab=row_n[27]}
N 8220 -3250 8230 -3240 {
lab=row_n[27]}
N 8220 -3030 8220 -3010 {
lab=row_n[27]}
N 8220 -3270 8220 -3250 {
lab=row_n[27]}
N 8100 -3170 8110 -3180 {
lab=col_n[8]}
N 8110 -3180 8310 -3180 {
lab=col_n[8]}
N 8310 -3180 8320 -3170 {
lab=col_n[8]}
N 8100 -3150 8110 -3160 {
lab=colon_n[8]}
N 8110 -3160 8310 -3160 {
lab=colon_n[8]}
N 8310 -3160 8320 -3150 {
lab=colon_n[8]}
N 8100 -3130 8110 -3140 {
lab=#net17}
N 8110 -3140 8310 -3140 {
lab=#net17}
N 8310 -3140 8320 -3130 {
lab=#net17}
N 8100 -3110 8110 -3120 {
lab=#net18}
N 8110 -3120 8310 -3120 {
lab=#net18}
N 8310 -3120 8320 -3110 {
lab=#net18}
N 8160 -3270 8160 -3250 {
lab=vcom}
N 8200 -3270 8200 -3250 {
lab=ctop}
N 8080 -3170 8100 -3170 {
lab=col_n[8]}
N 8080 -3150 8100 -3150 {
lab=colon_n[8]}
N 8080 -3130 8100 -3130 {
lab=#net17}
N 8080 -3110 8100 -3110 {
lab=#net18}
N 8320 -3110 8340 -3110 {
lab=#net18}
N 8320 -3130 8340 -3130 {
lab=#net17}
N 8320 -3150 8340 -3150 {
lab=colon_n[8]}
N 8320 -3170 8340 -3170 {
lab=col_n[8]}
N 8140 -3030 8140 -3020 {
lab=VSS}
N 8140 -3260 8140 -3250 {
lab=VDD}
N 8480 -3030 8490 -3040 {
lab=row_n[28]}
N 8490 -3240 8490 -3040 {
lab=row_n[28]}
N 8480 -3250 8490 -3240 {
lab=row_n[28]}
N 8480 -3030 8480 -3010 {
lab=row_n[28]}
N 8480 -3270 8480 -3250 {
lab=row_n[28]}
N 8360 -3170 8370 -3180 {
lab=col_n[8]}
N 8370 -3180 8570 -3180 {
lab=col_n[8]}
N 8570 -3180 8580 -3170 {
lab=col_n[8]}
N 8360 -3150 8370 -3160 {
lab=colon_n[8]}
N 8370 -3160 8570 -3160 {
lab=colon_n[8]}
N 8570 -3160 8580 -3150 {
lab=colon_n[8]}
N 8360 -3130 8370 -3140 {
lab=#net17}
N 8370 -3140 8570 -3140 {
lab=#net17}
N 8570 -3140 8580 -3130 {
lab=#net17}
N 8360 -3110 8370 -3120 {
lab=#net18}
N 8370 -3120 8570 -3120 {
lab=#net18}
N 8570 -3120 8580 -3110 {
lab=#net18}
N 8420 -3270 8420 -3250 {
lab=vcom}
N 8460 -3270 8460 -3250 {
lab=ctop}
N 8340 -3170 8360 -3170 {
lab=col_n[8]}
N 8340 -3150 8360 -3150 {
lab=colon_n[8]}
N 8340 -3130 8360 -3130 {
lab=#net17}
N 8340 -3110 8360 -3110 {
lab=#net18}
N 8580 -3110 8600 -3110 {
lab=#net18}
N 8580 -3130 8600 -3130 {
lab=#net17}
N 8580 -3150 8600 -3150 {
lab=colon_n[8]}
N 8580 -3170 8600 -3170 {
lab=col_n[8]}
N 8400 -3030 8400 -3020 {
lab=VSS}
N 8400 -3260 8400 -3250 {
lab=VDD}
N 8740 -3030 8750 -3040 {
lab=row_n[29]}
N 8750 -3240 8750 -3040 {
lab=row_n[29]}
N 8740 -3250 8750 -3240 {
lab=row_n[29]}
N 8740 -3030 8740 -3010 {
lab=row_n[29]}
N 8740 -3270 8740 -3250 {
lab=row_n[29]}
N 8620 -3170 8630 -3180 {
lab=col_n[8]}
N 8630 -3180 8830 -3180 {
lab=col_n[8]}
N 8830 -3180 8840 -3170 {
lab=col_n[8]}
N 8620 -3150 8630 -3160 {
lab=colon_n[8]}
N 8630 -3160 8830 -3160 {
lab=colon_n[8]}
N 8830 -3160 8840 -3150 {
lab=colon_n[8]}
N 8620 -3130 8630 -3140 {
lab=#net17}
N 8630 -3140 8830 -3140 {
lab=#net17}
N 8830 -3140 8840 -3130 {
lab=#net17}
N 8620 -3110 8630 -3120 {
lab=#net18}
N 8630 -3120 8830 -3120 {
lab=#net18}
N 8830 -3120 8840 -3110 {
lab=#net18}
N 8680 -3270 8680 -3250 {
lab=vcom}
N 8720 -3270 8720 -3250 {
lab=ctop}
N 8600 -3170 8620 -3170 {
lab=col_n[8]}
N 8600 -3150 8620 -3150 {
lab=colon_n[8]}
N 8600 -3130 8620 -3130 {
lab=#net17}
N 8600 -3110 8620 -3110 {
lab=#net18}
N 8840 -3110 8860 -3110 {
lab=#net18}
N 8840 -3130 8860 -3130 {
lab=#net17}
N 8840 -3150 8860 -3150 {
lab=colon_n[8]}
N 8840 -3170 8860 -3170 {
lab=col_n[8]}
N 8660 -3030 8660 -3020 {
lab=VSS}
N 8660 -3260 8660 -3250 {
lab=VDD}
N 9000 -3030 9010 -3040 {
lab=row_n[30]}
N 9010 -3240 9010 -3040 {
lab=row_n[30]}
N 9000 -3250 9010 -3240 {
lab=row_n[30]}
N 9000 -3030 9000 -3010 {
lab=row_n[30]}
N 9000 -3270 9000 -3250 {
lab=row_n[30]}
N 8880 -3170 8890 -3180 {
lab=col_n[8]}
N 8890 -3180 9090 -3180 {
lab=col_n[8]}
N 9090 -3180 9100 -3170 {
lab=col_n[8]}
N 8880 -3150 8890 -3160 {
lab=colon_n[8]}
N 8890 -3160 9090 -3160 {
lab=colon_n[8]}
N 9090 -3160 9100 -3150 {
lab=colon_n[8]}
N 8880 -3130 8890 -3140 {
lab=#net17}
N 8890 -3140 9090 -3140 {
lab=#net17}
N 9090 -3140 9100 -3130 {
lab=#net17}
N 8880 -3110 8890 -3120 {
lab=#net18}
N 8890 -3120 9090 -3120 {
lab=#net18}
N 9090 -3120 9100 -3110 {
lab=#net18}
N 8940 -3270 8940 -3250 {
lab=vcom}
N 8980 -3270 8980 -3250 {
lab=ctop}
N 8860 -3170 8880 -3170 {
lab=col_n[8]}
N 8860 -3150 8880 -3150 {
lab=colon_n[8]}
N 8860 -3130 8880 -3130 {
lab=#net17}
N 8860 -3110 8880 -3110 {
lab=#net18}
N 9100 -3110 9120 -3110 {
lab=#net18}
N 9100 -3130 9120 -3130 {
lab=#net17}
N 9100 -3150 9120 -3150 {
lab=colon_n[8]}
N 9100 -3170 9120 -3170 {
lab=col_n[8]}
N 8920 -3030 8920 -3020 {
lab=VSS}
N 8920 -3260 8920 -3250 {
lab=VDD}
N 9260 -3030 9270 -3040 {
lab=row_n[31]}
N 9270 -3240 9270 -3040 {
lab=row_n[31]}
N 9260 -3250 9270 -3240 {
lab=row_n[31]}
N 9260 -3030 9260 -3010 {
lab=row_n[31]}
N 9260 -3270 9260 -3250 {
lab=row_n[31]}
N 9140 -3170 9150 -3180 {
lab=col_n[8]}
N 9150 -3180 9350 -3180 {
lab=col_n[8]}
N 9350 -3180 9360 -3170 {
lab=col_n[8]}
N 9140 -3150 9150 -3160 {
lab=colon_n[8]}
N 9150 -3160 9350 -3160 {
lab=colon_n[8]}
N 9350 -3160 9360 -3150 {
lab=colon_n[8]}
N 9140 -3130 9150 -3140 {
lab=#net17}
N 9150 -3140 9350 -3140 {
lab=#net17}
N 9350 -3140 9360 -3130 {
lab=#net17}
N 9140 -3110 9150 -3120 {
lab=#net18}
N 9150 -3120 9350 -3120 {
lab=#net18}
N 9350 -3120 9360 -3110 {
lab=#net18}
N 9200 -3270 9200 -3250 {
lab=vcom}
N 9240 -3270 9240 -3250 {
lab=ctop}
N 9120 -3170 9140 -3170 {
lab=col_n[8]}
N 9120 -3150 9140 -3150 {
lab=colon_n[8]}
N 9120 -3130 9140 -3130 {
lab=#net17}
N 9120 -3110 9140 -3110 {
lab=#net18}
N 9360 -3110 9380 -3110 {
lab=#net18}
N 9360 -3130 9380 -3130 {
lab=#net17}
N 9360 -3150 9380 -3150 {
lab=colon_n[8]}
N 9360 -3170 9380 -3170 {
lab=col_n[8]}
N 9180 -3030 9180 -3020 {
lab=VSS}
N 9180 -3260 9180 -3250 {
lab=VDD}
N 1200 -3290 1210 -3300 {
lab=row_n[0]}
N 1210 -3500 1210 -3300 {
lab=row_n[0]}
N 1200 -3510 1210 -3500 {
lab=row_n[0]}
N 1200 -3290 1200 -3270 {
lab=row_n[0]}
N 1200 -3530 1200 -3510 {
lab=row_n[0]}
N 1080 -3430 1090 -3440 {
lab=col_n[9]}
N 1090 -3440 1290 -3440 {
lab=col_n[9]}
N 1290 -3440 1300 -3430 {
lab=col_n[9]}
N 1080 -3410 1090 -3420 {
lab=colon_n[9]}
N 1090 -3420 1290 -3420 {
lab=colon_n[9]}
N 1290 -3420 1300 -3410 {
lab=colon_n[9]}
N 1080 -3390 1090 -3400 {
lab=#net19}
N 1090 -3400 1290 -3400 {
lab=#net19}
N 1290 -3400 1300 -3390 {
lab=#net19}
N 1080 -3370 1090 -3380 {
lab=#net20}
N 1090 -3380 1290 -3380 {
lab=#net20}
N 1290 -3380 1300 -3370 {
lab=#net20}
N 1140 -3530 1140 -3510 {
lab=vcom}
N 1180 -3530 1180 -3510 {
lab=ctop}
N 1060 -3430 1080 -3430 {
lab=col_n[9]}
N 1060 -3410 1080 -3410 {
lab=colon_n[9]}
N 1060 -3390 1080 -3390 {
lab=#net19}
N 1060 -3370 1080 -3370 {
lab=#net20}
N 1300 -3370 1320 -3370 {
lab=#net20}
N 1300 -3390 1320 -3390 {
lab=#net19}
N 1300 -3410 1320 -3410 {
lab=colon_n[9]}
N 1300 -3430 1320 -3430 {
lab=col_n[9]}
N 1120 -3290 1120 -3280 {
lab=VSS}
N 1120 -3520 1120 -3510 {
lab=VDD}
N 1460 -3290 1470 -3300 {
lab=row_n[1]}
N 1470 -3500 1470 -3300 {
lab=row_n[1]}
N 1460 -3510 1470 -3500 {
lab=row_n[1]}
N 1460 -3290 1460 -3270 {
lab=row_n[1]}
N 1460 -3530 1460 -3510 {
lab=row_n[1]}
N 1340 -3430 1350 -3440 {
lab=col_n[9]}
N 1350 -3440 1550 -3440 {
lab=col_n[9]}
N 1550 -3440 1560 -3430 {
lab=col_n[9]}
N 1340 -3410 1350 -3420 {
lab=colon_n[9]}
N 1350 -3420 1550 -3420 {
lab=colon_n[9]}
N 1550 -3420 1560 -3410 {
lab=colon_n[9]}
N 1340 -3390 1350 -3400 {
lab=#net19}
N 1350 -3400 1550 -3400 {
lab=#net19}
N 1550 -3400 1560 -3390 {
lab=#net19}
N 1340 -3370 1350 -3380 {
lab=#net20}
N 1350 -3380 1550 -3380 {
lab=#net20}
N 1550 -3380 1560 -3370 {
lab=#net20}
N 1400 -3530 1400 -3510 {
lab=vcom}
N 1440 -3530 1440 -3510 {
lab=ctop}
N 1320 -3430 1340 -3430 {
lab=col_n[9]}
N 1320 -3410 1340 -3410 {
lab=colon_n[9]}
N 1320 -3390 1340 -3390 {
lab=#net19}
N 1320 -3370 1340 -3370 {
lab=#net20}
N 1560 -3370 1580 -3370 {
lab=#net20}
N 1560 -3390 1580 -3390 {
lab=#net19}
N 1560 -3410 1580 -3410 {
lab=colon_n[9]}
N 1560 -3430 1580 -3430 {
lab=col_n[9]}
N 1380 -3290 1380 -3280 {
lab=VSS}
N 1380 -3520 1380 -3510 {
lab=VDD}
N 1720 -3290 1730 -3300 {
lab=row_n[2]}
N 1730 -3500 1730 -3300 {
lab=row_n[2]}
N 1720 -3510 1730 -3500 {
lab=row_n[2]}
N 1720 -3290 1720 -3270 {
lab=row_n[2]}
N 1720 -3530 1720 -3510 {
lab=row_n[2]}
N 1600 -3430 1610 -3440 {
lab=col_n[9]}
N 1610 -3440 1810 -3440 {
lab=col_n[9]}
N 1810 -3440 1820 -3430 {
lab=col_n[9]}
N 1600 -3410 1610 -3420 {
lab=colon_n[9]}
N 1610 -3420 1810 -3420 {
lab=colon_n[9]}
N 1810 -3420 1820 -3410 {
lab=colon_n[9]}
N 1600 -3390 1610 -3400 {
lab=#net19}
N 1610 -3400 1810 -3400 {
lab=#net19}
N 1810 -3400 1820 -3390 {
lab=#net19}
N 1600 -3370 1610 -3380 {
lab=#net20}
N 1610 -3380 1810 -3380 {
lab=#net20}
N 1810 -3380 1820 -3370 {
lab=#net20}
N 1660 -3530 1660 -3510 {
lab=vcom}
N 1700 -3530 1700 -3510 {
lab=ctop}
N 1580 -3430 1600 -3430 {
lab=col_n[9]}
N 1580 -3410 1600 -3410 {
lab=colon_n[9]}
N 1580 -3390 1600 -3390 {
lab=#net19}
N 1580 -3370 1600 -3370 {
lab=#net20}
N 1820 -3370 1840 -3370 {
lab=#net20}
N 1820 -3390 1840 -3390 {
lab=#net19}
N 1820 -3410 1840 -3410 {
lab=colon_n[9]}
N 1820 -3430 1840 -3430 {
lab=col_n[9]}
N 1640 -3290 1640 -3280 {
lab=VSS}
N 1640 -3520 1640 -3510 {
lab=VDD}
N 1980 -3290 1990 -3300 {
lab=row_n[3]}
N 1990 -3500 1990 -3300 {
lab=row_n[3]}
N 1980 -3510 1990 -3500 {
lab=row_n[3]}
N 1980 -3290 1980 -3270 {
lab=row_n[3]}
N 1980 -3530 1980 -3510 {
lab=row_n[3]}
N 1860 -3430 1870 -3440 {
lab=col_n[9]}
N 1870 -3440 2070 -3440 {
lab=col_n[9]}
N 2070 -3440 2080 -3430 {
lab=col_n[9]}
N 1860 -3410 1870 -3420 {
lab=colon_n[9]}
N 1870 -3420 2070 -3420 {
lab=colon_n[9]}
N 2070 -3420 2080 -3410 {
lab=colon_n[9]}
N 1860 -3390 1870 -3400 {
lab=#net19}
N 1870 -3400 2070 -3400 {
lab=#net19}
N 2070 -3400 2080 -3390 {
lab=#net19}
N 1860 -3370 1870 -3380 {
lab=#net20}
N 1870 -3380 2070 -3380 {
lab=#net20}
N 2070 -3380 2080 -3370 {
lab=#net20}
N 1920 -3530 1920 -3510 {
lab=vcom}
N 1960 -3530 1960 -3510 {
lab=ctop}
N 1840 -3430 1860 -3430 {
lab=col_n[9]}
N 1840 -3410 1860 -3410 {
lab=colon_n[9]}
N 1840 -3390 1860 -3390 {
lab=#net19}
N 1840 -3370 1860 -3370 {
lab=#net20}
N 2080 -3370 2100 -3370 {
lab=#net20}
N 2080 -3390 2100 -3390 {
lab=#net19}
N 2080 -3410 2100 -3410 {
lab=colon_n[9]}
N 2080 -3430 2100 -3430 {
lab=col_n[9]}
N 1900 -3290 1900 -3280 {
lab=VSS}
N 1900 -3520 1900 -3510 {
lab=VDD}
N 2240 -3290 2250 -3300 {
lab=row_n[4]}
N 2250 -3500 2250 -3300 {
lab=row_n[4]}
N 2240 -3510 2250 -3500 {
lab=row_n[4]}
N 2240 -3290 2240 -3270 {
lab=row_n[4]}
N 2240 -3530 2240 -3510 {
lab=row_n[4]}
N 2120 -3430 2130 -3440 {
lab=col_n[9]}
N 2130 -3440 2330 -3440 {
lab=col_n[9]}
N 2330 -3440 2340 -3430 {
lab=col_n[9]}
N 2120 -3410 2130 -3420 {
lab=colon_n[9]}
N 2130 -3420 2330 -3420 {
lab=colon_n[9]}
N 2330 -3420 2340 -3410 {
lab=colon_n[9]}
N 2120 -3390 2130 -3400 {
lab=#net19}
N 2130 -3400 2330 -3400 {
lab=#net19}
N 2330 -3400 2340 -3390 {
lab=#net19}
N 2120 -3370 2130 -3380 {
lab=#net20}
N 2130 -3380 2330 -3380 {
lab=#net20}
N 2330 -3380 2340 -3370 {
lab=#net20}
N 2180 -3530 2180 -3510 {
lab=vcom}
N 2220 -3530 2220 -3510 {
lab=ctop}
N 2100 -3430 2120 -3430 {
lab=col_n[9]}
N 2100 -3410 2120 -3410 {
lab=colon_n[9]}
N 2100 -3390 2120 -3390 {
lab=#net19}
N 2100 -3370 2120 -3370 {
lab=#net20}
N 2340 -3370 2360 -3370 {
lab=#net20}
N 2340 -3390 2360 -3390 {
lab=#net19}
N 2340 -3410 2360 -3410 {
lab=colon_n[9]}
N 2340 -3430 2360 -3430 {
lab=col_n[9]}
N 2160 -3290 2160 -3280 {
lab=VSS}
N 2160 -3520 2160 -3510 {
lab=VDD}
N 2500 -3290 2510 -3300 {
lab=row_n[5]}
N 2510 -3500 2510 -3300 {
lab=row_n[5]}
N 2500 -3510 2510 -3500 {
lab=row_n[5]}
N 2500 -3290 2500 -3270 {
lab=row_n[5]}
N 2500 -3530 2500 -3510 {
lab=row_n[5]}
N 2380 -3430 2390 -3440 {
lab=col_n[9]}
N 2390 -3440 2590 -3440 {
lab=col_n[9]}
N 2590 -3440 2600 -3430 {
lab=col_n[9]}
N 2380 -3410 2390 -3420 {
lab=colon_n[9]}
N 2390 -3420 2590 -3420 {
lab=colon_n[9]}
N 2590 -3420 2600 -3410 {
lab=colon_n[9]}
N 2380 -3390 2390 -3400 {
lab=#net19}
N 2390 -3400 2590 -3400 {
lab=#net19}
N 2590 -3400 2600 -3390 {
lab=#net19}
N 2380 -3370 2390 -3380 {
lab=#net20}
N 2390 -3380 2590 -3380 {
lab=#net20}
N 2590 -3380 2600 -3370 {
lab=#net20}
N 2440 -3530 2440 -3510 {
lab=vcom}
N 2480 -3530 2480 -3510 {
lab=ctop}
N 2360 -3430 2380 -3430 {
lab=col_n[9]}
N 2360 -3410 2380 -3410 {
lab=colon_n[9]}
N 2360 -3390 2380 -3390 {
lab=#net19}
N 2360 -3370 2380 -3370 {
lab=#net20}
N 2600 -3370 2620 -3370 {
lab=#net20}
N 2600 -3390 2620 -3390 {
lab=#net19}
N 2600 -3410 2620 -3410 {
lab=colon_n[9]}
N 2600 -3430 2620 -3430 {
lab=col_n[9]}
N 2420 -3290 2420 -3280 {
lab=VSS}
N 2420 -3520 2420 -3510 {
lab=VDD}
N 2760 -3290 2770 -3300 {
lab=row_n[6]}
N 2770 -3500 2770 -3300 {
lab=row_n[6]}
N 2760 -3510 2770 -3500 {
lab=row_n[6]}
N 2760 -3290 2760 -3270 {
lab=row_n[6]}
N 2760 -3530 2760 -3510 {
lab=row_n[6]}
N 2640 -3430 2650 -3440 {
lab=col_n[9]}
N 2650 -3440 2850 -3440 {
lab=col_n[9]}
N 2850 -3440 2860 -3430 {
lab=col_n[9]}
N 2640 -3410 2650 -3420 {
lab=colon_n[9]}
N 2650 -3420 2850 -3420 {
lab=colon_n[9]}
N 2850 -3420 2860 -3410 {
lab=colon_n[9]}
N 2640 -3390 2650 -3400 {
lab=#net19}
N 2650 -3400 2850 -3400 {
lab=#net19}
N 2850 -3400 2860 -3390 {
lab=#net19}
N 2640 -3370 2650 -3380 {
lab=#net20}
N 2650 -3380 2850 -3380 {
lab=#net20}
N 2850 -3380 2860 -3370 {
lab=#net20}
N 2700 -3530 2700 -3510 {
lab=vcom}
N 2740 -3530 2740 -3510 {
lab=ctop}
N 2620 -3430 2640 -3430 {
lab=col_n[9]}
N 2620 -3410 2640 -3410 {
lab=colon_n[9]}
N 2620 -3390 2640 -3390 {
lab=#net19}
N 2620 -3370 2640 -3370 {
lab=#net20}
N 2860 -3370 2880 -3370 {
lab=#net20}
N 2860 -3390 2880 -3390 {
lab=#net19}
N 2860 -3410 2880 -3410 {
lab=colon_n[9]}
N 2860 -3430 2880 -3430 {
lab=col_n[9]}
N 2680 -3290 2680 -3280 {
lab=VSS}
N 2680 -3520 2680 -3510 {
lab=VDD}
N 3020 -3290 3030 -3300 {
lab=row_n[7]}
N 3030 -3500 3030 -3300 {
lab=row_n[7]}
N 3020 -3510 3030 -3500 {
lab=row_n[7]}
N 3020 -3290 3020 -3270 {
lab=row_n[7]}
N 3020 -3530 3020 -3510 {
lab=row_n[7]}
N 2900 -3430 2910 -3440 {
lab=col_n[9]}
N 2910 -3440 3110 -3440 {
lab=col_n[9]}
N 3110 -3440 3120 -3430 {
lab=col_n[9]}
N 2900 -3410 2910 -3420 {
lab=colon_n[9]}
N 2910 -3420 3110 -3420 {
lab=colon_n[9]}
N 3110 -3420 3120 -3410 {
lab=colon_n[9]}
N 2900 -3390 2910 -3400 {
lab=#net19}
N 2910 -3400 3110 -3400 {
lab=#net19}
N 3110 -3400 3120 -3390 {
lab=#net19}
N 2900 -3370 2910 -3380 {
lab=#net20}
N 2910 -3380 3110 -3380 {
lab=#net20}
N 3110 -3380 3120 -3370 {
lab=#net20}
N 2960 -3530 2960 -3510 {
lab=vcom}
N 3000 -3530 3000 -3510 {
lab=ctop}
N 2880 -3430 2900 -3430 {
lab=col_n[9]}
N 2880 -3410 2900 -3410 {
lab=colon_n[9]}
N 2880 -3390 2900 -3390 {
lab=#net19}
N 2880 -3370 2900 -3370 {
lab=#net20}
N 3120 -3370 3140 -3370 {
lab=#net20}
N 3120 -3390 3140 -3390 {
lab=#net19}
N 3120 -3410 3140 -3410 {
lab=colon_n[9]}
N 3120 -3430 3140 -3430 {
lab=col_n[9]}
N 2940 -3290 2940 -3280 {
lab=VSS}
N 2940 -3520 2940 -3510 {
lab=VDD}
N 3280 -3290 3290 -3300 {
lab=row_n[8]}
N 3290 -3500 3290 -3300 {
lab=row_n[8]}
N 3280 -3510 3290 -3500 {
lab=row_n[8]}
N 3280 -3290 3280 -3270 {
lab=row_n[8]}
N 3280 -3530 3280 -3510 {
lab=row_n[8]}
N 3160 -3430 3170 -3440 {
lab=col_n[9]}
N 3170 -3440 3370 -3440 {
lab=col_n[9]}
N 3370 -3440 3380 -3430 {
lab=col_n[9]}
N 3160 -3410 3170 -3420 {
lab=colon_n[9]}
N 3170 -3420 3370 -3420 {
lab=colon_n[9]}
N 3370 -3420 3380 -3410 {
lab=colon_n[9]}
N 3160 -3390 3170 -3400 {
lab=#net19}
N 3170 -3400 3370 -3400 {
lab=#net19}
N 3370 -3400 3380 -3390 {
lab=#net19}
N 3160 -3370 3170 -3380 {
lab=#net20}
N 3170 -3380 3370 -3380 {
lab=#net20}
N 3370 -3380 3380 -3370 {
lab=#net20}
N 3220 -3530 3220 -3510 {
lab=vcom}
N 3260 -3530 3260 -3510 {
lab=ctop}
N 3140 -3430 3160 -3430 {
lab=col_n[9]}
N 3140 -3410 3160 -3410 {
lab=colon_n[9]}
N 3140 -3390 3160 -3390 {
lab=#net19}
N 3140 -3370 3160 -3370 {
lab=#net20}
N 3380 -3370 3400 -3370 {
lab=#net20}
N 3380 -3390 3400 -3390 {
lab=#net19}
N 3380 -3410 3400 -3410 {
lab=colon_n[9]}
N 3380 -3430 3400 -3430 {
lab=col_n[9]}
N 3200 -3290 3200 -3280 {
lab=VSS}
N 3200 -3520 3200 -3510 {
lab=VDD}
N 3540 -3290 3550 -3300 {
lab=row_n[9]}
N 3550 -3500 3550 -3300 {
lab=row_n[9]}
N 3540 -3510 3550 -3500 {
lab=row_n[9]}
N 3540 -3290 3540 -3270 {
lab=row_n[9]}
N 3540 -3530 3540 -3510 {
lab=row_n[9]}
N 3420 -3430 3430 -3440 {
lab=col_n[9]}
N 3430 -3440 3630 -3440 {
lab=col_n[9]}
N 3630 -3440 3640 -3430 {
lab=col_n[9]}
N 3420 -3410 3430 -3420 {
lab=colon_n[9]}
N 3430 -3420 3630 -3420 {
lab=colon_n[9]}
N 3630 -3420 3640 -3410 {
lab=colon_n[9]}
N 3420 -3390 3430 -3400 {
lab=#net19}
N 3430 -3400 3630 -3400 {
lab=#net19}
N 3630 -3400 3640 -3390 {
lab=#net19}
N 3420 -3370 3430 -3380 {
lab=#net20}
N 3430 -3380 3630 -3380 {
lab=#net20}
N 3630 -3380 3640 -3370 {
lab=#net20}
N 3480 -3530 3480 -3510 {
lab=vcom}
N 3520 -3530 3520 -3510 {
lab=ctop}
N 3400 -3430 3420 -3430 {
lab=col_n[9]}
N 3400 -3410 3420 -3410 {
lab=colon_n[9]}
N 3400 -3390 3420 -3390 {
lab=#net19}
N 3400 -3370 3420 -3370 {
lab=#net20}
N 3640 -3370 3660 -3370 {
lab=#net20}
N 3640 -3390 3660 -3390 {
lab=#net19}
N 3640 -3410 3660 -3410 {
lab=colon_n[9]}
N 3640 -3430 3660 -3430 {
lab=col_n[9]}
N 3460 -3290 3460 -3280 {
lab=VSS}
N 3460 -3520 3460 -3510 {
lab=VDD}
N 3800 -3290 3810 -3300 {
lab=row_n[10]}
N 3810 -3500 3810 -3300 {
lab=row_n[10]}
N 3800 -3510 3810 -3500 {
lab=row_n[10]}
N 3800 -3290 3800 -3270 {
lab=row_n[10]}
N 3800 -3530 3800 -3510 {
lab=row_n[10]}
N 3680 -3430 3690 -3440 {
lab=col_n[9]}
N 3690 -3440 3890 -3440 {
lab=col_n[9]}
N 3890 -3440 3900 -3430 {
lab=col_n[9]}
N 3680 -3410 3690 -3420 {
lab=colon_n[9]}
N 3690 -3420 3890 -3420 {
lab=colon_n[9]}
N 3890 -3420 3900 -3410 {
lab=colon_n[9]}
N 3680 -3390 3690 -3400 {
lab=#net19}
N 3690 -3400 3890 -3400 {
lab=#net19}
N 3890 -3400 3900 -3390 {
lab=#net19}
N 3680 -3370 3690 -3380 {
lab=#net20}
N 3690 -3380 3890 -3380 {
lab=#net20}
N 3890 -3380 3900 -3370 {
lab=#net20}
N 3740 -3530 3740 -3510 {
lab=vcom}
N 3780 -3530 3780 -3510 {
lab=ctop}
N 3660 -3430 3680 -3430 {
lab=col_n[9]}
N 3660 -3410 3680 -3410 {
lab=colon_n[9]}
N 3660 -3390 3680 -3390 {
lab=#net19}
N 3660 -3370 3680 -3370 {
lab=#net20}
N 3900 -3370 3920 -3370 {
lab=#net20}
N 3900 -3390 3920 -3390 {
lab=#net19}
N 3900 -3410 3920 -3410 {
lab=colon_n[9]}
N 3900 -3430 3920 -3430 {
lab=col_n[9]}
N 3720 -3290 3720 -3280 {
lab=VSS}
N 3720 -3520 3720 -3510 {
lab=VDD}
N 4060 -3290 4070 -3300 {
lab=row_n[11]}
N 4070 -3500 4070 -3300 {
lab=row_n[11]}
N 4060 -3510 4070 -3500 {
lab=row_n[11]}
N 4060 -3290 4060 -3270 {
lab=row_n[11]}
N 4060 -3530 4060 -3510 {
lab=row_n[11]}
N 3940 -3430 3950 -3440 {
lab=col_n[9]}
N 3950 -3440 4150 -3440 {
lab=col_n[9]}
N 4150 -3440 4160 -3430 {
lab=col_n[9]}
N 3940 -3410 3950 -3420 {
lab=colon_n[9]}
N 3950 -3420 4150 -3420 {
lab=colon_n[9]}
N 4150 -3420 4160 -3410 {
lab=colon_n[9]}
N 3940 -3390 3950 -3400 {
lab=#net19}
N 3950 -3400 4150 -3400 {
lab=#net19}
N 4150 -3400 4160 -3390 {
lab=#net19}
N 3940 -3370 3950 -3380 {
lab=#net20}
N 3950 -3380 4150 -3380 {
lab=#net20}
N 4150 -3380 4160 -3370 {
lab=#net20}
N 4000 -3530 4000 -3510 {
lab=vcom}
N 4040 -3530 4040 -3510 {
lab=ctop}
N 3920 -3430 3940 -3430 {
lab=col_n[9]}
N 3920 -3410 3940 -3410 {
lab=colon_n[9]}
N 3920 -3390 3940 -3390 {
lab=#net19}
N 3920 -3370 3940 -3370 {
lab=#net20}
N 4160 -3370 4180 -3370 {
lab=#net20}
N 4160 -3390 4180 -3390 {
lab=#net19}
N 4160 -3410 4180 -3410 {
lab=colon_n[9]}
N 4160 -3430 4180 -3430 {
lab=col_n[9]}
N 3980 -3290 3980 -3280 {
lab=VSS}
N 3980 -3520 3980 -3510 {
lab=VDD}
N 4320 -3290 4330 -3300 {
lab=row_n[12]}
N 4330 -3500 4330 -3300 {
lab=row_n[12]}
N 4320 -3510 4330 -3500 {
lab=row_n[12]}
N 4320 -3290 4320 -3270 {
lab=row_n[12]}
N 4320 -3530 4320 -3510 {
lab=row_n[12]}
N 4200 -3430 4210 -3440 {
lab=col_n[9]}
N 4210 -3440 4410 -3440 {
lab=col_n[9]}
N 4410 -3440 4420 -3430 {
lab=col_n[9]}
N 4200 -3410 4210 -3420 {
lab=colon_n[9]}
N 4210 -3420 4410 -3420 {
lab=colon_n[9]}
N 4410 -3420 4420 -3410 {
lab=colon_n[9]}
N 4200 -3390 4210 -3400 {
lab=#net19}
N 4210 -3400 4410 -3400 {
lab=#net19}
N 4410 -3400 4420 -3390 {
lab=#net19}
N 4200 -3370 4210 -3380 {
lab=#net20}
N 4210 -3380 4410 -3380 {
lab=#net20}
N 4410 -3380 4420 -3370 {
lab=#net20}
N 4260 -3530 4260 -3510 {
lab=vcom}
N 4300 -3530 4300 -3510 {
lab=ctop}
N 4180 -3430 4200 -3430 {
lab=col_n[9]}
N 4180 -3410 4200 -3410 {
lab=colon_n[9]}
N 4180 -3390 4200 -3390 {
lab=#net19}
N 4180 -3370 4200 -3370 {
lab=#net20}
N 4420 -3370 4440 -3370 {
lab=#net20}
N 4420 -3390 4440 -3390 {
lab=#net19}
N 4420 -3410 4440 -3410 {
lab=colon_n[9]}
N 4420 -3430 4440 -3430 {
lab=col_n[9]}
N 4240 -3290 4240 -3280 {
lab=VSS}
N 4240 -3520 4240 -3510 {
lab=VDD}
N 4580 -3290 4590 -3300 {
lab=row_n[13]}
N 4590 -3500 4590 -3300 {
lab=row_n[13]}
N 4580 -3510 4590 -3500 {
lab=row_n[13]}
N 4580 -3290 4580 -3270 {
lab=row_n[13]}
N 4580 -3530 4580 -3510 {
lab=row_n[13]}
N 4460 -3430 4470 -3440 {
lab=col_n[9]}
N 4470 -3440 4670 -3440 {
lab=col_n[9]}
N 4670 -3440 4680 -3430 {
lab=col_n[9]}
N 4460 -3410 4470 -3420 {
lab=colon_n[9]}
N 4470 -3420 4670 -3420 {
lab=colon_n[9]}
N 4670 -3420 4680 -3410 {
lab=colon_n[9]}
N 4460 -3390 4470 -3400 {
lab=#net19}
N 4470 -3400 4670 -3400 {
lab=#net19}
N 4670 -3400 4680 -3390 {
lab=#net19}
N 4460 -3370 4470 -3380 {
lab=#net20}
N 4470 -3380 4670 -3380 {
lab=#net20}
N 4670 -3380 4680 -3370 {
lab=#net20}
N 4520 -3530 4520 -3510 {
lab=vcom}
N 4560 -3530 4560 -3510 {
lab=ctop}
N 4440 -3430 4460 -3430 {
lab=col_n[9]}
N 4440 -3410 4460 -3410 {
lab=colon_n[9]}
N 4440 -3390 4460 -3390 {
lab=#net19}
N 4440 -3370 4460 -3370 {
lab=#net20}
N 4680 -3370 4700 -3370 {
lab=#net20}
N 4680 -3390 4700 -3390 {
lab=#net19}
N 4680 -3410 4700 -3410 {
lab=colon_n[9]}
N 4680 -3430 4700 -3430 {
lab=col_n[9]}
N 4500 -3290 4500 -3280 {
lab=VSS}
N 4500 -3520 4500 -3510 {
lab=VDD}
N 4840 -3290 4850 -3300 {
lab=row_n[14]}
N 4850 -3500 4850 -3300 {
lab=row_n[14]}
N 4840 -3510 4850 -3500 {
lab=row_n[14]}
N 4840 -3290 4840 -3270 {
lab=row_n[14]}
N 4840 -3530 4840 -3510 {
lab=row_n[14]}
N 4720 -3430 4730 -3440 {
lab=col_n[9]}
N 4730 -3440 4930 -3440 {
lab=col_n[9]}
N 4930 -3440 4940 -3430 {
lab=col_n[9]}
N 4720 -3410 4730 -3420 {
lab=colon_n[9]}
N 4730 -3420 4930 -3420 {
lab=colon_n[9]}
N 4930 -3420 4940 -3410 {
lab=colon_n[9]}
N 4720 -3390 4730 -3400 {
lab=#net19}
N 4730 -3400 4930 -3400 {
lab=#net19}
N 4930 -3400 4940 -3390 {
lab=#net19}
N 4720 -3370 4730 -3380 {
lab=#net20}
N 4730 -3380 4930 -3380 {
lab=#net20}
N 4930 -3380 4940 -3370 {
lab=#net20}
N 4780 -3530 4780 -3510 {
lab=vcom}
N 4820 -3530 4820 -3510 {
lab=ctop}
N 4700 -3430 4720 -3430 {
lab=col_n[9]}
N 4700 -3410 4720 -3410 {
lab=colon_n[9]}
N 4700 -3390 4720 -3390 {
lab=#net19}
N 4700 -3370 4720 -3370 {
lab=#net20}
N 4940 -3370 4960 -3370 {
lab=#net20}
N 4940 -3390 4960 -3390 {
lab=#net19}
N 4940 -3410 4960 -3410 {
lab=colon_n[9]}
N 4940 -3430 4960 -3430 {
lab=col_n[9]}
N 4760 -3290 4760 -3280 {
lab=VSS}
N 4760 -3520 4760 -3510 {
lab=VDD}
N 5100 -3290 5110 -3300 {
lab=row_n[15]}
N 5110 -3500 5110 -3300 {
lab=row_n[15]}
N 5100 -3510 5110 -3500 {
lab=row_n[15]}
N 5100 -3290 5100 -3270 {
lab=row_n[15]}
N 5100 -3530 5100 -3510 {
lab=row_n[15]}
N 4980 -3430 4990 -3440 {
lab=col_n[9]}
N 4990 -3440 5190 -3440 {
lab=col_n[9]}
N 5190 -3440 5200 -3430 {
lab=col_n[9]}
N 4980 -3410 4990 -3420 {
lab=colon_n[9]}
N 4990 -3420 5190 -3420 {
lab=colon_n[9]}
N 5190 -3420 5200 -3410 {
lab=colon_n[9]}
N 4980 -3390 4990 -3400 {
lab=#net19}
N 4990 -3400 5190 -3400 {
lab=#net19}
N 5190 -3400 5200 -3390 {
lab=#net19}
N 4980 -3370 4990 -3380 {
lab=#net20}
N 4990 -3380 5190 -3380 {
lab=#net20}
N 5190 -3380 5200 -3370 {
lab=#net20}
N 5040 -3530 5040 -3510 {
lab=vcom}
N 5080 -3530 5080 -3510 {
lab=ctop}
N 4960 -3430 4980 -3430 {
lab=col_n[9]}
N 4960 -3410 4980 -3410 {
lab=colon_n[9]}
N 4960 -3390 4980 -3390 {
lab=#net19}
N 4960 -3370 4980 -3370 {
lab=#net20}
N 5200 -3370 5220 -3370 {
lab=#net20}
N 5200 -3390 5220 -3390 {
lab=#net19}
N 5200 -3410 5220 -3410 {
lab=colon_n[9]}
N 5200 -3430 5220 -3430 {
lab=col_n[9]}
N 5020 -3290 5020 -3280 {
lab=VSS}
N 5020 -3520 5020 -3510 {
lab=VDD}
N 5360 -3290 5370 -3300 {
lab=row_n[16]}
N 5370 -3500 5370 -3300 {
lab=row_n[16]}
N 5360 -3510 5370 -3500 {
lab=row_n[16]}
N 5360 -3290 5360 -3270 {
lab=row_n[16]}
N 5360 -3530 5360 -3510 {
lab=row_n[16]}
N 5240 -3430 5250 -3440 {
lab=col_n[9]}
N 5250 -3440 5450 -3440 {
lab=col_n[9]}
N 5450 -3440 5460 -3430 {
lab=col_n[9]}
N 5240 -3410 5250 -3420 {
lab=colon_n[9]}
N 5250 -3420 5450 -3420 {
lab=colon_n[9]}
N 5450 -3420 5460 -3410 {
lab=colon_n[9]}
N 5240 -3390 5250 -3400 {
lab=#net19}
N 5250 -3400 5450 -3400 {
lab=#net19}
N 5450 -3400 5460 -3390 {
lab=#net19}
N 5240 -3370 5250 -3380 {
lab=#net20}
N 5250 -3380 5450 -3380 {
lab=#net20}
N 5450 -3380 5460 -3370 {
lab=#net20}
N 5300 -3530 5300 -3510 {
lab=vcom}
N 5340 -3530 5340 -3510 {
lab=ctop}
N 5220 -3430 5240 -3430 {
lab=col_n[9]}
N 5220 -3410 5240 -3410 {
lab=colon_n[9]}
N 5220 -3390 5240 -3390 {
lab=#net19}
N 5220 -3370 5240 -3370 {
lab=#net20}
N 5460 -3370 5480 -3370 {
lab=#net20}
N 5460 -3390 5480 -3390 {
lab=#net19}
N 5460 -3410 5480 -3410 {
lab=colon_n[9]}
N 5460 -3430 5480 -3430 {
lab=col_n[9]}
N 5280 -3290 5280 -3280 {
lab=VSS}
N 5280 -3520 5280 -3510 {
lab=VDD}
N 5620 -3290 5630 -3300 {
lab=row_n[17]}
N 5630 -3500 5630 -3300 {
lab=row_n[17]}
N 5620 -3510 5630 -3500 {
lab=row_n[17]}
N 5620 -3290 5620 -3270 {
lab=row_n[17]}
N 5620 -3530 5620 -3510 {
lab=row_n[17]}
N 5500 -3430 5510 -3440 {
lab=col_n[9]}
N 5510 -3440 5710 -3440 {
lab=col_n[9]}
N 5710 -3440 5720 -3430 {
lab=col_n[9]}
N 5500 -3410 5510 -3420 {
lab=colon_n[9]}
N 5510 -3420 5710 -3420 {
lab=colon_n[9]}
N 5710 -3420 5720 -3410 {
lab=colon_n[9]}
N 5500 -3390 5510 -3400 {
lab=#net19}
N 5510 -3400 5710 -3400 {
lab=#net19}
N 5710 -3400 5720 -3390 {
lab=#net19}
N 5500 -3370 5510 -3380 {
lab=#net20}
N 5510 -3380 5710 -3380 {
lab=#net20}
N 5710 -3380 5720 -3370 {
lab=#net20}
N 5560 -3530 5560 -3510 {
lab=vcom}
N 5600 -3530 5600 -3510 {
lab=ctop}
N 5480 -3430 5500 -3430 {
lab=col_n[9]}
N 5480 -3410 5500 -3410 {
lab=colon_n[9]}
N 5480 -3390 5500 -3390 {
lab=#net19}
N 5480 -3370 5500 -3370 {
lab=#net20}
N 5720 -3370 5740 -3370 {
lab=#net20}
N 5720 -3390 5740 -3390 {
lab=#net19}
N 5720 -3410 5740 -3410 {
lab=colon_n[9]}
N 5720 -3430 5740 -3430 {
lab=col_n[9]}
N 5540 -3290 5540 -3280 {
lab=VSS}
N 5540 -3520 5540 -3510 {
lab=VDD}
N 5880 -3290 5890 -3300 {
lab=row_n[18]}
N 5890 -3500 5890 -3300 {
lab=row_n[18]}
N 5880 -3510 5890 -3500 {
lab=row_n[18]}
N 5880 -3290 5880 -3270 {
lab=row_n[18]}
N 5880 -3530 5880 -3510 {
lab=row_n[18]}
N 5760 -3430 5770 -3440 {
lab=col_n[9]}
N 5770 -3440 5970 -3440 {
lab=col_n[9]}
N 5970 -3440 5980 -3430 {
lab=col_n[9]}
N 5760 -3410 5770 -3420 {
lab=colon_n[9]}
N 5770 -3420 5970 -3420 {
lab=colon_n[9]}
N 5970 -3420 5980 -3410 {
lab=colon_n[9]}
N 5760 -3390 5770 -3400 {
lab=#net19}
N 5770 -3400 5970 -3400 {
lab=#net19}
N 5970 -3400 5980 -3390 {
lab=#net19}
N 5760 -3370 5770 -3380 {
lab=#net20}
N 5770 -3380 5970 -3380 {
lab=#net20}
N 5970 -3380 5980 -3370 {
lab=#net20}
N 5820 -3530 5820 -3510 {
lab=vcom}
N 5860 -3530 5860 -3510 {
lab=ctop}
N 5740 -3430 5760 -3430 {
lab=col_n[9]}
N 5740 -3410 5760 -3410 {
lab=colon_n[9]}
N 5740 -3390 5760 -3390 {
lab=#net19}
N 5740 -3370 5760 -3370 {
lab=#net20}
N 5980 -3370 6000 -3370 {
lab=#net20}
N 5980 -3390 6000 -3390 {
lab=#net19}
N 5980 -3410 6000 -3410 {
lab=colon_n[9]}
N 5980 -3430 6000 -3430 {
lab=col_n[9]}
N 5800 -3290 5800 -3280 {
lab=VSS}
N 5800 -3520 5800 -3510 {
lab=VDD}
N 6140 -3290 6150 -3300 {
lab=row_n[19]}
N 6150 -3500 6150 -3300 {
lab=row_n[19]}
N 6140 -3510 6150 -3500 {
lab=row_n[19]}
N 6140 -3290 6140 -3270 {
lab=row_n[19]}
N 6140 -3530 6140 -3510 {
lab=row_n[19]}
N 6020 -3430 6030 -3440 {
lab=col_n[9]}
N 6030 -3440 6230 -3440 {
lab=col_n[9]}
N 6230 -3440 6240 -3430 {
lab=col_n[9]}
N 6020 -3410 6030 -3420 {
lab=colon_n[9]}
N 6030 -3420 6230 -3420 {
lab=colon_n[9]}
N 6230 -3420 6240 -3410 {
lab=colon_n[9]}
N 6020 -3390 6030 -3400 {
lab=#net19}
N 6030 -3400 6230 -3400 {
lab=#net19}
N 6230 -3400 6240 -3390 {
lab=#net19}
N 6020 -3370 6030 -3380 {
lab=#net20}
N 6030 -3380 6230 -3380 {
lab=#net20}
N 6230 -3380 6240 -3370 {
lab=#net20}
N 6080 -3530 6080 -3510 {
lab=vcom}
N 6120 -3530 6120 -3510 {
lab=ctop}
N 6000 -3430 6020 -3430 {
lab=col_n[9]}
N 6000 -3410 6020 -3410 {
lab=colon_n[9]}
N 6000 -3390 6020 -3390 {
lab=#net19}
N 6000 -3370 6020 -3370 {
lab=#net20}
N 6240 -3370 6260 -3370 {
lab=#net20}
N 6240 -3390 6260 -3390 {
lab=#net19}
N 6240 -3410 6260 -3410 {
lab=colon_n[9]}
N 6240 -3430 6260 -3430 {
lab=col_n[9]}
N 6060 -3290 6060 -3280 {
lab=VSS}
N 6060 -3520 6060 -3510 {
lab=VDD}
N 6400 -3290 6410 -3300 {
lab=row_n[20]}
N 6410 -3500 6410 -3300 {
lab=row_n[20]}
N 6400 -3510 6410 -3500 {
lab=row_n[20]}
N 6400 -3290 6400 -3270 {
lab=row_n[20]}
N 6400 -3530 6400 -3510 {
lab=row_n[20]}
N 6280 -3430 6290 -3440 {
lab=col_n[9]}
N 6290 -3440 6490 -3440 {
lab=col_n[9]}
N 6490 -3440 6500 -3430 {
lab=col_n[9]}
N 6280 -3410 6290 -3420 {
lab=colon_n[9]}
N 6290 -3420 6490 -3420 {
lab=colon_n[9]}
N 6490 -3420 6500 -3410 {
lab=colon_n[9]}
N 6280 -3390 6290 -3400 {
lab=#net19}
N 6290 -3400 6490 -3400 {
lab=#net19}
N 6490 -3400 6500 -3390 {
lab=#net19}
N 6280 -3370 6290 -3380 {
lab=#net20}
N 6290 -3380 6490 -3380 {
lab=#net20}
N 6490 -3380 6500 -3370 {
lab=#net20}
N 6340 -3530 6340 -3510 {
lab=vcom}
N 6380 -3530 6380 -3510 {
lab=ctop}
N 6260 -3430 6280 -3430 {
lab=col_n[9]}
N 6260 -3410 6280 -3410 {
lab=colon_n[9]}
N 6260 -3390 6280 -3390 {
lab=#net19}
N 6260 -3370 6280 -3370 {
lab=#net20}
N 6500 -3370 6520 -3370 {
lab=#net20}
N 6500 -3390 6520 -3390 {
lab=#net19}
N 6500 -3410 6520 -3410 {
lab=colon_n[9]}
N 6500 -3430 6520 -3430 {
lab=col_n[9]}
N 6320 -3290 6320 -3280 {
lab=VSS}
N 6320 -3520 6320 -3510 {
lab=VDD}
N 6660 -3290 6670 -3300 {
lab=row_n[21]}
N 6670 -3500 6670 -3300 {
lab=row_n[21]}
N 6660 -3510 6670 -3500 {
lab=row_n[21]}
N 6660 -3290 6660 -3270 {
lab=row_n[21]}
N 6660 -3530 6660 -3510 {
lab=row_n[21]}
N 6540 -3430 6550 -3440 {
lab=col_n[9]}
N 6550 -3440 6750 -3440 {
lab=col_n[9]}
N 6750 -3440 6760 -3430 {
lab=col_n[9]}
N 6540 -3410 6550 -3420 {
lab=colon_n[9]}
N 6550 -3420 6750 -3420 {
lab=colon_n[9]}
N 6750 -3420 6760 -3410 {
lab=colon_n[9]}
N 6540 -3390 6550 -3400 {
lab=#net19}
N 6550 -3400 6750 -3400 {
lab=#net19}
N 6750 -3400 6760 -3390 {
lab=#net19}
N 6540 -3370 6550 -3380 {
lab=#net20}
N 6550 -3380 6750 -3380 {
lab=#net20}
N 6750 -3380 6760 -3370 {
lab=#net20}
N 6600 -3530 6600 -3510 {
lab=vcom}
N 6640 -3530 6640 -3510 {
lab=ctop}
N 6520 -3430 6540 -3430 {
lab=col_n[9]}
N 6520 -3410 6540 -3410 {
lab=colon_n[9]}
N 6520 -3390 6540 -3390 {
lab=#net19}
N 6520 -3370 6540 -3370 {
lab=#net20}
N 6760 -3370 6780 -3370 {
lab=#net20}
N 6760 -3390 6780 -3390 {
lab=#net19}
N 6760 -3410 6780 -3410 {
lab=colon_n[9]}
N 6760 -3430 6780 -3430 {
lab=col_n[9]}
N 6580 -3290 6580 -3280 {
lab=VSS}
N 6580 -3520 6580 -3510 {
lab=VDD}
N 6920 -3290 6930 -3300 {
lab=row_n[22]}
N 6930 -3500 6930 -3300 {
lab=row_n[22]}
N 6920 -3510 6930 -3500 {
lab=row_n[22]}
N 6920 -3290 6920 -3270 {
lab=row_n[22]}
N 6920 -3530 6920 -3510 {
lab=row_n[22]}
N 6800 -3430 6810 -3440 {
lab=col_n[9]}
N 6810 -3440 7010 -3440 {
lab=col_n[9]}
N 7010 -3440 7020 -3430 {
lab=col_n[9]}
N 6800 -3410 6810 -3420 {
lab=colon_n[9]}
N 6810 -3420 7010 -3420 {
lab=colon_n[9]}
N 7010 -3420 7020 -3410 {
lab=colon_n[9]}
N 6800 -3390 6810 -3400 {
lab=#net19}
N 6810 -3400 7010 -3400 {
lab=#net19}
N 7010 -3400 7020 -3390 {
lab=#net19}
N 6800 -3370 6810 -3380 {
lab=#net20}
N 6810 -3380 7010 -3380 {
lab=#net20}
N 7010 -3380 7020 -3370 {
lab=#net20}
N 6860 -3530 6860 -3510 {
lab=vcom}
N 6900 -3530 6900 -3510 {
lab=ctop}
N 6780 -3430 6800 -3430 {
lab=col_n[9]}
N 6780 -3410 6800 -3410 {
lab=colon_n[9]}
N 6780 -3390 6800 -3390 {
lab=#net19}
N 6780 -3370 6800 -3370 {
lab=#net20}
N 7020 -3370 7040 -3370 {
lab=#net20}
N 7020 -3390 7040 -3390 {
lab=#net19}
N 7020 -3410 7040 -3410 {
lab=colon_n[9]}
N 7020 -3430 7040 -3430 {
lab=col_n[9]}
N 6840 -3290 6840 -3280 {
lab=VSS}
N 6840 -3520 6840 -3510 {
lab=VDD}
N 7180 -3290 7190 -3300 {
lab=row_n[23]}
N 7190 -3500 7190 -3300 {
lab=row_n[23]}
N 7180 -3510 7190 -3500 {
lab=row_n[23]}
N 7180 -3290 7180 -3270 {
lab=row_n[23]}
N 7180 -3530 7180 -3510 {
lab=row_n[23]}
N 7060 -3430 7070 -3440 {
lab=col_n[9]}
N 7070 -3440 7270 -3440 {
lab=col_n[9]}
N 7270 -3440 7280 -3430 {
lab=col_n[9]}
N 7060 -3410 7070 -3420 {
lab=colon_n[9]}
N 7070 -3420 7270 -3420 {
lab=colon_n[9]}
N 7270 -3420 7280 -3410 {
lab=colon_n[9]}
N 7060 -3390 7070 -3400 {
lab=#net19}
N 7070 -3400 7270 -3400 {
lab=#net19}
N 7270 -3400 7280 -3390 {
lab=#net19}
N 7060 -3370 7070 -3380 {
lab=#net20}
N 7070 -3380 7270 -3380 {
lab=#net20}
N 7270 -3380 7280 -3370 {
lab=#net20}
N 7120 -3530 7120 -3510 {
lab=vcom}
N 7160 -3530 7160 -3510 {
lab=ctop}
N 7040 -3430 7060 -3430 {
lab=col_n[9]}
N 7040 -3410 7060 -3410 {
lab=colon_n[9]}
N 7040 -3390 7060 -3390 {
lab=#net19}
N 7040 -3370 7060 -3370 {
lab=#net20}
N 7280 -3370 7300 -3370 {
lab=#net20}
N 7280 -3390 7300 -3390 {
lab=#net19}
N 7280 -3410 7300 -3410 {
lab=colon_n[9]}
N 7280 -3430 7300 -3430 {
lab=col_n[9]}
N 7100 -3290 7100 -3280 {
lab=VSS}
N 7100 -3520 7100 -3510 {
lab=VDD}
N 7440 -3290 7450 -3300 {
lab=row_n[24]}
N 7450 -3500 7450 -3300 {
lab=row_n[24]}
N 7440 -3510 7450 -3500 {
lab=row_n[24]}
N 7440 -3290 7440 -3270 {
lab=row_n[24]}
N 7440 -3530 7440 -3510 {
lab=row_n[24]}
N 7320 -3430 7330 -3440 {
lab=col_n[9]}
N 7330 -3440 7530 -3440 {
lab=col_n[9]}
N 7530 -3440 7540 -3430 {
lab=col_n[9]}
N 7320 -3410 7330 -3420 {
lab=colon_n[9]}
N 7330 -3420 7530 -3420 {
lab=colon_n[9]}
N 7530 -3420 7540 -3410 {
lab=colon_n[9]}
N 7320 -3390 7330 -3400 {
lab=#net19}
N 7330 -3400 7530 -3400 {
lab=#net19}
N 7530 -3400 7540 -3390 {
lab=#net19}
N 7320 -3370 7330 -3380 {
lab=#net20}
N 7330 -3380 7530 -3380 {
lab=#net20}
N 7530 -3380 7540 -3370 {
lab=#net20}
N 7380 -3530 7380 -3510 {
lab=vcom}
N 7420 -3530 7420 -3510 {
lab=ctop}
N 7300 -3430 7320 -3430 {
lab=col_n[9]}
N 7300 -3410 7320 -3410 {
lab=colon_n[9]}
N 7300 -3390 7320 -3390 {
lab=#net19}
N 7300 -3370 7320 -3370 {
lab=#net20}
N 7540 -3370 7560 -3370 {
lab=#net20}
N 7540 -3390 7560 -3390 {
lab=#net19}
N 7540 -3410 7560 -3410 {
lab=colon_n[9]}
N 7540 -3430 7560 -3430 {
lab=col_n[9]}
N 7360 -3290 7360 -3280 {
lab=VSS}
N 7360 -3520 7360 -3510 {
lab=VDD}
N 7700 -3290 7710 -3300 {
lab=row_n[25]}
N 7710 -3500 7710 -3300 {
lab=row_n[25]}
N 7700 -3510 7710 -3500 {
lab=row_n[25]}
N 7700 -3290 7700 -3270 {
lab=row_n[25]}
N 7700 -3530 7700 -3510 {
lab=row_n[25]}
N 7580 -3430 7590 -3440 {
lab=col_n[9]}
N 7590 -3440 7790 -3440 {
lab=col_n[9]}
N 7790 -3440 7800 -3430 {
lab=col_n[9]}
N 7580 -3410 7590 -3420 {
lab=colon_n[9]}
N 7590 -3420 7790 -3420 {
lab=colon_n[9]}
N 7790 -3420 7800 -3410 {
lab=colon_n[9]}
N 7580 -3390 7590 -3400 {
lab=#net19}
N 7590 -3400 7790 -3400 {
lab=#net19}
N 7790 -3400 7800 -3390 {
lab=#net19}
N 7580 -3370 7590 -3380 {
lab=#net20}
N 7590 -3380 7790 -3380 {
lab=#net20}
N 7790 -3380 7800 -3370 {
lab=#net20}
N 7640 -3530 7640 -3510 {
lab=vcom}
N 7680 -3530 7680 -3510 {
lab=ctop}
N 7560 -3430 7580 -3430 {
lab=col_n[9]}
N 7560 -3410 7580 -3410 {
lab=colon_n[9]}
N 7560 -3390 7580 -3390 {
lab=#net19}
N 7560 -3370 7580 -3370 {
lab=#net20}
N 7800 -3370 7820 -3370 {
lab=#net20}
N 7800 -3390 7820 -3390 {
lab=#net19}
N 7800 -3410 7820 -3410 {
lab=colon_n[9]}
N 7800 -3430 7820 -3430 {
lab=col_n[9]}
N 7620 -3290 7620 -3280 {
lab=VSS}
N 7620 -3520 7620 -3510 {
lab=VDD}
N 7960 -3290 7970 -3300 {
lab=row_n[26]}
N 7970 -3500 7970 -3300 {
lab=row_n[26]}
N 7960 -3510 7970 -3500 {
lab=row_n[26]}
N 7960 -3290 7960 -3270 {
lab=row_n[26]}
N 7960 -3530 7960 -3510 {
lab=row_n[26]}
N 7840 -3430 7850 -3440 {
lab=col_n[9]}
N 7850 -3440 8050 -3440 {
lab=col_n[9]}
N 8050 -3440 8060 -3430 {
lab=col_n[9]}
N 7840 -3410 7850 -3420 {
lab=colon_n[9]}
N 7850 -3420 8050 -3420 {
lab=colon_n[9]}
N 8050 -3420 8060 -3410 {
lab=colon_n[9]}
N 7840 -3390 7850 -3400 {
lab=#net19}
N 7850 -3400 8050 -3400 {
lab=#net19}
N 8050 -3400 8060 -3390 {
lab=#net19}
N 7840 -3370 7850 -3380 {
lab=#net20}
N 7850 -3380 8050 -3380 {
lab=#net20}
N 8050 -3380 8060 -3370 {
lab=#net20}
N 7900 -3530 7900 -3510 {
lab=vcom}
N 7940 -3530 7940 -3510 {
lab=ctop}
N 7820 -3430 7840 -3430 {
lab=col_n[9]}
N 7820 -3410 7840 -3410 {
lab=colon_n[9]}
N 7820 -3390 7840 -3390 {
lab=#net19}
N 7820 -3370 7840 -3370 {
lab=#net20}
N 8060 -3370 8080 -3370 {
lab=#net20}
N 8060 -3390 8080 -3390 {
lab=#net19}
N 8060 -3410 8080 -3410 {
lab=colon_n[9]}
N 8060 -3430 8080 -3430 {
lab=col_n[9]}
N 7880 -3290 7880 -3280 {
lab=VSS}
N 7880 -3520 7880 -3510 {
lab=VDD}
N 8220 -3290 8230 -3300 {
lab=row_n[27]}
N 8230 -3500 8230 -3300 {
lab=row_n[27]}
N 8220 -3510 8230 -3500 {
lab=row_n[27]}
N 8220 -3290 8220 -3270 {
lab=row_n[27]}
N 8220 -3530 8220 -3510 {
lab=row_n[27]}
N 8100 -3430 8110 -3440 {
lab=col_n[9]}
N 8110 -3440 8310 -3440 {
lab=col_n[9]}
N 8310 -3440 8320 -3430 {
lab=col_n[9]}
N 8100 -3410 8110 -3420 {
lab=colon_n[9]}
N 8110 -3420 8310 -3420 {
lab=colon_n[9]}
N 8310 -3420 8320 -3410 {
lab=colon_n[9]}
N 8100 -3390 8110 -3400 {
lab=#net19}
N 8110 -3400 8310 -3400 {
lab=#net19}
N 8310 -3400 8320 -3390 {
lab=#net19}
N 8100 -3370 8110 -3380 {
lab=#net20}
N 8110 -3380 8310 -3380 {
lab=#net20}
N 8310 -3380 8320 -3370 {
lab=#net20}
N 8160 -3530 8160 -3510 {
lab=vcom}
N 8200 -3530 8200 -3510 {
lab=ctop}
N 8080 -3430 8100 -3430 {
lab=col_n[9]}
N 8080 -3410 8100 -3410 {
lab=colon_n[9]}
N 8080 -3390 8100 -3390 {
lab=#net19}
N 8080 -3370 8100 -3370 {
lab=#net20}
N 8320 -3370 8340 -3370 {
lab=#net20}
N 8320 -3390 8340 -3390 {
lab=#net19}
N 8320 -3410 8340 -3410 {
lab=colon_n[9]}
N 8320 -3430 8340 -3430 {
lab=col_n[9]}
N 8140 -3290 8140 -3280 {
lab=VSS}
N 8140 -3520 8140 -3510 {
lab=VDD}
N 8480 -3290 8490 -3300 {
lab=row_n[28]}
N 8490 -3500 8490 -3300 {
lab=row_n[28]}
N 8480 -3510 8490 -3500 {
lab=row_n[28]}
N 8480 -3290 8480 -3270 {
lab=row_n[28]}
N 8480 -3530 8480 -3510 {
lab=row_n[28]}
N 8360 -3430 8370 -3440 {
lab=col_n[9]}
N 8370 -3440 8570 -3440 {
lab=col_n[9]}
N 8570 -3440 8580 -3430 {
lab=col_n[9]}
N 8360 -3410 8370 -3420 {
lab=colon_n[9]}
N 8370 -3420 8570 -3420 {
lab=colon_n[9]}
N 8570 -3420 8580 -3410 {
lab=colon_n[9]}
N 8360 -3390 8370 -3400 {
lab=#net19}
N 8370 -3400 8570 -3400 {
lab=#net19}
N 8570 -3400 8580 -3390 {
lab=#net19}
N 8360 -3370 8370 -3380 {
lab=#net20}
N 8370 -3380 8570 -3380 {
lab=#net20}
N 8570 -3380 8580 -3370 {
lab=#net20}
N 8420 -3530 8420 -3510 {
lab=vcom}
N 8460 -3530 8460 -3510 {
lab=ctop}
N 8340 -3430 8360 -3430 {
lab=col_n[9]}
N 8340 -3410 8360 -3410 {
lab=colon_n[9]}
N 8340 -3390 8360 -3390 {
lab=#net19}
N 8340 -3370 8360 -3370 {
lab=#net20}
N 8580 -3370 8600 -3370 {
lab=#net20}
N 8580 -3390 8600 -3390 {
lab=#net19}
N 8580 -3410 8600 -3410 {
lab=colon_n[9]}
N 8580 -3430 8600 -3430 {
lab=col_n[9]}
N 8400 -3290 8400 -3280 {
lab=VSS}
N 8400 -3520 8400 -3510 {
lab=VDD}
N 8740 -3290 8750 -3300 {
lab=row_n[29]}
N 8750 -3500 8750 -3300 {
lab=row_n[29]}
N 8740 -3510 8750 -3500 {
lab=row_n[29]}
N 8740 -3290 8740 -3270 {
lab=row_n[29]}
N 8740 -3530 8740 -3510 {
lab=row_n[29]}
N 8620 -3430 8630 -3440 {
lab=col_n[9]}
N 8630 -3440 8830 -3440 {
lab=col_n[9]}
N 8830 -3440 8840 -3430 {
lab=col_n[9]}
N 8620 -3410 8630 -3420 {
lab=colon_n[9]}
N 8630 -3420 8830 -3420 {
lab=colon_n[9]}
N 8830 -3420 8840 -3410 {
lab=colon_n[9]}
N 8620 -3390 8630 -3400 {
lab=#net19}
N 8630 -3400 8830 -3400 {
lab=#net19}
N 8830 -3400 8840 -3390 {
lab=#net19}
N 8620 -3370 8630 -3380 {
lab=#net20}
N 8630 -3380 8830 -3380 {
lab=#net20}
N 8830 -3380 8840 -3370 {
lab=#net20}
N 8680 -3530 8680 -3510 {
lab=vcom}
N 8720 -3530 8720 -3510 {
lab=ctop}
N 8600 -3430 8620 -3430 {
lab=col_n[9]}
N 8600 -3410 8620 -3410 {
lab=colon_n[9]}
N 8600 -3390 8620 -3390 {
lab=#net19}
N 8600 -3370 8620 -3370 {
lab=#net20}
N 8840 -3370 8860 -3370 {
lab=#net20}
N 8840 -3390 8860 -3390 {
lab=#net19}
N 8840 -3410 8860 -3410 {
lab=colon_n[9]}
N 8840 -3430 8860 -3430 {
lab=col_n[9]}
N 8660 -3290 8660 -3280 {
lab=VSS}
N 8660 -3520 8660 -3510 {
lab=VDD}
N 9000 -3290 9010 -3300 {
lab=row_n[30]}
N 9010 -3500 9010 -3300 {
lab=row_n[30]}
N 9000 -3510 9010 -3500 {
lab=row_n[30]}
N 9000 -3290 9000 -3270 {
lab=row_n[30]}
N 9000 -3530 9000 -3510 {
lab=row_n[30]}
N 8880 -3430 8890 -3440 {
lab=col_n[9]}
N 8890 -3440 9090 -3440 {
lab=col_n[9]}
N 9090 -3440 9100 -3430 {
lab=col_n[9]}
N 8880 -3410 8890 -3420 {
lab=colon_n[9]}
N 8890 -3420 9090 -3420 {
lab=colon_n[9]}
N 9090 -3420 9100 -3410 {
lab=colon_n[9]}
N 8880 -3390 8890 -3400 {
lab=#net19}
N 8890 -3400 9090 -3400 {
lab=#net19}
N 9090 -3400 9100 -3390 {
lab=#net19}
N 8880 -3370 8890 -3380 {
lab=#net20}
N 8890 -3380 9090 -3380 {
lab=#net20}
N 9090 -3380 9100 -3370 {
lab=#net20}
N 8940 -3530 8940 -3510 {
lab=vcom}
N 8980 -3530 8980 -3510 {
lab=ctop}
N 8860 -3430 8880 -3430 {
lab=col_n[9]}
N 8860 -3410 8880 -3410 {
lab=colon_n[9]}
N 8860 -3390 8880 -3390 {
lab=#net19}
N 8860 -3370 8880 -3370 {
lab=#net20}
N 9100 -3370 9120 -3370 {
lab=#net20}
N 9100 -3390 9120 -3390 {
lab=#net19}
N 9100 -3410 9120 -3410 {
lab=colon_n[9]}
N 9100 -3430 9120 -3430 {
lab=col_n[9]}
N 8920 -3290 8920 -3280 {
lab=VSS}
N 8920 -3520 8920 -3510 {
lab=VDD}
N 9260 -3290 9270 -3300 {
lab=row_n[31]}
N 9270 -3500 9270 -3300 {
lab=row_n[31]}
N 9260 -3510 9270 -3500 {
lab=row_n[31]}
N 9260 -3290 9260 -3270 {
lab=row_n[31]}
N 9260 -3530 9260 -3510 {
lab=row_n[31]}
N 9140 -3430 9150 -3440 {
lab=col_n[9]}
N 9150 -3440 9350 -3440 {
lab=col_n[9]}
N 9350 -3440 9360 -3430 {
lab=col_n[9]}
N 9140 -3410 9150 -3420 {
lab=colon_n[9]}
N 9150 -3420 9350 -3420 {
lab=colon_n[9]}
N 9350 -3420 9360 -3410 {
lab=colon_n[9]}
N 9140 -3390 9150 -3400 {
lab=#net19}
N 9150 -3400 9350 -3400 {
lab=#net19}
N 9350 -3400 9360 -3390 {
lab=#net19}
N 9140 -3370 9150 -3380 {
lab=#net20}
N 9150 -3380 9350 -3380 {
lab=#net20}
N 9350 -3380 9360 -3370 {
lab=#net20}
N 9200 -3530 9200 -3510 {
lab=vcom}
N 9240 -3530 9240 -3510 {
lab=ctop}
N 9120 -3430 9140 -3430 {
lab=col_n[9]}
N 9120 -3410 9140 -3410 {
lab=colon_n[9]}
N 9120 -3390 9140 -3390 {
lab=#net19}
N 9120 -3370 9140 -3370 {
lab=#net20}
N 9360 -3370 9380 -3370 {
lab=#net20}
N 9360 -3390 9380 -3390 {
lab=#net19}
N 9360 -3410 9380 -3410 {
lab=colon_n[9]}
N 9360 -3430 9380 -3430 {
lab=col_n[9]}
N 9180 -3290 9180 -3280 {
lab=VSS}
N 9180 -3520 9180 -3510 {
lab=VDD}
N 1200 -3550 1210 -3560 {
lab=row_n[0]}
N 1210 -3760 1210 -3560 {
lab=row_n[0]}
N 1200 -3770 1210 -3760 {
lab=row_n[0]}
N 1200 -3550 1200 -3530 {
lab=row_n[0]}
N 1200 -3790 1200 -3770 {
lab=row_n[0]}
N 1080 -3690 1090 -3700 {
lab=col_n[10]}
N 1090 -3700 1290 -3700 {
lab=col_n[10]}
N 1290 -3700 1300 -3690 {
lab=col_n[10]}
N 1080 -3670 1090 -3680 {
lab=colon_n[10]}
N 1090 -3680 1290 -3680 {
lab=colon_n[10]}
N 1290 -3680 1300 -3670 {
lab=colon_n[10]}
N 1080 -3650 1090 -3660 {
lab=#net21}
N 1090 -3660 1290 -3660 {
lab=#net21}
N 1290 -3660 1300 -3650 {
lab=#net21}
N 1080 -3630 1090 -3640 {
lab=#net22}
N 1090 -3640 1290 -3640 {
lab=#net22}
N 1290 -3640 1300 -3630 {
lab=#net22}
N 1140 -3790 1140 -3770 {
lab=vcom}
N 1180 -3790 1180 -3770 {
lab=ctop}
N 1060 -3690 1080 -3690 {
lab=col_n[10]}
N 1060 -3670 1080 -3670 {
lab=colon_n[10]}
N 1060 -3650 1080 -3650 {
lab=#net21}
N 1060 -3630 1080 -3630 {
lab=#net22}
N 1300 -3630 1320 -3630 {
lab=#net22}
N 1300 -3650 1320 -3650 {
lab=#net21}
N 1300 -3670 1320 -3670 {
lab=colon_n[10]}
N 1300 -3690 1320 -3690 {
lab=col_n[10]}
N 1120 -3550 1120 -3540 {
lab=VSS}
N 1120 -3780 1120 -3770 {
lab=VDD}
N 1460 -3550 1470 -3560 {
lab=row_n[1]}
N 1470 -3760 1470 -3560 {
lab=row_n[1]}
N 1460 -3770 1470 -3760 {
lab=row_n[1]}
N 1460 -3550 1460 -3530 {
lab=row_n[1]}
N 1460 -3790 1460 -3770 {
lab=row_n[1]}
N 1340 -3690 1350 -3700 {
lab=col_n[10]}
N 1350 -3700 1550 -3700 {
lab=col_n[10]}
N 1550 -3700 1560 -3690 {
lab=col_n[10]}
N 1340 -3670 1350 -3680 {
lab=colon_n[10]}
N 1350 -3680 1550 -3680 {
lab=colon_n[10]}
N 1550 -3680 1560 -3670 {
lab=colon_n[10]}
N 1340 -3650 1350 -3660 {
lab=#net21}
N 1350 -3660 1550 -3660 {
lab=#net21}
N 1550 -3660 1560 -3650 {
lab=#net21}
N 1340 -3630 1350 -3640 {
lab=#net22}
N 1350 -3640 1550 -3640 {
lab=#net22}
N 1550 -3640 1560 -3630 {
lab=#net22}
N 1400 -3790 1400 -3770 {
lab=vcom}
N 1440 -3790 1440 -3770 {
lab=ctop}
N 1320 -3690 1340 -3690 {
lab=col_n[10]}
N 1320 -3670 1340 -3670 {
lab=colon_n[10]}
N 1320 -3650 1340 -3650 {
lab=#net21}
N 1320 -3630 1340 -3630 {
lab=#net22}
N 1560 -3630 1580 -3630 {
lab=#net22}
N 1560 -3650 1580 -3650 {
lab=#net21}
N 1560 -3670 1580 -3670 {
lab=colon_n[10]}
N 1560 -3690 1580 -3690 {
lab=col_n[10]}
N 1380 -3550 1380 -3540 {
lab=VSS}
N 1380 -3780 1380 -3770 {
lab=VDD}
N 1720 -3550 1730 -3560 {
lab=row_n[2]}
N 1730 -3760 1730 -3560 {
lab=row_n[2]}
N 1720 -3770 1730 -3760 {
lab=row_n[2]}
N 1720 -3550 1720 -3530 {
lab=row_n[2]}
N 1720 -3790 1720 -3770 {
lab=row_n[2]}
N 1600 -3690 1610 -3700 {
lab=col_n[10]}
N 1610 -3700 1810 -3700 {
lab=col_n[10]}
N 1810 -3700 1820 -3690 {
lab=col_n[10]}
N 1600 -3670 1610 -3680 {
lab=colon_n[10]}
N 1610 -3680 1810 -3680 {
lab=colon_n[10]}
N 1810 -3680 1820 -3670 {
lab=colon_n[10]}
N 1600 -3650 1610 -3660 {
lab=#net21}
N 1610 -3660 1810 -3660 {
lab=#net21}
N 1810 -3660 1820 -3650 {
lab=#net21}
N 1600 -3630 1610 -3640 {
lab=#net22}
N 1610 -3640 1810 -3640 {
lab=#net22}
N 1810 -3640 1820 -3630 {
lab=#net22}
N 1660 -3790 1660 -3770 {
lab=vcom}
N 1700 -3790 1700 -3770 {
lab=ctop}
N 1580 -3690 1600 -3690 {
lab=col_n[10]}
N 1580 -3670 1600 -3670 {
lab=colon_n[10]}
N 1580 -3650 1600 -3650 {
lab=#net21}
N 1580 -3630 1600 -3630 {
lab=#net22}
N 1820 -3630 1840 -3630 {
lab=#net22}
N 1820 -3650 1840 -3650 {
lab=#net21}
N 1820 -3670 1840 -3670 {
lab=colon_n[10]}
N 1820 -3690 1840 -3690 {
lab=col_n[10]}
N 1640 -3550 1640 -3540 {
lab=VSS}
N 1640 -3780 1640 -3770 {
lab=VDD}
N 1980 -3550 1990 -3560 {
lab=row_n[3]}
N 1990 -3760 1990 -3560 {
lab=row_n[3]}
N 1980 -3770 1990 -3760 {
lab=row_n[3]}
N 1980 -3550 1980 -3530 {
lab=row_n[3]}
N 1980 -3790 1980 -3770 {
lab=row_n[3]}
N 1860 -3690 1870 -3700 {
lab=col_n[10]}
N 1870 -3700 2070 -3700 {
lab=col_n[10]}
N 2070 -3700 2080 -3690 {
lab=col_n[10]}
N 1860 -3670 1870 -3680 {
lab=colon_n[10]}
N 1870 -3680 2070 -3680 {
lab=colon_n[10]}
N 2070 -3680 2080 -3670 {
lab=colon_n[10]}
N 1860 -3650 1870 -3660 {
lab=#net21}
N 1870 -3660 2070 -3660 {
lab=#net21}
N 2070 -3660 2080 -3650 {
lab=#net21}
N 1860 -3630 1870 -3640 {
lab=#net22}
N 1870 -3640 2070 -3640 {
lab=#net22}
N 2070 -3640 2080 -3630 {
lab=#net22}
N 1920 -3790 1920 -3770 {
lab=vcom}
N 1960 -3790 1960 -3770 {
lab=ctop}
N 1840 -3690 1860 -3690 {
lab=col_n[10]}
N 1840 -3670 1860 -3670 {
lab=colon_n[10]}
N 1840 -3650 1860 -3650 {
lab=#net21}
N 1840 -3630 1860 -3630 {
lab=#net22}
N 2080 -3630 2100 -3630 {
lab=#net22}
N 2080 -3650 2100 -3650 {
lab=#net21}
N 2080 -3670 2100 -3670 {
lab=colon_n[10]}
N 2080 -3690 2100 -3690 {
lab=col_n[10]}
N 1900 -3550 1900 -3540 {
lab=VSS}
N 1900 -3780 1900 -3770 {
lab=VDD}
N 2240 -3550 2250 -3560 {
lab=row_n[4]}
N 2250 -3760 2250 -3560 {
lab=row_n[4]}
N 2240 -3770 2250 -3760 {
lab=row_n[4]}
N 2240 -3550 2240 -3530 {
lab=row_n[4]}
N 2240 -3790 2240 -3770 {
lab=row_n[4]}
N 2120 -3690 2130 -3700 {
lab=col_n[10]}
N 2130 -3700 2330 -3700 {
lab=col_n[10]}
N 2330 -3700 2340 -3690 {
lab=col_n[10]}
N 2120 -3670 2130 -3680 {
lab=colon_n[10]}
N 2130 -3680 2330 -3680 {
lab=colon_n[10]}
N 2330 -3680 2340 -3670 {
lab=colon_n[10]}
N 2120 -3650 2130 -3660 {
lab=#net21}
N 2130 -3660 2330 -3660 {
lab=#net21}
N 2330 -3660 2340 -3650 {
lab=#net21}
N 2120 -3630 2130 -3640 {
lab=#net22}
N 2130 -3640 2330 -3640 {
lab=#net22}
N 2330 -3640 2340 -3630 {
lab=#net22}
N 2180 -3790 2180 -3770 {
lab=vcom}
N 2220 -3790 2220 -3770 {
lab=ctop}
N 2100 -3690 2120 -3690 {
lab=col_n[10]}
N 2100 -3670 2120 -3670 {
lab=colon_n[10]}
N 2100 -3650 2120 -3650 {
lab=#net21}
N 2100 -3630 2120 -3630 {
lab=#net22}
N 2340 -3630 2360 -3630 {
lab=#net22}
N 2340 -3650 2360 -3650 {
lab=#net21}
N 2340 -3670 2360 -3670 {
lab=colon_n[10]}
N 2340 -3690 2360 -3690 {
lab=col_n[10]}
N 2160 -3550 2160 -3540 {
lab=VSS}
N 2160 -3780 2160 -3770 {
lab=VDD}
N 2500 -3550 2510 -3560 {
lab=row_n[5]}
N 2510 -3760 2510 -3560 {
lab=row_n[5]}
N 2500 -3770 2510 -3760 {
lab=row_n[5]}
N 2500 -3550 2500 -3530 {
lab=row_n[5]}
N 2500 -3790 2500 -3770 {
lab=row_n[5]}
N 2380 -3690 2390 -3700 {
lab=col_n[10]}
N 2390 -3700 2590 -3700 {
lab=col_n[10]}
N 2590 -3700 2600 -3690 {
lab=col_n[10]}
N 2380 -3670 2390 -3680 {
lab=colon_n[10]}
N 2390 -3680 2590 -3680 {
lab=colon_n[10]}
N 2590 -3680 2600 -3670 {
lab=colon_n[10]}
N 2380 -3650 2390 -3660 {
lab=#net21}
N 2390 -3660 2590 -3660 {
lab=#net21}
N 2590 -3660 2600 -3650 {
lab=#net21}
N 2380 -3630 2390 -3640 {
lab=#net22}
N 2390 -3640 2590 -3640 {
lab=#net22}
N 2590 -3640 2600 -3630 {
lab=#net22}
N 2440 -3790 2440 -3770 {
lab=vcom}
N 2480 -3790 2480 -3770 {
lab=ctop}
N 2360 -3690 2380 -3690 {
lab=col_n[10]}
N 2360 -3670 2380 -3670 {
lab=colon_n[10]}
N 2360 -3650 2380 -3650 {
lab=#net21}
N 2360 -3630 2380 -3630 {
lab=#net22}
N 2600 -3630 2620 -3630 {
lab=#net22}
N 2600 -3650 2620 -3650 {
lab=#net21}
N 2600 -3670 2620 -3670 {
lab=colon_n[10]}
N 2600 -3690 2620 -3690 {
lab=col_n[10]}
N 2420 -3550 2420 -3540 {
lab=VSS}
N 2420 -3780 2420 -3770 {
lab=VDD}
N 2760 -3550 2770 -3560 {
lab=row_n[6]}
N 2770 -3760 2770 -3560 {
lab=row_n[6]}
N 2760 -3770 2770 -3760 {
lab=row_n[6]}
N 2760 -3550 2760 -3530 {
lab=row_n[6]}
N 2760 -3790 2760 -3770 {
lab=row_n[6]}
N 2640 -3690 2650 -3700 {
lab=col_n[10]}
N 2650 -3700 2850 -3700 {
lab=col_n[10]}
N 2850 -3700 2860 -3690 {
lab=col_n[10]}
N 2640 -3670 2650 -3680 {
lab=colon_n[10]}
N 2650 -3680 2850 -3680 {
lab=colon_n[10]}
N 2850 -3680 2860 -3670 {
lab=colon_n[10]}
N 2640 -3650 2650 -3660 {
lab=#net21}
N 2650 -3660 2850 -3660 {
lab=#net21}
N 2850 -3660 2860 -3650 {
lab=#net21}
N 2640 -3630 2650 -3640 {
lab=#net22}
N 2650 -3640 2850 -3640 {
lab=#net22}
N 2850 -3640 2860 -3630 {
lab=#net22}
N 2700 -3790 2700 -3770 {
lab=vcom}
N 2740 -3790 2740 -3770 {
lab=ctop}
N 2620 -3690 2640 -3690 {
lab=col_n[10]}
N 2620 -3670 2640 -3670 {
lab=colon_n[10]}
N 2620 -3650 2640 -3650 {
lab=#net21}
N 2620 -3630 2640 -3630 {
lab=#net22}
N 2860 -3630 2880 -3630 {
lab=#net22}
N 2860 -3650 2880 -3650 {
lab=#net21}
N 2860 -3670 2880 -3670 {
lab=colon_n[10]}
N 2860 -3690 2880 -3690 {
lab=col_n[10]}
N 2680 -3550 2680 -3540 {
lab=VSS}
N 2680 -3780 2680 -3770 {
lab=VDD}
N 3020 -3550 3030 -3560 {
lab=row_n[7]}
N 3030 -3760 3030 -3560 {
lab=row_n[7]}
N 3020 -3770 3030 -3760 {
lab=row_n[7]}
N 3020 -3550 3020 -3530 {
lab=row_n[7]}
N 3020 -3790 3020 -3770 {
lab=row_n[7]}
N 2900 -3690 2910 -3700 {
lab=col_n[10]}
N 2910 -3700 3110 -3700 {
lab=col_n[10]}
N 3110 -3700 3120 -3690 {
lab=col_n[10]}
N 2900 -3670 2910 -3680 {
lab=colon_n[10]}
N 2910 -3680 3110 -3680 {
lab=colon_n[10]}
N 3110 -3680 3120 -3670 {
lab=colon_n[10]}
N 2900 -3650 2910 -3660 {
lab=#net21}
N 2910 -3660 3110 -3660 {
lab=#net21}
N 3110 -3660 3120 -3650 {
lab=#net21}
N 2900 -3630 2910 -3640 {
lab=#net22}
N 2910 -3640 3110 -3640 {
lab=#net22}
N 3110 -3640 3120 -3630 {
lab=#net22}
N 2960 -3790 2960 -3770 {
lab=vcom}
N 3000 -3790 3000 -3770 {
lab=ctop}
N 2880 -3690 2900 -3690 {
lab=col_n[10]}
N 2880 -3670 2900 -3670 {
lab=colon_n[10]}
N 2880 -3650 2900 -3650 {
lab=#net21}
N 2880 -3630 2900 -3630 {
lab=#net22}
N 3120 -3630 3140 -3630 {
lab=#net22}
N 3120 -3650 3140 -3650 {
lab=#net21}
N 3120 -3670 3140 -3670 {
lab=colon_n[10]}
N 3120 -3690 3140 -3690 {
lab=col_n[10]}
N 2940 -3550 2940 -3540 {
lab=VSS}
N 2940 -3780 2940 -3770 {
lab=VDD}
N 3280 -3550 3290 -3560 {
lab=row_n[8]}
N 3290 -3760 3290 -3560 {
lab=row_n[8]}
N 3280 -3770 3290 -3760 {
lab=row_n[8]}
N 3280 -3550 3280 -3530 {
lab=row_n[8]}
N 3280 -3790 3280 -3770 {
lab=row_n[8]}
N 3160 -3690 3170 -3700 {
lab=col_n[10]}
N 3170 -3700 3370 -3700 {
lab=col_n[10]}
N 3370 -3700 3380 -3690 {
lab=col_n[10]}
N 3160 -3670 3170 -3680 {
lab=colon_n[10]}
N 3170 -3680 3370 -3680 {
lab=colon_n[10]}
N 3370 -3680 3380 -3670 {
lab=colon_n[10]}
N 3160 -3650 3170 -3660 {
lab=#net21}
N 3170 -3660 3370 -3660 {
lab=#net21}
N 3370 -3660 3380 -3650 {
lab=#net21}
N 3160 -3630 3170 -3640 {
lab=#net22}
N 3170 -3640 3370 -3640 {
lab=#net22}
N 3370 -3640 3380 -3630 {
lab=#net22}
N 3220 -3790 3220 -3770 {
lab=vcom}
N 3260 -3790 3260 -3770 {
lab=ctop}
N 3140 -3690 3160 -3690 {
lab=col_n[10]}
N 3140 -3670 3160 -3670 {
lab=colon_n[10]}
N 3140 -3650 3160 -3650 {
lab=#net21}
N 3140 -3630 3160 -3630 {
lab=#net22}
N 3380 -3630 3400 -3630 {
lab=#net22}
N 3380 -3650 3400 -3650 {
lab=#net21}
N 3380 -3670 3400 -3670 {
lab=colon_n[10]}
N 3380 -3690 3400 -3690 {
lab=col_n[10]}
N 3200 -3550 3200 -3540 {
lab=VSS}
N 3200 -3780 3200 -3770 {
lab=VDD}
N 3540 -3550 3550 -3560 {
lab=row_n[9]}
N 3550 -3760 3550 -3560 {
lab=row_n[9]}
N 3540 -3770 3550 -3760 {
lab=row_n[9]}
N 3540 -3550 3540 -3530 {
lab=row_n[9]}
N 3540 -3790 3540 -3770 {
lab=row_n[9]}
N 3420 -3690 3430 -3700 {
lab=col_n[10]}
N 3430 -3700 3630 -3700 {
lab=col_n[10]}
N 3630 -3700 3640 -3690 {
lab=col_n[10]}
N 3420 -3670 3430 -3680 {
lab=colon_n[10]}
N 3430 -3680 3630 -3680 {
lab=colon_n[10]}
N 3630 -3680 3640 -3670 {
lab=colon_n[10]}
N 3420 -3650 3430 -3660 {
lab=#net21}
N 3430 -3660 3630 -3660 {
lab=#net21}
N 3630 -3660 3640 -3650 {
lab=#net21}
N 3420 -3630 3430 -3640 {
lab=#net22}
N 3430 -3640 3630 -3640 {
lab=#net22}
N 3630 -3640 3640 -3630 {
lab=#net22}
N 3480 -3790 3480 -3770 {
lab=vcom}
N 3520 -3790 3520 -3770 {
lab=ctop}
N 3400 -3690 3420 -3690 {
lab=col_n[10]}
N 3400 -3670 3420 -3670 {
lab=colon_n[10]}
N 3400 -3650 3420 -3650 {
lab=#net21}
N 3400 -3630 3420 -3630 {
lab=#net22}
N 3640 -3630 3660 -3630 {
lab=#net22}
N 3640 -3650 3660 -3650 {
lab=#net21}
N 3640 -3670 3660 -3670 {
lab=colon_n[10]}
N 3640 -3690 3660 -3690 {
lab=col_n[10]}
N 3460 -3550 3460 -3540 {
lab=VSS}
N 3460 -3780 3460 -3770 {
lab=VDD}
N 3800 -3550 3810 -3560 {
lab=row_n[10]}
N 3810 -3760 3810 -3560 {
lab=row_n[10]}
N 3800 -3770 3810 -3760 {
lab=row_n[10]}
N 3800 -3550 3800 -3530 {
lab=row_n[10]}
N 3800 -3790 3800 -3770 {
lab=row_n[10]}
N 3680 -3690 3690 -3700 {
lab=col_n[10]}
N 3690 -3700 3890 -3700 {
lab=col_n[10]}
N 3890 -3700 3900 -3690 {
lab=col_n[10]}
N 3680 -3670 3690 -3680 {
lab=colon_n[10]}
N 3690 -3680 3890 -3680 {
lab=colon_n[10]}
N 3890 -3680 3900 -3670 {
lab=colon_n[10]}
N 3680 -3650 3690 -3660 {
lab=#net21}
N 3690 -3660 3890 -3660 {
lab=#net21}
N 3890 -3660 3900 -3650 {
lab=#net21}
N 3680 -3630 3690 -3640 {
lab=#net22}
N 3690 -3640 3890 -3640 {
lab=#net22}
N 3890 -3640 3900 -3630 {
lab=#net22}
N 3740 -3790 3740 -3770 {
lab=vcom}
N 3780 -3790 3780 -3770 {
lab=ctop}
N 3660 -3690 3680 -3690 {
lab=col_n[10]}
N 3660 -3670 3680 -3670 {
lab=colon_n[10]}
N 3660 -3650 3680 -3650 {
lab=#net21}
N 3660 -3630 3680 -3630 {
lab=#net22}
N 3900 -3630 3920 -3630 {
lab=#net22}
N 3900 -3650 3920 -3650 {
lab=#net21}
N 3900 -3670 3920 -3670 {
lab=colon_n[10]}
N 3900 -3690 3920 -3690 {
lab=col_n[10]}
N 3720 -3550 3720 -3540 {
lab=VSS}
N 3720 -3780 3720 -3770 {
lab=VDD}
N 4060 -3550 4070 -3560 {
lab=row_n[11]}
N 4070 -3760 4070 -3560 {
lab=row_n[11]}
N 4060 -3770 4070 -3760 {
lab=row_n[11]}
N 4060 -3550 4060 -3530 {
lab=row_n[11]}
N 4060 -3790 4060 -3770 {
lab=row_n[11]}
N 3940 -3690 3950 -3700 {
lab=col_n[10]}
N 3950 -3700 4150 -3700 {
lab=col_n[10]}
N 4150 -3700 4160 -3690 {
lab=col_n[10]}
N 3940 -3670 3950 -3680 {
lab=colon_n[10]}
N 3950 -3680 4150 -3680 {
lab=colon_n[10]}
N 4150 -3680 4160 -3670 {
lab=colon_n[10]}
N 3940 -3650 3950 -3660 {
lab=#net21}
N 3950 -3660 4150 -3660 {
lab=#net21}
N 4150 -3660 4160 -3650 {
lab=#net21}
N 3940 -3630 3950 -3640 {
lab=#net22}
N 3950 -3640 4150 -3640 {
lab=#net22}
N 4150 -3640 4160 -3630 {
lab=#net22}
N 4000 -3790 4000 -3770 {
lab=vcom}
N 4040 -3790 4040 -3770 {
lab=ctop}
N 3920 -3690 3940 -3690 {
lab=col_n[10]}
N 3920 -3670 3940 -3670 {
lab=colon_n[10]}
N 3920 -3650 3940 -3650 {
lab=#net21}
N 3920 -3630 3940 -3630 {
lab=#net22}
N 4160 -3630 4180 -3630 {
lab=#net22}
N 4160 -3650 4180 -3650 {
lab=#net21}
N 4160 -3670 4180 -3670 {
lab=colon_n[10]}
N 4160 -3690 4180 -3690 {
lab=col_n[10]}
N 3980 -3550 3980 -3540 {
lab=VSS}
N 3980 -3780 3980 -3770 {
lab=VDD}
N 4320 -3550 4330 -3560 {
lab=row_n[12]}
N 4330 -3760 4330 -3560 {
lab=row_n[12]}
N 4320 -3770 4330 -3760 {
lab=row_n[12]}
N 4320 -3550 4320 -3530 {
lab=row_n[12]}
N 4320 -3790 4320 -3770 {
lab=row_n[12]}
N 4200 -3690 4210 -3700 {
lab=col_n[10]}
N 4210 -3700 4410 -3700 {
lab=col_n[10]}
N 4410 -3700 4420 -3690 {
lab=col_n[10]}
N 4200 -3670 4210 -3680 {
lab=colon_n[10]}
N 4210 -3680 4410 -3680 {
lab=colon_n[10]}
N 4410 -3680 4420 -3670 {
lab=colon_n[10]}
N 4200 -3650 4210 -3660 {
lab=#net21}
N 4210 -3660 4410 -3660 {
lab=#net21}
N 4410 -3660 4420 -3650 {
lab=#net21}
N 4200 -3630 4210 -3640 {
lab=#net22}
N 4210 -3640 4410 -3640 {
lab=#net22}
N 4410 -3640 4420 -3630 {
lab=#net22}
N 4260 -3790 4260 -3770 {
lab=vcom}
N 4300 -3790 4300 -3770 {
lab=ctop}
N 4180 -3690 4200 -3690 {
lab=col_n[10]}
N 4180 -3670 4200 -3670 {
lab=colon_n[10]}
N 4180 -3650 4200 -3650 {
lab=#net21}
N 4180 -3630 4200 -3630 {
lab=#net22}
N 4420 -3630 4440 -3630 {
lab=#net22}
N 4420 -3650 4440 -3650 {
lab=#net21}
N 4420 -3670 4440 -3670 {
lab=colon_n[10]}
N 4420 -3690 4440 -3690 {
lab=col_n[10]}
N 4240 -3550 4240 -3540 {
lab=VSS}
N 4240 -3780 4240 -3770 {
lab=VDD}
N 4580 -3550 4590 -3560 {
lab=row_n[13]}
N 4590 -3760 4590 -3560 {
lab=row_n[13]}
N 4580 -3770 4590 -3760 {
lab=row_n[13]}
N 4580 -3550 4580 -3530 {
lab=row_n[13]}
N 4580 -3790 4580 -3770 {
lab=row_n[13]}
N 4460 -3690 4470 -3700 {
lab=col_n[10]}
N 4470 -3700 4670 -3700 {
lab=col_n[10]}
N 4670 -3700 4680 -3690 {
lab=col_n[10]}
N 4460 -3670 4470 -3680 {
lab=colon_n[10]}
N 4470 -3680 4670 -3680 {
lab=colon_n[10]}
N 4670 -3680 4680 -3670 {
lab=colon_n[10]}
N 4460 -3650 4470 -3660 {
lab=#net21}
N 4470 -3660 4670 -3660 {
lab=#net21}
N 4670 -3660 4680 -3650 {
lab=#net21}
N 4460 -3630 4470 -3640 {
lab=#net22}
N 4470 -3640 4670 -3640 {
lab=#net22}
N 4670 -3640 4680 -3630 {
lab=#net22}
N 4520 -3790 4520 -3770 {
lab=vcom}
N 4560 -3790 4560 -3770 {
lab=ctop}
N 4440 -3690 4460 -3690 {
lab=col_n[10]}
N 4440 -3670 4460 -3670 {
lab=colon_n[10]}
N 4440 -3650 4460 -3650 {
lab=#net21}
N 4440 -3630 4460 -3630 {
lab=#net22}
N 4680 -3630 4700 -3630 {
lab=#net22}
N 4680 -3650 4700 -3650 {
lab=#net21}
N 4680 -3670 4700 -3670 {
lab=colon_n[10]}
N 4680 -3690 4700 -3690 {
lab=col_n[10]}
N 4500 -3550 4500 -3540 {
lab=VSS}
N 4500 -3780 4500 -3770 {
lab=VDD}
N 4840 -3550 4850 -3560 {
lab=row_n[14]}
N 4850 -3760 4850 -3560 {
lab=row_n[14]}
N 4840 -3770 4850 -3760 {
lab=row_n[14]}
N 4840 -3550 4840 -3530 {
lab=row_n[14]}
N 4840 -3790 4840 -3770 {
lab=row_n[14]}
N 4720 -3690 4730 -3700 {
lab=col_n[10]}
N 4730 -3700 4930 -3700 {
lab=col_n[10]}
N 4930 -3700 4940 -3690 {
lab=col_n[10]}
N 4720 -3670 4730 -3680 {
lab=colon_n[10]}
N 4730 -3680 4930 -3680 {
lab=colon_n[10]}
N 4930 -3680 4940 -3670 {
lab=colon_n[10]}
N 4720 -3650 4730 -3660 {
lab=#net21}
N 4730 -3660 4930 -3660 {
lab=#net21}
N 4930 -3660 4940 -3650 {
lab=#net21}
N 4720 -3630 4730 -3640 {
lab=#net22}
N 4730 -3640 4930 -3640 {
lab=#net22}
N 4930 -3640 4940 -3630 {
lab=#net22}
N 4780 -3790 4780 -3770 {
lab=vcom}
N 4820 -3790 4820 -3770 {
lab=ctop}
N 4700 -3690 4720 -3690 {
lab=col_n[10]}
N 4700 -3670 4720 -3670 {
lab=colon_n[10]}
N 4700 -3650 4720 -3650 {
lab=#net21}
N 4700 -3630 4720 -3630 {
lab=#net22}
N 4940 -3630 4960 -3630 {
lab=#net22}
N 4940 -3650 4960 -3650 {
lab=#net21}
N 4940 -3670 4960 -3670 {
lab=colon_n[10]}
N 4940 -3690 4960 -3690 {
lab=col_n[10]}
N 4760 -3550 4760 -3540 {
lab=VSS}
N 4760 -3780 4760 -3770 {
lab=VDD}
N 5100 -3550 5110 -3560 {
lab=row_n[15]}
N 5110 -3760 5110 -3560 {
lab=row_n[15]}
N 5100 -3770 5110 -3760 {
lab=row_n[15]}
N 5100 -3550 5100 -3530 {
lab=row_n[15]}
N 5100 -3790 5100 -3770 {
lab=row_n[15]}
N 4980 -3690 4990 -3700 {
lab=col_n[10]}
N 4990 -3700 5190 -3700 {
lab=col_n[10]}
N 5190 -3700 5200 -3690 {
lab=col_n[10]}
N 4980 -3670 4990 -3680 {
lab=colon_n[10]}
N 4990 -3680 5190 -3680 {
lab=colon_n[10]}
N 5190 -3680 5200 -3670 {
lab=colon_n[10]}
N 4980 -3650 4990 -3660 {
lab=#net21}
N 4990 -3660 5190 -3660 {
lab=#net21}
N 5190 -3660 5200 -3650 {
lab=#net21}
N 4980 -3630 4990 -3640 {
lab=#net22}
N 4990 -3640 5190 -3640 {
lab=#net22}
N 5190 -3640 5200 -3630 {
lab=#net22}
N 5040 -3790 5040 -3770 {
lab=vcom}
N 5080 -3790 5080 -3770 {
lab=ctop}
N 4960 -3690 4980 -3690 {
lab=col_n[10]}
N 4960 -3670 4980 -3670 {
lab=colon_n[10]}
N 4960 -3650 4980 -3650 {
lab=#net21}
N 4960 -3630 4980 -3630 {
lab=#net22}
N 5200 -3630 5220 -3630 {
lab=#net22}
N 5200 -3650 5220 -3650 {
lab=#net21}
N 5200 -3670 5220 -3670 {
lab=colon_n[10]}
N 5200 -3690 5220 -3690 {
lab=col_n[10]}
N 5020 -3550 5020 -3540 {
lab=VSS}
N 5020 -3780 5020 -3770 {
lab=VDD}
N 5360 -3550 5370 -3560 {
lab=row_n[16]}
N 5370 -3760 5370 -3560 {
lab=row_n[16]}
N 5360 -3770 5370 -3760 {
lab=row_n[16]}
N 5360 -3550 5360 -3530 {
lab=row_n[16]}
N 5360 -3790 5360 -3770 {
lab=row_n[16]}
N 5240 -3690 5250 -3700 {
lab=col_n[10]}
N 5250 -3700 5450 -3700 {
lab=col_n[10]}
N 5450 -3700 5460 -3690 {
lab=col_n[10]}
N 5240 -3670 5250 -3680 {
lab=colon_n[10]}
N 5250 -3680 5450 -3680 {
lab=colon_n[10]}
N 5450 -3680 5460 -3670 {
lab=colon_n[10]}
N 5240 -3650 5250 -3660 {
lab=#net21}
N 5250 -3660 5450 -3660 {
lab=#net21}
N 5450 -3660 5460 -3650 {
lab=#net21}
N 5240 -3630 5250 -3640 {
lab=#net22}
N 5250 -3640 5450 -3640 {
lab=#net22}
N 5450 -3640 5460 -3630 {
lab=#net22}
N 5300 -3790 5300 -3770 {
lab=vcom}
N 5340 -3790 5340 -3770 {
lab=ctop}
N 5220 -3690 5240 -3690 {
lab=col_n[10]}
N 5220 -3670 5240 -3670 {
lab=colon_n[10]}
N 5220 -3650 5240 -3650 {
lab=#net21}
N 5220 -3630 5240 -3630 {
lab=#net22}
N 5460 -3630 5480 -3630 {
lab=#net22}
N 5460 -3650 5480 -3650 {
lab=#net21}
N 5460 -3670 5480 -3670 {
lab=colon_n[10]}
N 5460 -3690 5480 -3690 {
lab=col_n[10]}
N 5280 -3550 5280 -3540 {
lab=VSS}
N 5280 -3780 5280 -3770 {
lab=VDD}
N 5620 -3550 5630 -3560 {
lab=row_n[17]}
N 5630 -3760 5630 -3560 {
lab=row_n[17]}
N 5620 -3770 5630 -3760 {
lab=row_n[17]}
N 5620 -3550 5620 -3530 {
lab=row_n[17]}
N 5620 -3790 5620 -3770 {
lab=row_n[17]}
N 5500 -3690 5510 -3700 {
lab=col_n[10]}
N 5510 -3700 5710 -3700 {
lab=col_n[10]}
N 5710 -3700 5720 -3690 {
lab=col_n[10]}
N 5500 -3670 5510 -3680 {
lab=colon_n[10]}
N 5510 -3680 5710 -3680 {
lab=colon_n[10]}
N 5710 -3680 5720 -3670 {
lab=colon_n[10]}
N 5500 -3650 5510 -3660 {
lab=#net21}
N 5510 -3660 5710 -3660 {
lab=#net21}
N 5710 -3660 5720 -3650 {
lab=#net21}
N 5500 -3630 5510 -3640 {
lab=#net22}
N 5510 -3640 5710 -3640 {
lab=#net22}
N 5710 -3640 5720 -3630 {
lab=#net22}
N 5560 -3790 5560 -3770 {
lab=vcom}
N 5600 -3790 5600 -3770 {
lab=ctop}
N 5480 -3690 5500 -3690 {
lab=col_n[10]}
N 5480 -3670 5500 -3670 {
lab=colon_n[10]}
N 5480 -3650 5500 -3650 {
lab=#net21}
N 5480 -3630 5500 -3630 {
lab=#net22}
N 5720 -3630 5740 -3630 {
lab=#net22}
N 5720 -3650 5740 -3650 {
lab=#net21}
N 5720 -3670 5740 -3670 {
lab=colon_n[10]}
N 5720 -3690 5740 -3690 {
lab=col_n[10]}
N 5540 -3550 5540 -3540 {
lab=VSS}
N 5540 -3780 5540 -3770 {
lab=VDD}
N 5880 -3550 5890 -3560 {
lab=row_n[18]}
N 5890 -3760 5890 -3560 {
lab=row_n[18]}
N 5880 -3770 5890 -3760 {
lab=row_n[18]}
N 5880 -3550 5880 -3530 {
lab=row_n[18]}
N 5880 -3790 5880 -3770 {
lab=row_n[18]}
N 5760 -3690 5770 -3700 {
lab=col_n[10]}
N 5770 -3700 5970 -3700 {
lab=col_n[10]}
N 5970 -3700 5980 -3690 {
lab=col_n[10]}
N 5760 -3670 5770 -3680 {
lab=colon_n[10]}
N 5770 -3680 5970 -3680 {
lab=colon_n[10]}
N 5970 -3680 5980 -3670 {
lab=colon_n[10]}
N 5760 -3650 5770 -3660 {
lab=#net21}
N 5770 -3660 5970 -3660 {
lab=#net21}
N 5970 -3660 5980 -3650 {
lab=#net21}
N 5760 -3630 5770 -3640 {
lab=#net22}
N 5770 -3640 5970 -3640 {
lab=#net22}
N 5970 -3640 5980 -3630 {
lab=#net22}
N 5820 -3790 5820 -3770 {
lab=vcom}
N 5860 -3790 5860 -3770 {
lab=ctop}
N 5740 -3690 5760 -3690 {
lab=col_n[10]}
N 5740 -3670 5760 -3670 {
lab=colon_n[10]}
N 5740 -3650 5760 -3650 {
lab=#net21}
N 5740 -3630 5760 -3630 {
lab=#net22}
N 5980 -3630 6000 -3630 {
lab=#net22}
N 5980 -3650 6000 -3650 {
lab=#net21}
N 5980 -3670 6000 -3670 {
lab=colon_n[10]}
N 5980 -3690 6000 -3690 {
lab=col_n[10]}
N 5800 -3550 5800 -3540 {
lab=VSS}
N 5800 -3780 5800 -3770 {
lab=VDD}
N 6140 -3550 6150 -3560 {
lab=row_n[19]}
N 6150 -3760 6150 -3560 {
lab=row_n[19]}
N 6140 -3770 6150 -3760 {
lab=row_n[19]}
N 6140 -3550 6140 -3530 {
lab=row_n[19]}
N 6140 -3790 6140 -3770 {
lab=row_n[19]}
N 6020 -3690 6030 -3700 {
lab=col_n[10]}
N 6030 -3700 6230 -3700 {
lab=col_n[10]}
N 6230 -3700 6240 -3690 {
lab=col_n[10]}
N 6020 -3670 6030 -3680 {
lab=colon_n[10]}
N 6030 -3680 6230 -3680 {
lab=colon_n[10]}
N 6230 -3680 6240 -3670 {
lab=colon_n[10]}
N 6020 -3650 6030 -3660 {
lab=#net21}
N 6030 -3660 6230 -3660 {
lab=#net21}
N 6230 -3660 6240 -3650 {
lab=#net21}
N 6020 -3630 6030 -3640 {
lab=#net22}
N 6030 -3640 6230 -3640 {
lab=#net22}
N 6230 -3640 6240 -3630 {
lab=#net22}
N 6080 -3790 6080 -3770 {
lab=vcom}
N 6120 -3790 6120 -3770 {
lab=ctop}
N 6000 -3690 6020 -3690 {
lab=col_n[10]}
N 6000 -3670 6020 -3670 {
lab=colon_n[10]}
N 6000 -3650 6020 -3650 {
lab=#net21}
N 6000 -3630 6020 -3630 {
lab=#net22}
N 6240 -3630 6260 -3630 {
lab=#net22}
N 6240 -3650 6260 -3650 {
lab=#net21}
N 6240 -3670 6260 -3670 {
lab=colon_n[10]}
N 6240 -3690 6260 -3690 {
lab=col_n[10]}
N 6060 -3550 6060 -3540 {
lab=VSS}
N 6060 -3780 6060 -3770 {
lab=VDD}
N 6400 -3550 6410 -3560 {
lab=row_n[20]}
N 6410 -3760 6410 -3560 {
lab=row_n[20]}
N 6400 -3770 6410 -3760 {
lab=row_n[20]}
N 6400 -3550 6400 -3530 {
lab=row_n[20]}
N 6400 -3790 6400 -3770 {
lab=row_n[20]}
N 6280 -3690 6290 -3700 {
lab=col_n[10]}
N 6290 -3700 6490 -3700 {
lab=col_n[10]}
N 6490 -3700 6500 -3690 {
lab=col_n[10]}
N 6280 -3670 6290 -3680 {
lab=colon_n[10]}
N 6290 -3680 6490 -3680 {
lab=colon_n[10]}
N 6490 -3680 6500 -3670 {
lab=colon_n[10]}
N 6280 -3650 6290 -3660 {
lab=#net21}
N 6290 -3660 6490 -3660 {
lab=#net21}
N 6490 -3660 6500 -3650 {
lab=#net21}
N 6280 -3630 6290 -3640 {
lab=#net22}
N 6290 -3640 6490 -3640 {
lab=#net22}
N 6490 -3640 6500 -3630 {
lab=#net22}
N 6340 -3790 6340 -3770 {
lab=vcom}
N 6380 -3790 6380 -3770 {
lab=ctop}
N 6260 -3690 6280 -3690 {
lab=col_n[10]}
N 6260 -3670 6280 -3670 {
lab=colon_n[10]}
N 6260 -3650 6280 -3650 {
lab=#net21}
N 6260 -3630 6280 -3630 {
lab=#net22}
N 6500 -3630 6520 -3630 {
lab=#net22}
N 6500 -3650 6520 -3650 {
lab=#net21}
N 6500 -3670 6520 -3670 {
lab=colon_n[10]}
N 6500 -3690 6520 -3690 {
lab=col_n[10]}
N 6320 -3550 6320 -3540 {
lab=VSS}
N 6320 -3780 6320 -3770 {
lab=VDD}
N 6660 -3550 6670 -3560 {
lab=row_n[21]}
N 6670 -3760 6670 -3560 {
lab=row_n[21]}
N 6660 -3770 6670 -3760 {
lab=row_n[21]}
N 6660 -3550 6660 -3530 {
lab=row_n[21]}
N 6660 -3790 6660 -3770 {
lab=row_n[21]}
N 6540 -3690 6550 -3700 {
lab=col_n[10]}
N 6550 -3700 6750 -3700 {
lab=col_n[10]}
N 6750 -3700 6760 -3690 {
lab=col_n[10]}
N 6540 -3670 6550 -3680 {
lab=colon_n[10]}
N 6550 -3680 6750 -3680 {
lab=colon_n[10]}
N 6750 -3680 6760 -3670 {
lab=colon_n[10]}
N 6540 -3650 6550 -3660 {
lab=#net21}
N 6550 -3660 6750 -3660 {
lab=#net21}
N 6750 -3660 6760 -3650 {
lab=#net21}
N 6540 -3630 6550 -3640 {
lab=#net22}
N 6550 -3640 6750 -3640 {
lab=#net22}
N 6750 -3640 6760 -3630 {
lab=#net22}
N 6600 -3790 6600 -3770 {
lab=vcom}
N 6640 -3790 6640 -3770 {
lab=ctop}
N 6520 -3690 6540 -3690 {
lab=col_n[10]}
N 6520 -3670 6540 -3670 {
lab=colon_n[10]}
N 6520 -3650 6540 -3650 {
lab=#net21}
N 6520 -3630 6540 -3630 {
lab=#net22}
N 6760 -3630 6780 -3630 {
lab=#net22}
N 6760 -3650 6780 -3650 {
lab=#net21}
N 6760 -3670 6780 -3670 {
lab=colon_n[10]}
N 6760 -3690 6780 -3690 {
lab=col_n[10]}
N 6580 -3550 6580 -3540 {
lab=VSS}
N 6580 -3780 6580 -3770 {
lab=VDD}
N 6920 -3550 6930 -3560 {
lab=row_n[22]}
N 6930 -3760 6930 -3560 {
lab=row_n[22]}
N 6920 -3770 6930 -3760 {
lab=row_n[22]}
N 6920 -3550 6920 -3530 {
lab=row_n[22]}
N 6920 -3790 6920 -3770 {
lab=row_n[22]}
N 6800 -3690 6810 -3700 {
lab=col_n[10]}
N 6810 -3700 7010 -3700 {
lab=col_n[10]}
N 7010 -3700 7020 -3690 {
lab=col_n[10]}
N 6800 -3670 6810 -3680 {
lab=colon_n[10]}
N 6810 -3680 7010 -3680 {
lab=colon_n[10]}
N 7010 -3680 7020 -3670 {
lab=colon_n[10]}
N 6800 -3650 6810 -3660 {
lab=#net21}
N 6810 -3660 7010 -3660 {
lab=#net21}
N 7010 -3660 7020 -3650 {
lab=#net21}
N 6800 -3630 6810 -3640 {
lab=#net22}
N 6810 -3640 7010 -3640 {
lab=#net22}
N 7010 -3640 7020 -3630 {
lab=#net22}
N 6860 -3790 6860 -3770 {
lab=vcom}
N 6900 -3790 6900 -3770 {
lab=ctop}
N 6780 -3690 6800 -3690 {
lab=col_n[10]}
N 6780 -3670 6800 -3670 {
lab=colon_n[10]}
N 6780 -3650 6800 -3650 {
lab=#net21}
N 6780 -3630 6800 -3630 {
lab=#net22}
N 7020 -3630 7040 -3630 {
lab=#net22}
N 7020 -3650 7040 -3650 {
lab=#net21}
N 7020 -3670 7040 -3670 {
lab=colon_n[10]}
N 7020 -3690 7040 -3690 {
lab=col_n[10]}
N 6840 -3550 6840 -3540 {
lab=VSS}
N 6840 -3780 6840 -3770 {
lab=VDD}
N 7180 -3550 7190 -3560 {
lab=row_n[23]}
N 7190 -3760 7190 -3560 {
lab=row_n[23]}
N 7180 -3770 7190 -3760 {
lab=row_n[23]}
N 7180 -3550 7180 -3530 {
lab=row_n[23]}
N 7180 -3790 7180 -3770 {
lab=row_n[23]}
N 7060 -3690 7070 -3700 {
lab=col_n[10]}
N 7070 -3700 7270 -3700 {
lab=col_n[10]}
N 7270 -3700 7280 -3690 {
lab=col_n[10]}
N 7060 -3670 7070 -3680 {
lab=colon_n[10]}
N 7070 -3680 7270 -3680 {
lab=colon_n[10]}
N 7270 -3680 7280 -3670 {
lab=colon_n[10]}
N 7060 -3650 7070 -3660 {
lab=#net21}
N 7070 -3660 7270 -3660 {
lab=#net21}
N 7270 -3660 7280 -3650 {
lab=#net21}
N 7060 -3630 7070 -3640 {
lab=#net22}
N 7070 -3640 7270 -3640 {
lab=#net22}
N 7270 -3640 7280 -3630 {
lab=#net22}
N 7120 -3790 7120 -3770 {
lab=vcom}
N 7160 -3790 7160 -3770 {
lab=ctop}
N 7040 -3690 7060 -3690 {
lab=col_n[10]}
N 7040 -3670 7060 -3670 {
lab=colon_n[10]}
N 7040 -3650 7060 -3650 {
lab=#net21}
N 7040 -3630 7060 -3630 {
lab=#net22}
N 7280 -3630 7300 -3630 {
lab=#net22}
N 7280 -3650 7300 -3650 {
lab=#net21}
N 7280 -3670 7300 -3670 {
lab=colon_n[10]}
N 7280 -3690 7300 -3690 {
lab=col_n[10]}
N 7100 -3550 7100 -3540 {
lab=VSS}
N 7100 -3780 7100 -3770 {
lab=VDD}
N 7440 -3550 7450 -3560 {
lab=row_n[24]}
N 7450 -3760 7450 -3560 {
lab=row_n[24]}
N 7440 -3770 7450 -3760 {
lab=row_n[24]}
N 7440 -3550 7440 -3530 {
lab=row_n[24]}
N 7440 -3790 7440 -3770 {
lab=row_n[24]}
N 7320 -3690 7330 -3700 {
lab=col_n[10]}
N 7330 -3700 7530 -3700 {
lab=col_n[10]}
N 7530 -3700 7540 -3690 {
lab=col_n[10]}
N 7320 -3670 7330 -3680 {
lab=colon_n[10]}
N 7330 -3680 7530 -3680 {
lab=colon_n[10]}
N 7530 -3680 7540 -3670 {
lab=colon_n[10]}
N 7320 -3650 7330 -3660 {
lab=#net21}
N 7330 -3660 7530 -3660 {
lab=#net21}
N 7530 -3660 7540 -3650 {
lab=#net21}
N 7320 -3630 7330 -3640 {
lab=#net22}
N 7330 -3640 7530 -3640 {
lab=#net22}
N 7530 -3640 7540 -3630 {
lab=#net22}
N 7380 -3790 7380 -3770 {
lab=vcom}
N 7420 -3790 7420 -3770 {
lab=ctop}
N 7300 -3690 7320 -3690 {
lab=col_n[10]}
N 7300 -3670 7320 -3670 {
lab=colon_n[10]}
N 7300 -3650 7320 -3650 {
lab=#net21}
N 7300 -3630 7320 -3630 {
lab=#net22}
N 7540 -3630 7560 -3630 {
lab=#net22}
N 7540 -3650 7560 -3650 {
lab=#net21}
N 7540 -3670 7560 -3670 {
lab=colon_n[10]}
N 7540 -3690 7560 -3690 {
lab=col_n[10]}
N 7360 -3550 7360 -3540 {
lab=VSS}
N 7360 -3780 7360 -3770 {
lab=VDD}
N 7700 -3550 7710 -3560 {
lab=row_n[25]}
N 7710 -3760 7710 -3560 {
lab=row_n[25]}
N 7700 -3770 7710 -3760 {
lab=row_n[25]}
N 7700 -3550 7700 -3530 {
lab=row_n[25]}
N 7700 -3790 7700 -3770 {
lab=row_n[25]}
N 7580 -3690 7590 -3700 {
lab=col_n[10]}
N 7590 -3700 7790 -3700 {
lab=col_n[10]}
N 7790 -3700 7800 -3690 {
lab=col_n[10]}
N 7580 -3670 7590 -3680 {
lab=colon_n[10]}
N 7590 -3680 7790 -3680 {
lab=colon_n[10]}
N 7790 -3680 7800 -3670 {
lab=colon_n[10]}
N 7580 -3650 7590 -3660 {
lab=#net21}
N 7590 -3660 7790 -3660 {
lab=#net21}
N 7790 -3660 7800 -3650 {
lab=#net21}
N 7580 -3630 7590 -3640 {
lab=#net22}
N 7590 -3640 7790 -3640 {
lab=#net22}
N 7790 -3640 7800 -3630 {
lab=#net22}
N 7640 -3790 7640 -3770 {
lab=vcom}
N 7680 -3790 7680 -3770 {
lab=ctop}
N 7560 -3690 7580 -3690 {
lab=col_n[10]}
N 7560 -3670 7580 -3670 {
lab=colon_n[10]}
N 7560 -3650 7580 -3650 {
lab=#net21}
N 7560 -3630 7580 -3630 {
lab=#net22}
N 7800 -3630 7820 -3630 {
lab=#net22}
N 7800 -3650 7820 -3650 {
lab=#net21}
N 7800 -3670 7820 -3670 {
lab=colon_n[10]}
N 7800 -3690 7820 -3690 {
lab=col_n[10]}
N 7620 -3550 7620 -3540 {
lab=VSS}
N 7620 -3780 7620 -3770 {
lab=VDD}
N 7960 -3550 7970 -3560 {
lab=row_n[26]}
N 7970 -3760 7970 -3560 {
lab=row_n[26]}
N 7960 -3770 7970 -3760 {
lab=row_n[26]}
N 7960 -3550 7960 -3530 {
lab=row_n[26]}
N 7960 -3790 7960 -3770 {
lab=row_n[26]}
N 7840 -3690 7850 -3700 {
lab=col_n[10]}
N 7850 -3700 8050 -3700 {
lab=col_n[10]}
N 8050 -3700 8060 -3690 {
lab=col_n[10]}
N 7840 -3670 7850 -3680 {
lab=colon_n[10]}
N 7850 -3680 8050 -3680 {
lab=colon_n[10]}
N 8050 -3680 8060 -3670 {
lab=colon_n[10]}
N 7840 -3650 7850 -3660 {
lab=#net21}
N 7850 -3660 8050 -3660 {
lab=#net21}
N 8050 -3660 8060 -3650 {
lab=#net21}
N 7840 -3630 7850 -3640 {
lab=#net22}
N 7850 -3640 8050 -3640 {
lab=#net22}
N 8050 -3640 8060 -3630 {
lab=#net22}
N 7900 -3790 7900 -3770 {
lab=vcom}
N 7940 -3790 7940 -3770 {
lab=ctop}
N 7820 -3690 7840 -3690 {
lab=col_n[10]}
N 7820 -3670 7840 -3670 {
lab=colon_n[10]}
N 7820 -3650 7840 -3650 {
lab=#net21}
N 7820 -3630 7840 -3630 {
lab=#net22}
N 8060 -3630 8080 -3630 {
lab=#net22}
N 8060 -3650 8080 -3650 {
lab=#net21}
N 8060 -3670 8080 -3670 {
lab=colon_n[10]}
N 8060 -3690 8080 -3690 {
lab=col_n[10]}
N 7880 -3550 7880 -3540 {
lab=VSS}
N 7880 -3780 7880 -3770 {
lab=VDD}
N 8220 -3550 8230 -3560 {
lab=row_n[27]}
N 8230 -3760 8230 -3560 {
lab=row_n[27]}
N 8220 -3770 8230 -3760 {
lab=row_n[27]}
N 8220 -3550 8220 -3530 {
lab=row_n[27]}
N 8220 -3790 8220 -3770 {
lab=row_n[27]}
N 8100 -3690 8110 -3700 {
lab=col_n[10]}
N 8110 -3700 8310 -3700 {
lab=col_n[10]}
N 8310 -3700 8320 -3690 {
lab=col_n[10]}
N 8100 -3670 8110 -3680 {
lab=colon_n[10]}
N 8110 -3680 8310 -3680 {
lab=colon_n[10]}
N 8310 -3680 8320 -3670 {
lab=colon_n[10]}
N 8100 -3650 8110 -3660 {
lab=#net21}
N 8110 -3660 8310 -3660 {
lab=#net21}
N 8310 -3660 8320 -3650 {
lab=#net21}
N 8100 -3630 8110 -3640 {
lab=#net22}
N 8110 -3640 8310 -3640 {
lab=#net22}
N 8310 -3640 8320 -3630 {
lab=#net22}
N 8160 -3790 8160 -3770 {
lab=vcom}
N 8200 -3790 8200 -3770 {
lab=ctop}
N 8080 -3690 8100 -3690 {
lab=col_n[10]}
N 8080 -3670 8100 -3670 {
lab=colon_n[10]}
N 8080 -3650 8100 -3650 {
lab=#net21}
N 8080 -3630 8100 -3630 {
lab=#net22}
N 8320 -3630 8340 -3630 {
lab=#net22}
N 8320 -3650 8340 -3650 {
lab=#net21}
N 8320 -3670 8340 -3670 {
lab=colon_n[10]}
N 8320 -3690 8340 -3690 {
lab=col_n[10]}
N 8140 -3550 8140 -3540 {
lab=VSS}
N 8140 -3780 8140 -3770 {
lab=VDD}
N 8480 -3550 8490 -3560 {
lab=row_n[28]}
N 8490 -3760 8490 -3560 {
lab=row_n[28]}
N 8480 -3770 8490 -3760 {
lab=row_n[28]}
N 8480 -3550 8480 -3530 {
lab=row_n[28]}
N 8480 -3790 8480 -3770 {
lab=row_n[28]}
N 8360 -3690 8370 -3700 {
lab=col_n[10]}
N 8370 -3700 8570 -3700 {
lab=col_n[10]}
N 8570 -3700 8580 -3690 {
lab=col_n[10]}
N 8360 -3670 8370 -3680 {
lab=colon_n[10]}
N 8370 -3680 8570 -3680 {
lab=colon_n[10]}
N 8570 -3680 8580 -3670 {
lab=colon_n[10]}
N 8360 -3650 8370 -3660 {
lab=#net21}
N 8370 -3660 8570 -3660 {
lab=#net21}
N 8570 -3660 8580 -3650 {
lab=#net21}
N 8360 -3630 8370 -3640 {
lab=#net22}
N 8370 -3640 8570 -3640 {
lab=#net22}
N 8570 -3640 8580 -3630 {
lab=#net22}
N 8420 -3790 8420 -3770 {
lab=vcom}
N 8460 -3790 8460 -3770 {
lab=ctop}
N 8340 -3690 8360 -3690 {
lab=col_n[10]}
N 8340 -3670 8360 -3670 {
lab=colon_n[10]}
N 8340 -3650 8360 -3650 {
lab=#net21}
N 8340 -3630 8360 -3630 {
lab=#net22}
N 8580 -3630 8600 -3630 {
lab=#net22}
N 8580 -3650 8600 -3650 {
lab=#net21}
N 8580 -3670 8600 -3670 {
lab=colon_n[10]}
N 8580 -3690 8600 -3690 {
lab=col_n[10]}
N 8400 -3550 8400 -3540 {
lab=VSS}
N 8400 -3780 8400 -3770 {
lab=VDD}
N 8740 -3550 8750 -3560 {
lab=row_n[29]}
N 8750 -3760 8750 -3560 {
lab=row_n[29]}
N 8740 -3770 8750 -3760 {
lab=row_n[29]}
N 8740 -3550 8740 -3530 {
lab=row_n[29]}
N 8740 -3790 8740 -3770 {
lab=row_n[29]}
N 8620 -3690 8630 -3700 {
lab=col_n[10]}
N 8630 -3700 8830 -3700 {
lab=col_n[10]}
N 8830 -3700 8840 -3690 {
lab=col_n[10]}
N 8620 -3670 8630 -3680 {
lab=colon_n[10]}
N 8630 -3680 8830 -3680 {
lab=colon_n[10]}
N 8830 -3680 8840 -3670 {
lab=colon_n[10]}
N 8620 -3650 8630 -3660 {
lab=#net21}
N 8630 -3660 8830 -3660 {
lab=#net21}
N 8830 -3660 8840 -3650 {
lab=#net21}
N 8620 -3630 8630 -3640 {
lab=#net22}
N 8630 -3640 8830 -3640 {
lab=#net22}
N 8830 -3640 8840 -3630 {
lab=#net22}
N 8680 -3790 8680 -3770 {
lab=vcom}
N 8720 -3790 8720 -3770 {
lab=ctop}
N 8600 -3690 8620 -3690 {
lab=col_n[10]}
N 8600 -3670 8620 -3670 {
lab=colon_n[10]}
N 8600 -3650 8620 -3650 {
lab=#net21}
N 8600 -3630 8620 -3630 {
lab=#net22}
N 8840 -3630 8860 -3630 {
lab=#net22}
N 8840 -3650 8860 -3650 {
lab=#net21}
N 8840 -3670 8860 -3670 {
lab=colon_n[10]}
N 8840 -3690 8860 -3690 {
lab=col_n[10]}
N 8660 -3550 8660 -3540 {
lab=VSS}
N 8660 -3780 8660 -3770 {
lab=VDD}
N 9000 -3550 9010 -3560 {
lab=row_n[30]}
N 9010 -3760 9010 -3560 {
lab=row_n[30]}
N 9000 -3770 9010 -3760 {
lab=row_n[30]}
N 9000 -3550 9000 -3530 {
lab=row_n[30]}
N 9000 -3790 9000 -3770 {
lab=row_n[30]}
N 8880 -3690 8890 -3700 {
lab=col_n[10]}
N 8890 -3700 9090 -3700 {
lab=col_n[10]}
N 9090 -3700 9100 -3690 {
lab=col_n[10]}
N 8880 -3670 8890 -3680 {
lab=colon_n[10]}
N 8890 -3680 9090 -3680 {
lab=colon_n[10]}
N 9090 -3680 9100 -3670 {
lab=colon_n[10]}
N 8880 -3650 8890 -3660 {
lab=#net21}
N 8890 -3660 9090 -3660 {
lab=#net21}
N 9090 -3660 9100 -3650 {
lab=#net21}
N 8880 -3630 8890 -3640 {
lab=#net22}
N 8890 -3640 9090 -3640 {
lab=#net22}
N 9090 -3640 9100 -3630 {
lab=#net22}
N 8940 -3790 8940 -3770 {
lab=vcom}
N 8980 -3790 8980 -3770 {
lab=ctop}
N 8860 -3690 8880 -3690 {
lab=col_n[10]}
N 8860 -3670 8880 -3670 {
lab=colon_n[10]}
N 8860 -3650 8880 -3650 {
lab=#net21}
N 8860 -3630 8880 -3630 {
lab=#net22}
N 9100 -3630 9120 -3630 {
lab=#net22}
N 9100 -3650 9120 -3650 {
lab=#net21}
N 9100 -3670 9120 -3670 {
lab=colon_n[10]}
N 9100 -3690 9120 -3690 {
lab=col_n[10]}
N 8920 -3550 8920 -3540 {
lab=VSS}
N 8920 -3780 8920 -3770 {
lab=VDD}
N 9260 -3550 9270 -3560 {
lab=row_n[31]}
N 9270 -3760 9270 -3560 {
lab=row_n[31]}
N 9260 -3770 9270 -3760 {
lab=row_n[31]}
N 9260 -3550 9260 -3530 {
lab=row_n[31]}
N 9260 -3790 9260 -3770 {
lab=row_n[31]}
N 9140 -3690 9150 -3700 {
lab=col_n[10]}
N 9150 -3700 9350 -3700 {
lab=col_n[10]}
N 9350 -3700 9360 -3690 {
lab=col_n[10]}
N 9140 -3670 9150 -3680 {
lab=colon_n[10]}
N 9150 -3680 9350 -3680 {
lab=colon_n[10]}
N 9350 -3680 9360 -3670 {
lab=colon_n[10]}
N 9140 -3650 9150 -3660 {
lab=#net21}
N 9150 -3660 9350 -3660 {
lab=#net21}
N 9350 -3660 9360 -3650 {
lab=#net21}
N 9140 -3630 9150 -3640 {
lab=#net22}
N 9150 -3640 9350 -3640 {
lab=#net22}
N 9350 -3640 9360 -3630 {
lab=#net22}
N 9200 -3790 9200 -3770 {
lab=vcom}
N 9240 -3790 9240 -3770 {
lab=ctop}
N 9120 -3690 9140 -3690 {
lab=col_n[10]}
N 9120 -3670 9140 -3670 {
lab=colon_n[10]}
N 9120 -3650 9140 -3650 {
lab=#net21}
N 9120 -3630 9140 -3630 {
lab=#net22}
N 9360 -3630 9380 -3630 {
lab=#net22}
N 9360 -3650 9380 -3650 {
lab=#net21}
N 9360 -3670 9380 -3670 {
lab=colon_n[10]}
N 9360 -3690 9380 -3690 {
lab=col_n[10]}
N 9180 -3550 9180 -3540 {
lab=VSS}
N 9180 -3780 9180 -3770 {
lab=VDD}
N 1200 -3810 1210 -3820 {
lab=row_n[0]}
N 1210 -4020 1210 -3820 {
lab=row_n[0]}
N 1200 -4030 1210 -4020 {
lab=row_n[0]}
N 1200 -3810 1200 -3790 {
lab=row_n[0]}
N 1200 -4050 1200 -4030 {
lab=row_n[0]}
N 1080 -3950 1090 -3960 {
lab=col_n[11]}
N 1090 -3960 1290 -3960 {
lab=col_n[11]}
N 1290 -3960 1300 -3950 {
lab=col_n[11]}
N 1080 -3930 1090 -3940 {
lab=colon_n[11]}
N 1090 -3940 1290 -3940 {
lab=colon_n[11]}
N 1290 -3940 1300 -3930 {
lab=colon_n[11]}
N 1080 -3910 1090 -3920 {
lab=#net23}
N 1090 -3920 1290 -3920 {
lab=#net23}
N 1290 -3920 1300 -3910 {
lab=#net23}
N 1080 -3890 1090 -3900 {
lab=#net24}
N 1090 -3900 1290 -3900 {
lab=#net24}
N 1290 -3900 1300 -3890 {
lab=#net24}
N 1140 -4050 1140 -4030 {
lab=vcom}
N 1180 -4050 1180 -4030 {
lab=ctop}
N 1060 -3950 1080 -3950 {
lab=col_n[11]}
N 1060 -3930 1080 -3930 {
lab=colon_n[11]}
N 1060 -3910 1080 -3910 {
lab=#net23}
N 1060 -3890 1080 -3890 {
lab=#net24}
N 1300 -3890 1320 -3890 {
lab=#net24}
N 1300 -3910 1320 -3910 {
lab=#net23}
