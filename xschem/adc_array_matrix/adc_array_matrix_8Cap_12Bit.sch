lab=colon_n[11]}
N 1090 -3940 1290 -3940 {
lab=colon_n[11]}
N 1290 -3940 1300 -3930 {
lab=colon_n[11]}
N 1080 -3910 1090 -3920 {
lab=#net23}
N 1090 -3920 1290 -3920 {
lab=#net23}
N 1290 -3920 1300 -3910 {
lab=#net23}
N 1080 -3890 1090 -3900 {
lab=#net24}
N 1090 -3900 1290 -3900 {
lab=#net24}
N 1290 -3900 1300 -3890 {
lab=#net24}
N 1140 -4050 1140 -4030 {
lab=vcom}
N 1180 -4050 1180 -4030 {
lab=ctop}
N 1060 -3950 1080 -3950 {
lab=col_n[11]}
N 1060 -3930 1080 -3930 {
lab=colon_n[11]}
N 1060 -3910 1080 -3910 {
lab=#net23}
N 1060 -3890 1080 -3890 {
lab=#net24}
N 1300 -3890 1320 -3890 {
lab=#net24}
N 1300 -3910 1320 -3910 {
lab=#net23}
N 1300 -3930 1320 -3930 {
lab=colon_n[11]}
N 1300 -3950 1320 -3950 {
lab=col_n[11]}
N 1120 -3810 1120 -3800 {
lab=VSS}
N 1120 -4040 1120 -4030 {
lab=VDD}
N 1460 -3810 1470 -3820 {
lab=row_n[1]}
N 1470 -4020 1470 -3820 {
lab=row_n[1]}
N 1460 -4030 1470 -4020 {
lab=row_n[1]}
N 1460 -3810 1460 -3790 {
lab=row_n[1]}
N 1460 -4050 1460 -4030 {
lab=row_n[1]}
N 1340 -3950 1350 -3960 {
lab=col_n[11]}
N 1350 -3960 1550 -3960 {
lab=col_n[11]}
N 1550 -3960 1560 -3950 {
lab=col_n[11]}
N 1340 -3930 1350 -3940 {
lab=colon_n[11]}
N 1350 -3940 1550 -3940 {
lab=colon_n[11]}
N 1550 -3940 1560 -3930 {
lab=colon_n[11]}
N 1340 -3910 1350 -3920 {
lab=#net23}
N 1350 -3920 1550 -3920 {
lab=#net23}
N 1550 -3920 1560 -3910 {
lab=#net23}
N 1340 -3890 1350 -3900 {
lab=#net24}
N 1350 -3900 1550 -3900 {
lab=#net24}
N 1550 -3900 1560 -3890 {
lab=#net24}
N 1400 -4050 1400 -4030 {
lab=vcom}
N 1440 -4050 1440 -4030 {
lab=ctop}
N 1320 -3950 1340 -3950 {
lab=col_n[11]}
N 1320 -3930 1340 -3930 {
lab=colon_n[11]}
N 1320 -3910 1340 -3910 {
lab=#net23}
N 1320 -3890 1340 -3890 {
lab=#net24}
N 1560 -3890 1580 -3890 {
lab=#net24}
N 1560 -3910 1580 -3910 {
lab=#net23}
N 1560 -3930 1580 -3930 {
lab=colon_n[11]}
N 1560 -3950 1580 -3950 {
lab=col_n[11]}
N 1380 -3810 1380 -3800 {
lab=VSS}
N 1380 -4040 1380 -4030 {
lab=VDD}
N 1720 -3810 1730 -3820 {
lab=row_n[2]}
N 1730 -4020 1730 -3820 {
lab=row_n[2]}
N 1720 -4030 1730 -4020 {
lab=row_n[2]}
N 1720 -3810 1720 -3790 {
lab=row_n[2]}
N 1720 -4050 1720 -4030 {
lab=row_n[2]}
N 1600 -3950 1610 -3960 {
lab=col_n[11]}
N 1610 -3960 1810 -3960 {
lab=col_n[11]}
N 1810 -3960 1820 -3950 {
lab=col_n[11]}
N 1600 -3930 1610 -3940 {
lab=colon_n[11]}
N 1610 -3940 1810 -3940 {
lab=colon_n[11]}
N 1810 -3940 1820 -3930 {
lab=colon_n[11]}
N 1600 -3910 1610 -3920 {
lab=#net23}
N 1610 -3920 1810 -3920 {
lab=#net23}
N 1810 -3920 1820 -3910 {
lab=#net23}
N 1600 -3890 1610 -3900 {
lab=#net24}
N 1610 -3900 1810 -3900 {
lab=#net24}
N 1810 -3900 1820 -3890 {
lab=#net24}
N 1660 -4050 1660 -4030 {
lab=vcom}
N 1700 -4050 1700 -4030 {
lab=ctop}
N 1580 -3950 1600 -3950 {
lab=col_n[11]}
N 1580 -3930 1600 -3930 {
lab=colon_n[11]}
N 1580 -3910 1600 -3910 {
lab=#net23}
N 1580 -3890 1600 -3890 {
lab=#net24}
N 1820 -3890 1840 -3890 {
lab=#net24}
N 1820 -3910 1840 -3910 {
lab=#net23}
N 1820 -3930 1840 -3930 {
lab=colon_n[11]}
N 1820 -3950 1840 -3950 {
lab=col_n[11]}
N 1640 -3810 1640 -3800 {
lab=VSS}
N 1640 -4040 1640 -4030 {
lab=VDD}
N 1980 -3810 1990 -3820 {
lab=row_n[3]}
N 1990 -4020 1990 -3820 {
lab=row_n[3]}
N 1980 -4030 1990 -4020 {
lab=row_n[3]}
N 1980 -3810 1980 -3790 {
lab=row_n[3]}
N 1980 -4050 1980 -4030 {
lab=row_n[3]}
N 1860 -3950 1870 -3960 {
lab=col_n[11]}
N 1870 -3960 2070 -3960 {
lab=col_n[11]}
N 2070 -3960 2080 -3950 {
lab=col_n[11]}
N 1860 -3930 1870 -3940 {
lab=colon_n[11]}
N 1870 -3940 2070 -3940 {
lab=colon_n[11]}
N 2070 -3940 2080 -3930 {
lab=colon_n[11]}
N 1860 -3910 1870 -3920 {
lab=#net23}
N 1870 -3920 2070 -3920 {
lab=#net23}
N 2070 -3920 2080 -3910 {
lab=#net23}
N 1860 -3890 1870 -3900 {
lab=#net24}
N 1870 -3900 2070 -3900 {
lab=#net24}
N 2070 -3900 2080 -3890 {
lab=#net24}
N 1920 -4050 1920 -4030 {
lab=vcom}
N 1960 -4050 1960 -4030 {
lab=ctop}
N 1840 -3950 1860 -3950 {
lab=col_n[11]}
N 1840 -3930 1860 -3930 {
lab=colon_n[11]}
N 1840 -3910 1860 -3910 {
lab=#net23}
N 1840 -3890 1860 -3890 {
lab=#net24}
N 2080 -3890 2100 -3890 {
lab=#net24}
N 2080 -3910 2100 -3910 {
lab=#net23}
N 2080 -3930 2100 -3930 {
lab=colon_n[11]}
N 2080 -3950 2100 -3950 {
lab=col_n[11]}
N 1900 -3810 1900 -3800 {
lab=VSS}
N 1900 -4040 1900 -4030 {
lab=VDD}
N 2240 -3810 2250 -3820 {
lab=row_n[4]}
N 2250 -4020 2250 -3820 {
lab=row_n[4]}
N 2240 -4030 2250 -4020 {
lab=row_n[4]}
N 2240 -3810 2240 -3790 {
lab=row_n[4]}
N 2240 -4050 2240 -4030 {
lab=row_n[4]}
N 2120 -3950 2130 -3960 {
lab=col_n[11]}
N 2130 -3960 2330 -3960 {
lab=col_n[11]}
N 2330 -3960 2340 -3950 {
lab=col_n[11]}
N 2120 -3930 2130 -3940 {
lab=colon_n[11]}
N 2130 -3940 2330 -3940 {
lab=colon_n[11]}
N 2330 -3940 2340 -3930 {
lab=colon_n[11]}
N 2120 -3910 2130 -3920 {
lab=#net23}
N 2130 -3920 2330 -3920 {
lab=#net23}
N 2330 -3920 2340 -3910 {
lab=#net23}
N 2120 -3890 2130 -3900 {
lab=#net24}
N 2130 -3900 2330 -3900 {
lab=#net24}
N 2330 -3900 2340 -3890 {
lab=#net24}
N 2180 -4050 2180 -4030 {
lab=vcom}
N 2220 -4050 2220 -4030 {
lab=ctop}
N 2100 -3950 2120 -3950 {
lab=col_n[11]}
N 2100 -3930 2120 -3930 {
lab=colon_n[11]}
N 2100 -3910 2120 -3910 {
lab=#net23}
N 2100 -3890 2120 -3890 {
lab=#net24}
N 2340 -3890 2360 -3890 {
lab=#net24}
N 2340 -3910 2360 -3910 {
lab=#net23}
N 2340 -3930 2360 -3930 {
lab=colon_n[11]}
N 2340 -3950 2360 -3950 {
lab=col_n[11]}
N 2160 -3810 2160 -3800 {
lab=VSS}
N 2160 -4040 2160 -4030 {
lab=VDD}
N 2500 -3810 2510 -3820 {
lab=row_n[5]}
N 2510 -4020 2510 -3820 {
lab=row_n[5]}
N 2500 -4030 2510 -4020 {
lab=row_n[5]}
N 2500 -3810 2500 -3790 {
lab=row_n[5]}
N 2500 -4050 2500 -4030 {
lab=row_n[5]}
N 2380 -3950 2390 -3960 {
lab=col_n[11]}
N 2390 -3960 2590 -3960 {
lab=col_n[11]}
N 2590 -3960 2600 -3950 {
lab=col_n[11]}
N 2380 -3930 2390 -3940 {
lab=colon_n[11]}
N 2390 -3940 2590 -3940 {
lab=colon_n[11]}
N 2590 -3940 2600 -3930 {
lab=colon_n[11]}
N 2380 -3910 2390 -3920 {
lab=#net23}
N 2390 -3920 2590 -3920 {
lab=#net23}
N 2590 -3920 2600 -3910 {
lab=#net23}
N 2380 -3890 2390 -3900 {
lab=#net24}
N 2390 -3900 2590 -3900 {
lab=#net24}
N 2590 -3900 2600 -3890 {
lab=#net24}
N 2440 -4050 2440 -4030 {
lab=vcom}
N 2480 -4050 2480 -4030 {
lab=ctop}
N 2360 -3950 2380 -3950 {
lab=col_n[11]}
N 2360 -3930 2380 -3930 {
lab=colon_n[11]}
N 2360 -3910 2380 -3910 {
lab=#net23}
N 2360 -3890 2380 -3890 {
lab=#net24}
N 2600 -3890 2620 -3890 {
lab=#net24}
N 2600 -3910 2620 -3910 {
lab=#net23}
N 2600 -3930 2620 -3930 {
lab=colon_n[11]}
N 2600 -3950 2620 -3950 {
lab=col_n[11]}
N 2420 -3810 2420 -3800 {
lab=VSS}
N 2420 -4040 2420 -4030 {
lab=VDD}
N 2760 -3810 2770 -3820 {
lab=row_n[6]}
N 2770 -4020 2770 -3820 {
lab=row_n[6]}
N 2760 -4030 2770 -4020 {
lab=row_n[6]}
N 2760 -3810 2760 -3790 {
lab=row_n[6]}
N 2760 -4050 2760 -4030 {
lab=row_n[6]}
N 2640 -3950 2650 -3960 {
lab=col_n[11]}
N 2650 -3960 2850 -3960 {
lab=col_n[11]}
N 2850 -3960 2860 -3950 {
lab=col_n[11]}
N 2640 -3930 2650 -3940 {
lab=colon_n[11]}
N 2650 -3940 2850 -3940 {
lab=colon_n[11]}
N 2850 -3940 2860 -3930 {
lab=colon_n[11]}
N 2640 -3910 2650 -3920 {
lab=#net23}
N 2650 -3920 2850 -3920 {
lab=#net23}
N 2850 -3920 2860 -3910 {
lab=#net23}
N 2640 -3890 2650 -3900 {
lab=#net24}
N 2650 -3900 2850 -3900 {
lab=#net24}
N 2850 -3900 2860 -3890 {
lab=#net24}
N 2700 -4050 2700 -4030 {
lab=vcom}
N 2740 -4050 2740 -4030 {
lab=ctop}
N 2620 -3950 2640 -3950 {
lab=col_n[11]}
N 2620 -3930 2640 -3930 {
lab=colon_n[11]}
N 2620 -3910 2640 -3910 {
lab=#net23}
N 2620 -3890 2640 -3890 {
lab=#net24}
N 2860 -3890 2880 -3890 {
lab=#net24}
N 2860 -3910 2880 -3910 {
lab=#net23}
N 2860 -3930 2880 -3930 {
lab=colon_n[11]}
N 2860 -3950 2880 -3950 {
lab=col_n[11]}
N 2680 -3810 2680 -3800 {
lab=VSS}
N 2680 -4040 2680 -4030 {
lab=VDD}
N 3020 -3810 3030 -3820 {
lab=row_n[7]}
N 3030 -4020 3030 -3820 {
lab=row_n[7]}
N 3020 -4030 3030 -4020 {
lab=row_n[7]}
N 3020 -3810 3020 -3790 {
lab=row_n[7]}
N 3020 -4050 3020 -4030 {
lab=row_n[7]}
N 2900 -3950 2910 -3960 {
lab=col_n[11]}
N 2910 -3960 3110 -3960 {
lab=col_n[11]}
N 3110 -3960 3120 -3950 {
lab=col_n[11]}
N 2900 -3930 2910 -3940 {
lab=colon_n[11]}
N 2910 -3940 3110 -3940 {
lab=colon_n[11]}
N 3110 -3940 3120 -3930 {
lab=colon_n[11]}
N 2900 -3910 2910 -3920 {
lab=#net23}
N 2910 -3920 3110 -3920 {
lab=#net23}
N 3110 -3920 3120 -3910 {
lab=#net23}
N 2900 -3890 2910 -3900 {
lab=#net24}
N 2910 -3900 3110 -3900 {
lab=#net24}
N 3110 -3900 3120 -3890 {
lab=#net24}
N 2960 -4050 2960 -4030 {
lab=vcom}
N 3000 -4050 3000 -4030 {
lab=ctop}
N 2880 -3950 2900 -3950 {
lab=col_n[11]}
N 2880 -3930 2900 -3930 {
lab=colon_n[11]}
N 2880 -3910 2900 -3910 {
lab=#net23}
N 2880 -3890 2900 -3890 {
lab=#net24}
N 3120 -3890 3140 -3890 {
lab=#net24}
N 3120 -3910 3140 -3910 {
lab=#net23}
N 3120 -3930 3140 -3930 {
lab=colon_n[11]}
N 3120 -3950 3140 -3950 {
lab=col_n[11]}
N 2940 -3810 2940 -3800 {
lab=VSS}
N 2940 -4040 2940 -4030 {
lab=VDD}
N 3280 -3810 3290 -3820 {
lab=row_n[8]}
N 3290 -4020 3290 -3820 {
lab=row_n[8]}
N 3280 -4030 3290 -4020 {
lab=row_n[8]}
N 3280 -3810 3280 -3790 {
lab=row_n[8]}
N 3280 -4050 3280 -4030 {
lab=row_n[8]}
N 3160 -3950 3170 -3960 {
lab=col_n[11]}
N 3170 -3960 3370 -3960 {
lab=col_n[11]}
N 3370 -3960 3380 -3950 {
lab=col_n[11]}
N 3160 -3930 3170 -3940 {
lab=colon_n[11]}
N 3170 -3940 3370 -3940 {
lab=colon_n[11]}
N 3370 -3940 3380 -3930 {
lab=colon_n[11]}
N 3160 -3910 3170 -3920 {
lab=#net23}
N 3170 -3920 3370 -3920 {
lab=#net23}
N 3370 -3920 3380 -3910 {
lab=#net23}
N 3160 -3890 3170 -3900 {
lab=#net24}
N 3170 -3900 3370 -3900 {
lab=#net24}
N 3370 -3900 3380 -3890 {
lab=#net24}
N 3220 -4050 3220 -4030 {
lab=vcom}
N 3260 -4050 3260 -4030 {
lab=ctop}
N 3140 -3950 3160 -3950 {
lab=col_n[11]}
N 3140 -3930 3160 -3930 {
lab=colon_n[11]}
N 3140 -3910 3160 -3910 {
lab=#net23}
N 3140 -3890 3160 -3890 {
lab=#net24}
N 3380 -3890 3400 -3890 {
lab=#net24}
N 3380 -3910 3400 -3910 {
lab=#net23}
N 3380 -3930 3400 -3930 {
lab=colon_n[11]}
N 3380 -3950 3400 -3950 {
lab=col_n[11]}
N 3200 -3810 3200 -3800 {
lab=VSS}
N 3200 -4040 3200 -4030 {
lab=VDD}
N 3540 -3810 3550 -3820 {
lab=row_n[9]}
N 3550 -4020 3550 -3820 {
lab=row_n[9]}
N 3540 -4030 3550 -4020 {
lab=row_n[9]}
N 3540 -3810 3540 -3790 {
lab=row_n[9]}
N 3540 -4050 3540 -4030 {
lab=row_n[9]}
N 3420 -3950 3430 -3960 {
lab=col_n[11]}
N 3430 -3960 3630 -3960 {
lab=col_n[11]}
N 3630 -3960 3640 -3950 {
lab=col_n[11]}
N 3420 -3930 3430 -3940 {
lab=colon_n[11]}
N 3430 -3940 3630 -3940 {
lab=colon_n[11]}
N 3630 -3940 3640 -3930 {
lab=colon_n[11]}
N 3420 -3910 3430 -3920 {
lab=#net23}
N 3430 -3920 3630 -3920 {
lab=#net23}
N 3630 -3920 3640 -3910 {
lab=#net23}
N 3420 -3890 3430 -3900 {
lab=#net24}
N 3430 -3900 3630 -3900 {
lab=#net24}
N 3630 -3900 3640 -3890 {
lab=#net24}
N 3480 -4050 3480 -4030 {
lab=vcom}
N 3520 -4050 3520 -4030 {
lab=ctop}
N 3400 -3950 3420 -3950 {
lab=col_n[11]}
N 3400 -3930 3420 -3930 {
lab=colon_n[11]}
N 3400 -3910 3420 -3910 {
lab=#net23}
N 3400 -3890 3420 -3890 {
lab=#net24}
N 3640 -3890 3660 -3890 {
lab=#net24}
N 3640 -3910 3660 -3910 {
lab=#net23}
N 3640 -3930 3660 -3930 {
lab=colon_n[11]}
N 3640 -3950 3660 -3950 {
lab=col_n[11]}
N 3460 -3810 3460 -3800 {
lab=VSS}
N 3460 -4040 3460 -4030 {
lab=VDD}
N 3800 -3810 3810 -3820 {
lab=row_n[10]}
N 3810 -4020 3810 -3820 {
lab=row_n[10]}
N 3800 -4030 3810 -4020 {
lab=row_n[10]}
N 3800 -3810 3800 -3790 {
lab=row_n[10]}
N 3800 -4050 3800 -4030 {
lab=row_n[10]}
N 3680 -3950 3690 -3960 {
lab=col_n[11]}
N 3690 -3960 3890 -3960 {
lab=col_n[11]}
N 3890 -3960 3900 -3950 {
lab=col_n[11]}
N 3680 -3930 3690 -3940 {
lab=colon_n[11]}
N 3690 -3940 3890 -3940 {
lab=colon_n[11]}
N 3890 -3940 3900 -3930 {
lab=colon_n[11]}
N 3680 -3910 3690 -3920 {
lab=#net23}
N 3690 -3920 3890 -3920 {
lab=#net23}
N 3890 -3920 3900 -3910 {
lab=#net23}
N 3680 -3890 3690 -3900 {
lab=#net24}
N 3690 -3900 3890 -3900 {
lab=#net24}
N 3890 -3900 3900 -3890 {
lab=#net24}
N 3740 -4050 3740 -4030 {
lab=vcom}
N 3780 -4050 3780 -4030 {
lab=ctop}
N 3660 -3950 3680 -3950 {
lab=col_n[11]}
N 3660 -3930 3680 -3930 {
lab=colon_n[11]}
N 3660 -3910 3680 -3910 {
lab=#net23}
N 3660 -3890 3680 -3890 {
lab=#net24}
N 3900 -3890 3920 -3890 {
lab=#net24}
N 3900 -3910 3920 -3910 {
lab=#net23}
N 3900 -3930 3920 -3930 {
lab=colon_n[11]}
N 3900 -3950 3920 -3950 {
lab=col_n[11]}
N 3720 -3810 3720 -3800 {
lab=VSS}
N 3720 -4040 3720 -4030 {
lab=VDD}
N 4060 -3810 4070 -3820 {
lab=row_n[11]}
N 4070 -4020 4070 -3820 {
lab=row_n[11]}
N 4060 -4030 4070 -4020 {
lab=row_n[11]}
N 4060 -3810 4060 -3790 {
lab=row_n[11]}
N 4060 -4050 4060 -4030 {
lab=row_n[11]}
N 3940 -3950 3950 -3960 {
lab=col_n[11]}
N 3950 -3960 4150 -3960 {
lab=col_n[11]}
N 4150 -3960 4160 -3950 {
lab=col_n[11]}
N 3940 -3930 3950 -3940 {
lab=colon_n[11]}
N 3950 -3940 4150 -3940 {
lab=colon_n[11]}
N 4150 -3940 4160 -3930 {
lab=colon_n[11]}
N 3940 -3910 3950 -3920 {
lab=#net23}
N 3950 -3920 4150 -3920 {
lab=#net23}
N 4150 -3920 4160 -3910 {
lab=#net23}
N 3940 -3890 3950 -3900 {
lab=#net24}
N 3950 -3900 4150 -3900 {
lab=#net24}
N 4150 -3900 4160 -3890 {
lab=#net24}
N 4000 -4050 4000 -4030 {
lab=vcom}
N 4040 -4050 4040 -4030 {
lab=ctop}
N 3920 -3950 3940 -3950 {
lab=col_n[11]}
N 3920 -3930 3940 -3930 {
lab=colon_n[11]}
N 3920 -3910 3940 -3910 {
lab=#net23}
N 3920 -3890 3940 -3890 {
lab=#net24}
N 4160 -3890 4180 -3890 {
lab=#net24}
N 4160 -3910 4180 -3910 {
lab=#net23}
N 4160 -3930 4180 -3930 {
lab=colon_n[11]}
N 4160 -3950 4180 -3950 {
lab=col_n[11]}
N 3980 -3810 3980 -3800 {
lab=VSS}
N 3980 -4040 3980 -4030 {
lab=VDD}
N 4320 -3810 4330 -3820 {
lab=row_n[12]}
N 4330 -4020 4330 -3820 {
lab=row_n[12]}
N 4320 -4030 4330 -4020 {
lab=row_n[12]}
N 4320 -3810 4320 -3790 {
lab=row_n[12]}
N 4320 -4050 4320 -4030 {
lab=row_n[12]}
N 4200 -3950 4210 -3960 {
lab=col_n[11]}
N 4210 -3960 4410 -3960 {
lab=col_n[11]}
N 4410 -3960 4420 -3950 {
lab=col_n[11]}
N 4200 -3930 4210 -3940 {
lab=colon_n[11]}
N 4210 -3940 4410 -3940 {
lab=colon_n[11]}
N 4410 -3940 4420 -3930 {
lab=colon_n[11]}
N 4200 -3910 4210 -3920 {
lab=#net23}
N 4210 -3920 4410 -3920 {
lab=#net23}
N 4410 -3920 4420 -3910 {
lab=#net23}
N 4200 -3890 4210 -3900 {
lab=#net24}
N 4210 -3900 4410 -3900 {
lab=#net24}
N 4410 -3900 4420 -3890 {
lab=#net24}
N 4260 -4050 4260 -4030 {
lab=vcom}
N 4300 -4050 4300 -4030 {
lab=ctop}
N 4180 -3950 4200 -3950 {
lab=col_n[11]}
N 4180 -3930 4200 -3930 {
lab=colon_n[11]}
N 4180 -3910 4200 -3910 {
lab=#net23}
N 4180 -3890 4200 -3890 {
lab=#net24}
N 4420 -3890 4440 -3890 {
lab=#net24}
N 4420 -3910 4440 -3910 {
lab=#net23}
N 4420 -3930 4440 -3930 {
lab=colon_n[11]}
N 4420 -3950 4440 -3950 {
lab=col_n[11]}
N 4240 -3810 4240 -3800 {
lab=VSS}
N 4240 -4040 4240 -4030 {
lab=VDD}
N 4580 -3810 4590 -3820 {
lab=row_n[13]}
N 4590 -4020 4590 -3820 {
lab=row_n[13]}
N 4580 -4030 4590 -4020 {
lab=row_n[13]}
N 4580 -3810 4580 -3790 {
lab=row_n[13]}
N 4580 -4050 4580 -4030 {
lab=row_n[13]}
N 4460 -3950 4470 -3960 {
lab=col_n[11]}
N 4470 -3960 4670 -3960 {
lab=col_n[11]}
N 4670 -3960 4680 -3950 {
lab=col_n[11]}
N 4460 -3930 4470 -3940 {
lab=colon_n[11]}
N 4470 -3940 4670 -3940 {
lab=colon_n[11]}
N 4670 -3940 4680 -3930 {
lab=colon_n[11]}
N 4460 -3910 4470 -3920 {
lab=#net23}
N 4470 -3920 4670 -3920 {
lab=#net23}
N 4670 -3920 4680 -3910 {
lab=#net23}
N 4460 -3890 4470 -3900 {
lab=#net24}
N 4470 -3900 4670 -3900 {
lab=#net24}
N 4670 -3900 4680 -3890 {
lab=#net24}
N 4520 -4050 4520 -4030 {
lab=vcom}
N 4560 -4050 4560 -4030 {
lab=ctop}
N 4440 -3950 4460 -3950 {
lab=col_n[11]}
N 4440 -3930 4460 -3930 {
lab=colon_n[11]}
N 4440 -3910 4460 -3910 {
lab=#net23}
N 4440 -3890 4460 -3890 {
lab=#net24}
N 4680 -3890 4700 -3890 {
lab=#net24}
N 4680 -3910 4700 -3910 {
lab=#net23}
N 4680 -3930 4700 -3930 {
lab=colon_n[11]}
N 4680 -3950 4700 -3950 {
lab=col_n[11]}
N 4500 -3810 4500 -3800 {
lab=VSS}
N 4500 -4040 4500 -4030 {
lab=VDD}
N 4840 -3810 4850 -3820 {
lab=row_n[14]}
N 4850 -4020 4850 -3820 {
lab=row_n[14]}
N 4840 -4030 4850 -4020 {
lab=row_n[14]}
N 4840 -3810 4840 -3790 {
lab=row_n[14]}
N 4840 -4050 4840 -4030 {
lab=row_n[14]}
N 4720 -3950 4730 -3960 {
lab=col_n[11]}
N 4730 -3960 4930 -3960 {
lab=col_n[11]}
N 4930 -3960 4940 -3950 {
lab=col_n[11]}
N 4720 -3930 4730 -3940 {
lab=colon_n[11]}
N 4730 -3940 4930 -3940 {
lab=colon_n[11]}
N 4930 -3940 4940 -3930 {
lab=colon_n[11]}
N 4720 -3910 4730 -3920 {
lab=#net23}
N 4730 -3920 4930 -3920 {
lab=#net23}
N 4930 -3920 4940 -3910 {
lab=#net23}
N 4720 -3890 4730 -3900 {
lab=#net24}
N 4730 -3900 4930 -3900 {
lab=#net24}
N 4930 -3900 4940 -3890 {
lab=#net24}
N 4780 -4050 4780 -4030 {
lab=vcom}
N 4820 -4050 4820 -4030 {
lab=ctop}
N 4700 -3950 4720 -3950 {
lab=col_n[11]}
N 4700 -3930 4720 -3930 {
lab=colon_n[11]}
N 4700 -3910 4720 -3910 {
lab=#net23}
N 4700 -3890 4720 -3890 {
lab=#net24}
N 4940 -3890 4960 -3890 {
lab=#net24}
N 4940 -3910 4960 -3910 {
lab=#net23}
N 4940 -3930 4960 -3930 {
lab=colon_n[11]}
N 4940 -3950 4960 -3950 {
lab=col_n[11]}
N 4760 -3810 4760 -3800 {
lab=VSS}
N 4760 -4040 4760 -4030 {
lab=VDD}
N 5100 -3810 5110 -3820 {
lab=row_n[15]}
N 5110 -4020 5110 -3820 {
lab=row_n[15]}
N 5100 -4030 5110 -4020 {
lab=row_n[15]}
N 5100 -3810 5100 -3790 {
lab=row_n[15]}
N 5100 -4050 5100 -4030 {
lab=row_n[15]}
N 4980 -3950 4990 -3960 {
lab=col_n[11]}
N 4990 -3960 5190 -3960 {
lab=col_n[11]}
N 5190 -3960 5200 -3950 {
lab=col_n[11]}
N 4980 -3930 4990 -3940 {
lab=colon_n[11]}
N 4990 -3940 5190 -3940 {
lab=colon_n[11]}
N 5190 -3940 5200 -3930 {
lab=colon_n[11]}
N 4980 -3910 4990 -3920 {
lab=#net23}
N 4990 -3920 5190 -3920 {
lab=#net23}
N 5190 -3920 5200 -3910 {
lab=#net23}
N 4980 -3890 4990 -3900 {
lab=#net24}
N 4990 -3900 5190 -3900 {
lab=#net24}
N 5190 -3900 5200 -3890 {
lab=#net24}
N 5040 -4050 5040 -4030 {
lab=vcom}
N 5080 -4050 5080 -4030 {
lab=ctop}
N 4960 -3950 4980 -3950 {
lab=col_n[11]}
N 4960 -3930 4980 -3930 {
lab=colon_n[11]}
N 4960 -3910 4980 -3910 {
lab=#net23}
N 4960 -3890 4980 -3890 {
lab=#net24}
N 5200 -3890 5220 -3890 {
lab=#net24}
N 5200 -3910 5220 -3910 {
lab=#net23}
N 5200 -3930 5220 -3930 {
lab=colon_n[11]}
N 5200 -3950 5220 -3950 {
lab=col_n[11]}
N 5020 -3810 5020 -3800 {
lab=VSS}
N 5020 -4040 5020 -4030 {
lab=VDD}
N 5360 -3810 5370 -3820 {
lab=row_n[16]}
N 5370 -4020 5370 -3820 {
lab=row_n[16]}
N 5360 -4030 5370 -4020 {
lab=row_n[16]}
N 5360 -3810 5360 -3790 {
lab=row_n[16]}
N 5360 -4050 5360 -4030 {
lab=row_n[16]}
N 5240 -3950 5250 -3960 {
lab=col_n[11]}
N 5250 -3960 5450 -3960 {
lab=col_n[11]}
N 5450 -3960 5460 -3950 {
lab=col_n[11]}
N 5240 -3930 5250 -3940 {
lab=colon_n[11]}
N 5250 -3940 5450 -3940 {
lab=colon_n[11]}
N 5450 -3940 5460 -3930 {
lab=colon_n[11]}
N 5240 -3910 5250 -3920 {
lab=#net23}
N 5250 -3920 5450 -3920 {
lab=#net23}
N 5450 -3920 5460 -3910 {
lab=#net23}
N 5240 -3890 5250 -3900 {
lab=#net24}
N 5250 -3900 5450 -3900 {
lab=#net24}
N 5450 -3900 5460 -3890 {
lab=#net24}
N 5300 -4050 5300 -4030 {
lab=vcom}
N 5340 -4050 5340 -4030 {
lab=ctop}
N 5220 -3950 5240 -3950 {
lab=col_n[11]}
N 5220 -3930 5240 -3930 {
lab=colon_n[11]}
N 5220 -3910 5240 -3910 {
lab=#net23}
N 5220 -3890 5240 -3890 {
lab=#net24}
N 5460 -3890 5480 -3890 {
lab=#net24}
N 5460 -3910 5480 -3910 {
lab=#net23}
N 5460 -3930 5480 -3930 {
lab=colon_n[11]}
N 5460 -3950 5480 -3950 {
lab=col_n[11]}
N 5280 -3810 5280 -3800 {
lab=VSS}
N 5280 -4040 5280 -4030 {
lab=VDD}
N 5620 -3810 5630 -3820 {
lab=row_n[17]}
N 5630 -4020 5630 -3820 {
lab=row_n[17]}
N 5620 -4030 5630 -4020 {
lab=row_n[17]}
N 5620 -3810 5620 -3790 {
lab=row_n[17]}
N 5620 -4050 5620 -4030 {
lab=row_n[17]}
N 5500 -3950 5510 -3960 {
lab=col_n[11]}
N 5510 -3960 5710 -3960 {
lab=col_n[11]}
N 5710 -3960 5720 -3950 {
lab=col_n[11]}
N 5500 -3930 5510 -3940 {
lab=colon_n[11]}
N 5510 -3940 5710 -3940 {
lab=colon_n[11]}
N 5710 -3940 5720 -3930 {
lab=colon_n[11]}
N 5500 -3910 5510 -3920 {
lab=#net23}
N 5510 -3920 5710 -3920 {
lab=#net23}
N 5710 -3920 5720 -3910 {
lab=#net23}
N 5500 -3890 5510 -3900 {
lab=#net24}
N 5510 -3900 5710 -3900 {
lab=#net24}
N 5710 -3900 5720 -3890 {
lab=#net24}
N 5560 -4050 5560 -4030 {
lab=vcom}
N 5600 -4050 5600 -4030 {
lab=ctop}
N 5480 -3950 5500 -3950 {
lab=col_n[11]}
N 5480 -3930 5500 -3930 {
lab=colon_n[11]}
N 5480 -3910 5500 -3910 {
lab=#net23}
N 5480 -3890 5500 -3890 {
lab=#net24}
N 5720 -3890 5740 -3890 {
lab=#net24}
N 5720 -3910 5740 -3910 {
lab=#net23}
N 5720 -3930 5740 -3930 {
lab=colon_n[11]}
N 5720 -3950 5740 -3950 {
lab=col_n[11]}
N 5540 -3810 5540 -3800 {
lab=VSS}
N 5540 -4040 5540 -4030 {
lab=VDD}
N 5880 -3810 5890 -3820 {
lab=row_n[18]}
N 5890 -4020 5890 -3820 {
lab=row_n[18]}
N 5880 -4030 5890 -4020 {
lab=row_n[18]}
N 5880 -3810 5880 -3790 {
lab=row_n[18]}
N 5880 -4050 5880 -4030 {
lab=row_n[18]}
N 5760 -3950 5770 -3960 {
lab=col_n[11]}
N 5770 -3960 5970 -3960 {
lab=col_n[11]}
N 5970 -3960 5980 -3950 {
lab=col_n[11]}
N 5760 -3930 5770 -3940 {
lab=colon_n[11]}
N 5770 -3940 5970 -3940 {
lab=colon_n[11]}
N 5970 -3940 5980 -3930 {
lab=colon_n[11]}
N 5760 -3910 5770 -3920 {
lab=#net23}
N 5770 -3920 5970 -3920 {
lab=#net23}
N 5970 -3920 5980 -3910 {
lab=#net23}
N 5760 -3890 5770 -3900 {
lab=#net24}
N 5770 -3900 5970 -3900 {
lab=#net24}
N 5970 -3900 5980 -3890 {
lab=#net24}
N 5820 -4050 5820 -4030 {
lab=vcom}
N 5860 -4050 5860 -4030 {
lab=ctop}
N 5740 -3950 5760 -3950 {
lab=col_n[11]}
N 5740 -3930 5760 -3930 {
lab=colon_n[11]}
N 5740 -3910 5760 -3910 {
lab=#net23}
N 5740 -3890 5760 -3890 {
lab=#net24}
N 5980 -3890 6000 -3890 {
lab=#net24}
N 5980 -3910 6000 -3910 {
lab=#net23}
N 5980 -3930 6000 -3930 {
lab=colon_n[11]}
N 5980 -3950 6000 -3950 {
lab=col_n[11]}
N 5800 -3810 5800 -3800 {
lab=VSS}
N 5800 -4040 5800 -4030 {
lab=VDD}
N 6140 -3810 6150 -3820 {
lab=row_n[19]}
N 6150 -4020 6150 -3820 {
lab=row_n[19]}
N 6140 -4030 6150 -4020 {
lab=row_n[19]}
N 6140 -3810 6140 -3790 {
lab=row_n[19]}
N 6140 -4050 6140 -4030 {
lab=row_n[19]}
N 6020 -3950 6030 -3960 {
lab=col_n[11]}
N 6030 -3960 6230 -3960 {
lab=col_n[11]}
N 6230 -3960 6240 -3950 {
lab=col_n[11]}
N 6020 -3930 6030 -3940 {
lab=colon_n[11]}
N 6030 -3940 6230 -3940 {
lab=colon_n[11]}
N 6230 -3940 6240 -3930 {
lab=colon_n[11]}
N 6020 -3910 6030 -3920 {
lab=#net23}
N 6030 -3920 6230 -3920 {
lab=#net23}
N 6230 -3920 6240 -3910 {
lab=#net23}
N 6020 -3890 6030 -3900 {
lab=#net24}
N 6030 -3900 6230 -3900 {
lab=#net24}
N 6230 -3900 6240 -3890 {
lab=#net24}
N 6080 -4050 6080 -4030 {
lab=vcom}
N 6120 -4050 6120 -4030 {
lab=ctop}
N 6000 -3950 6020 -3950 {
lab=col_n[11]}
N 6000 -3930 6020 -3930 {
lab=colon_n[11]}
N 6000 -3910 6020 -3910 {
lab=#net23}
N 6000 -3890 6020 -3890 {
lab=#net24}
N 6240 -3890 6260 -3890 {
lab=#net24}
N 6240 -3910 6260 -3910 {
lab=#net23}
N 6240 -3930 6260 -3930 {
lab=colon_n[11]}
N 6240 -3950 6260 -3950 {
lab=col_n[11]}
N 6060 -3810 6060 -3800 {
lab=VSS}
N 6060 -4040 6060 -4030 {
lab=VDD}
N 6400 -3810 6410 -3820 {
lab=row_n[20]}
N 6410 -4020 6410 -3820 {
lab=row_n[20]}
N 6400 -4030 6410 -4020 {
lab=row_n[20]}
N 6400 -3810 6400 -3790 {
lab=row_n[20]}
N 6400 -4050 6400 -4030 {
lab=row_n[20]}
N 6280 -3950 6290 -3960 {
lab=col_n[11]}
N 6290 -3960 6490 -3960 {
lab=col_n[11]}
N 6490 -3960 6500 -3950 {
lab=col_n[11]}
N 6280 -3930 6290 -3940 {
lab=colon_n[11]}
N 6290 -3940 6490 -3940 {
lab=colon_n[11]}
N 6490 -3940 6500 -3930 {
lab=colon_n[11]}
N 6280 -3910 6290 -3920 {
lab=#net23}
N 6290 -3920 6490 -3920 {
lab=#net23}
N 6490 -3920 6500 -3910 {
lab=#net23}
N 6280 -3890 6290 -3900 {
lab=#net24}
N 6290 -3900 6490 -3900 {
lab=#net24}
N 6490 -3900 6500 -3890 {
lab=#net24}
N 6340 -4050 6340 -4030 {
lab=vcom}
N 6380 -4050 6380 -4030 {
lab=ctop}
N 6260 -3950 6280 -3950 {
lab=col_n[11]}
N 6260 -3930 6280 -3930 {
lab=colon_n[11]}
N 6260 -3910 6280 -3910 {
lab=#net23}
N 6260 -3890 6280 -3890 {
lab=#net24}
N 6500 -3890 6520 -3890 {
lab=#net24}
N 6500 -3910 6520 -3910 {
lab=#net23}
N 6500 -3930 6520 -3930 {
lab=colon_n[11]}
N 6500 -3950 6520 -3950 {
lab=col_n[11]}
N 6320 -3810 6320 -3800 {
lab=VSS}
N 6320 -4040 6320 -4030 {
lab=VDD}
N 6660 -3810 6670 -3820 {
lab=row_n[21]}
N 6670 -4020 6670 -3820 {
lab=row_n[21]}
N 6660 -4030 6670 -4020 {
lab=row_n[21]}
N 6660 -3810 6660 -3790 {
lab=row_n[21]}
N 6660 -4050 6660 -4030 {
lab=row_n[21]}
N 6540 -3950 6550 -3960 {
lab=col_n[11]}
N 6550 -3960 6750 -3960 {
lab=col_n[11]}
N 6750 -3960 6760 -3950 {
lab=col_n[11]}
N 6540 -3930 6550 -3940 {
lab=colon_n[11]}
N 6550 -3940 6750 -3940 {
lab=colon_n[11]}
N 6750 -3940 6760 -3930 {
lab=colon_n[11]}
N 6540 -3910 6550 -3920 {
lab=#net23}
N 6550 -3920 6750 -3920 {
lab=#net23}
N 6750 -3920 6760 -3910 {
lab=#net23}
N 6540 -3890 6550 -3900 {
lab=#net24}
N 6550 -3900 6750 -3900 {
lab=#net24}
N 6750 -3900 6760 -3890 {
lab=#net24}
N 6600 -4050 6600 -4030 {
lab=vcom}
N 6640 -4050 6640 -4030 {
lab=ctop}
N 6520 -3950 6540 -3950 {
lab=col_n[11]}
N 6520 -3930 6540 -3930 {
lab=colon_n[11]}
N 6520 -3910 6540 -3910 {
lab=#net23}
N 6520 -3890 6540 -3890 {
lab=#net24}
N 6760 -3890 6780 -3890 {
lab=#net24}
N 6760 -3910 6780 -3910 {
lab=#net23}
N 6760 -3930 6780 -3930 {
lab=colon_n[11]}
N 6760 -3950 6780 -3950 {
lab=col_n[11]}
N 6580 -3810 6580 -3800 {
lab=VSS}
N 6580 -4040 6580 -4030 {
lab=VDD}
N 6920 -3810 6930 -3820 {
lab=row_n[22]}
N 6930 -4020 6930 -3820 {
lab=row_n[22]}
N 6920 -4030 6930 -4020 {
lab=row_n[22]}
N 6920 -3810 6920 -3790 {
lab=row_n[22]}
N 6920 -4050 6920 -4030 {
lab=row_n[22]}
N 6800 -3950 6810 -3960 {
lab=col_n[11]}
N 6810 -3960 7010 -3960 {
lab=col_n[11]}
N 7010 -3960 7020 -3950 {
lab=col_n[11]}
N 6800 -3930 6810 -3940 {
lab=colon_n[11]}
N 6810 -3940 7010 -3940 {
lab=colon_n[11]}
N 7010 -3940 7020 -3930 {
lab=colon_n[11]}
N 6800 -3910 6810 -3920 {
lab=#net23}
N 6810 -3920 7010 -3920 {
lab=#net23}
N 7010 -3920 7020 -3910 {
lab=#net23}
N 6800 -3890 6810 -3900 {
lab=#net24}
N 6810 -3900 7010 -3900 {
lab=#net24}
N 7010 -3900 7020 -3890 {
lab=#net24}
N 6860 -4050 6860 -4030 {
lab=vcom}
N 6900 -4050 6900 -4030 {
lab=ctop}
N 6780 -3950 6800 -3950 {
lab=col_n[11]}
N 6780 -3930 6800 -3930 {
lab=colon_n[11]}
N 6780 -3910 6800 -3910 {
lab=#net23}
N 6780 -3890 6800 -3890 {
lab=#net24}
N 7020 -3890 7040 -3890 {
lab=#net24}
N 7020 -3910 7040 -3910 {
lab=#net23}
N 7020 -3930 7040 -3930 {
lab=colon_n[11]}
N 7020 -3950 7040 -3950 {
lab=col_n[11]}
N 6840 -3810 6840 -3800 {
lab=VSS}
N 6840 -4040 6840 -4030 {
lab=VDD}
N 7180 -3810 7190 -3820 {
lab=row_n[23]}
N 7190 -4020 7190 -3820 {
lab=row_n[23]}
N 7180 -4030 7190 -4020 {
lab=row_n[23]}
N 7180 -3810 7180 -3790 {
lab=row_n[23]}
N 7180 -4050 7180 -4030 {
lab=row_n[23]}
N 7060 -3950 7070 -3960 {
lab=col_n[11]}
N 7070 -3960 7270 -3960 {
lab=col_n[11]}
N 7270 -3960 7280 -3950 {
lab=col_n[11]}
N 7060 -3930 7070 -3940 {
lab=colon_n[11]}
N 7070 -3940 7270 -3940 {
lab=colon_n[11]}
N 7270 -3940 7280 -3930 {
lab=colon_n[11]}
N 7060 -3910 7070 -3920 {
lab=#net23}
N 7070 -3920 7270 -3920 {
lab=#net23}
N 7270 -3920 7280 -3910 {
lab=#net23}
N 7060 -3890 7070 -3900 {
lab=#net24}
N 7070 -3900 7270 -3900 {
lab=#net24}
N 7270 -3900 7280 -3890 {
lab=#net24}
N 7120 -4050 7120 -4030 {
lab=vcom}
N 7160 -4050 7160 -4030 {
lab=ctop}
N 7040 -3950 7060 -3950 {
lab=col_n[11]}
N 7040 -3930 7060 -3930 {
lab=colon_n[11]}
N 7040 -3910 7060 -3910 {
lab=#net23}
N 7040 -3890 7060 -3890 {
lab=#net24}
N 7280 -3890 7300 -3890 {
lab=#net24}
N 7280 -3910 7300 -3910 {
lab=#net23}
N 7280 -3930 7300 -3930 {
lab=colon_n[11]}
N 7280 -3950 7300 -3950 {
lab=col_n[11]}
N 7100 -3810 7100 -3800 {
lab=VSS}
N 7100 -4040 7100 -4030 {
lab=VDD}
N 7440 -3810 7450 -3820 {
lab=row_n[24]}
N 7450 -4020 7450 -3820 {
lab=row_n[24]}
N 7440 -4030 7450 -4020 {
lab=row_n[24]}
N 7440 -3810 7440 -3790 {
lab=row_n[24]}
N 7440 -4050 7440 -4030 {
lab=row_n[24]}
N 7320 -3950 7330 -3960 {
lab=col_n[11]}
N 7330 -3960 7530 -3960 {
lab=col_n[11]}
N 7530 -3960 7540 -3950 {
lab=col_n[11]}
N 7320 -3930 7330 -3940 {
lab=colon_n[11]}
N 7330 -3940 7530 -3940 {
lab=colon_n[11]}
N 7530 -3940 7540 -3930 {
lab=colon_n[11]}
N 7320 -3910 7330 -3920 {
lab=#net23}
N 7330 -3920 7530 -3920 {
lab=#net23}
N 7530 -3920 7540 -3910 {
lab=#net23}
N 7320 -3890 7330 -3900 {
lab=#net24}
N 7330 -3900 7530 -3900 {
lab=#net24}
N 7530 -3900 7540 -3890 {
lab=#net24}
N 7380 -4050 7380 -4030 {
lab=vcom}
N 7420 -4050 7420 -4030 {
lab=ctop}
N 7300 -3950 7320 -3950 {
lab=col_n[11]}
N 7300 -3930 7320 -3930 {
lab=colon_n[11]}
N 7300 -3910 7320 -3910 {
lab=#net23}
N 7300 -3890 7320 -3890 {
lab=#net24}
N 7540 -3890 7560 -3890 {
lab=#net24}
N 7540 -3910 7560 -3910 {
lab=#net23}
N 7540 -3930 7560 -3930 {
lab=colon_n[11]}
N 7540 -3950 7560 -3950 {
lab=col_n[11]}
N 7360 -3810 7360 -3800 {
lab=VSS}
N 7360 -4040 7360 -4030 {
lab=VDD}
N 7700 -3810 7710 -3820 {
lab=row_n[25]}
N 7710 -4020 7710 -3820 {
lab=row_n[25]}
N 7700 -4030 7710 -4020 {
lab=row_n[25]}
N 7700 -3810 7700 -3790 {
lab=row_n[25]}
N 7700 -4050 7700 -4030 {
lab=row_n[25]}
N 7580 -3950 7590 -3960 {
lab=col_n[11]}
N 7590 -3960 7790 -3960 {
lab=col_n[11]}
N 7790 -3960 7800 -3950 {
lab=col_n[11]}
N 7580 -3930 7590 -3940 {
lab=colon_n[11]}
N 7590 -3940 7790 -3940 {
lab=colon_n[11]}
N 7790 -3940 7800 -3930 {
lab=colon_n[11]}
N 7580 -3910 7590 -3920 {
lab=#net23}
N 7590 -3920 7790 -3920 {
lab=#net23}
N 7790 -3920 7800 -3910 {
lab=#net23}
N 7580 -3890 7590 -3900 {
lab=#net24}
N 7590 -3900 7790 -3900 {
lab=#net24}
N 7790 -3900 7800 -3890 {
lab=#net24}
N 7640 -4050 7640 -4030 {
lab=vcom}
N 7680 -4050 7680 -4030 {
lab=ctop}
N 7560 -3950 7580 -3950 {
lab=col_n[11]}
N 7560 -3930 7580 -3930 {
lab=colon_n[11]}
N 7560 -3910 7580 -3910 {
lab=#net23}
N 7560 -3890 7580 -3890 {
lab=#net24}
N 7800 -3890 7820 -3890 {
lab=#net24}
N 7800 -3910 7820 -3910 {
lab=#net23}
N 7800 -3930 7820 -3930 {
lab=colon_n[11]}
N 7800 -3950 7820 -3950 {
lab=col_n[11]}
N 7620 -3810 7620 -3800 {
lab=VSS}
N 7620 -4040 7620 -4030 {
lab=VDD}
N 7960 -3810 7970 -3820 {
lab=row_n[26]}
N 7970 -4020 7970 -3820 {
lab=row_n[26]}
N 7960 -4030 7970 -4020 {
lab=row_n[26]}
N 7960 -3810 7960 -3790 {
lab=row_n[26]}
N 7960 -4050 7960 -4030 {
lab=row_n[26]}
N 7840 -3950 7850 -3960 {
lab=col_n[11]}
N 7850 -3960 8050 -3960 {
lab=col_n[11]}
N 8050 -3960 8060 -3950 {
lab=col_n[11]}
N 7840 -3930 7850 -3940 {
lab=colon_n[11]}
N 7850 -3940 8050 -3940 {
lab=colon_n[11]}
N 8050 -3940 8060 -3930 {
lab=colon_n[11]}
N 7840 -3910 7850 -3920 {
lab=#net23}
N 7850 -3920 8050 -3920 {
lab=#net23}
N 8050 -3920 8060 -3910 {
lab=#net23}
N 7840 -3890 7850 -3900 {
lab=#net24}
N 7850 -3900 8050 -3900 {
lab=#net24}
N 8050 -3900 8060 -3890 {
lab=#net24}
N 7900 -4050 7900 -4030 {
lab=vcom}
N 7940 -4050 7940 -4030 {
lab=ctop}
N 7820 -3950 7840 -3950 {
lab=col_n[11]}
N 7820 -3930 7840 -3930 {
lab=colon_n[11]}
N 7820 -3910 7840 -3910 {
lab=#net23}
N 7820 -3890 7840 -3890 {
lab=#net24}
N 8060 -3890 8080 -3890 {
lab=#net24}
N 8060 -3910 8080 -3910 {
lab=#net23}
N 8060 -3930 8080 -3930 {
lab=colon_n[11]}
N 8060 -3950 8080 -3950 {
lab=col_n[11]}
N 7880 -3810 7880 -3800 {
lab=VSS}
N 7880 -4040 7880 -4030 {
lab=VDD}
N 8220 -3810 8230 -3820 {
lab=row_n[27]}
N 8230 -4020 8230 -3820 {
lab=row_n[27]}
N 8220 -4030 8230 -4020 {
lab=row_n[27]}
N 8220 -3810 8220 -3790 {
lab=row_n[27]}
N 8220 -4050 8220 -4030 {
lab=row_n[27]}
N 8100 -3950 8110 -3960 {
lab=col_n[11]}
N 8110 -3960 8310 -3960 {
lab=col_n[11]}
N 8310 -3960 8320 -3950 {
lab=col_n[11]}
N 8100 -3930 8110 -3940 {
lab=colon_n[11]}
N 8110 -3940 8310 -3940 {
lab=colon_n[11]}
N 8310 -3940 8320 -3930 {
lab=colon_n[11]}
N 8100 -3910 8110 -3920 {
lab=#net23}
N 8110 -3920 8310 -3920 {
lab=#net23}
N 8310 -3920 8320 -3910 {
lab=#net23}
N 8100 -3890 8110 -3900 {
lab=#net24}
N 8110 -3900 8310 -3900 {
lab=#net24}
N 8310 -3900 8320 -3890 {
lab=#net24}
N 8160 -4050 8160 -4030 {
lab=vcom}
N 8200 -4050 8200 -4030 {
lab=ctop}
N 8080 -3950 8100 -3950 {
lab=col_n[11]}
N 8080 -3930 8100 -3930 {
lab=colon_n[11]}
N 8080 -3910 8100 -3910 {
lab=#net23}
N 8080 -3890 8100 -3890 {
lab=#net24}
N 8320 -3890 8340 -3890 {
lab=#net24}
N 8320 -3910 8340 -3910 {
lab=#net23}
N 8320 -3930 8340 -3930 {
lab=colon_n[11]}
N 8320 -3950 8340 -3950 {
lab=col_n[11]}
N 8140 -3810 8140 -3800 {
lab=VSS}
N 8140 -4040 8140 -4030 {
lab=VDD}
N 8480 -3810 8490 -3820 {
lab=row_n[28]}
N 8490 -4020 8490 -3820 {
lab=row_n[28]}
N 8480 -4030 8490 -4020 {
lab=row_n[28]}
N 8480 -3810 8480 -3790 {
lab=row_n[28]}
N 8480 -4050 8480 -4030 {
lab=row_n[28]}
N 8360 -3950 8370 -3960 {
lab=col_n[11]}
N 8370 -3960 8570 -3960 {
lab=col_n[11]}
N 8570 -3960 8580 -3950 {
lab=col_n[11]}
N 8360 -3930 8370 -3940 {
lab=colon_n[11]}
N 8370 -3940 8570 -3940 {
lab=colon_n[11]}
N 8570 -3940 8580 -3930 {
lab=colon_n[11]}
N 8360 -3910 8370 -3920 {
lab=#net23}
N 8370 -3920 8570 -3920 {
lab=#net23}
N 8570 -3920 8580 -3910 {
lab=#net23}
N 8360 -3890 8370 -3900 {
lab=#net24}
N 8370 -3900 8570 -3900 {
lab=#net24}
N 8570 -3900 8580 -3890 {
lab=#net24}
N 8420 -4050 8420 -4030 {
lab=vcom}
N 8460 -4050 8460 -4030 {
lab=ctop}
N 8340 -3950 8360 -3950 {
lab=col_n[11]}
N 8340 -3930 8360 -3930 {
lab=colon_n[11]}
N 8340 -3910 8360 -3910 {
lab=#net23}
N 8340 -3890 8360 -3890 {
lab=#net24}
N 8580 -3890 8600 -3890 {
lab=#net24}
N 8580 -3910 8600 -3910 {
lab=#net23}
N 8580 -3930 8600 -3930 {
lab=colon_n[11]}
N 8580 -3950 8600 -3950 {
lab=col_n[11]}
N 8400 -3810 8400 -3800 {
lab=VSS}
N 8400 -4040 8400 -4030 {
lab=VDD}
N 8740 -3810 8750 -3820 {
lab=row_n[29]}
N 8750 -4020 8750 -3820 {
lab=row_n[29]}
N 8740 -4030 8750 -4020 {
lab=row_n[29]}
N 8740 -3810 8740 -3790 {
lab=row_n[29]}
N 8740 -4050 8740 -4030 {
lab=row_n[29]}
N 8620 -3950 8630 -3960 {
lab=col_n[11]}
N 8630 -3960 8830 -3960 {
lab=col_n[11]}
N 8830 -3960 8840 -3950 {
lab=col_n[11]}
N 8620 -3930 8630 -3940 {
lab=colon_n[11]}
N 8630 -3940 8830 -3940 {
lab=colon_n[11]}
N 8830 -3940 8840 -3930 {
lab=colon_n[11]}
N 8620 -3910 8630 -3920 {
lab=#net23}
N 8630 -3920 8830 -3920 {
lab=#net23}
N 8830 -3920 8840 -3910 {
lab=#net23}
N 8620 -3890 8630 -3900 {
lab=#net24}
N 8630 -3900 8830 -3900 {
lab=#net24}
N 8830 -3900 8840 -3890 {
lab=#net24}
N 8680 -4050 8680 -4030 {
lab=vcom}
N 8720 -4050 8720 -4030 {
lab=ctop}
N 8600 -3950 8620 -3950 {
lab=col_n[11]}
N 8600 -3930 8620 -3930 {
lab=colon_n[11]}
N 8600 -3910 8620 -3910 {
lab=#net23}
N 8600 -3890 8620 -3890 {
lab=#net24}
N 8840 -3890 8860 -3890 {
lab=#net24}
N 8840 -3910 8860 -3910 {
lab=#net23}
N 8840 -3930 8860 -3930 {
lab=colon_n[11]}
N 8840 -3950 8860 -3950 {
lab=col_n[11]}
N 8660 -3810 8660 -3800 {
lab=VSS}
N 8660 -4040 8660 -4030 {
lab=VDD}
N 9000 -3810 9010 -3820 {
lab=row_n[30]}
N 9010 -4020 9010 -3820 {
lab=row_n[30]}
N 9000 -4030 9010 -4020 {
lab=row_n[30]}
N 9000 -3810 9000 -3790 {
lab=row_n[30]}
N 9000 -4050 9000 -4030 {
lab=row_n[30]}
N 8880 -3950 8890 -3960 {
lab=col_n[11]}
N 8890 -3960 9090 -3960 {
lab=col_n[11]}
N 9090 -3960 9100 -3950 {
lab=col_n[11]}
N 8880 -3930 8890 -3940 {
lab=colon_n[11]}
N 8890 -3940 9090 -3940 {
lab=colon_n[11]}
N 9090 -3940 9100 -3930 {
lab=colon_n[11]}
N 8880 -3910 8890 -3920 {
lab=#net23}
N 8890 -3920 9090 -3920 {
lab=#net23}
N 9090 -3920 9100 -3910 {
lab=#net23}
N 8880 -3890 8890 -3900 {
lab=#net24}
N 8890 -3900 9090 -3900 {
lab=#net24}
N 9090 -3900 9100 -3890 {
lab=#net24}
N 8940 -4050 8940 -4030 {
lab=vcom}
N 8980 -4050 8980 -4030 {
lab=ctop}
N 8860 -3950 8880 -3950 {
lab=col_n[11]}
N 8860 -3930 8880 -3930 {
lab=colon_n[11]}
N 8860 -3910 8880 -3910 {
lab=#net23}
N 8860 -3890 8880 -3890 {
lab=#net24}
N 9100 -3890 9120 -3890 {
lab=#net24}
N 9100 -3910 9120 -3910 {
lab=#net23}
N 9100 -3930 9120 -3930 {
lab=colon_n[11]}
N 9100 -3950 9120 -3950 {
lab=col_n[11]}
N 8920 -3810 8920 -3800 {
lab=VSS}
N 8920 -4040 8920 -4030 {
lab=VDD}
N 9260 -3810 9270 -3820 {
lab=row_n[31]}
N 9270 -4020 9270 -3820 {
lab=row_n[31]}
N 9260 -4030 9270 -4020 {
lab=row_n[31]}
N 9260 -3810 9260 -3790 {
lab=row_n[31]}
N 9260 -4050 9260 -4030 {
lab=row_n[31]}
N 9140 -3950 9150 -3960 {
lab=col_n[11]}
N 9150 -3960 9350 -3960 {
lab=col_n[11]}
N 9350 -3960 9360 -3950 {
lab=col_n[11]}
N 9140 -3930 9150 -3940 {
lab=colon_n[11]}
N 9150 -3940 9350 -3940 {
lab=colon_n[11]}
N 9350 -3940 9360 -3930 {
lab=colon_n[11]}
N 9140 -3910 9150 -3920 {
lab=#net23}
N 9150 -3920 9350 -3920 {
lab=#net23}
N 9350 -3920 9360 -3910 {
lab=#net23}
N 9140 -3890 9150 -3900 {
lab=#net24}
N 9150 -3900 9350 -3900 {
lab=#net24}
N 9350 -3900 9360 -3890 {
lab=#net24}
N 9200 -4050 9200 -4030 {
lab=vcom}
N 9240 -4050 9240 -4030 {
lab=ctop}
N 9120 -3950 9140 -3950 {
lab=col_n[11]}
N 9120 -3930 9140 -3930 {
lab=colon_n[11]}
N 9120 -3910 9140 -3910 {
lab=#net23}
N 9120 -3890 9140 -3890 {
lab=#net24}
N 9360 -3890 9380 -3890 {
lab=#net24}
N 9360 -3910 9380 -3910 {
lab=#net23}
N 9360 -3930 9380 -3930 {
lab=colon_n[11]}
N 9360 -3950 9380 -3950 {
lab=col_n[11]}
N 9180 -3810 9180 -3800 {
lab=VSS}
N 9180 -4040 9180 -4030 {
lab=VDD}
N 1200 -4070 1210 -4080 {
lab=row_n[0]}
N 1210 -4280 1210 -4080 {
lab=row_n[0]}
N 1200 -4290 1210 -4280 {
lab=row_n[0]}
N 1200 -4070 1200 -4050 {
lab=row_n[0]}
N 1200 -4310 1200 -4290 {
lab=row_n[0]}
N 1080 -4210 1090 -4220 {
lab=col_n[12]}
N 1090 -4220 1290 -4220 {
lab=col_n[12]}
N 1290 -4220 1300 -4210 {
lab=col_n[12]}
N 1080 -4190 1090 -4200 {
lab=colon_n[12]}
N 1090 -4200 1290 -4200 {
lab=colon_n[12]}
N 1290 -4200 1300 -4190 {
lab=colon_n[12]}
N 1080 -4170 1090 -4180 {
lab=#net25}
N 1090 -4180 1290 -4180 {
lab=#net25}
N 1290 -4180 1300 -4170 {
lab=#net25}
N 1080 -4150 1090 -4160 {
lab=#net26}
N 1090 -4160 1290 -4160 {
lab=#net26}
N 1290 -4160 1300 -4150 {
lab=#net26}
N 1140 -4310 1140 -4290 {
lab=vcom}
N 1180 -4310 1180 -4290 {
lab=ctop}
N 1060 -4210 1080 -4210 {
lab=col_n[12]}
N 1060 -4190 1080 -4190 {
lab=colon_n[12]}
N 1060 -4170 1080 -4170 {
lab=#net25}
N 1060 -4150 1080 -4150 {
lab=#net26}
N 1300 -4150 1320 -4150 {
lab=#net26}
N 1300 -4170 1320 -4170 {
lab=#net25}
N 1300 -4190 1320 -4190 {
lab=colon_n[12]}
N 1300 -4210 1320 -4210 {
lab=col_n[12]}
N 1120 -4070 1120 -4060 {
lab=VSS}
N 1120 -4300 1120 -4290 {
lab=VDD}
N 1460 -4070 1470 -4080 {
lab=row_n[1]}
N 1470 -4280 1470 -4080 {
lab=row_n[1]}
N 1460 -4290 1470 -4280 {
lab=row_n[1]}
N 1460 -4070 1460 -4050 {
lab=row_n[1]}
N 1460 -4310 1460 -4290 {
lab=row_n[1]}
N 1340 -4210 1350 -4220 {
lab=col_n[12]}
N 1350 -4220 1550 -4220 {
lab=col_n[12]}
N 1550 -4220 1560 -4210 {
lab=col_n[12]}
N 1340 -4190 1350 -4200 {
lab=colon_n[12]}
N 1350 -4200 1550 -4200 {
lab=colon_n[12]}
N 1550 -4200 1560 -4190 {
lab=colon_n[12]}
N 1340 -4170 1350 -4180 {
lab=#net25}
N 1350 -4180 1550 -4180 {
lab=#net25}
N 1550 -4180 1560 -4170 {
lab=#net25}
N 1340 -4150 1350 -4160 {
lab=#net26}
N 1350 -4160 1550 -4160 {
lab=#net26}
N 1550 -4160 1560 -4150 {
lab=#net26}
N 1400 -4310 1400 -4290 {
lab=vcom}
N 1440 -4310 1440 -4290 {
lab=ctop}
N 1320 -4210 1340 -4210 {
lab=col_n[12]}
N 1320 -4190 1340 -4190 {
lab=colon_n[12]}
N 1320 -4170 1340 -4170 {
lab=#net25}
N 1320 -4150 1340 -4150 {
lab=#net26}
N 1560 -4150 1580 -4150 {
lab=#net26}
N 1560 -4170 1580 -4170 {
lab=#net25}
N 1560 -4190 1580 -4190 {
lab=colon_n[12]}
N 1560 -4210 1580 -4210 {
lab=col_n[12]}
N 1380 -4070 1380 -4060 {
lab=VSS}
N 1380 -4300 1380 -4290 {
lab=VDD}
N 1720 -4070 1730 -4080 {
lab=row_n[2]}
N 1730 -4280 1730 -4080 {
lab=row_n[2]}
N 1720 -4290 1730 -4280 {
lab=row_n[2]}
N 1720 -4070 1720 -4050 {
lab=row_n[2]}
N 1720 -4310 1720 -4290 {
lab=row_n[2]}
N 1600 -4210 1610 -4220 {
lab=col_n[12]}
N 1610 -4220 1810 -4220 {
lab=col_n[12]}
N 1810 -4220 1820 -4210 {
lab=col_n[12]}
N 1600 -4190 1610 -4200 {
lab=colon_n[12]}
N 1610 -4200 1810 -4200 {
lab=colon_n[12]}
N 1810 -4200 1820 -4190 {
lab=colon_n[12]}
N 1600 -4170 1610 -4180 {
lab=#net25}
N 1610 -4180 1810 -4180 {
lab=#net25}
N 1810 -4180 1820 -4170 {
lab=#net25}
N 1600 -4150 1610 -4160 {
lab=#net26}
N 1610 -4160 1810 -4160 {
lab=#net26}
N 1810 -4160 1820 -4150 {
lab=#net26}
N 1660 -4310 1660 -4290 {
lab=vcom}
N 1700 -4310 1700 -4290 {
lab=ctop}
N 1580 -4210 1600 -4210 {
lab=col_n[12]}
N 1580 -4190 1600 -4190 {
lab=colon_n[12]}
N 1580 -4170 1600 -4170 {
lab=#net25}
N 1580 -4150 1600 -4150 {
lab=#net26}
N 1820 -4150 1840 -4150 {
lab=#net26}
N 1820 -4170 1840 -4170 {
lab=#net25}
N 1820 -4190 1840 -4190 {
lab=colon_n[12]}
N 1820 -4210 1840 -4210 {
lab=col_n[12]}
N 1640 -4070 1640 -4060 {
lab=VSS}
N 1640 -4300 1640 -4290 {
lab=VDD}
N 1980 -4070 1990 -4080 {
lab=row_n[3]}
N 1990 -4280 1990 -4080 {
lab=row_n[3]}
N 1980 -4290 1990 -4280 {
lab=row_n[3]}
N 1980 -4070 1980 -4050 {
lab=row_n[3]}
N 1980 -4310 1980 -4290 {
lab=row_n[3]}
N 1860 -4210 1870 -4220 {
lab=col_n[12]}
N 1870 -4220 2070 -4220 {
lab=col_n[12]}
N 2070 -4220 2080 -4210 {
lab=col_n[12]}
N 1860 -4190 1870 -4200 {
lab=colon_n[12]}
N 1870 -4200 2070 -4200 {
lab=colon_n[12]}
N 2070 -4200 2080 -4190 {
lab=colon_n[12]}
N 1860 -4170 1870 -4180 {
lab=#net25}
N 1870 -4180 2070 -4180 {
lab=#net25}
N 2070 -4180 2080 -4170 {
lab=#net25}
N 1860 -4150 1870 -4160 {
lab=#net26}
N 1870 -4160 2070 -4160 {
lab=#net26}
N 2070 -4160 2080 -4150 {
lab=#net26}
N 1920 -4310 1920 -4290 {
lab=vcom}
N 1960 -4310 1960 -4290 {
lab=ctop}
N 1840 -4210 1860 -4210 {
lab=col_n[12]}
N 1840 -4190 1860 -4190 {
lab=colon_n[12]}
N 1840 -4170 1860 -4170 {
lab=#net25}
N 1840 -4150 1860 -4150 {
lab=#net26}
N 2080 -4150 2100 -4150 {
lab=#net26}
N 2080 -4170 2100 -4170 {
lab=#net25}
N 2080 -4190 2100 -4190 {
lab=colon_n[12]}
N 2080 -4210 2100 -4210 {
lab=col_n[12]}
N 1900 -4070 1900 -4060 {
lab=VSS}
N 1900 -4300 1900 -4290 {
lab=VDD}
N 2240 -4070 2250 -4080 {
lab=row_n[4]}
N 2250 -4280 2250 -4080 {
lab=row_n[4]}
N 2240 -4290 2250 -4280 {
lab=row_n[4]}
N 2240 -4070 2240 -4050 {
lab=row_n[4]}
N 2240 -4310 2240 -4290 {
lab=row_n[4]}
N 2120 -4210 2130 -4220 {
lab=col_n[12]}
N 2130 -4220 2330 -4220 {
lab=col_n[12]}
N 2330 -4220 2340 -4210 {
lab=col_n[12]}
N 2120 -4190 2130 -4200 {
lab=colon_n[12]}
N 2130 -4200 2330 -4200 {
lab=colon_n[12]}
N 2330 -4200 2340 -4190 {
lab=colon_n[12]}
N 2120 -4170 2130 -4180 {
lab=#net25}
N 2130 -4180 2330 -4180 {
lab=#net25}
N 2330 -4180 2340 -4170 {
lab=#net25}
N 2120 -4150 2130 -4160 {
lab=#net26}
N 2130 -4160 2330 -4160 {
lab=#net26}
N 2330 -4160 2340 -4150 {
lab=#net26}
N 2180 -4310 2180 -4290 {
lab=vcom}
N 2220 -4310 2220 -4290 {
lab=ctop}
N 2100 -4210 2120 -4210 {
lab=col_n[12]}
N 2100 -4190 2120 -4190 {
lab=colon_n[12]}
N 2100 -4170 2120 -4170 {
lab=#net25}
N 2100 -4150 2120 -4150 {
lab=#net26}
N 2340 -4150 2360 -4150 {
lab=#net26}
N 2340 -4170 2360 -4170 {
lab=#net25}
N 2340 -4190 2360 -4190 {
lab=colon_n[12]}
N 2340 -4210 2360 -4210 {
lab=col_n[12]}
N 2160 -4070 2160 -4060 {
lab=VSS}
N 2160 -4300 2160 -4290 {
lab=VDD}
N 2500 -4070 2510 -4080 {
lab=row_n[5]}
N 2510 -4280 2510 -4080 {
lab=row_n[5]}
N 2500 -4290 2510 -4280 {
lab=row_n[5]}
N 2500 -4070 2500 -4050 {
lab=row_n[5]}
N 2500 -4310 2500 -4290 {
lab=row_n[5]}
N 2380 -4210 2390 -4220 {
lab=col_n[12]}
N 2390 -4220 2590 -4220 {
lab=col_n[12]}
N 2590 -4220 2600 -4210 {
lab=col_n[12]}
N 2380 -4190 2390 -4200 {
lab=colon_n[12]}
N 2390 -4200 2590 -4200 {
lab=colon_n[12]}
N 2590 -4200 2600 -4190 {
lab=colon_n[12]}
N 2380 -4170 2390 -4180 {
lab=#net25}
N 2390 -4180 2590 -4180 {
lab=#net25}
N 2590 -4180 2600 -4170 {
lab=#net25}
N 2380 -4150 2390 -4160 {
lab=#net26}
N 2390 -4160 2590 -4160 {
lab=#net26}
N 2590 -4160 2600 -4150 {
lab=#net26}
N 2440 -4310 2440 -4290 {
lab=vcom}
N 2480 -4310 2480 -4290 {
lab=ctop}
N 2360 -4210 2380 -4210 {
lab=col_n[12]}
N 2360 -4190 2380 -4190 {
lab=colon_n[12]}
N 2360 -4170 2380 -4170 {
lab=#net25}
N 2360 -4150 2380 -4150 {
lab=#net26}
N 2600 -4150 2620 -4150 {
lab=#net26}
N 2600 -4170 2620 -4170 {
lab=#net25}
N 2600 -4190 2620 -4190 {
lab=colon_n[12]}
N 2600 -4210 2620 -4210 {
lab=col_n[12]}
N 2420 -4070 2420 -4060 {
lab=VSS}
N 2420 -4300 2420 -4290 {
lab=VDD}
N 2760 -4070 2770 -4080 {
lab=row_n[6]}
N 2770 -4280 2770 -4080 {
lab=row_n[6]}
N 2760 -4290 2770 -4280 {
lab=row_n[6]}
N 2760 -4070 2760 -4050 {
lab=row_n[6]}
N 2760 -4310 2760 -4290 {
lab=row_n[6]}
N 2640 -4210 2650 -4220 {
lab=col_n[12]}
N 2650 -4220 2850 -4220 {
lab=col_n[12]}
N 2850 -4220 2860 -4210 {
lab=col_n[12]}
N 2640 -4190 2650 -4200 {
lab=colon_n[12]}
N 2650 -4200 2850 -4200 {
lab=colon_n[12]}
N 2850 -4200 2860 -4190 {
lab=colon_n[12]}
N 2640 -4170 2650 -4180 {
lab=#net25}
N 2650 -4180 2850 -4180 {
lab=#net25}
N 2850 -4180 2860 -4170 {
lab=#net25}
N 2640 -4150 2650 -4160 {
lab=#net26}
N 2650 -4160 2850 -4160 {
lab=#net26}
N 2850 -4160 2860 -4150 {
lab=#net26}
N 2700 -4310 2700 -4290 {
lab=vcom}
N 2740 -4310 2740 -4290 {
lab=ctop}
N 2620 -4210 2640 -4210 {
lab=col_n[12]}
N 2620 -4190 2640 -4190 {
lab=colon_n[12]}
N 2620 -4170 2640 -4170 {
lab=#net25}
N 2620 -4150 2640 -4150 {
lab=#net26}
N 2860 -4150 2880 -4150 {
lab=#net26}
N 2860 -4170 2880 -4170 {
lab=#net25}
N 2860 -4190 2880 -4190 {
lab=colon_n[12]}
N 2860 -4210 2880 -4210 {
lab=col_n[12]}
N 2680 -4070 2680 -4060 {
lab=VSS}
N 2680 -4300 2680 -4290 {
lab=VDD}
N 3020 -4070 3030 -4080 {
lab=row_n[7]}
N 3030 -4280 3030 -4080 {
lab=row_n[7]}
N 3020 -4290 3030 -4280 {
lab=row_n[7]}
N 3020 -4070 3020 -4050 {
lab=row_n[7]}
N 3020 -4310 3020 -4290 {
lab=row_n[7]}
N 2900 -4210 2910 -4220 {
lab=col_n[12]}
N 2910 -4220 3110 -4220 {
lab=col_n[12]}
N 3110 -4220 3120 -4210 {
lab=col_n[12]}
N 2900 -4190 2910 -4200 {
lab=colon_n[12]}
N 2910 -4200 3110 -4200 {
lab=colon_n[12]}
N 3110 -4200 3120 -4190 {
lab=colon_n[12]}
N 2900 -4170 2910 -4180 {
lab=#net25}
N 2910 -4180 3110 -4180 {
lab=#net25}
N 3110 -4180 3120 -4170 {
lab=#net25}
N 2900 -4150 2910 -4160 {
lab=#net26}
N 2910 -4160 3110 -4160 {
lab=#net26}
N 3110 -4160 3120 -4150 {
lab=#net26}
N 2960 -4310 2960 -4290 {
lab=vcom}
N 3000 -4310 3000 -4290 {
lab=ctop}
N 2880 -4210 2900 -4210 {
lab=col_n[12]}
N 2880 -4190 2900 -4190 {
lab=colon_n[12]}
N 2880 -4170 2900 -4170 {
lab=#net25}
N 2880 -4150 2900 -4150 {
lab=#net26}
N 3120 -4150 3140 -4150 {
lab=#net26}
N 3120 -4170 3140 -4170 {
lab=#net25}
N 3120 -4190 3140 -4190 {
lab=colon_n[12]}
N 3120 -4210 3140 -4210 {
lab=col_n[12]}
N 2940 -4070 2940 -4060 {
lab=VSS}
N 2940 -4300 2940 -4290 {
lab=VDD}
N 3280 -4070 3290 -4080 {
lab=row_n[8]}
N 3290 -4280 3290 -4080 {
lab=row_n[8]}
N 3280 -4290 3290 -4280 {
lab=row_n[8]}
N 3280 -4070 3280 -4050 {
lab=row_n[8]}
N 3280 -4310 3280 -4290 {
lab=row_n[8]}
N 3160 -4210 3170 -4220 {
lab=col_n[12]}
N 3170 -4220 3370 -4220 {
lab=col_n[12]}
N 3370 -4220 3380 -4210 {
lab=col_n[12]}
N 3160 -4190 3170 -4200 {
lab=colon_n[12]}
N 3170 -4200 3370 -4200 {
lab=colon_n[12]}
N 3370 -4200 3380 -4190 {
lab=colon_n[12]}
N 3160 -4170 3170 -4180 {
lab=#net25}
N 3170 -4180 3370 -4180 {
lab=#net25}
N 3370 -4180 3380 -4170 {
lab=#net25}
N 3160 -4150 3170 -4160 {
lab=#net26}
N 3170 -4160 3370 -4160 {
lab=#net26}
N 3370 -4160 3380 -4150 {
lab=#net26}
N 3220 -4310 3220 -4290 {
lab=vcom}
N 3260 -4310 3260 -4290 {
lab=ctop}
N 3140 -4210 3160 -4210 {
lab=col_n[12]}
N 3140 -4190 3160 -4190 {
lab=colon_n[12]}
N 3140 -4170 3160 -4170 {
lab=#net25}
N 3140 -4150 3160 -4150 {
lab=#net26}
N 3380 -4150 3400 -4150 {
lab=#net26}
N 3380 -4170 3400 -4170 {
lab=#net25}
N 3380 -4190 3400 -4190 {
lab=colon_n[12]}
N 3380 -4210 3400 -4210 {
lab=col_n[12]}
N 3200 -4070 3200 -4060 {
lab=VSS}
N 3200 -4300 3200 -4290 {
lab=VDD}
N 3540 -4070 3550 -4080 {
lab=row_n[9]}
N 3550 -4280 3550 -4080 {
lab=row_n[9]}
N 3540 -4290 3550 -4280 {
lab=row_n[9]}
N 3540 -4070 3540 -4050 {
lab=row_n[9]}
N 3540 -4310 3540 -4290 {
lab=row_n[9]}
N 3420 -4210 3430 -4220 {
lab=col_n[12]}
N 3430 -4220 3630 -4220 {
lab=col_n[12]}
N 3630 -4220 3640 -4210 {
lab=col_n[12]}
N 3420 -4190 3430 -4200 {
lab=colon_n[12]}
N 3430 -4200 3630 -4200 {
lab=colon_n[12]}
N 3630 -4200 3640 -4190 {
lab=colon_n[12]}
N 3420 -4170 3430 -4180 {
lab=#net25}
N 3430 -4180 3630 -4180 {
lab=#net25}
N 3630 -4180 3640 -4170 {
lab=#net25}
N 3420 -4150 3430 -4160 {
lab=#net26}
N 3430 -4160 3630 -4160 {
lab=#net26}
N 3630 -4160 3640 -4150 {
lab=#net26}
N 3480 -4310 3480 -4290 {
lab=vcom}
N 3520 -4310 3520 -4290 {
lab=ctop}
N 3400 -4210 3420 -4210 {
lab=col_n[12]}
N 3400 -4190 3420 -4190 {
lab=colon_n[12]}
N 3400 -4170 3420 -4170 {
lab=#net25}
N 3400 -4150 3420 -4150 {
lab=#net26}
N 3640 -4150 3660 -4150 {
lab=#net26}
N 3640 -4170 3660 -4170 {
lab=#net25}
N 3640 -4190 3660 -4190 {
lab=colon_n[12]}
N 3640 -4210 3660 -4210 {
lab=col_n[12]}
N 3460 -4070 3460 -4060 {
lab=VSS}
N 3460 -4300 3460 -4290 {
lab=VDD}
N 3800 -4070 3810 -4080 {
lab=row_n[10]}
N 3810 -4280 3810 -4080 {
lab=row_n[10]}
N 3800 -4290 3810 -4280 {
lab=row_n[10]}
N 3800 -4070 3800 -4050 {
lab=row_n[10]}
N 3800 -4310 3800 -4290 {
lab=row_n[10]}
N 3680 -4210 3690 -4220 {
lab=col_n[12]}
N 3690 -4220 3890 -4220 {
lab=col_n[12]}
N 3890 -4220 3900 -4210 {
lab=col_n[12]}
N 3680 -4190 3690 -4200 {
lab=colon_n[12]}
N 3690 -4200 3890 -4200 {
lab=colon_n[12]}
N 3890 -4200 3900 -4190 {
lab=colon_n[12]}
N 3680 -4170 3690 -4180 {
lab=#net25}
N 3690 -4180 3890 -4180 {
lab=#net25}
N 3890 -4180 3900 -4170 {
lab=#net25}
N 3680 -4150 3690 -4160 {
lab=#net26}
N 3690 -4160 3890 -4160 {
lab=#net26}
N 3890 -4160 3900 -4150 {
lab=#net26}
N 3740 -4310 3740 -4290 {
lab=vcom}
N 3780 -4310 3780 -4290 {
lab=ctop}
N 3660 -4210 3680 -4210 {
lab=col_n[12]}
N 3660 -4190 3680 -4190 {
lab=colon_n[12]}
N 3660 -4170 3680 -4170 {
lab=#net25}
N 3660 -4150 3680 -4150 {
lab=#net26}
N 3900 -4150 3920 -4150 {
lab=#net26}
N 3900 -4170 3920 -4170 {
lab=#net25}
N 3900 -4190 3920 -4190 {
lab=colon_n[12]}
N 3900 -4210 3920 -4210 {
lab=col_n[12]}
N 3720 -4070 3720 -4060 {
lab=VSS}
N 3720 -4300 3720 -4290 {
lab=VDD}
N 4060 -4070 4070 -4080 {
lab=row_n[11]}
N 4070 -4280 4070 -4080 {
lab=row_n[11]}
N 4060 -4290 4070 -4280 {
lab=row_n[11]}
N 4060 -4070 4060 -4050 {
lab=row_n[11]}
N 4060 -4310 4060 -4290 {
lab=row_n[11]}
N 3940 -4210 3950 -4220 {
lab=col_n[12]}
N 3950 -4220 4150 -4220 {
lab=col_n[12]}
N 4150 -4220 4160 -4210 {
lab=col_n[12]}
N 3940 -4190 3950 -4200 {
lab=colon_n[12]}
N 3950 -4200 4150 -4200 {
lab=colon_n[12]}
N 4150 -4200 4160 -4190 {
lab=colon_n[12]}
N 3940 -4170 3950 -4180 {
lab=#net25}
N 3950 -4180 4150 -4180 {
lab=#net25}
N 4150 -4180 4160 -4170 {
lab=#net25}
N 3940 -4150 3950 -4160 {
lab=#net26}
N 3950 -4160 4150 -4160 {
lab=#net26}
N 4150 -4160 4160 -4150 {
lab=#net26}
N 4000 -4310 4000 -4290 {
lab=vcom}
N 4040 -4310 4040 -4290 {
lab=ctop}
N 3920 -4210 3940 -4210 {
lab=col_n[12]}
N 3920 -4190 3940 -4190 {
lab=colon_n[12]}
N 3920 -4170 3940 -4170 {
lab=#net25}
N 3920 -4150 3940 -4150 {
lab=#net26}
N 4160 -4150 4180 -4150 {
lab=#net26}
N 4160 -4170 4180 -4170 {
lab=#net25}
N 4160 -4190 4180 -4190 {
lab=colon_n[12]}
N 4160 -4210 4180 -4210 {
lab=col_n[12]}
N 3980 -4070 3980 -4060 {
lab=VSS}
N 3980 -4300 3980 -4290 {
lab=VDD}
N 4320 -4070 4330 -4080 {
lab=row_n[12]}
N 4330 -4280 4330 -4080 {
lab=row_n[12]}
N 4320 -4290 4330 -4280 {
lab=row_n[12]}
N 4320 -4070 4320 -4050 {
lab=row_n[12]}
N 4320 -4310 4320 -4290 {
lab=row_n[12]}
N 4200 -4210 4210 -4220 {
lab=col_n[12]}
N 4210 -4220 4410 -4220 {
lab=col_n[12]}
N 4410 -4220 4420 -4210 {
lab=col_n[12]}
N 4200 -4190 4210 -4200 {
lab=colon_n[12]}
N 4210 -4200 4410 -4200 {
lab=colon_n[12]}
N 4410 -4200 4420 -4190 {
lab=colon_n[12]}
N 4200 -4170 4210 -4180 {
lab=#net25}
N 4210 -4180 4410 -4180 {
lab=#net25}
N 4410 -4180 4420 -4170 {
lab=#net25}
N 4200 -4150 4210 -4160 {
lab=#net26}
N 4210 -4160 4410 -4160 {
lab=#net26}
N 4410 -4160 4420 -4150 {
lab=#net26}
N 4260 -4310 4260 -4290 {
lab=vcom}
N 4300 -4310 4300 -4290 {
lab=ctop}
N 4180 -4210 4200 -4210 {
lab=col_n[12]}
N 4180 -4190 4200 -4190 {
lab=colon_n[12]}
N 4180 -4170 4200 -4170 {
lab=#net25}
N 4180 -4150 4200 -4150 {
lab=#net26}
N 4420 -4150 4440 -4150 {
lab=#net26}
N 4420 -4170 4440 -4170 {
lab=#net25}
N 4420 -4190 4440 -4190 {
lab=colon_n[12]}
N 4420 -4210 4440 -4210 {
lab=col_n[12]}
N 4240 -4070 4240 -4060 {
lab=VSS}
N 4240 -4300 4240 -4290 {
lab=VDD}
N 4580 -4070 4590 -4080 {
lab=row_n[13]}
N 4590 -4280 4590 -4080 {
lab=row_n[13]}
N 4580 -4290 4590 -4280 {
lab=row_n[13]}
N 4580 -4070 4580 -4050 {
lab=row_n[13]}
N 4580 -4310 4580 -4290 {
lab=row_n[13]}
N 4460 -4210 4470 -4220 {
lab=col_n[12]}
N 4470 -4220 4670 -4220 {
lab=col_n[12]}
N 4670 -4220 4680 -4210 {
lab=col_n[12]}
N 4460 -4190 4470 -4200 {
lab=colon_n[12]}
N 4470 -4200 4670 -4200 {
lab=colon_n[12]}
N 4670 -4200 4680 -4190 {
lab=colon_n[12]}
N 4460 -4170 4470 -4180 {
lab=#net25}
N 4470 -4180 4670 -4180 {
lab=#net25}
N 4670 -4180 4680 -4170 {
lab=#net25}
N 4460 -4150 4470 -4160 {
lab=#net26}
N 4470 -4160 4670 -4160 {
lab=#net26}
N 4670 -4160 4680 -4150 {
lab=#net26}
N 4520 -4310 4520 -4290 {
lab=vcom}
N 4560 -4310 4560 -4290 {
lab=ctop}
N 4440 -4210 4460 -4210 {
lab=col_n[12]}
N 4440 -4190 4460 -4190 {
lab=colon_n[12]}
N 4440 -4170 4460 -4170 {
lab=#net25}
N 4440 -4150 4460 -4150 {
lab=#net26}
N 4680 -4150 4700 -4150 {
lab=#net26}
N 4680 -4170 4700 -4170 {
lab=#net25}
N 4680 -4190 4700 -4190 {
lab=colon_n[12]}
N 4680 -4210 4700 -4210 {
lab=col_n[12]}
N 4500 -4070 4500 -4060 {
lab=VSS}
N 4500 -4300 4500 -4290 {
lab=VDD}
N 4840 -4070 4850 -4080 {
lab=row_n[14]}
N 4850 -4280 4850 -4080 {
lab=row_n[14]}
N 4840 -4290 4850 -4280 {
lab=row_n[14]}
N 4840 -4070 4840 -4050 {
lab=row_n[14]}
N 4840 -4310 4840 -4290 {
lab=row_n[14]}
N 4720 -4210 4730 -4220 {
lab=col_n[12]}
N 4730 -4220 4930 -4220 {
lab=col_n[12]}
N 4930 -4220 4940 -4210 {
lab=col_n[12]}
N 4720 -4190 4730 -4200 {
lab=colon_n[12]}
N 4730 -4200 4930 -4200 {
lab=colon_n[12]}
N 4930 -4200 4940 -4190 {
lab=colon_n[12]}
N 4720 -4170 4730 -4180 {
lab=#net25}
N 4730 -4180 4930 -4180 {
lab=#net25}
N 4930 -4180 4940 -4170 {
lab=#net25}
N 4720 -4150 4730 -4160 {
lab=#net26}
N 4730 -4160 4930 -4160 {
lab=#net26}
N 4930 -4160 4940 -4150 {
lab=#net26}
N 4780 -4310 4780 -4290 {
lab=vcom}
N 4820 -4310 4820 -4290 {
lab=ctop}
N 4700 -4210 4720 -4210 {
lab=col_n[12]}
N 4700 -4190 4720 -4190 {
lab=colon_n[12]}
N 4700 -4170 4720 -4170 {
lab=#net25}
N 4700 -4150 4720 -4150 {
lab=#net26}
N 4940 -4150 4960 -4150 {
lab=#net26}
N 4940 -4170 4960 -4170 {
lab=#net25}
N 4940 -4190 4960 -4190 {
lab=colon_n[12]}
N 4940 -4210 4960 -4210 {
lab=col_n[12]}
N 4760 -4070 4760 -4060 {
lab=VSS}
N 4760 -4300 4760 -4290 {
lab=VDD}
N 5100 -4070 5110 -4080 {
lab=row_n[15]}
N 5110 -4280 5110 -4080 {
lab=row_n[15]}
N 5100 -4290 5110 -4280 {
lab=row_n[15]}
N 5100 -4070 5100 -4050 {
lab=row_n[15]}
N 5100 -4310 5100 -4290 {
lab=row_n[15]}
N 4980 -4210 4990 -4220 {
lab=col_n[12]}
N 4990 -4220 5190 -4220 {
lab=col_n[12]}
N 5190 -4220 5200 -4210 {
lab=col_n[12]}
N 4980 -4190 4990 -4200 {
lab=colon_n[12]}
N 4990 -4200 5190 -4200 {
lab=colon_n[12]}
N 5190 -4200 5200 -4190 {
lab=colon_n[12]}
N 4980 -4170 4990 -4180 {
lab=#net25}
N 4990 -4180 5190 -4180 {
lab=#net25}
N 5190 -4180 5200 -4170 {
lab=#net25}
N 4980 -4150 4990 -4160 {
lab=#net26}
N 4990 -4160 5190 -4160 {
lab=#net26}
N 5190 -4160 5200 -4150 {
lab=#net26}
N 5040 -4310 5040 -4290 {
lab=vcom}
N 5080 -4310 5080 -4290 {
lab=ctop}
N 4960 -4210 4980 -4210 {
lab=col_n[12]}
N 4960 -4190 4980 -4190 {
lab=colon_n[12]}
N 4960 -4170 4980 -4170 {
lab=#net25}
N 4960 -4150 4980 -4150 {
lab=#net26}
N 5200 -4150 5220 -4150 {
lab=#net26}
N 5200 -4170 5220 -4170 {
lab=#net25}
N 5200 -4190 5220 -4190 {
lab=colon_n[12]}
N 5200 -4210 5220 -4210 {
lab=col_n[12]}
N 5020 -4070 5020 -4060 {
lab=VSS}
N 5020 -4300 5020 -4290 {
lab=VDD}
N 5360 -4070 5370 -4080 {
lab=row_n[16]}
N 5370 -4280 5370 -4080 {
lab=row_n[16]}
N 5360 -4290 5370 -4280 {
lab=row_n[16]}
N 5360 -4070 5360 -4050 {
lab=row_n[16]}
N 5360 -4310 5360 -4290 {
lab=row_n[16]}
N 5240 -4210 5250 -4220 {
lab=col_n[12]}
N 5250 -4220 5450 -4220 {
lab=col_n[12]}
N 5450 -4220 5460 -4210 {
lab=col_n[12]}
N 5240 -4190 5250 -4200 {
lab=colon_n[12]}
N 5250 -4200 5450 -4200 {
lab=colon_n[12]}
N 5450 -4200 5460 -4190 {
lab=colon_n[12]}
N 5240 -4170 5250 -4180 {
lab=#net25}
N 5250 -4180 5450 -4180 {
lab=#net25}
N 5450 -4180 5460 -4170 {
lab=#net25}
N 5240 -4150 5250 -4160 {
lab=#net26}
N 5250 -4160 5450 -4160 {
lab=#net26}
N 5450 -4160 5460 -4150 {
lab=#net26}
N 5300 -4310 5300 -4290 {
lab=vcom}
N 5340 -4310 5340 -4290 {
lab=ctop}
N 5220 -4210 5240 -4210 {
lab=col_n[12]}
N 5220 -4190 5240 -4190 {
lab=colon_n[12]}
N 5220 -4170 5240 -4170 {
lab=#net25}
N 5220 -4150 5240 -4150 {
lab=#net26}
N 5460 -4150 5480 -4150 {
lab=#net26}
N 5460 -4170 5480 -4170 {
lab=#net25}
N 5460 -4190 5480 -4190 {
lab=colon_n[12]}
N 5460 -4210 5480 -4210 {
lab=col_n[12]}
N 5280 -4070 5280 -4060 {
lab=VSS}
N 5280 -4300 5280 -4290 {
lab=VDD}
N 5620 -4070 5630 -4080 {
lab=row_n[17]}
N 5630 -4280 5630 -4080 {
lab=row_n[17]}
N 5620 -4290 5630 -4280 {
lab=row_n[17]}
N 5620 -4070 5620 -4050 {
lab=row_n[17]}
N 5620 -4310 5620 -4290 {
lab=row_n[17]}
N 5500 -4210 5510 -4220 {
lab=col_n[12]}
N 5510 -4220 5710 -4220 {
lab=col_n[12]}
N 5710 -4220 5720 -4210 {
lab=col_n[12]}
N 5500 -4190 5510 -4200 {
lab=colon_n[12]}
N 5510 -4200 5710 -4200 {
lab=colon_n[12]}
N 5710 -4200 5720 -4190 {
lab=colon_n[12]}
N 5500 -4170 5510 -4180 {
lab=#net25}
N 5510 -4180 5710 -4180 {
lab=#net25}
N 5710 -4180 5720 -4170 {
lab=#net25}
N 5500 -4150 5510 -4160 {
lab=#net26}
N 5510 -4160 5710 -4160 {
lab=#net26}
N 5710 -4160 5720 -4150 {
lab=#net26}
N 5560 -4310 5560 -4290 {
lab=vcom}
N 5600 -4310 5600 -4290 {
lab=ctop}
N 5480 -4210 5500 -4210 {
lab=col_n[12]}
N 5480 -4190 5500 -4190 {
lab=colon_n[12]}
N 5480 -4170 5500 -4170 {
lab=#net25}
N 5480 -4150 5500 -4150 {
lab=#net26}
N 5720 -4150 5740 -4150 {
lab=#net26}
N 5720 -4170 5740 -4170 {
lab=#net25}
N 5720 -4190 5740 -4190 {
lab=colon_n[12]}
N 5720 -4210 5740 -4210 {
lab=col_n[12]}
N 5540 -4070 5540 -4060 {
lab=VSS}
N 5540 -4300 5540 -4290 {
lab=VDD}
N 5880 -4070 5890 -4080 {
lab=row_n[18]}
N 5890 -4280 5890 -4080 {
lab=row_n[18]}
N 5880 -4290 5890 -4280 {
lab=row_n[18]}
N 5880 -4070 5880 -4050 {
lab=row_n[18]}
N 5880 -4310 5880 -4290 {
lab=row_n[18]}
N 5760 -4210 5770 -4220 {
lab=col_n[12]}
N 5770 -4220 5970 -4220 {
lab=col_n[12]}
N 5970 -4220 5980 -4210 {
lab=col_n[12]}
N 5760 -4190 5770 -4200 {
lab=colon_n[12]}
N 5770 -4200 5970 -4200 {
lab=colon_n[12]}
N 5970 -4200 5980 -4190 {
lab=colon_n[12]}
N 5760 -4170 5770 -4180 {
lab=#net25}
N 5770 -4180 5970 -4180 {
lab=#net25}
N 5970 -4180 5980 -4170 {
lab=#net25}
N 5760 -4150 5770 -4160 {
lab=#net26}
N 5770 -4160 5970 -4160 {
lab=#net26}
N 5970 -4160 5980 -4150 {
lab=#net26}
N 5820 -4310 5820 -4290 {
lab=vcom}
N 5860 -4310 5860 -4290 {
lab=ctop}
N 5740 -4210 5760 -4210 {
lab=col_n[12]}
N 5740 -4190 5760 -4190 {
lab=colon_n[12]}
N 5740 -4170 5760 -4170 {
lab=#net25}
N 5740 -4150 5760 -4150 {
lab=#net26}
N 5980 -4150 6000 -4150 {
lab=#net26}
N 5980 -4170 6000 -4170 {
lab=#net25}
N 5980 -4190 6000 -4190 {
lab=colon_n[12]}
N 5980 -4210 6000 -4210 {
lab=col_n[12]}
N 5800 -4070 5800 -4060 {
lab=VSS}
N 5800 -4300 5800 -4290 {
lab=VDD}
N 6140 -4070 6150 -4080 {
lab=row_n[19]}
N 6150 -4280 6150 -4080 {
lab=row_n[19]}
N 6140 -4290 6150 -4280 {
lab=row_n[19]}
N 6140 -4070 6140 -4050 {
lab=row_n[19]}
N 6140 -4310 6140 -4290 {
lab=row_n[19]}
N 6020 -4210 6030 -4220 {
lab=col_n[12]}
N 6030 -4220 6230 -4220 {
lab=col_n[12]}
N 6230 -4220 6240 -4210 {
lab=col_n[12]}
N 6020 -4190 6030 -4200 {
lab=colon_n[12]}
N 6030 -4200 6230 -4200 {
lab=colon_n[12]}
N 6230 -4200 6240 -4190 {
lab=colon_n[12]}
N 6020 -4170 6030 -4180 {
lab=#net25}
N 6030 -4180 6230 -4180 {
lab=#net25}
N 6230 -4180 6240 -4170 {
lab=#net25}
N 6020 -4150 6030 -4160 {
lab=#net26}
N 6030 -4160 6230 -4160 {
lab=#net26}
N 6230 -4160 6240 -4150 {
lab=#net26}
N 6080 -4310 6080 -4290 {
lab=vcom}
N 6120 -4310 6120 -4290 {
lab=ctop}
N 6000 -4210 6020 -4210 {
lab=col_n[12]}
N 6000 -4190 6020 -4190 {
lab=colon_n[12]}
N 6000 -4170 6020 -4170 {
lab=#net25}
N 6000 -4150 6020 -4150 {
lab=#net26}
N 6240 -4150 6260 -4150 {
lab=#net26}
N 6240 -4170 6260 -4170 {
lab=#net25}
N 6240 -4190 6260 -4190 {
lab=colon_n[12]}
N 6240 -4210 6260 -4210 {
lab=col_n[12]}
N 6060 -4070 6060 -4060 {
lab=VSS}
N 6060 -4300 6060 -4290 {
lab=VDD}
N 6400 -4070 6410 -4080 {
lab=row_n[20]}
N 6410 -4280 6410 -4080 {
lab=row_n[20]}
N 6400 -4290 6410 -4280 {
lab=row_n[20]}
N 6400 -4070 6400 -4050 {
lab=row_n[20]}
N 6400 -4310 6400 -4290 {
lab=row_n[20]}
N 6280 -4210 6290 -4220 {
lab=col_n[12]}
N 6290 -4220 6490 -4220 {
lab=col_n[12]}
N 6490 -4220 6500 -4210 {
lab=col_n[12]}
N 6280 -4190 6290 -4200 {
lab=colon_n[12]}
N 6290 -4200 6490 -4200 {
lab=colon_n[12]}
N 6490 -4200 6500 -4190 {
lab=colon_n[12]}
N 6280 -4170 6290 -4180 {
lab=#net25}
N 6290 -4180 6490 -4180 {
lab=#net25}
N 6490 -4180 6500 -4170 {
lab=#net25}
N 6280 -4150 6290 -4160 {
lab=#net26}
N 6290 -4160 6490 -4160 {
lab=#net26}
N 6490 -4160 6500 -4150 {
lab=#net26}
N 6340 -4310 6340 -4290 {
lab=vcom}
N 6380 -4310 6380 -4290 {
lab=ctop}
N 6260 -4210 6280 -4210 {
lab=col_n[12]}
N 6260 -4190 6280 -4190 {
lab=colon_n[12]}
N 6260 -4170 6280 -4170 {
lab=#net25}
N 6260 -4150 6280 -4150 {
lab=#net26}
N 6500 -4150 6520 -4150 {
lab=#net26}
N 6500 -4170 6520 -4170 {
lab=#net25}
N 6500 -4190 6520 -4190 {
lab=colon_n[12]}
N 6500 -4210 6520 -4210 {
lab=col_n[12]}
N 6320 -4070 6320 -4060 {
lab=VSS}
N 6320 -4300 6320 -4290 {
lab=VDD}
N 6660 -4070 6670 -4080 {
lab=row_n[21]}
N 6670 -4280 6670 -4080 {
lab=row_n[21]}
N 6660 -4290 6670 -4280 {
lab=row_n[21]}
N 6660 -4070 6660 -4050 {
lab=row_n[21]}
N 6660 -4310 6660 -4290 {
lab=row_n[21]}
N 6540 -4210 6550 -4220 {
lab=col_n[12]}
N 6550 -4220 6750 -4220 {
lab=col_n[12]}
N 6750 -4220 6760 -4210 {
lab=col_n[12]}
N 6540 -4190 6550 -4200 {
lab=colon_n[12]}
N 6550 -4200 6750 -4200 {
lab=colon_n[12]}
N 6750 -4200 6760 -4190 {
lab=colon_n[12]}
N 6540 -4170 6550 -4180 {
lab=#net25}
N 6550 -4180 6750 -4180 {
lab=#net25}
N 6750 -4180 6760 -4170 {
lab=#net25}
N 6540 -4150 6550 -4160 {
lab=#net26}
N 6550 -4160 6750 -4160 {
lab=#net26}
N 6750 -4160 6760 -4150 {
lab=#net26}
N 6600 -4310 6600 -4290 {
lab=vcom}
N 6640 -4310 6640 -4290 {
lab=ctop}
N 6520 -4210 6540 -4210 {
lab=col_n[12]}
N 6520 -4190 6540 -4190 {
lab=colon_n[12]}
N 6520 -4170 6540 -4170 {
lab=#net25}
N 6520 -4150 6540 -4150 {
lab=#net26}
N 6760 -4150 6780 -4150 {
lab=#net26}
N 6760 -4170 6780 -4170 {
lab=#net25}
N 6760 -4190 6780 -4190 {
lab=colon_n[12]}
N 6760 -4210 6780 -4210 {
lab=col_n[12]}
N 6580 -4070 6580 -4060 {
lab=VSS}
N 6580 -4300 6580 -4290 {
lab=VDD}
N 6920 -4070 6930 -4080 {
lab=row_n[22]}
N 6930 -4280 6930 -4080 {
lab=row_n[22]}
N 6920 -4290 6930 -4280 {
lab=row_n[22]}
N 6920 -4070 6920 -4050 {
lab=row_n[22]}
N 6920 -4310 6920 -4290 {
lab=row_n[22]}
N 6800 -4210 6810 -4220 {
lab=col_n[12]}
N 6810 -4220 7010 -4220 {
lab=col_n[12]}
N 7010 -4220 7020 -4210 {
lab=col_n[12]}
N 6800 -4190 6810 -4200 {
lab=colon_n[12]}
N 6810 -4200 7010 -4200 {
lab=colon_n[12]}
N 7010 -4200 7020 -4190 {
lab=colon_n[12]}
N 6800 -4170 6810 -4180 {
lab=#net25}
N 6810 -4180 7010 -4180 {
lab=#net25}
N 7010 -4180 7020 -4170 {
lab=#net25}
N 6800 -4150 6810 -4160 {
lab=#net26}
N 6810 -4160 7010 -4160 {
lab=#net26}
N 7010 -4160 7020 -4150 {
lab=#net26}
N 6860 -4310 6860 -4290 {
lab=vcom}
N 6900 -4310 6900 -4290 {
lab=ctop}
N 6780 -4210 6800 -4210 {
lab=col_n[12]}
N 6780 -4190 6800 -4190 {
lab=colon_n[12]}
N 6780 -4170 6800 -4170 {
lab=#net25}
N 6780 -4150 6800 -4150 {
lab=#net26}
N 7020 -4150 7040 -4150 {
lab=#net26}
N 7020 -4170 7040 -4170 {
lab=#net25}
N 7020 -4190 7040 -4190 {
lab=colon_n[12]}
N 7020 -4210 7040 -4210 {
lab=col_n[12]}
N 6840 -4070 6840 -4060 {
lab=VSS}
N 6840 -4300 6840 -4290 {
lab=VDD}
N 7180 -4070 7190 -4080 {
lab=row_n[23]}
N 7190 -4280 7190 -4080 {
lab=row_n[23]}
N 7180 -4290 7190 -4280 {
lab=row_n[23]}
N 7180 -4070 7180 -4050 {
lab=row_n[23]}
N 7180 -4310 7180 -4290 {
lab=row_n[23]}
N 7060 -4210 7070 -4220 {
lab=col_n[12]}
N 7070 -4220 7270 -4220 {
lab=col_n[12]}
N 7270 -4220 7280 -4210 {
lab=col_n[12]}
N 7060 -4190 7070 -4200 {
lab=colon_n[12]}
N 7070 -4200 7270 -4200 {
lab=colon_n[12]}
N 7270 -4200 7280 -4190 {
lab=colon_n[12]}
N 7060 -4170 7070 -4180 {
lab=#net25}
N 7070 -4180 7270 -4180 {
lab=#net25}
N 7270 -4180 7280 -4170 {
lab=#net25}
N 7060 -4150 7070 -4160 {
lab=#net26}
N 7070 -4160 7270 -4160 {
lab=#net26}
N 7270 -4160 7280 -4150 {
lab=#net26}
N 7120 -4310 7120 -4290 {
lab=vcom}
N 7160 -4310 7160 -4290 {
lab=ctop}
N 7040 -4210 7060 -4210 {
lab=col_n[12]}
N 7040 -4190 7060 -4190 {
lab=colon_n[12]}
N 7040 -4170 7060 -4170 {
lab=#net25}
N 7040 -4150 7060 -4150 {
lab=#net26}
N 7280 -4150 7300 -4150 {
lab=#net26}
N 7280 -4170 7300 -4170 {
lab=#net25}
N 7280 -4190 7300 -4190 {
lab=colon_n[12]}
N 7280 -4210 7300 -4210 {
lab=col_n[12]}
N 7100 -4070 7100 -4060 {
lab=VSS}
N 7100 -4300 7100 -4290 {
lab=VDD}
N 7440 -4070 7450 -4080 {
lab=row_n[24]}
N 7450 -4280 7450 -4080 {
lab=row_n[24]}
N 7440 -4290 7450 -4280 {
lab=row_n[24]}
N 7440 -4070 7440 -4050 {
lab=row_n[24]}
N 7440 -4310 7440 -4290 {
lab=row_n[24]}
N 7320 -4210 7330 -4220 {
lab=col_n[12]}
N 7330 -4220 7530 -4220 {
lab=col_n[12]}
N 7530 -4220 7540 -4210 {
lab=col_n[12]}
N 7320 -4190 7330 -4200 {
lab=colon_n[12]}
N 7330 -4200 7530 -4200 {
lab=colon_n[12]}
N 7530 -4200 7540 -4190 {
lab=colon_n[12]}
N 7320 -4170 7330 -4180 {
lab=#net25}
N 7330 -4180 7530 -4180 {
lab=#net25}
N 7530 -4180 7540 -4170 {
lab=#net25}
N 7320 -4150 7330 -4160 {
lab=#net26}
N 7330 -4160 7530 -4160 {
lab=#net26}
N 7530 -4160 7540 -4150 {
lab=#net26}
N 7380 -4310 7380 -4290 {
lab=vcom}
N 7420 -4310 7420 -4290 {
lab=ctop}
N 7300 -4210 7320 -4210 {
lab=col_n[12]}
N 7300 -4190 7320 -4190 {
lab=colon_n[12]}
N 7300 -4170 7320 -4170 {
lab=#net25}
N 7300 -4150 7320 -4150 {
lab=#net26}
N 7540 -4150 7560 -4150 {
lab=#net26}
N 7540 -4170 7560 -4170 {
lab=#net25}
N 7540 -4190 7560 -4190 {
lab=colon_n[12]}
N 7540 -4210 7560 -4210 {
lab=col_n[12]}
N 7360 -4070 7360 -4060 {
lab=VSS}
N 7360 -4300 7360 -4290 {
lab=VDD}
N 7700 -4070 7710 -4080 {
lab=row_n[25]}
N 7710 -4280 7710 -4080 {
lab=row_n[25]}
N 7700 -4290 7710 -4280 {
lab=row_n[25]}
N 7700 -4070 7700 -4050 {
lab=row_n[25]}
N 7700 -4310 7700 -4290 {
lab=row_n[25]}
N 7580 -4210 7590 -4220 {
lab=col_n[12]}
N 7590 -4220 7790 -4220 {
lab=col_n[12]}
N 7790 -4220 7800 -4210 {
lab=col_n[12]}
N 7580 -4190 7590 -4200 {
lab=colon_n[12]}
N 7590 -4200 7790 -4200 {
lab=colon_n[12]}
N 7790 -4200 7800 -4190 {
lab=colon_n[12]}
N 7580 -4170 7590 -4180 {
lab=#net25}
N 7590 -4180 7790 -4180 {
lab=#net25}
N 7790 -4180 7800 -4170 {
lab=#net25}
N 7580 -4150 7590 -4160 {
lab=#net26}
N 7590 -4160 7790 -4160 {
lab=#net26}
N 7790 -4160 7800 -4150 {
lab=#net26}
N 7640 -4310 7640 -4290 {
lab=vcom}
N 7680 -4310 7680 -4290 {
lab=ctop}
N 7560 -4210 7580 -4210 {
lab=col_n[12]}
N 7560 -4190 7580 -4190 {
lab=colon_n[12]}
N 7560 -4170 7580 -4170 {
lab=#net25}
N 7560 -4150 7580 -4150 {
lab=#net26}
N 7800 -4150 7820 -4150 {
lab=#net26}
N 7800 -4170 7820 -4170 {
lab=#net25}
N 7800 -4190 7820 -4190 {
lab=colon_n[12]}
N 7800 -4210 7820 -4210 {
lab=col_n[12]}
N 7620 -4070 7620 -4060 {
lab=VSS}
N 7620 -4300 7620 -4290 {
lab=VDD}
N 7960 -4070 7970 -4080 {
lab=row_n[26]}
N 7970 -4280 7970 -4080 {
lab=row_n[26]}
N 7960 -4290 7970 -4280 {
lab=row_n[26]}
N 7960 -4070 7960 -4050 {
lab=row_n[26]}
N 7960 -4310 7960 -4290 {
lab=row_n[26]}
N 7840 -4210 7850 -4220 {
lab=col_n[12]}
N 7850 -4220 8050 -4220 {
lab=col_n[12]}
N 8050 -4220 8060 -4210 {
lab=col_n[12]}
N 7840 -4190 7850 -4200 {
lab=colon_n[12]}
N 7850 -4200 8050 -4200 {
lab=colon_n[12]}
N 8050 -4200 8060 -4190 {
lab=colon_n[12]}
N 7840 -4170 7850 -4180 {
lab=#net25}
N 7850 -4180 8050 -4180 {
lab=#net25}
N 8050 -4180 8060 -4170 {
lab=#net25}
N 7840 -4150 7850 -4160 {
lab=#net26}
N 7850 -4160 8050 -4160 {
lab=#net26}
N 8050 -4160 8060 -4150 {
lab=#net26}
N 7900 -4310 7900 -4290 {
lab=vcom}
N 7940 -4310 7940 -4290 {
lab=ctop}
N 7820 -4210 7840 -4210 {
lab=col_n[12]}
N 7820 -4190 7840 -4190 {
lab=colon_n[12]}
N 7820 -4170 7840 -4170 {
lab=#net25}
N 7820 -4150 7840 -4150 {
lab=#net26}
N 8060 -4150 8080 -4150 {
lab=#net26}
N 8060 -4170 8080 -4170 {
lab=#net25}
N 8060 -4190 8080 -4190 {
lab=colon_n[12]}
N 8060 -4210 8080 -4210 {
lab=col_n[12]}
N 7880 -4070 7880 -4060 {
lab=VSS}
N 7880 -4300 7880 -4290 {
lab=VDD}
N 8220 -4070 8230 -4080 {
lab=row_n[27]}
N 8230 -4280 8230 -4080 {
lab=row_n[27]}
N 8220 -4290 8230 -4280 {
lab=row_n[27]}
N 8220 -4070 8220 -4050 {
lab=row_n[27]}
N 8220 -4310 8220 -4290 {
lab=row_n[27]}
N 8100 -4210 8110 -4220 {
lab=col_n[12]}
N 8110 -4220 8310 -4220 {
lab=col_n[12]}
N 8310 -4220 8320 -4210 {
lab=col_n[12]}
N 8100 -4190 8110 -4200 {
lab=colon_n[12]}
N 8110 -4200 8310 -4200 {
lab=colon_n[12]}
N 8310 -4200 8320 -4190 {
lab=colon_n[12]}
N 8100 -4170 8110 -4180 {
lab=#net25}
N 8110 -4180 8310 -4180 {
lab=#net25}
N 8310 -4180 8320 -4170 {
lab=#net25}
N 8100 -4150 8110 -4160 {
lab=#net26}
N 8110 -4160 8310 -4160 {
lab=#net26}
N 8310 -4160 8320 -4150 {
lab=#net26}
N 8160 -4310 8160 -4290 {
lab=vcom}
N 8200 -4310 8200 -4290 {
lab=ctop}
N 8080 -4210 8100 -4210 {
lab=col_n[12]}
N 8080 -4190 8100 -4190 {
lab=colon_n[12]}
N 8080 -4170 8100 -4170 {
lab=#net25}
N 8080 -4150 8100 -4150 {
lab=#net26}
N 8320 -4150 8340 -4150 {
lab=#net26}
N 8320 -4170 8340 -4170 {
lab=#net25}
N 8320 -4190 8340 -4190 {
lab=colon_n[12]}
N 8320 -4210 8340 -4210 {
lab=col_n[12]}
N 8140 -4070 8140 -4060 {
lab=VSS}
N 8140 -4300 8140 -4290 {
lab=VDD}
N 8480 -4070 8490 -4080 {
lab=row_n[28]}
N 8490 -4280 8490 -4080 {
lab=row_n[28]}
N 8480 -4290 8490 -4280 {
lab=row_n[28]}
N 8480 -4070 8480 -4050 {
lab=row_n[28]}
N 8480 -4310 8480 -4290 {
lab=row_n[28]}
N 8360 -4210 8370 -4220 {
lab=col_n[12]}
N 8370 -4220 8570 -4220 {
lab=col_n[12]}
N 8570 -4220 8580 -4210 {
lab=col_n[12]}
N 8360 -4190 8370 -4200 {
lab=colon_n[12]}
N 8370 -4200 8570 -4200 {
lab=colon_n[12]}
N 8570 -4200 8580 -4190 {
lab=colon_n[12]}
N 8360 -4170 8370 -4180 {
lab=#net25}
N 8370 -4180 8570 -4180 {
lab=#net25}
N 8570 -4180 8580 -4170 {
lab=#net25}
N 8360 -4150 8370 -4160 {
lab=#net26}
N 8370 -4160 8570 -4160 {
lab=#net26}
N 8570 -4160 8580 -4150 {
lab=#net26}
N 8420 -4310 8420 -4290 {
lab=vcom}
N 8460 -4310 8460 -4290 {
lab=ctop}
N 8340 -4210 8360 -4210 {
lab=col_n[12]}
N 8340 -4190 8360 -4190 {
lab=colon_n[12]}
N 8340 -4170 8360 -4170 {
lab=#net25}
N 8340 -4150 8360 -4150 {
lab=#net26}
N 8580 -4150 8600 -4150 {
lab=#net26}
N 8580 -4170 8600 -4170 {
lab=#net25}
N 8580 -4190 8600 -4190 {
lab=colon_n[12]}
N 8580 -4210 8600 -4210 {
lab=col_n[12]}
N 8400 -4070 8400 -4060 {
lab=VSS}
N 8400 -4300 8400 -4290 {
lab=VDD}
N 8740 -4070 8750 -4080 {
lab=row_n[29]}
N 8750 -4280 8750 -4080 {
lab=row_n[29]}
N 8740 -4290 8750 -4280 {
lab=row_n[29]}
N 8740 -4070 8740 -4050 {
lab=row_n[29]}
N 8740 -4310 8740 -4290 {
lab=row_n[29]}
N 8620 -4210 8630 -4220 {
lab=col_n[12]}
N 8630 -4220 8830 -4220 {
lab=col_n[12]}
N 8830 -4220 8840 -4210 {
lab=col_n[12]}
N 8620 -4190 8630 -4200 {
lab=colon_n[12]}
N 8630 -4200 8830 -4200 {
lab=colon_n[12]}
N 8830 -4200 8840 -4190 {
lab=colon_n[12]}
N 8620 -4170 8630 -4180 {
lab=#net25}
N 8630 -4180 8830 -4180 {
lab=#net25}
N 8830 -4180 8840 -4170 {
lab=#net25}
N 8620 -4150 8630 -4160 {
lab=#net26}
N 8630 -4160 8830 -4160 {
lab=#net26}
N 8830 -4160 8840 -4150 {
lab=#net26}
N 8680 -4310 8680 -4290 {
lab=vcom}
N 8720 -4310 8720 -4290 {
lab=ctop}
N 8600 -4210 8620 -4210 {
lab=col_n[12]}
N 8600 -4190 8620 -4190 {
lab=colon_n[12]}
N 8600 -4170 8620 -4170 {
lab=#net25}
N 8600 -4150 8620 -4150 {
lab=#net26}
N 8840 -4150 8860 -4150 {
lab=#net26}
N 8840 -4170 8860 -4170 {
lab=#net25}
N 8840 -4190 8860 -4190 {
lab=colon_n[12]}
N 8840 -4210 8860 -4210 {
lab=col_n[12]}
N 8660 -4070 8660 -4060 {
lab=VSS}
N 8660 -4300 8660 -4290 {
lab=VDD}
N 9000 -4070 9010 -4080 {
lab=row_n[30]}
N 9010 -4280 9010 -4080 {
lab=row_n[30]}
N 9000 -4290 9010 -4280 {
lab=row_n[30]}
N 9000 -4070 9000 -4050 {
lab=row_n[30]}
N 9000 -4310 9000 -4290 {
lab=row_n[30]}
N 8880 -4210 8890 -4220 {
lab=col_n[12]}
N 8890 -4220 9090 -4220 {
lab=col_n[12]}
N 9090 -4220 9100 -4210 {
lab=col_n[12]}
N 8880 -4190 8890 -4200 {
lab=colon_n[12]}
N 8890 -4200 9090 -4200 {
lab=colon_n[12]}
N 9090 -4200 9100 -4190 {
lab=colon_n[12]}
N 8880 -4170 8890 -4180 {
lab=#net25}
N 8890 -4180 9090 -4180 {
lab=#net25}
N 9090 -4180 9100 -4170 {
lab=#net25}
N 8880 -4150 8890 -4160 {
lab=#net26}
N 8890 -4160 9090 -4160 {
lab=#net26}
N 9090 -4160 9100 -4150 {
lab=#net26}
N 8940 -4310 8940 -4290 {
lab=vcom}
N 8980 -4310 8980 -4290 {
lab=ctop}
N 8860 -4210 8880 -4210 {
lab=col_n[12]}
N 8860 -4190 8880 -4190 {
lab=colon_n[12]}
N 8860 -4170 8880 -4170 {
lab=#net25}
N 8860 -4150 8880 -4150 {
lab=#net26}
N 9100 -4150 9120 -4150 {
lab=#net26}
N 9100 -4170 9120 -4170 {
lab=#net25}
N 9100 -4190 9120 -4190 {
lab=colon_n[12]}
N 9100 -4210 9120 -4210 {
lab=col_n[12]}
N 8920 -4070 8920 -4060 {
lab=VSS}
N 8920 -4300 8920 -4290 {
lab=VDD}
N 9260 -4070 9270 -4080 {
lab=row_n[31]}
N 9270 -4280 9270 -4080 {
lab=row_n[31]}
N 9260 -4290 9270 -4280 {
lab=row_n[31]}
N 9260 -4070 9260 -4050 {
lab=row_n[31]}
N 9260 -4310 9260 -4290 {
lab=row_n[31]}
N 9140 -4210 9150 -4220 {
lab=col_n[12]}
N 9150 -4220 9350 -4220 {
lab=col_n[12]}
N 9350 -4220 9360 -4210 {
lab=col_n[12]}
N 9140 -4190 9150 -4200 {
lab=colon_n[12]}
N 9150 -4200 9350 -4200 {
lab=colon_n[12]}
N 9350 -4200 9360 -4190 {
lab=colon_n[12]}
N 9140 -4170 9150 -4180 {
lab=#net25}
N 9150 -4180 9350 -4180 {
lab=#net25}
N 9350 -4180 9360 -4170 {
lab=#net25}
N 9140 -4150 9150 -4160 {
lab=#net26}
N 9150 -4160 9350 -4160 {
lab=#net26}
N 9350 -4160 9360 -4150 {
lab=#net26}
N 9200 -4310 9200 -4290 {
lab=vcom}
N 9240 -4310 9240 -4290 {
lab=ctop}
N 9120 -4210 9140 -4210 {
lab=col_n[12]}
N 9120 -4190 9140 -4190 {
lab=colon_n[12]}
N 9120 -4170 9140 -4170 {
lab=#net25}
N 9120 -4150 9140 -4150 {
lab=#net26}
N 9360 -4150 9380 -4150 {
lab=#net26}
N 9360 -4170 9380 -4170 {
lab=#net25}
N 9360 -4190 9380 -4190 {
lab=colon_n[12]}
N 9360 -4210 9380 -4210 {
lab=col_n[12]}
N 9180 -4070 9180 -4060 {
lab=VSS}
N 9180 -4300 9180 -4290 {
lab=VDD}
N 1200 -4330 1210 -4340 {
lab=row_n[0]}
N 1210 -4540 1210 -4340 {
lab=row_n[0]}
N 1200 -4550 1210 -4540 {
lab=row_n[0]}
N 1200 -4330 1200 -4310 {
lab=row_n[0]}
N 1200 -4570 1200 -4550 {
lab=row_n[0]}
N 1080 -4470 1090 -4480 {
lab=col_n[13]}
N 1090 -4480 1290 -4480 {
lab=col_n[13]}
N 1290 -4480 1300 -4470 {
lab=col_n[13]}
N 1080 -4450 1090 -4460 {
lab=colon_n[13]}
N 1090 -4460 1290 -4460 {
lab=colon_n[13]}
N 1290 -4460 1300 -4450 {
lab=colon_n[13]}
N 1080 -4430 1090 -4440 {
lab=#net27}
N 1090 -4440 1290 -4440 {
lab=#net27}
N 1290 -4440 1300 -4430 {
lab=#net27}
N 1080 -4410 1090 -4420 {
lab=#net28}
N 1090 -4420 1290 -4420 {
lab=#net28}
N 1290 -4420 1300 -4410 {
lab=#net28}
N 1140 -4570 1140 -4550 {
lab=vcom}
N 1180 -4570 1180 -4550 {
lab=ctop}
N 1060 -4470 1080 -4470 {
lab=col_n[13]}
N 1060 -4450 1080 -4450 {
lab=colon_n[13]}
N 1060 -4430 1080 -4430 {
lab=#net27}
N 1060 -4410 1080 -4410 {
lab=#net28}
N 1300 -4410 1320 -4410 {
lab=#net28}
N 1300 -4430 1320 -4430 {
lab=#net27}
N 1300 -4450 1320 -4450 {
lab=colon_n[13]}
N 1300 -4470 1320 -4470 {
lab=col_n[13]}
N 1120 -4330 1120 -4320 {
lab=VSS}
N 1120 -4560 1120 -4550 {
lab=VDD}
N 1460 -4330 1470 -4340 {
lab=row_n[1]}
N 1470 -4540 1470 -4340 {
lab=row_n[1]}
N 1460 -4550 1470 -4540 {
lab=row_n[1]}
N 1460 -4330 1460 -4310 {
lab=row_n[1]}
N 1460 -4570 1460 -4550 {
lab=row_n[1]}
N 1340 -4470 1350 -4480 {
lab=col_n[13]}
N 1350 -4480 1550 -4480 {
lab=col_n[13]}
N 1550 -4480 1560 -4470 {
lab=col_n[13]}
N 1340 -4450 1350 -4460 {
lab=colon_n[13]}
N 1350 -4460 1550 -4460 {
lab=colon_n[13]}
N 1550 -4460 1560 -4450 {
lab=colon_n[13]}
N 1340 -4430 1350 -4440 {
lab=#net27}
N 1350 -4440 1550 -4440 {
lab=#net27}
N 1550 -4440 1560 -4430 {
lab=#net27}
N 1340 -4410 1350 -4420 {
lab=#net28}
N 1350 -4420 1550 -4420 {
lab=#net28}
N 1550 -4420 1560 -4410 {
lab=#net28}
N 1400 -4570 1400 -4550 {
lab=vcom}
N 1440 -4570 1440 -4550 {
lab=ctop}
N 1320 -4470 1340 -4470 {
lab=col_n[13]}
N 1320 -4450 1340 -4450 {
lab=colon_n[13]}
N 1320 -4430 1340 -4430 {
lab=#net27}
N 1320 -4410 1340 -4410 {
lab=#net28}
N 1560 -4410 1580 -4410 {
lab=#net28}
N 1560 -4430 1580 -4430 {
lab=#net27}
N 1560 -4450 1580 -4450 {
lab=colon_n[13]}
N 1560 -4470 1580 -4470 {
lab=col_n[13]}
N 1380 -4330 1380 -4320 {
lab=VSS}
N 1380 -4560 1380 -4550 {
lab=VDD}
N 1720 -4330 1730 -4340 {
lab=row_n[2]}
N 1730 -4540 1730 -4340 {
lab=row_n[2]}
N 1720 -4550 1730 -4540 {
lab=row_n[2]}
N 1720 -4330 1720 -4310 {
lab=row_n[2]}
N 1720 -4570 1720 -4550 {
lab=row_n[2]}
N 1600 -4470 1610 -4480 {
lab=col_n[13]}
N 1610 -4480 1810 -4480 {
lab=col_n[13]}
N 1810 -4480 1820 -4470 {
lab=col_n[13]}
N 1600 -4450 1610 -4460 {
lab=colon_n[13]}
N 1610 -4460 1810 -4460 {
lab=colon_n[13]}
N 1810 -4460 1820 -4450 {
lab=colon_n[13]}
N 1600 -4430 1610 -4440 {
lab=#net27}
N 1610 -4440 1810 -4440 {
lab=#net27}
N 1810 -4440 1820 -4430 {
lab=#net27}
N 1600 -4410 1610 -4420 {
lab=#net28}
N 1610 -4420 1810 -4420 {
lab=#net28}
N 1810 -4420 1820 -4410 {
lab=#net28}
N 1660 -4570 1660 -4550 {
lab=vcom}
N 1700 -4570 1700 -4550 {
lab=ctop}
N 1580 -4470 1600 -4470 {
lab=col_n[13]}
N 1580 -4450 1600 -4450 {
lab=colon_n[13]}
N 1580 -4430 1600 -4430 {
lab=#net27}
N 1580 -4410 1600 -4410 {
lab=#net28}
N 1820 -4410 1840 -4410 {
lab=#net28}
N 1820 -4430 1840 -4430 {
lab=#net27}
N 1820 -4450 1840 -4450 {
lab=colon_n[13]}
N 1820 -4470 1840 -4470 {
lab=col_n[13]}
N 1640 -4330 1640 -4320 {
lab=VSS}
N 1640 -4560 1640 -4550 {
lab=VDD}
N 1980 -4330 1990 -4340 {
lab=row_n[3]}
N 1990 -4540 1990 -4340 {
lab=row_n[3]}
N 1980 -4550 1990 -4540 {
lab=row_n[3]}
N 1980 -4330 1980 -4310 {
lab=row_n[3]}
N 1980 -4570 1980 -4550 {
lab=row_n[3]}
N 1860 -4470 1870 -4480 {
lab=col_n[13]}
N 1870 -4480 2070 -4480 {
lab=col_n[13]}
N 2070 -4480 2080 -4470 {
lab=col_n[13]}
N 1860 -4450 1870 -4460 {
lab=colon_n[13]}
N 1870 -4460 2070 -4460 {
lab=colon_n[13]}
N 2070 -4460 2080 -4450 {
lab=colon_n[13]}
N 1860 -4430 1870 -4440 {
lab=#net27}
N 1870 -4440 2070 -4440 {
lab=#net27}
N 2070 -4440 2080 -4430 {
lab=#net27}
N 1860 -4410 1870 -4420 {
lab=#net28}
N 1870 -4420 2070 -4420 {
lab=#net28}
N 2070 -4420 2080 -4410 {
lab=#net28}
N 1920 -4570 1920 -4550 {
lab=vcom}
N 1960 -4570 1960 -4550 {
lab=ctop}
N 1840 -4470 1860 -4470 {
lab=col_n[13]}
N 1840 -4450 1860 -4450 {
lab=colon_n[13]}
N 1840 -4430 1860 -4430 {
lab=#net27}
N 1840 -4410 1860 -4410 {
lab=#net28}
N 2080 -4410 2100 -4410 {
lab=#net28}
N 2080 -4430 2100 -4430 {
lab=#net27}
N 2080 -4450 2100 -4450 {
lab=colon_n[13]}
N 2080 -4470 2100 -4470 {
lab=col_n[13]}
N 1900 -4330 1900 -4320 {
lab=VSS}
N 1900 -4560 1900 -4550 {
lab=VDD}
N 2240 -4330 2250 -4340 {
lab=row_n[4]}
N 2250 -4540 2250 -4340 {
lab=row_n[4]}
N 2240 -4550 2250 -4540 {
lab=row_n[4]}
N 2240 -4330 2240 -4310 {
lab=row_n[4]}
N 2240 -4570 2240 -4550 {
lab=row_n[4]}
N 2120 -4470 2130 -4480 {
lab=col_n[13]}
N 2130 -4480 2330 -4480 {
lab=col_n[13]}
N 2330 -4480 2340 -4470 {
lab=col_n[13]}
N 2120 -4450 2130 -4460 {
lab=colon_n[13]}
N 2130 -4460 2330 -4460 {
lab=colon_n[13]}
N 2330 -4460 2340 -4450 {
lab=colon_n[13]}
N 2120 -4430 2130 -4440 {
lab=#net27}
N 2130 -4440 2330 -4440 {
lab=#net27}
N 2330 -4440 2340 -4430 {
lab=#net27}
N 2120 -4410 2130 -4420 {
lab=#net28}
N 2130 -4420 2330 -4420 {
lab=#net28}
N 2330 -4420 2340 -4410 {
lab=#net28}
N 2180 -4570 2180 -4550 {
lab=vcom}
N 2220 -4570 2220 -4550 {
lab=ctop}
N 2100 -4470 2120 -4470 {
lab=col_n[13]}
N 2100 -4450 2120 -4450 {
lab=colon_n[13]}
N 2100 -4430 2120 -4430 {
lab=#net27}
N 2100 -4410 2120 -4410 {
lab=#net28}
N 2340 -4410 2360 -4410 {
lab=#net28}
N 2340 -4430 2360 -4430 {
lab=#net27}
N 2340 -4450 2360 -4450 {
lab=colon_n[13]}
N 2340 -4470 2360 -4470 {
lab=col_n[13]}
N 2160 -4330 2160 -4320 {
lab=VSS}
N 2160 -4560 2160 -4550 {
lab=VDD}
N 2500 -4330 2510 -4340 {
lab=row_n[5]}
N 2510 -4540 2510 -4340 {
lab=row_n[5]}
N 2500 -4550 2510 -4540 {
lab=row_n[5]}
N 2500 -4330 2500 -4310 {
lab=row_n[5]}
N 2500 -4570 2500 -4550 {
lab=row_n[5]}
N 2380 -4470 2390 -4480 {
lab=col_n[13]}
N 2390 -4480 2590 -4480 {
lab=col_n[13]}
N 2590 -4480 2600 -4470 {
lab=col_n[13]}
N 2380 -4450 2390 -4460 {
lab=colon_n[13]}
N 2390 -4460 2590 -4460 {
lab=colon_n[13]}
N 2590 -4460 2600 -4450 {
lab=colon_n[13]}
N 2380 -4430 2390 -4440 {
lab=#net27}
N 2390 -4440 2590 -4440 {
lab=#net27}
N 2590 -4440 2600 -4430 {
lab=#net27}
N 2380 -4410 2390 -4420 {
lab=#net28}
N 2390 -4420 2590 -4420 {
lab=#net28}
N 2590 -4420 2600 -4410 {
lab=#net28}
N 2440 -4570 2440 -4550 {
lab=vcom}
N 2480 -4570 2480 -4550 {
lab=ctop}
N 2360 -4470 2380 -4470 {
lab=col_n[13]}
N 2360 -4450 2380 -4450 {
lab=colon_n[13]}
N 2360 -4430 2380 -4430 {
lab=#net27}
N 2360 -4410 2380 -4410 {
lab=#net28}
N 2600 -4410 2620 -4410 {
lab=#net28}
N 2600 -4430 2620 -4430 {
lab=#net27}
N 2600 -4450 2620 -4450 {
lab=colon_n[13]}
N 2600 -4470 2620 -4470 {
lab=col_n[13]}
N 2420 -4330 2420 -4320 {
lab=VSS}
N 2420 -4560 2420 -4550 {
lab=VDD}
N 2760 -4330 2770 -4340 {
lab=row_n[6]}
N 2770 -4540 2770 -4340 {
lab=row_n[6]}
N 2760 -4550 2770 -4540 {
lab=row_n[6]}
N 2760 -4330 2760 -4310 {
lab=row_n[6]}
N 2760 -4570 2760 -4550 {
lab=row_n[6]}
N 2640 -4470 2650 -4480 {
lab=col_n[13]}
N 2650 -4480 2850 -4480 {
lab=col_n[13]}
N 2850 -4480 2860 -4470 {
lab=col_n[13]}
N 2640 -4450 2650 -4460 {
lab=colon_n[13]}
N 2650 -4460 2850 -4460 {
lab=colon_n[13]}
N 2850 -4460 2860 -4450 {
lab=colon_n[13]}
N 2640 -4430 2650 -4440 {
lab=#net27}
N 2650 -4440 2850 -4440 {
lab=#net27}
N 2850 -4440 2860 -4430 {
lab=#net27}
N 2640 -4410 2650 -4420 {
lab=#net28}
N 2650 -4420 2850 -4420 {
lab=#net28}
N 2850 -4420 2860 -4410 {
lab=#net28}
N 2700 -4570 2700 -4550 {
lab=vcom}
N 2740 -4570 2740 -4550 {
lab=ctop}
N 2620 -4470 2640 -4470 {
lab=col_n[13]}
N 2620 -4450 2640 -4450 {
lab=colon_n[13]}
N 2620 -4430 2640 -4430 {
lab=#net27}
N 2620 -4410 2640 -4410 {
lab=#net28}
N 2860 -4410 2880 -4410 {
lab=#net28}
N 2860 -4430 2880 -4430 {
lab=#net27}
N 2860 -4450 2880 -4450 {
lab=colon_n[13]}
N 2860 -4470 2880 -4470 {
lab=col_n[13]}
N 2680 -4330 2680 -4320 {
lab=VSS}
N 2680 -4560 2680 -4550 {
lab=VDD}
N 3020 -4330 3030 -4340 {
lab=row_n[7]}
N 3030 -4540 3030 -4340 {
lab=row_n[7]}
N 3020 -4550 3030 -4540 {
lab=row_n[7]}
N 3020 -4330 3020 -4310 {
lab=row_n[7]}
N 3020 -4570 3020 -4550 {
lab=row_n[7]}
N 2900 -4470 2910 -4480 {
lab=col_n[13]}
N 2910 -4480 3110 -4480 {
lab=col_n[13]}
N 3110 -4480 3120 -4470 {
lab=col_n[13]}
N 2900 -4450 2910 -4460 {
lab=colon_n[13]}
N 2910 -4460 3110 -4460 {
lab=colon_n[13]}
N 3110 -4460 3120 -4450 {
lab=colon_n[13]}
N 2900 -4430 2910 -4440 {
lab=#net27}
N 2910 -4440 3110 -4440 {
lab=#net27}
N 3110 -4440 3120 -4430 {
lab=#net27}
N 2900 -4410 2910 -4420 {
lab=#net28}
N 2910 -4420 3110 -4420 {
lab=#net28}
N 3110 -4420 3120 -4410 {
lab=#net28}
N 2960 -4570 2960 -4550 {
lab=vcom}
N 3000 -4570 3000 -4550 {
lab=ctop}
N 2880 -4470 2900 -4470 {
lab=col_n[13]}
N 2880 -4450 2900 -4450 {
lab=colon_n[13]}
N 2880 -4430 2900 -4430 {
lab=#net27}
N 2880 -4410 2900 -4410 {
lab=#net28}
N 3120 -4410 3140 -4410 {
lab=#net28}
N 3120 -4430 3140 -4430 {
lab=#net27}
N 3120 -4450 3140 -4450 {
lab=colon_n[13]}
N 3120 -4470 3140 -4470 {
lab=col_n[13]}
N 2940 -4330 2940 -4320 {
lab=VSS}
N 2940 -4560 2940 -4550 {
lab=VDD}
N 3280 -4330 3290 -4340 {
lab=row_n[8]}
N 3290 -4540 3290 -4340 {
lab=row_n[8]}
N 3280 -4550 3290 -4540 {
lab=row_n[8]}
N 3280 -4330 3280 -4310 {
lab=row_n[8]}
N 3280 -4570 3280 -4550 {
lab=row_n[8]}
N 3160 -4470 3170 -4480 {
lab=col_n[13]}
N 3170 -4480 3370 -4480 {
lab=col_n[13]}
N 3370 -4480 3380 -4470 {
lab=col_n[13]}
N 3160 -4450 3170 -4460 {
lab=colon_n[13]}
N 3170 -4460 3370 -4460 {
lab=colon_n[13]}
N 3370 -4460 3380 -4450 {
lab=colon_n[13]}
N 3160 -4430 3170 -4440 {
lab=#net27}
N 3170 -4440 3370 -4440 {
lab=#net27}
N 3370 -4440 3380 -4430 {
lab=#net27}
N 3160 -4410 3170 -4420 {
lab=#net28}
N 3170 -4420 3370 -4420 {
lab=#net28}
N 3370 -4420 3380 -4410 {
lab=#net28}
N 3220 -4570 3220 -4550 {
lab=vcom}
N 3260 -4570 3260 -4550 {
lab=ctop}
N 3140 -4470 3160 -4470 {
lab=col_n[13]}
N 3140 -4450 3160 -4450 {
lab=colon_n[13]}
N 3140 -4430 3160 -4430 {
lab=#net27}
N 3140 -4410 3160 -4410 {
lab=#net28}
N 3380 -4410 3400 -4410 {
lab=#net28}
N 3380 -4430 3400 -4430 {
lab=#net27}
N 3380 -4450 3400 -4450 {
lab=colon_n[13]}
N 3380 -4470 3400 -4470 {
lab=col_n[13]}
N 3200 -4330 3200 -4320 {
lab=VSS}
N 3200 -4560 3200 -4550 {
lab=VDD}
N 3540 -4330 3550 -4340 {
lab=row_n[9]}
N 3550 -4540 3550 -4340 {
lab=row_n[9]}
N 3540 -4550 3550 -4540 {
lab=row_n[9]}
N 3540 -4330 3540 -4310 {
lab=row_n[9]}
N 3540 -4570 3540 -4550 {
lab=row_n[9]}
N 3420 -4470 3430 -4480 {
lab=col_n[13]}
N 3430 -4480 3630 -4480 {
lab=col_n[13]}
N 3630 -4480 3640 -4470 {
lab=col_n[13]}
N 3420 -4450 3430 -4460 {
lab=colon_n[13]}
N 3430 -4460 3630 -4460 {
lab=colon_n[13]}
N 3630 -4460 3640 -4450 {
lab=colon_n[13]}
N 3420 -4430 3430 -4440 {
lab=#net27}
N 3430 -4440 3630 -4440 {
lab=#net27}
N 3630 -4440 3640 -4430 {
lab=#net27}
N 3420 -4410 3430 -4420 {
lab=#net28}
N 3430 -4420 3630 -4420 {
lab=#net28}
N 3630 -4420 3640 -4410 {
lab=#net28}
N 3480 -4570 3480 -4550 {
lab=vcom}
N 3520 -4570 3520 -4550 {
lab=ctop}
N 3400 -4470 3420 -4470 {
lab=col_n[13]}
N 3400 -4450 3420 -4450 {
lab=colon_n[13]}
N 3400 -4430 3420 -4430 {
lab=#net27}
N 3400 -4410 3420 -4410 {
lab=#net28}
N 3640 -4410 3660 -4410 {
lab=#net28}
N 3640 -4430 3660 -4430 {
lab=#net27}
N 3640 -4450 3660 -4450 {
lab=colon_n[13]}
N 3640 -4470 3660 -4470 {
lab=col_n[13]}
N 3460 -4330 3460 -4320 {
lab=VSS}
N 3460 -4560 3460 -4550 {
lab=VDD}
N 3800 -4330 3810 -4340 {
lab=row_n[10]}
N 3810 -4540 3810 -4340 {
lab=row_n[10]}
N 3800 -4550 3810 -4540 {
lab=row_n[10]}
N 3800 -4330 3800 -4310 {
lab=row_n[10]}
N 3800 -4570 3800 -4550 {
lab=row_n[10]}
N 3680 -4470 3690 -4480 {
lab=col_n[13]}
N 3690 -4480 3890 -4480 {
lab=col_n[13]}
N 3890 -4480 3900 -4470 {
lab=col_n[13]}
N 3680 -4450 3690 -4460 {
lab=colon_n[13]}
N 3690 -4460 3890 -4460 {
lab=colon_n[13]}
N 3890 -4460 3900 -4450 {
lab=colon_n[13]}
N 3680 -4430 3690 -4440 {
lab=#net27}
N 3690 -4440 3890 -4440 {
lab=#net27}
N 3890 -4440 3900 -4430 {
lab=#net27}
N 3680 -4410 3690 -4420 {
lab=#net28}
N 3690 -4420 3890 -4420 {
lab=#net28}
N 3890 -4420 3900 -4410 {
lab=#net28}
N 3740 -4570 3740 -4550 {
lab=vcom}
N 3780 -4570 3780 -4550 {
lab=ctop}
N 3660 -4470 3680 -4470 {
lab=col_n[13]}
N 3660 -4450 3680 -4450 {
lab=colon_n[13]}
N 3660 -4430 3680 -4430 {
lab=#net27}
N 3660 -4410 3680 -4410 {
lab=#net28}
N 3900 -4410 3920 -4410 {
lab=#net28}
N 3900 -4430 3920 -4430 {
lab=#net27}
N 3900 -4450 3920 -4450 {
lab=colon_n[13]}
N 3900 -4470 3920 -4470 {
lab=col_n[13]}
N 3720 -4330 3720 -4320 {
lab=VSS}
N 3720 -4560 3720 -4550 {
lab=VDD}
N 4060 -4330 4070 -4340 {
lab=row_n[11]}
N 4070 -4540 4070 -4340 {
lab=row_n[11]}
N 4060 -4550 4070 -4540 {
lab=row_n[11]}
N 4060 -4330 4060 -4310 {
lab=row_n[11]}
N 4060 -4570 4060 -4550 {
lab=row_n[11]}
N 3940 -4470 3950 -4480 {
lab=col_n[13]}
N 3950 -4480 4150 -4480 {
lab=col_n[13]}
N 4150 -4480 4160 -4470 {
lab=col_n[13]}
N 3940 -4450 3950 -4460 {
lab=colon_n[13]}
N 3950 -4460 4150 -4460 {
lab=colon_n[13]}
N 4150 -4460 4160 -4450 {
lab=colon_n[13]}
N 3940 -4430 3950 -4440 {
lab=#net27}
N 3950 -4440 4150 -4440 {
lab=#net27}
N 4150 -4440 4160 -4430 {
lab=#net27}
N 3940 -4410 3950 -4420 {
lab=#net28}
N 3950 -4420 4150 -4420 {
lab=#net28}
N 4150 -4420 4160 -4410 {
lab=#net28}
N 4000 -4570 4000 -4550 {
lab=vcom}
N 4040 -4570 4040 -4550 {
lab=ctop}
N 3920 -4470 3940 -4470 {
lab=col_n[13]}
N 3920 -4450 3940 -4450 {
lab=colon_n[13]}
N 3920 -4430 3940 -4430 {
lab=#net27}
N 3920 -4410 3940 -4410 {
lab=#net28}
N 4160 -4410 4180 -4410 {
lab=#net28}
N 4160 -4430 4180 -4430 {
lab=#net27}
N 4160 -4450 4180 -4450 {
lab=colon_n[13]}
N 4160 -4470 4180 -4470 {
lab=col_n[13]}
N 3980 -4330 3980 -4320 {
lab=VSS}
N 3980 -4560 3980 -4550 {
lab=VDD}
N 4320 -4330 4330 -4340 {
lab=row_n[12]}
N 4330 -4540 4330 -4340 {
lab=row_n[12]}
N 4320 -4550 4330 -4540 {
lab=row_n[12]}
N 4320 -4330 4320 -4310 {
lab=row_n[12]}
N 4320 -4570 4320 -4550 {
lab=row_n[12]}
N 4200 -4470 4210 -4480 {
lab=col_n[13]}
N 4210 -4480 4410 -4480 {
lab=col_n[13]}
N 4410 -4480 4420 -4470 {
lab=col_n[13]}
N 4200 -4450 4210 -4460 {
lab=colon_n[13]}
N 4210 -4460 4410 -4460 {
lab=colon_n[13]}
N 4410 -4460 4420 -4450 {
lab=colon_n[13]}
N 4200 -4430 4210 -4440 {
lab=#net27}
N 4210 -4440 4410 -4440 {
lab=#net27}
N 4410 -4440 4420 -4430 {
lab=#net27}
N 4200 -4410 4210 -4420 {
lab=#net28}
N 4210 -4420 4410 -4420 {
lab=#net28}
N 4410 -4420 4420 -4410 {
lab=#net28}
N 4260 -4570 4260 -4550 {
lab=vcom}
N 4300 -4570 4300 -4550 {
lab=ctop}
N 4180 -4470 4200 -4470 {
lab=col_n[13]}
N 4180 -4450 4200 -4450 {
lab=colon_n[13]}
N 4180 -4430 4200 -4430 {
lab=#net27}
N 4180 -4410 4200 -4410 {
lab=#net28}
N 4420 -4410 4440 -4410 {
lab=#net28}
N 4420 -4430 4440 -4430 {
lab=#net27}
N 4420 -4450 4440 -4450 {
lab=colon_n[13]}
N 4420 -4470 4440 -4470 {
lab=col_n[13]}
N 4240 -4330 4240 -4320 {
lab=VSS}
N 4240 -4560 4240 -4550 {
lab=VDD}
N 4580 -4330 4590 -4340 {
lab=row_n[13]}
N 4590 -4540 4590 -4340 {
lab=row_n[13]}
N 4580 -4550 4590 -4540 {
lab=row_n[13]}
N 4580 -4330 4580 -4310 {
lab=row_n[13]}
N 4580 -4570 4580 -4550 {
lab=row_n[13]}
N 4460 -4470 4470 -4480 {
lab=col_n[13]}
N 4470 -4480 4670 -4480 {
lab=col_n[13]}
N 4670 -4480 4680 -4470 {
lab=col_n[13]}
N 4460 -4450 4470 -4460 {
lab=colon_n[13]}
N 4470 -4460 4670 -4460 {
lab=colon_n[13]}
N 4670 -4460 4680 -4450 {
lab=colon_n[13]}
N 4460 -4430 4470 -4440 {
lab=#net27}
N 4470 -4440 4670 -4440 {
lab=#net27}
N 4670 -4440 4680 -4430 {
lab=#net27}
N 4460 -4410 4470 -4420 {
lab=#net28}
N 4470 -4420 4670 -4420 {
lab=#net28}
N 4670 -4420 4680 -4410 {
lab=#net28}
N 4520 -4570 4520 -4550 {
lab=vcom}
N 4560 -4570 4560 -4550 {
lab=ctop}
N 4440 -4470 4460 -4470 {
lab=col_n[13]}
N 4440 -4450 4460 -4450 {
lab=colon_n[13]}
N 4440 -4430 4460 -4430 {
lab=#net27}
N 4440 -4410 4460 -4410 {
lab=#net28}
N 4680 -4410 4700 -4410 {
lab=#net28}
N 4680 -4430 4700 -4430 {
lab=#net27}
N 4680 -4450 4700 -4450 {
lab=colon_n[13]}
N 4680 -4470 4700 -4470 {
lab=col_n[13]}
N 4500 -4330 4500 -4320 {
lab=VSS}
N 4500 -4560 4500 -4550 {
lab=VDD}
N 4840 -4330 4850 -4340 {
lab=row_n[14]}
N 4850 -4540 4850 -4340 {
lab=row_n[14]}
N 4840 -4550 4850 -4540 {
lab=row_n[14]}
N 4840 -4330 4840 -4310 {
lab=row_n[14]}
N 4840 -4570 4840 -4550 {
lab=row_n[14]}
N 4720 -4470 4730 -4480 {
lab=col_n[13]}
N 4730 -4480 4930 -4480 {
lab=col_n[13]}
N 4930 -4480 4940 -4470 {
lab=col_n[13]}
N 4720 -4450 4730 -4460 {
lab=colon_n[13]}
N 4730 -4460 4930 -4460 {
lab=colon_n[13]}
N 4930 -4460 4940 -4450 {
lab=colon_n[13]}
N 4720 -4430 4730 -4440 {
lab=#net27}
N 4730 -4440 4930 -4440 {
lab=#net27}
N 4930 -4440 4940 -4430 {
lab=#net27}
N 4720 -4410 4730 -4420 {
lab=#net28}
N 4730 -4420 4930 -4420 {
lab=#net28}
N 4930 -4420 4940 -4410 {
lab=#net28}
N 4780 -4570 4780 -4550 {
lab=vcom}
N 4820 -4570 4820 -4550 {
lab=ctop}
N 4700 -4470 4720 -4470 {
lab=col_n[13]}
N 4700 -4450 4720 -4450 {
lab=colon_n[13]}
N 4700 -4430 4720 -4430 {
lab=#net27}
N 4700 -4410 4720 -4410 {
lab=#net28}
N 4940 -4410 4960 -4410 {
lab=#net28}
N 4940 -4430 4960 -4430 {
lab=#net27}
N 4940 -4450 4960 -4450 {
lab=colon_n[13]}
N 4940 -4470 4960 -4470 {
lab=col_n[13]}
N 4760 -4330 4760 -4320 {
lab=VSS}
N 4760 -4560 4760 -4550 {
lab=VDD}
N 5100 -4330 5110 -4340 {
lab=row_n[15]}
N 5110 -4540 5110 -4340 {
lab=row_n[15]}
N 5100 -4550 5110 -4540 {
lab=row_n[15]}
N 5100 -4330 5100 -4310 {
lab=row_n[15]}
N 5100 -4570 5100 -4550 {
lab=row_n[15]}
N 4980 -4470 4990 -4480 {
lab=col_n[13]}
N 4990 -4480 5190 -4480 {
lab=col_n[13]}
N 5190 -4480 5200 -4470 {
lab=col_n[13]}
N 4980 -4450 4990 -4460 {
lab=colon_n[13]}
N 4990 -4460 5190 -4460 {
lab=colon_n[13]}
N 5190 -4460 5200 -4450 {
lab=colon_n[13]}
N 4980 -4430 4990 -4440 {
lab=#net27}
N 4990 -4440 5190 -4440 {
lab=#net27}
N 5190 -4440 5200 -4430 {
lab=#net27}
N 4980 -4410 4990 -4420 {
lab=#net28}
N 4990 -4420 5190 -4420 {
lab=#net28}
N 5190 -4420 5200 -4410 {
lab=#net28}
N 5040 -4570 5040 -4550 {
lab=vcom}
N 5080 -4570 5080 -4550 {
lab=ctop}
N 4960 -4470 4980 -4470 {
lab=col_n[13]}
N 4960 -4450 4980 -4450 {
lab=colon_n[13]}
N 4960 -4430 4980 -4430 {
lab=#net27}
N 4960 -4410 4980 -4410 {
lab=#net28}
N 5200 -4410 5220 -4410 {
lab=#net28}
N 5200 -4430 5220 -4430 {
lab=#net27}
N 5200 -4450 5220 -4450 {
lab=colon_n[13]}
N 5200 -4470 5220 -4470 {
lab=col_n[13]}
N 5020 -4330 5020 -4320 {
lab=VSS}
N 5020 -4560 5020 -4550 {
lab=VDD}
N 5360 -4330 5370 -4340 {
lab=row_n[16]}
N 5370 -4540 5370 -4340 {
lab=row_n[16]}
N 5360 -4550 5370 -4540 {
lab=row_n[16]}
N 5360 -4330 5360 -4310 {
lab=row_n[16]}
N 5360 -4570 5360 -4550 {
lab=row_n[16]}
N 5240 -4470 5250 -4480 {
lab=col_n[13]}
N 5250 -4480 5450 -4480 {
lab=col_n[13]}
N 5450 -4480 5460 -4470 {
lab=col_n[13]}
N 5240 -4450 5250 -4460 {
lab=colon_n[13]}
N 5250 -4460 5450 -4460 {
lab=colon_n[13]}
N 5450 -4460 5460 -4450 {
lab=colon_n[13]}
N 5240 -4430 5250 -4440 {
lab=#net27}
N 5250 -4440 5450 -4440 {
lab=#net27}
N 5450 -4440 5460 -4430 {
lab=#net27}
N 5240 -4410 5250 -4420 {
lab=#net28}
N 5250 -4420 5450 -4420 {
lab=#net28}
N 5450 -4420 5460 -4410 {
lab=#net28}
N 5300 -4570 5300 -4550 {
lab=vcom}
N 5340 -4570 5340 -4550 {
lab=ctop}
N 5220 -4470 5240 -4470 {
lab=col_n[13]}
N 5220 -4450 5240 -4450 {
lab=colon_n[13]}
N 5220 -4430 5240 -4430 {
lab=#net27}
N 5220 -4410 5240 -4410 {
lab=#net28}
N 5460 -4410 5480 -4410 {
lab=#net28}
N 5460 -4430 5480 -4430 {
lab=#net27}
N 5460 -4450 5480 -4450 {
lab=colon_n[13]}
N 5460 -4470 5480 -4470 {
lab=col_n[13]}
N 5280 -4330 5280 -4320 {
lab=VSS}
N 5280 -4560 5280 -4550 {
lab=VDD}
N 5620 -4330 5630 -4340 {
lab=row_n[17]}
N 5630 -4540 5630 -4340 {
lab=row_n[17]}
N 5620 -4550 5630 -4540 {
lab=row_n[17]}
N 5620 -4330 5620 -4310 {
lab=row_n[17]}
N 5620 -4570 5620 -4550 {
lab=row_n[17]}
N 5500 -4470 5510 -4480 {
lab=col_n[13]}
N 5510 -4480 5710 -4480 {
lab=col_n[13]}
N 5710 -4480 5720 -4470 {
lab=col_n[13]}
N 5500 -4450 5510 -4460 {
lab=colon_n[13]}
N 5510 -4460 5710 -4460 {
lab=colon_n[13]}
N 5710 -4460 5720 -4450 {
lab=colon_n[13]}
N 5500 -4430 5510 -4440 {
lab=#net27}
N 5510 -4440 5710 -4440 {
lab=#net27}
N 5710 -4440 5720 -4430 {
lab=#net27}
N 5500 -4410 5510 -4420 {
lab=#net28}
N 5510 -4420 5710 -4420 {
lab=#net28}
N 5710 -4420 5720 -4410 {
lab=#net28}
N 5560 -4570 5560 -4550 {
lab=vcom}
N 5600 -4570 5600 -4550 {
lab=ctop}
N 5480 -4470 5500 -4470 {
lab=col_n[13]}
N 5480 -4450 5500 -4450 {
lab=colon_n[13]}
N 5480 -4430 5500 -4430 {
lab=#net27}
N 5480 -4410 5500 -4410 {
lab=#net28}
N 5720 -4410 5740 -4410 {
lab=#net28}
N 5720 -4430 5740 -4430 {
lab=#net27}
N 5720 -4450 5740 -4450 {
lab=colon_n[13]}
N 5720 -4470 5740 -4470 {
lab=col_n[13]}
N 5540 -4330 5540 -4320 {
lab=VSS}
N 5540 -4560 5540 -4550 {
lab=VDD}
N 5880 -4330 5890 -4340 {
lab=row_n[18]}
N 5890 -4540 5890 -4340 {
lab=row_n[18]}
N 5880 -4550 5890 -4540 {
lab=row_n[18]}
N 5880 -4330 5880 -4310 {
lab=row_n[18]}
N 5880 -4570 5880 -4550 {
lab=row_n[18]}
N 5760 -4470 5770 -4480 {
lab=col_n[13]}
N 5770 -4480 5970 -4480 {
lab=col_n[13]}
N 5970 -4480 5980 -4470 {
lab=col_n[13]}
N 5760 -4450 5770 -4460 {
lab=colon_n[13]}
N 5770 -4460 5970 -4460 {
lab=colon_n[13]}
N 5970 -4460 5980 -4450 {
lab=colon_n[13]}
N 5760 -4430 5770 -4440 {
lab=#net27}
N 5770 -4440 5970 -4440 {
lab=#net27}
N 5970 -4440 5980 -4430 {
lab=#net27}
N 5760 -4410 5770 -4420 {
lab=#net28}
N 5770 -4420 5970 -4420 {
lab=#net28}
N 5970 -4420 5980 -4410 {
lab=#net28}
N 5820 -4570 5820 -4550 {
lab=vcom}
N 5860 -4570 5860 -4550 {
lab=ctop}
N 5740 -4470 5760 -4470 {
lab=col_n[13]}
N 5740 -4450 5760 -4450 {
lab=colon_n[13]}
N 5740 -4430 5760 -4430 {
lab=#net27}
N 5740 -4410 5760 -4410 {
lab=#net28}
N 5980 -4410 6000 -4410 {
lab=#net28}
N 5980 -4430 6000 -4430 {
lab=#net27}
N 5980 -4450 6000 -4450 {
lab=colon_n[13]}
N 5980 -4470 6000 -4470 {
lab=col_n[13]}
N 5800 -4330 5800 -4320 {
lab=VSS}
N 5800 -4560 5800 -4550 {
lab=VDD}
N 6140 -4330 6150 -4340 {
lab=row_n[19]}
N 6150 -4540 6150 -4340 {
lab=row_n[19]}
N 6140 -4550 6150 -4540 {
lab=row_n[19]}
N 6140 -4330 6140 -4310 {
lab=row_n[19]}
N 6140 -4570 6140 -4550 {
lab=row_n[19]}
N 6020 -4470 6030 -4480 {
lab=col_n[13]}
N 6030 -4480 6230 -4480 {
lab=col_n[13]}
N 6230 -4480 6240 -4470 {
lab=col_n[13]}
N 6020 -4450 6030 -4460 {
lab=colon_n[13]}
N 6030 -4460 6230 -4460 {
lab=colon_n[13]}
N 6230 -4460 6240 -4450 {
lab=colon_n[13]}
N 6020 -4430 6030 -4440 {
lab=#net27}
N 6030 -4440 6230 -4440 {
lab=#net27}
N 6230 -4440 6240 -4430 {
lab=#net27}
N 6020 -4410 6030 -4420 {
lab=#net28}
N 6030 -4420 6230 -4420 {
lab=#net28}
N 6230 -4420 6240 -4410 {
lab=#net28}
N 6080 -4570 6080 -4550 {
lab=vcom}
N 6120 -4570 6120 -4550 {
lab=ctop}
N 6000 -4470 6020 -4470 {
lab=col_n[13]}
N 6000 -4450 6020 -4450 {
lab=colon_n[13]}
N 6000 -4430 6020 -4430 {
lab=#net27}
N 6000 -4410 6020 -4410 {
lab=#net28}
N 6240 -4410 6260 -4410 {
lab=#net28}
N 6240 -4430 6260 -4430 {
lab=#net27}
N 6240 -4450 6260 -4450 {
lab=colon_n[13]}
N 6240 -4470 6260 -4470 {
lab=col_n[13]}
N 6060 -4330 6060 -4320 {
lab=VSS}
N 6060 -4560 6060 -4550 {
lab=VDD}
N 6400 -4330 6410 -4340 {
lab=row_n[20]}
N 6410 -4540 6410 -4340 {
lab=row_n[20]}
N 6400 -4550 6410 -4540 {
lab=row_n[20]}
N 6400 -4330 6400 -4310 {
lab=row_n[20]}
N 6400 -4570 6400 -4550 {
lab=row_n[20]}
N 6280 -4470 6290 -4480 {
lab=col_n[13]}
N 6290 -4480 6490 -4480 {
lab=col_n[13]}
N 6490 -4480 6500 -4470 {
lab=col_n[13]}
N 6280 -4450 6290 -4460 {
lab=colon_n[13]}
N 6290 -4460 6490 -4460 {
lab=colon_n[13]}
N 6490 -4460 6500 -4450 {
lab=colon_n[13]}
N 6280 -4430 6290 -4440 {
lab=#net27}
N 6290 -4440 6490 -4440 {
lab=#net27}
N 6490 -4440 6500 -4430 {
lab=#net27}
N 6280 -4410 6290 -4420 {
lab=#net28}
N 6290 -4420 6490 -4420 {
lab=#net28}
N 6490 -4420 6500 -4410 {
lab=#net28}
N 6340 -4570 6340 -4550 {
lab=vcom}
N 6380 -4570 6380 -4550 {
lab=ctop}
N 6260 -4470 6280 -4470 {
lab=col_n[13]}
N 6260 -4450 6280 -4450 {
lab=colon_n[13]}
N 6260 -4430 6280 -4430 {
lab=#net27}
N 6260 -4410 6280 -4410 {
lab=#net28}
N 6500 -4410 6520 -4410 {
lab=#net28}
N 6500 -4430 6520 -4430 {
lab=#net27}
N 6500 -4450 6520 -4450 {
lab=colon_n[13]}
N 6500 -4470 6520 -4470 {
lab=col_n[13]}
N 6320 -4330 6320 -4320 {
lab=VSS}
N 6320 -4560 6320 -4550 {
lab=VDD}
N 6660 -4330 6670 -4340 {
lab=row_n[21]}
N 6670 -4540 6670 -4340 {
lab=row_n[21]}
N 6660 -4550 6670 -4540 {
lab=row_n[21]}
N 6660 -4330 6660 -4310 {
lab=row_n[21]}
N 6660 -4570 6660 -4550 {
lab=row_n[21]}
N 6540 -4470 6550 -4480 {
lab=col_n[13]}
N 6550 -4480 6750 -4480 {
lab=col_n[13]}
N 6750 -4480 6760 -4470 {
lab=col_n[13]}
N 6540 -4450 6550 -4460 {
lab=colon_n[13]}
N 6550 -4460 6750 -4460 {
lab=colon_n[13]}
N 6750 -4460 6760 -4450 {
lab=colon_n[13]}
N 6540 -4430 6550 -4440 {
lab=#net27}
N 6550 -4440 6750 -4440 {
lab=#net27}
N 6750 -4440 6760 -4430 {
lab=#net27}
N 6540 -4410 6550 -4420 {
lab=#net28}
N 6550 -4420 6750 -4420 {
lab=#net28}
N 6750 -4420 6760 -4410 {
lab=#net28}
N 6600 -4570 6600 -4550 {
lab=vcom}
N 6640 -4570 6640 -4550 {
lab=ctop}
N 6520 -4470 6540 -4470 {
lab=col_n[13]}
N 6520 -4450 6540 -4450 {
lab=colon_n[13]}
N 6520 -4430 6540 -4430 {
lab=#net27}
N 6520 -4410 6540 -4410 {
lab=#net28}
N 6760 -4410 6780 -4410 {
lab=#net28}
N 6760 -4430 6780 -4430 {
lab=#net27}
N 6760 -4450 6780 -4450 {
lab=colon_n[13]}
N 6760 -4470 6780 -4470 {
lab=col_n[13]}
N 6580 -4330 6580 -4320 {
lab=VSS}
N 6580 -4560 6580 -4550 {
lab=VDD}
N 6920 -4330 6930 -4340 {
lab=row_n[22]}
N 6930 -4540 6930 -4340 {
lab=row_n[22]}
N 6920 -4550 6930 -4540 {
lab=row_n[22]}
N 6920 -4330 6920 -4310 {
lab=row_n[22]}
N 6920 -4570 6920 -4550 {
lab=row_n[22]}
N 6800 -4470 6810 -4480 {
lab=col_n[13]}
N 6810 -4480 7010 -4480 {
lab=col_n[13]}
N 7010 -4480 7020 -4470 {
lab=col_n[13]}
N 6800 -4450 6810 -4460 {
lab=colon_n[13]}
N 6810 -4460 7010 -4460 {
lab=colon_n[13]}
N 7010 -4460 7020 -4450 {
lab=colon_n[13]}
N 6800 -4430 6810 -4440 {
lab=#net27}
N 6810 -4440 7010 -4440 {
lab=#net27}
N 7010 -4440 7020 -4430 {
lab=#net27}
N 6800 -4410 6810 -4420 {
lab=#net28}
N 6810 -4420 7010 -4420 {
lab=#net28}
N 7010 -4420 7020 -4410 {
lab=#net28}
N 6860 -4570 6860 -4550 {
lab=vcom}
N 6900 -4570 6900 -4550 {
lab=ctop}
N 6780 -4470 6800 -4470 {
lab=col_n[13]}
N 6780 -4450 6800 -4450 {
lab=colon_n[13]}
N 6780 -4430 6800 -4430 {
lab=#net27}
N 6780 -4410 6800 -4410 {
lab=#net28}
N 7020 -4410 7040 -4410 {
lab=#net28}
N 7020 -4430 7040 -4430 {
lab=#net27}
N 7020 -4450 7040 -4450 {
lab=colon_n[13]}
N 7020 -4470 7040 -4470 {
lab=col_n[13]}
N 6840 -4330 6840 -4320 {
lab=VSS}
N 6840 -4560 6840 -4550 {
lab=VDD}
N 7180 -4330 7190 -4340 {
lab=row_n[23]}
N 7190 -4540 7190 -4340 {
lab=row_n[23]}
N 7180 -4550 7190 -4540 {
lab=row_n[23]}
N 7180 -4330 7180 -4310 {
lab=row_n[23]}
N 7180 -4570 7180 -4550 {
lab=row_n[23]}
N 7060 -4470 7070 -4480 {
lab=col_n[13]}
N 7070 -4480 7270 -4480 {
lab=col_n[13]}
N 7270 -4480 7280 -4470 {
lab=col_n[13]}
N 7060 -4450 7070 -4460 {
lab=colon_n[13]}
N 7070 -4460 7270 -4460 {
lab=colon_n[13]}
N 7270 -4460 7280 -4450 {
lab=colon_n[13]}
N 7060 -4430 7070 -4440 {
lab=#net27}
N 7070 -4440 7270 -4440 {
lab=#net27}
N 7270 -4440 7280 -4430 {
lab=#net27}
N 7060 -4410 7070 -4420 {
lab=#net28}
N 7070 -4420 7270 -4420 {
lab=#net28}
N 7270 -4420 7280 -4410 {
lab=#net28}
N 7120 -4570 7120 -4550 {
lab=vcom}
N 7160 -4570 7160 -4550 {
lab=ctop}
N 7040 -4470 7060 -4470 {
lab=col_n[13]}
N 7040 -4450 7060 -4450 {
lab=colon_n[13]}
N 7040 -4430 7060 -4430 {
lab=#net27}
N 7040 -4410 7060 -4410 {
lab=#net28}
N 7280 -4410 7300 -4410 {
lab=#net28}
N 7280 -4430 7300 -4430 {
lab=#net27}
N 7280 -4450 7300 -4450 {
lab=colon_n[13]}
N 7280 -4470 7300 -4470 {
lab=col_n[13]}
N 7100 -4330 7100 -4320 {
lab=VSS}
N 7100 -4560 7100 -4550 {
lab=VDD}
N 7440 -4330 7450 -4340 {
lab=row_n[24]}
N 7450 -4540 7450 -4340 {
lab=row_n[24]}
N 7440 -4550 7450 -4540 {
lab=row_n[24]}
N 7440 -4330 7440 -4310 {
lab=row_n[24]}
N 7440 -4570 7440 -4550 {
lab=row_n[24]}
N 7320 -4470 7330 -4480 {
lab=col_n[13]}
N 7330 -4480 7530 -4480 {
lab=col_n[13]}
N 7530 -4480 7540 -4470 {
lab=col_n[13]}
N 7320 -4450 7330 -4460 {
lab=colon_n[13]}
N 7330 -4460 7530 -4460 {
lab=colon_n[13]}
N 7530 -4460 7540 -4450 {
lab=colon_n[13]}
N 7320 -4430 7330 -4440 {
lab=#net27}
N 7330 -4440 7530 -4440 {
lab=#net27}
N 7530 -4440 7540 -4430 {
lab=#net27}
N 7320 -4410 7330 -4420 {
lab=#net28}
N 7330 -4420 7530 -4420 {
lab=#net28}
N 7530 -4420 7540 -4410 {
lab=#net28}
N 7380 -4570 7380 -4550 {
lab=vcom}
N 7420 -4570 7420 -4550 {
lab=ctop}
N 7300 -4470 7320 -4470 {
lab=col_n[13]}
N 7300 -4450 7320 -4450 {
lab=colon_n[13]}
N 7300 -4430 7320 -4430 {
lab=#net27}
N 7300 -4410 7320 -4410 {
lab=#net28}
N 7540 -4410 7560 -4410 {
lab=#net28}
N 7540 -4430 7560 -4430 {
lab=#net27}
N 7540 -4450 7560 -4450 {
lab=colon_n[13]}
N 7540 -4470 7560 -4470 {
lab=col_n[13]}
N 7360 -4330 7360 -4320 {
lab=VSS}
N 7360 -4560 7360 -4550 {
lab=VDD}
N 7700 -4330 7710 -4340 {
lab=row_n[25]}
N 7710 -4540 7710 -4340 {
lab=row_n[25]}
N 7700 -4550 7710 -4540 {
lab=row_n[25]}
N 7700 -4330 7700 -4310 {
lab=row_n[25]}
N 7700 -4570 7700 -4550 {
lab=row_n[25]}
N 7580 -4470 7590 -4480 {
lab=col_n[13]}
N 7590 -4480 7790 -4480 {
lab=col_n[13]}
N 7790 -4480 7800 -4470 {
lab=col_n[13]}
N 7580 -4450 7590 -4460 {
lab=colon_n[13]}
N 7590 -4460 7790 -4460 {
lab=colon_n[13]}
N 7790 -4460 7800 -4450 {
lab=colon_n[13]}
N 7580 -4430 7590 -4440 {
lab=#net27}
N 7590 -4440 7790 -4440 {
lab=#net27}
N 7790 -4440 7800 -4430 {
lab=#net27}
N 7580 -4410 7590 -4420 {
lab=#net28}
N 7590 -4420 7790 -4420 {
lab=#net28}
N 7790 -4420 7800 -4410 {
lab=#net28}
N 7640 -4570 7640 -4550 {
lab=vcom}
N 7680 -4570 7680 -4550 {
lab=ctop}
N 7560 -4470 7580 -4470 {
lab=col_n[13]}
N 7560 -4450 7580 -4450 {
lab=colon_n[13]}
N 7560 -4430 7580 -4430 {
lab=#net27}
N 7560 -4410 7580 -4410 {
lab=#net28}
N 7800 -4410 7820 -4410 {
lab=#net28}
N 7800 -4430 7820 -4430 {
lab=#net27}
N 7800 -4450 7820 -4450 {
lab=colon_n[13]}
N 7800 -4470 7820 -4470 {
lab=col_n[13]}
N 7620 -4330 7620 -4320 {
lab=VSS}
N 7620 -4560 7620 -4550 {
lab=VDD}
N 7960 -4330 7970 -4340 {
lab=row_n[26]}
N 7970 -4540 7970 -4340 {
lab=row_n[26]}
N 7960 -4550 7970 -4540 {
lab=row_n[26]}
N 7960 -4330 7960 -4310 {
lab=row_n[26]}
N 7960 -4570 7960 -4550 {
lab=row_n[26]}
N 7840 -4470 7850 -4480 {
lab=col_n[13]}
N 7850 -4480 8050 -4480 {
lab=col_n[13]}
N 8050 -4480 8060 -4470 {
lab=col_n[13]}
N 7840 -4450 7850 -4460 {
lab=colon_n[13]}
N 7850 -4460 8050 -4460 {
lab=colon_n[13]}
N 8050 -4460 8060 -4450 {
lab=colon_n[13]}
N 7840 -4430 7850 -4440 {
lab=#net27}
N 7850 -4440 8050 -4440 {
lab=#net27}
N 8050 -4440 8060 -4430 {
lab=#net27}
N 7840 -4410 7850 -4420 {
lab=#net28}
N 7850 -4420 8050 -4420 {
lab=#net28}
N 8050 -4420 8060 -4410 {
lab=#net28}
N 7900 -4570 7900 -4550 {
lab=vcom}
N 7940 -4570 7940 -4550 {
lab=ctop}
N 7820 -4470 7840 -4470 {
lab=col_n[13]}
N 7820 -4450 7840 -4450 {
lab=colon_n[13]}
N 7820 -4430 7840 -4430 {
lab=#net27}
N 7820 -4410 7840 -4410 {
lab=#net28}
N 8060 -4410 8080 -4410 {
lab=#net28}
N 8060 -4430 8080 -4430 {
lab=#net27}
N 8060 -4450 8080 -4450 {
lab=colon_n[13]}
N 8060 -4470 8080 -4470 {
lab=col_n[13]}
N 7880 -4330 7880 -4320 {
lab=VSS}
N 7880 -4560 7880 -4550 {
lab=VDD}
N 8220 -4330 8230 -4340 {
lab=row_n[27]}
N 8230 -4540 8230 -4340 {
lab=row_n[27]}
N 8220 -4550 8230 -4540 {
lab=row_n[27]}
N 8220 -4330 8220 -4310 {
lab=row_n[27]}
N 8220 -4570 8220 -4550 {
lab=row_n[27]}
N 8100 -4470 8110 -4480 {
lab=col_n[13]}
N 8110 -4480 8310 -4480 {
lab=col_n[13]}
N 8310 -4480 8320 -4470 {
lab=col_n[13]}
N 8100 -4450 8110 -4460 {
lab=colon_n[13]}
N 8110 -4460 8310 -4460 {
lab=colon_n[13]}
N 8310 -4460 8320 -4450 {
lab=colon_n[13]}
N 8100 -4430 8110 -4440 {
lab=#net27}
N 8110 -4440 8310 -4440 {
lab=#net27}
N 8310 -4440 8320 -4430 {
lab=#net27}
N 8100 -4410 8110 -4420 {
lab=#net28}
N 8110 -4420 8310 -4420 {
lab=#net28}
N 8310 -4420 8320 -4410 {
lab=#net28}
N 8160 -4570 8160 -4550 {
lab=vcom}
N 8200 -4570 8200 -4550 {
lab=ctop}
N 8080 -4470 8100 -4470 {
lab=col_n[13]}
N 8080 -4450 8100 -4450 {
lab=colon_n[13]}
N 8080 -4430 8100 -4430 {
lab=#net27}
N 8080 -4410 8100 -4410 {
lab=#net28}
N 8320 -4410 8340 -4410 {
lab=#net28}
N 8320 -4430 8340 -4430 {
lab=#net27}
N 8320 -4450 8340 -4450 {
lab=colon_n[13]}
N 8320 -4470 8340 -4470 {
lab=col_n[13]}
N 8140 -4330 8140 -4320 {
lab=VSS}
N 8140 -4560 8140 -4550 {
lab=VDD}
N 8480 -4330 8490 -4340 {
lab=row_n[28]}
N 8490 -4540 8490 -4340 {
lab=row_n[28]}
N 8480 -4550 8490 -4540 {
lab=row_n[28]}
N 8480 -4330 8480 -4310 {
lab=row_n[28]}
N 8480 -4570 8480 -4550 {
lab=row_n[28]}
N 8360 -4470 8370 -4480 {
lab=col_n[13]}
N 8370 -4480 8570 -4480 {
lab=col_n[13]}
N 8570 -4480 8580 -4470 {
lab=col_n[13]}
N 8360 -4450 8370 -4460 {
lab=colon_n[13]}
N 8370 -4460 8570 -4460 {
lab=colon_n[13]}
N 8570 -4460 8580 -4450 {
lab=colon_n[13]}
N 8360 -4430 8370 -4440 {
lab=#net27}
N 8370 -4440 8570 -4440 {
lab=#net27}
N 8570 -4440 8580 -4430 {
lab=#net27}
N 8360 -4410 8370 -4420 {
lab=#net28}
N 8370 -4420 8570 -4420 {
lab=#net28}
N 8570 -4420 8580 -4410 {
lab=#net28}
N 8420 -4570 8420 -4550 {
lab=vcom}
N 8460 -4570 8460 -4550 {
lab=ctop}
N 8340 -4470 8360 -4470 {
lab=col_n[13]}
N 8340 -4450 8360 -4450 {
lab=colon_n[13]}
N 8340 -4430 8360 -4430 {
lab=#net27}
N 8340 -4410 8360 -4410 {
lab=#net28}
N 8580 -4410 8600 -4410 {
lab=#net28}
N 8580 -4430 8600 -4430 {
lab=#net27}
N 8580 -4450 8600 -4450 {
lab=colon_n[13]}
N 8580 -4470 8600 -4470 {
lab=col_n[13]}
N 8400 -4330 8400 -4320 {
lab=VSS}
N 8400 -4560 8400 -4550 {
lab=VDD}
N 8740 -4330 8750 -4340 {
lab=row_n[29]}
N 8750 -4540 8750 -4340 {
lab=row_n[29]}
N 8740 -4550 8750 -4540 {
lab=row_n[29]}
N 8740 -4330 8740 -4310 {
lab=row_n[29]}
N 8740 -4570 8740 -4550 {
lab=row_n[29]}
N 8620 -4470 8630 -4480 {
lab=col_n[13]}
N 8630 -4480 8830 -4480 {
lab=col_n[13]}
N 8830 -4480 8840 -4470 {
lab=col_n[13]}
N 8620 -4450 8630 -4460 {
lab=colon_n[13]}
N 8630 -4460 8830 -4460 {
lab=colon_n[13]}
N 8830 -4460 8840 -4450 {
lab=colon_n[13]}
N 8620 -4430 8630 -4440 {
lab=#net27}
N 8630 -4440 8830 -4440 {
lab=#net27}
N 8830 -4440 8840 -4430 {
lab=#net27}
N 8620 -4410 8630 -4420 {
lab=#net28}
N 8630 -4420 8830 -4420 {
lab=#net28}
N 8830 -4420 8840 -4410 {
lab=#net28}
N 8680 -4570 8680 -4550 {
lab=vcom}
N 8720 -4570 8720 -4550 {
lab=ctop}
N 8600 -4470 8620 -4470 {
lab=col_n[13]}
N 8600 -4450 8620 -4450 {
lab=colon_n[13]}
N 8600 -4430 8620 -4430 {
lab=#net27}
N 8600 -4410 8620 -4410 {
lab=#net28}
N 8840 -4410 8860 -4410 {
lab=#net28}
N 8840 -4430 8860 -4430 {
lab=#net27}
N 8840 -4450 8860 -4450 {
lab=colon_n[13]}
N 8840 -4470 8860 -4470 {
lab=col_n[13]}
N 8660 -4330 8660 -4320 {
lab=VSS}
N 8660 -4560 8660 -4550 {
lab=VDD}
N 9000 -4330 9010 -4340 {
lab=row_n[30]}
N 9010 -4540 9010 -4340 {
lab=row_n[30]}
N 9000 -4550 9010 -4540 {
lab=row_n[30]}
N 9000 -4330 9000 -4310 {
lab=row_n[30]}
N 9000 -4570 9000 -4550 {
lab=row_n[30]}
N 8880 -4470 8890 -4480 {
lab=col_n[13]}
N 8890 -4480 9090 -4480 {
lab=col_n[13]}
N 9090 -4480 9100 -4470 {
lab=col_n[13]}
N 8880 -4450 8890 -4460 {
lab=colon_n[13]}
N 8890 -4460 9090 -4460 {
lab=colon_n[13]}
N 9090 -4460 9100 -4450 {
lab=colon_n[13]}
N 8880 -4430 8890 -4440 {
lab=#net27}
N 8890 -4440 9090 -4440 {
lab=#net27}
N 9090 -4440 9100 -4430 {
lab=#net27}
N 8880 -4410 8890 -4420 {
lab=#net28}
N 8890 -4420 9090 -4420 {
lab=#net28}
N 9090 -4420 9100 -4410 {
lab=#net28}
N 8940 -4570 8940 -4550 {
lab=vcom}
N 8980 -4570 8980 -4550 {
lab=ctop}
N 8860 -4470 8880 -4470 {
lab=col_n[13]}
N 8860 -4450 8880 -4450 {
lab=colon_n[13]}
N 8860 -4430 8880 -4430 {
lab=#net27}
N 8860 -4410 8880 -4410 {
lab=#net28}
N 9100 -4410 9120 -4410 {
lab=#net28}
N 9100 -4430 9120 -4430 {
lab=#net27}
N 9100 -4450 9120 -4450 {
lab=colon_n[13]}
N 9100 -4470 9120 -4470 {
lab=col_n[13]}
N 8920 -4330 8920 -4320 {
lab=VSS}
N 8920 -4560 8920 -4550 {
lab=VDD}
N 9260 -4330 9270 -4340 {
lab=row_n[31]}
N 9270 -4540 9270 -4340 {
lab=row_n[31]}
N 9260 -4550 9270 -4540 {
lab=row_n[31]}
N 9260 -4330 9260 -4310 {
lab=row_n[31]}
N 9260 -4570 9260 -4550 {
lab=row_n[31]}
N 9140 -4470 9150 -4480 {
lab=col_n[13]}
N 9150 -4480 9350 -4480 {
lab=col_n[13]}
N 9350 -4480 9360 -4470 {
lab=col_n[13]}
N 9140 -4450 9150 -4460 {
lab=colon_n[13]}
N 9150 -4460 9350 -4460 {
lab=colon_n[13]}
N 9350 -4460 9360 -4450 {
lab=colon_n[13]}
N 9140 -4430 9150 -4440 {
lab=#net27}
N 9150 -4440 9350 -4440 {
lab=#net27}
N 9350 -4440 9360 -4430 {
lab=#net27}
N 9140 -4410 9150 -4420 {
lab=#net28}
N 9150 -4420 9350 -4420 {
lab=#net28}
N 9350 -4420 9360 -4410 {
lab=#net28}
N 9200 -4570 9200 -4550 {
lab=vcom}
N 9240 -4570 9240 -4550 {
lab=ctop}
N 9120 -4470 9140 -4470 {
lab=col_n[13]}
N 9120 -4450 9140 -4450 {
lab=colon_n[13]}
N 9120 -4430 9140 -4430 {
lab=#net27}
N 9120 -4410 9140 -4410 {
lab=#net28}
N 9360 -4410 9380 -4410 {
lab=#net28}
N 9360 -4430 9380 -4430 {
lab=#net27}
N 9360 -4450 9380 -4450 {
lab=colon_n[13]}
N 9360 -4470 9380 -4470 {
lab=col_n[13]}
N 9180 -4330 9180 -4320 {
lab=VSS}
N 9180 -4560 9180 -4550 {
lab=VDD}
N 1200 -4590 1210 -4600 {
lab=row_n[0]}
N 1210 -4800 1210 -4600 {
lab=row_n[0]}
N 1200 -4810 1210 -4800 {
lab=row_n[0]}
N 1200 -4590 1200 -4570 {
lab=row_n[0]}
N 1200 -4830 1200 -4810 {
lab=row_n[0]}
N 1080 -4730 1090 -4740 {
lab=col_n[14]}
N 1090 -4740 1290 -4740 {
lab=col_n[14]}
N 1290 -4740 1300 -4730 {
lab=col_n[14]}
N 1080 -4710 1090 -4720 {
lab=colon_n[14]}
N 1090 -4720 1290 -4720 {
lab=colon_n[14]}
N 1290 -4720 1300 -4710 {
lab=colon_n[14]}
N 1080 -4690 1090 -4700 {
lab=#net29}
N 1090 -4700 1290 -4700 {
lab=#net29}
N 1290 -4700 1300 -4690 {
lab=#net29}
N 1080 -4670 1090 -4680 {
lab=#net30}
N 1090 -4680 1290 -4680 {
lab=#net30}
N 1290 -4680 1300 -4670 {
lab=#net30}
N 1140 -4830 1140 -4810 {
lab=vcom}
N 1180 -4830 1180 -4810 {
lab=ctop}
N 1060 -4730 1080 -4730 {
lab=col_n[14]}
N 1060 -4710 1080 -4710 {
lab=colon_n[14]}
N 1060 -4690 1080 -4690 {
lab=#net29}
N 1060 -4670 1080 -4670 {
lab=#net30}
N 1300 -4670 1320 -4670 {
lab=#net30}
N 1300 -4690 1320 -4690 {
lab=#net29}
N 1300 -4710 1320 -4710 {
lab=colon_n[14]}
N 1300 -4730 1320 -4730 {
lab=col_n[14]}
N 1120 -4590 1120 -4580 {
lab=VSS}
N 1120 -4820 1120 -4810 {
lab=VDD}
N 1460 -4590 1470 -4600 {
lab=row_n[1]}
N 1470 -4800 1470 -4600 {
lab=row_n[1]}
N 1460 -4810 1470 -4800 {
lab=row_n[1]}
N 1460 -4590 1460 -4570 {
lab=row_n[1]}
N 1460 -4830 1460 -4810 {
lab=row_n[1]}
N 1340 -4730 1350 -4740 {
lab=col_n[14]}
N 1350 -4740 1550 -4740 {
lab=col_n[14]}
N 1550 -4740 1560 -4730 {
lab=col_n[14]}
N 1340 -4710 1350 -4720 {
lab=colon_n[14]}
N 1350 -4720 1550 -4720 {
lab=colon_n[14]}
N 1550 -4720 1560 -4710 {
lab=colon_n[14]}
N 1340 -4690 1350 -4700 {
lab=#net29}
N 1350 -4700 1550 -4700 {
lab=#net29}
N 1550 -4700 1560 -4690 {
lab=#net29}
N 1340 -4670 1350 -4680 {
lab=#net30}
N 1350 -4680 1550 -4680 {
lab=#net30}
N 1550 -4680 1560 -4670 {
lab=#net30}
N 1400 -4830 1400 -4810 {
lab=vcom}
N 1440 -4830 1440 -4810 {
lab=ctop}
N 1320 -4730 1340 -4730 {
lab=col_n[14]}
N 1320 -4710 1340 -4710 {
lab=colon_n[14]}
N 1320 -4690 1340 -4690 {
lab=#net29}
N 1320 -4670 1340 -4670 {
lab=#net30}
N 1560 -4670 1580 -4670 {
lab=#net30}
N 1560 -4690 1580 -4690 {
lab=#net29}
N 1560 -4710 1580 -4710 {
lab=colon_n[14]}
N 1560 -4730 1580 -4730 {
lab=col_n[14]}
N 1380 -4590 1380 -4580 {
lab=VSS}
N 1380 -4820 1380 -4810 {
lab=VDD}
N 1720 -4590 1730 -4600 {
lab=row_n[2]}
N 1730 -4800 1730 -4600 {
lab=row_n[2]}
N 1720 -4810 1730 -4800 {
lab=row_n[2]}
N 1720 -4590 1720 -4570 {
lab=row_n[2]}
N 1720 -4830 1720 -4810 {
lab=row_n[2]}
N 1600 -4730 1610 -4740 {
lab=col_n[14]}
N 1610 -4740 1810 -4740 {
lab=col_n[14]}
N 1810 -4740 1820 -4730 {
lab=col_n[14]}
N 1600 -4710 1610 -4720 {
lab=colon_n[14]}
N 1610 -4720 1810 -4720 {
lab=colon_n[14]}
N 1810 -4720 1820 -4710 {
lab=colon_n[14]}
N 1600 -4690 1610 -4700 {
lab=#net29}
N 1610 -4700 1810 -4700 {
lab=#net29}
N 1810 -4700 1820 -4690 {
lab=#net29}
N 1600 -4670 1610 -4680 {
lab=#net30}
N 1610 -4680 1810 -4680 {
lab=#net30}
N 1810 -4680 1820 -4670 {
lab=#net30}
N 1660 -4830 1660 -4810 {
lab=vcom}
N 1700 -4830 1700 -4810 {
lab=ctop}
N 1580 -4730 1600 -4730 {
lab=col_n[14]}
N 1580 -4710 1600 -4710 {
lab=colon_n[14]}
N 1580 -4690 1600 -4690 {
lab=#net29}
N 1580 -4670 1600 -4670 {
lab=#net30}
N 1820 -4670 1840 -4670 {
lab=#net30}
N 1820 -4690 1840 -4690 {
lab=#net29}
N 1820 -4710 1840 -4710 {
lab=colon_n[14]}
N 1820 -4730 1840 -4730 {
lab=col_n[14]}
N 1640 -4590 1640 -4580 {
lab=VSS}
N 1640 -4820 1640 -4810 {
lab=VDD}
N 1980 -4590 1990 -4600 {
lab=row_n[3]}
N 1990 -4800 1990 -4600 {
lab=row_n[3]}
N 1980 -4810 1990 -4800 {
lab=row_n[3]}
N 1980 -4590 1980 -4570 {
lab=row_n[3]}
N 1980 -4830 1980 -4810 {
lab=row_n[3]}
N 1860 -4730 1870 -4740 {
lab=col_n[14]}
N 1870 -4740 2070 -4740 {
lab=col_n[14]}
N 2070 -4740 2080 -4730 {
lab=col_n[14]}
N 1860 -4710 1870 -4720 {
lab=colon_n[14]}
N 1870 -4720 2070 -4720 {
lab=colon_n[14]}
N 2070 -4720 2080 -4710 {
lab=colon_n[14]}
N 1860 -4690 1870 -4700 {
lab=#net29}
N 1870 -4700 2070 -4700 {
lab=#net29}
N 2070 -4700 2080 -4690 {
lab=#net29}
N 1860 -4670 1870 -4680 {
lab=#net30}
N 1870 -4680 2070 -4680 {
lab=#net30}
N 2070 -4680 2080 -4670 {
lab=#net30}
N 1920 -4830 1920 -4810 {
lab=vcom}
N 1960 -4830 1960 -4810 {
lab=ctop}
N 1840 -4730 1860 -4730 {
lab=col_n[14]}
N 1840 -4710 1860 -4710 {
lab=colon_n[14]}
N 1840 -4690 1860 -4690 {
lab=#net29}
N 1840 -4670 1860 -4670 {
lab=#net30}
N 2080 -4670 2100 -4670 {
lab=#net30}
N 2080 -4690 2100 -4690 {
lab=#net29}
N 2080 -4710 2100 -4710 {
lab=colon_n[14]}
N 2080 -4730 2100 -4730 {
lab=col_n[14]}
N 1900 -4590 1900 -4580 {
lab=VSS}
N 1900 -4820 1900 -4810 {
lab=VDD}
N 2240 -4590 2250 -4600 {
lab=row_n[4]}
N 2250 -4800 2250 -4600 {
lab=row_n[4]}
N 2240 -4810 2250 -4800 {
lab=row_n[4]}
N 2240 -4590 2240 -4570 {
lab=row_n[4]}
N 2240 -4830 2240 -4810 {
lab=row_n[4]}
N 2120 -4730 2130 -4740 {
lab=col_n[14]}
N 2130 -4740 2330 -4740 {
lab=col_n[14]}
N 2330 -4740 2340 -4730 {
lab=col_n[14]}
N 2120 -4710 2130 -4720 {
lab=colon_n[14]}
N 2130 -4720 2330 -4720 {
lab=colon_n[14]}
N 2330 -4720 2340 -4710 {
lab=colon_n[14]}
N 2120 -4690 2130 -4700 {
lab=#net29}
N 2130 -4700 2330 -4700 {
lab=#net29}
N 2330 -4700 2340 -4690 {
lab=#net29}
N 2120 -4670 2130 -4680 {
lab=#net30}
N 2130 -4680 2330 -4680 {
lab=#net30}
N 2330 -4680 2340 -4670 {
lab=#net30}
N 2180 -4830 2180 -4810 {
lab=vcom}
N 2220 -4830 2220 -4810 {
lab=ctop}
N 2100 -4730 2120 -4730 {
lab=col_n[14]}
N 2100 -4710 2120 -4710 {
lab=colon_n[14]}
N 2100 -4690 2120 -4690 {
lab=#net29}
N 2100 -4670 2120 -4670 {
lab=#net30}
N 2340 -4670 2360 -4670 {
lab=#net30}
N 2340 -4690 2360 -4690 {
lab=#net29}
N 2340 -4710 2360 -4710 {
lab=colon_n[14]}
N 2340 -4730 2360 -4730 {
lab=col_n[14]}
N 2160 -4590 2160 -4580 {
lab=VSS}
N 2160 -4820 2160 -4810 {
lab=VDD}
N 2500 -4590 2510 -4600 {
lab=row_n[5]}
N 2510 -4800 2510 -4600 {
lab=row_n[5]}
N 2500 -4810 2510 -4800 {
lab=row_n[5]}
N 2500 -4590 2500 -4570 {
lab=row_n[5]}
N 2500 -4830 2500 -4810 {
lab=row_n[5]}
N 2380 -4730 2390 -4740 {
lab=col_n[14]}
N 2390 -4740 2590 -4740 {
lab=col_n[14]}
N 2590 -4740 2600 -4730 {
lab=col_n[14]}
N 2380 -4710 2390 -4720 {
lab=colon_n[14]}
N 2390 -4720 2590 -4720 {
lab=colon_n[14]}
N 2590 -4720 2600 -4710 {
lab=colon_n[14]}
N 2380 -4690 2390 -4700 {
lab=#net29}
N 2390 -4700 2590 -4700 {
lab=#net29}
N 2590 -4700 2600 -4690 {
lab=#net29}
N 2380 -4670 2390 -4680 {
lab=#net30}
N 2390 -4680 2590 -4680 {
lab=#net30}
N 2590 -4680 2600 -4670 {
lab=#net30}
N 2440 -4830 2440 -4810 {
lab=vcom}
N 2480 -4830 2480 -4810 {
lab=ctop}
N 2360 -4730 2380 -4730 {
lab=col_n[14]}
N 2360 -4710 2380 -4710 {
lab=colon_n[14]}
N 2360 -4690 2380 -4690 {
lab=#net29}
N 2360 -4670 2380 -4670 {
lab=#net30}
N 2600 -4670 2620 -4670 {
lab=#net30}
N 2600 -4690 2620 -4690 {
lab=#net29}
N 2600 -4710 2620 -4710 {
lab=colon_n[14]}
N 2600 -4730 2620 -4730 {
lab=col_n[14]}
N 2420 -4590 2420 -4580 {
lab=VSS}
N 2420 -4820 2420 -4810 {
lab=VDD}
N 2760 -4590 2770 -4600 {
lab=row_n[6]}
N 2770 -4800 2770 -4600 {
lab=row_n[6]}
N 2760 -4810 2770 -4800 {
lab=row_n[6]}
N 2760 -4590 2760 -4570 {
lab=row_n[6]}
N 2760 -4830 2760 -4810 {
lab=row_n[6]}
N 2640 -4730 2650 -4740 {
lab=col_n[14]}
N 2650 -4740 2850 -4740 {
lab=col_n[14]}
N 2850 -4740 2860 -4730 {
lab=col_n[14]}
N 2640 -4710 2650 -4720 {
lab=colon_n[14]}
N 2650 -4720 2850 -4720 {
lab=colon_n[14]}
N 2850 -4720 2860 -4710 {
lab=colon_n[14]}
N 2640 -4690 2650 -4700 {
lab=#net29}
N 2650 -4700 2850 -4700 {
lab=#net29}
N 2850 -4700 2860 -4690 {
lab=#net29}
N 2640 -4670 2650 -4680 {
lab=#net30}
N 2650 -4680 2850 -4680 {
lab=#net30}
N 2850 -4680 2860 -4670 {
lab=#net30}
N 2700 -4830 2700 -4810 {
lab=vcom}
N 2740 -4830 2740 -4810 {
lab=ctop}
N 2620 -4730 2640 -4730 {
lab=col_n[14]}
N 2620 -4710 2640 -4710 {
lab=colon_n[14]}
N 2620 -4690 2640 -4690 {
lab=#net29}
N 2620 -4670 2640 -4670 {
lab=#net30}
N 2860 -4670 2880 -4670 {
lab=#net30}
N 2860 -4690 2880 -4690 {
lab=#net29}
N 2860 -4710 2880 -4710 {
lab=colon_n[14]}
N 2860 -4730 2880 -4730 {
lab=col_n[14]}
N 2680 -4590 2680 -4580 {
lab=VSS}
N 2680 -4820 2680 -4810 {
lab=VDD}
N 3020 -4590 3030 -4600 {
lab=row_n[7]}
N 3030 -4800 3030 -4600 {
lab=row_n[7]}
N 3020 -4810 3030 -4800 {
lab=row_n[7]}
N 3020 -4590 3020 -4570 {
lab=row_n[7]}
N 3020 -4830 3020 -4810 {
lab=row_n[7]}
N 2900 -4730 2910 -4740 {
lab=col_n[14]}
N 2910 -4740 3110 -4740 {
lab=col_n[14]}
N 3110 -4740 3120 -4730 {
lab=col_n[14]}
N 2900 -4710 2910 -4720 {
lab=colon_n[14]}
N 2910 -4720 3110 -4720 {
lab=colon_n[14]}
N 3110 -4720 3120 -4710 {
lab=colon_n[14]}
N 2900 -4690 2910 -4700 {
lab=#net29}
N 2910 -4700 3110 -4700 {
lab=#net29}
N 3110 -4700 3120 -4690 {
lab=#net29}
N 2900 -4670 2910 -4680 {
lab=#net30}
N 2910 -4680 3110 -4680 {
lab=#net30}
N 3110 -4680 3120 -4670 {
lab=#net30}
N 2960 -4830 2960 -4810 {
lab=vcom}
N 3000 -4830 3000 -4810 {
lab=ctop}
N 2880 -4730 2900 -4730 {
lab=col_n[14]}
N 2880 -4710 2900 -4710 {
lab=colon_n[14]}
N 2880 -4690 2900 -4690 {
lab=#net29}
N 2880 -4670 2900 -4670 {
lab=#net30}
N 3120 -4670 3140 -4670 {
lab=#net30}
N 3120 -4690 3140 -4690 {
lab=#net29}
N 3120 -4710 3140 -4710 {
lab=colon_n[14]}
N 3120 -4730 3140 -4730 {
lab=col_n[14]}
N 2940 -4590 2940 -4580 {
lab=VSS}
N 2940 -4820 2940 -4810 {
lab=VDD}
N 3280 -4590 3290 -4600 {
lab=row_n[8]}
N 3290 -4800 3290 -4600 {
lab=row_n[8]}
N 3280 -4810 3290 -4800 {
lab=row_n[8]}
N 3280 -4590 3280 -4570 {
lab=row_n[8]}
N 3280 -4830 3280 -4810 {
lab=row_n[8]}
N 3160 -4730 3170 -4740 {
lab=col_n[14]}
N 3170 -4740 3370 -4740 {
lab=col_n[14]}
N 3370 -4740 3380 -4730 {
lab=col_n[14]}
N 3160 -4710 3170 -4720 {
lab=colon_n[14]}
N 3170 -4720 3370 -4720 {
lab=colon_n[14]}
N 3370 -4720 3380 -4710 {
lab=colon_n[14]}
N 3160 -4690 3170 -4700 {
lab=#net29}
N 3170 -4700 3370 -4700 {
lab=#net29}
N 3370 -4700 3380 -4690 {
lab=#net29}
N 3160 -4670 3170 -4680 {
lab=#net30}
N 3170 -4680 3370 -4680 {
lab=#net30}
N 3370 -4680 3380 -4670 {
lab=#net30}
N 3220 -4830 3220 -4810 {
lab=vcom}
N 3260 -4830 3260 -4810 {
lab=ctop}
N 3140 -4730 3160 -4730 {
lab=col_n[14]}
N 3140 -4710 3160 -4710 {
lab=colon_n[14]}
N 3140 -4690 3160 -4690 {
lab=#net29}
N 3140 -4670 3160 -4670 {
lab=#net30}
N 3380 -4670 3400 -4670 {
lab=#net30}
N 3380 -4690 3400 -4690 {
lab=#net29}
N 3380 -4710 3400 -4710 {
lab=colon_n[14]}
N 3380 -4730 3400 -4730 {
lab=col_n[14]}
N 3200 -4590 3200 -4580 {
lab=VSS}
N 3200 -4820 3200 -4810 {
lab=VDD}
N 3540 -4590 3550 -4600 {
lab=row_n[9]}
N 3550 -4800 3550 -4600 {
lab=row_n[9]}
N 3540 -4810 3550 -4800 {
lab=row_n[9]}
N 3540 -4590 3540 -4570 {
lab=row_n[9]}
N 3540 -4830 3540 -4810 {
lab=row_n[9]}
N 3420 -4730 3430 -4740 {
lab=col_n[14]}
N 3430 -4740 3630 -4740 {
lab=col_n[14]}
N 3630 -4740 3640 -4730 {
lab=col_n[14]}
N 3420 -4710 3430 -4720 {
lab=colon_n[14]}
N 3430 -4720 3630 -4720 {
lab=colon_n[14]}
N 3630 -4720 3640 -4710 {
lab=colon_n[14]}
N 3420 -4690 3430 -4700 {
lab=#net29}
N 3430 -4700 3630 -4700 {
lab=#net29}
N 3630 -4700 3640 -4690 {
lab=#net29}
N 3420 -4670 3430 -4680 {
lab=#net30}
N 3430 -4680 3630 -4680 {
lab=#net30}
N 3630 -4680 3640 -4670 {
lab=#net30}
N 3480 -4830 3480 -4810 {
lab=vcom}
N 3520 -4830 3520 -4810 {
lab=ctop}
N 3400 -4730 3420 -4730 {
lab=col_n[14]}
N 3400 -4710 3420 -4710 {
lab=colon_n[14]}
N 3400 -4690 3420 -4690 {
lab=#net29}
N 3400 -4670 3420 -4670 {
lab=#net30}
N 3640 -4670 3660 -4670 {
lab=#net30}
N 3640 -4690 3660 -4690 {
lab=#net29}
N 3640 -4710 3660 -4710 {
lab=colon_n[14]}
N 3640 -4730 3660 -4730 {
lab=col_n[14]}
N 3460 -4590 3460 -4580 {
lab=VSS}
N 3460 -4820 3460 -4810 {
lab=VDD}
N 3800 -4590 3810 -4600 {
lab=row_n[10]}
N 3810 -4800 3810 -4600 {
lab=row_n[10]}
N 3800 -4810 3810 -4800 {
lab=row_n[10]}
N 3800 -4590 3800 -4570 {
lab=row_n[10]}
N 3800 -4830 3800 -4810 {
lab=row_n[10]}
N 3680 -4730 3690 -4740 {
lab=col_n[14]}
N 3690 -4740 3890 -4740 {
lab=col_n[14]}
N 3890 -4740 3900 -4730 {
lab=col_n[14]}
N 3680 -4710 3690 -4720 {
lab=colon_n[14]}
N 3690 -4720 3890 -4720 {
lab=colon_n[14]}
N 3890 -4720 3900 -4710 {
lab=colon_n[14]}
N 3680 -4690 3690 -4700 {
lab=#net29}
N 3690 -4700 3890 -4700 {
lab=#net29}
N 3890 -4700 3900 -4690 {
lab=#net29}
N 3680 -4670 3690 -4680 {
lab=#net30}
N 3690 -4680 3890 -4680 {
lab=#net30}
N 3890 -4680 3900 -4670 {
lab=#net30}
N 3740 -4830 3740 -4810 {
lab=vcom}
N 3780 -4830 3780 -4810 {
lab=ctop}
N 3660 -4730 3680 -4730 {
lab=col_n[14]}
N 3660 -4710 3680 -4710 {
lab=colon_n[14]}
N 3660 -4690 3680 -4690 {
lab=#net29}
N 3660 -4670 3680 -4670 {
lab=#net30}
N 3900 -4670 3920 -4670 {
lab=#net30}
N 3900 -4690 3920 -4690 {
lab=#net29}
N 3900 -4710 3920 -4710 {
lab=colon_n[14]}
N 3900 -4730 3920 -4730 {
lab=col_n[14]}
N 3720 -4590 3720 -4580 {
lab=VSS}
N 3720 -4820 3720 -4810 {
lab=VDD}
N 4060 -4590 4070 -4600 {
lab=row_n[11]}
N 4070 -4800 4070 -4600 {
lab=row_n[11]}
N 4060 -4810 4070 -4800 {
lab=row_n[11]}
N 4060 -4590 4060 -4570 {
lab=row_n[11]}
N 4060 -4830 4060 -4810 {
lab=row_n[11]}
N 3940 -4730 3950 -4740 {
lab=col_n[14]}
N 3950 -4740 4150 -4740 {
lab=col_n[14]}
N 4150 -4740 4160 -4730 {
lab=col_n[14]}
N 3940 -4710 3950 -4720 {
lab=colon_n[14]}
N 3950 -4720 4150 -4720 {
lab=colon_n[14]}
N 4150 -4720 4160 -4710 {
lab=colon_n[14]}
N 3940 -4690 3950 -4700 {
lab=#net29}
N 3950 -4700 4150 -4700 {
lab=#net29}
N 4150 -4700 4160 -4690 {
lab=#net29}
N 3940 -4670 3950 -4680 {
lab=#net30}
N 3950 -4680 4150 -4680 {
lab=#net30}
N 4150 -4680 4160 -4670 {
lab=#net30}
N 4000 -4830 4000 -4810 {
lab=vcom}
N 4040 -4830 4040 -4810 {
lab=ctop}
N 3920 -4730 3940 -4730 {
lab=col_n[14]}
N 3920 -4710 3940 -4710 {
lab=colon_n[14]}
N 3920 -4690 3940 -4690 {
lab=#net29}
N 3920 -4670 3940 -4670 {
lab=#net30}
N 4160 -4670 4180 -4670 {
lab=#net30}
N 4160 -4690 4180 -4690 {
lab=#net29}
N 4160 -4710 4180 -4710 {
lab=colon_n[14]}
N 4160 -4730 4180 -4730 {
lab=col_n[14]}
N 3980 -4590 3980 -4580 {
lab=VSS}
N 3980 -4820 3980 -4810 {
lab=VDD}
N 4320 -4590 4330 -4600 {
lab=row_n[12]}
N 4330 -4800 4330 -4600 {
lab=row_n[12]}
N 4320 -4810 4330 -4800 {
lab=row_n[12]}
N 4320 -4590 4320 -4570 {
lab=row_n[12]}
N 4320 -4830 4320 -4810 {
lab=row_n[12]}
N 4200 -4730 4210 -4740 {
lab=col_n[14]}
N 4210 -4740 4410 -4740 {
lab=col_n[14]}
N 4410 -4740 4420 -4730 {
lab=col_n[14]}
N 4200 -4710 4210 -4720 {
lab=colon_n[14]}
N 4210 -4720 4410 -4720 {
lab=colon_n[14]}
N 4410 -4720 4420 -4710 {
lab=colon_n[14]}
N 4200 -4690 4210 -4700 {
lab=#net29}
N 4210 -4700 4410 -4700 {
lab=#net29}
N 4410 -4700 4420 -4690 {
lab=#net29}
N 4200 -4670 4210 -4680 {
lab=#net30}
N 4210 -4680 4410 -4680 {
lab=#net30}
N 4410 -4680 4420 -4670 {
lab=#net30}
N 4260 -4830 4260 -4810 {
lab=vcom}
N 4300 -4830 4300 -4810 {
lab=ctop}
N 4180 -4730 4200 -4730 {
lab=col_n[14]}
N 4180 -4710 4200 -4710 {
lab=colon_n[14]}
N 4180 -4690 4200 -4690 {
lab=#net29}
N 4180 -4670 4200 -4670 {
lab=#net30}
N 4420 -4670 4440 -4670 {
lab=#net30}
N 4420 -4690 4440 -4690 {
lab=#net29}
N 4420 -4710 4440 -4710 {
lab=colon_n[14]}
N 4420 -4730 4440 -4730 {
lab=col_n[14]}
N 4240 -4590 4240 -4580 {
lab=VSS}
N 4240 -4820 4240 -4810 {
lab=VDD}
N 4580 -4590 4590 -4600 {
lab=row_n[13]}
N 4590 -4800 4590 -4600 {
lab=row_n[13]}
N 4580 -4810 4590 -4800 {
lab=row_n[13]}
N 4580 -4590 4580 -4570 {
lab=row_n[13]}
N 4580 -4830 4580 -4810 {
lab=row_n[13]}
N 4460 -4730 4470 -4740 {
lab=col_n[14]}
N 4470 -4740 4670 -4740 {
lab=col_n[14]}
N 4670 -4740 4680 -4730 {
lab=col_n[14]}
N 4460 -4710 4470 -4720 {
lab=colon_n[14]}
N 4470 -4720 4670 -4720 {
lab=colon_n[14]}
N 4670 -4720 4680 -4710 {
lab=colon_n[14]}
N 4460 -4690 4470 -4700 {
lab=#net29}
N 4470 -4700 4670 -4700 {
lab=#net29}
N 4670 -4700 4680 -4690 {
lab=#net29}
N 4460 -4670 4470 -4680 {
lab=#net30}
N 4470 -4680 4670 -4680 {
lab=#net30}
N 4670 -4680 4680 -4670 {
lab=#net30}
N 4520 -4830 4520 -4810 {
lab=vcom}
N 4560 -4830 4560 -4810 {
lab=ctop}
N 4440 -4730 4460 -4730 {
lab=col_n[14]}
N 4440 -4710 4460 -4710 {
lab=colon_n[14]}
N 4440 -4690 4460 -4690 {
lab=#net29}
N 4440 -4670 4460 -4670 {
lab=#net30}
N 4680 -4670 4700 -4670 {
lab=#net30}
N 4680 -4690 4700 -4690 {
lab=#net29}
N 4680 -4710 4700 -4710 {
lab=colon_n[14]}
N 4680 -4730 4700 -4730 {
lab=col_n[14]}
N 4500 -4590 4500 -4580 {
lab=VSS}
N 4500 -4820 4500 -4810 {
lab=VDD}
N 4840 -4590 4850 -4600 {
lab=row_n[14]}
N 4850 -4800 4850 -4600 {
lab=row_n[14]}
N 4840 -4810 4850 -4800 {
lab=row_n[14]}
N 4840 -4590 4840 -4570 {
lab=row_n[14]}
N 4840 -4830 4840 -4810 {
lab=row_n[14]}
N 4720 -4730 4730 -4740 {
lab=col_n[14]}
N 4730 -4740 4930 -4740 {
lab=col_n[14]}
N 4930 -4740 4940 -4730 {
lab=col_n[14]}
N 4720 -4710 4730 -4720 {
lab=colon_n[14]}
N 4730 -4720 4930 -4720 {
lab=colon_n[14]}
N 4930 -4720 4940 -4710 {
lab=colon_n[14]}
N 4720 -4690 4730 -4700 {
lab=#net29}
N 4730 -4700 4930 -4700 {
lab=#net29}
N 4930 -4700 4940 -4690 {
lab=#net29}
N 4720 -4670 4730 -4680 {
lab=#net30}
N 4730 -4680 4930 -4680 {
lab=#net30}
N 4930 -4680 4940 -4670 {
lab=#net30}
N 4780 -4830 4780 -4810 {
lab=vcom}
N 4820 -4830 4820 -4810 {
lab=ctop}
N 4700 -4730 4720 -4730 {
lab=col_n[14]}
N 4700 -4710 4720 -4710 {
lab=colon_n[14]}
N 4700 -4690 4720 -4690 {
lab=#net29}
N 4700 -4670 4720 -4670 {
lab=#net30}
N 4940 -4670 4960 -4670 {
lab=#net30}
N 4940 -4690 4960 -4690 {
lab=#net29}
N 4940 -4710 4960 -4710 {
lab=colon_n[14]}
N 4940 -4730 4960 -4730 {
lab=col_n[14]}
N 4760 -4590 4760 -4580 {
lab=VSS}
N 4760 -4820 4760 -4810 {
lab=VDD}
N 5100 -4590 5110 -4600 {
lab=row_n[15]}
N 5110 -4800 5110 -4600 {
lab=row_n[15]}
N 5100 -4810 5110 -4800 {
lab=row_n[15]}
N 5100 -4590 5100 -4570 {
lab=row_n[15]}
N 5100 -4830 5100 -4810 {
lab=row_n[15]}
N 4980 -4730 4990 -4740 {
lab=col_n[14]}
N 4990 -4740 5190 -4740 {
lab=col_n[14]}
N 5190 -4740 5200 -4730 {
lab=col_n[14]}
N 4980 -4710 4990 -4720 {
lab=colon_n[14]}
N 4990 -4720 5190 -4720 {
lab=colon_n[14]}
N 5190 -4720 5200 -4710 {
lab=colon_n[14]}
N 4980 -4690 4990 -4700 {
lab=#net29}
N 4990 -4700 5190 -4700 {
lab=#net29}
N 5190 -4700 5200 -4690 {
lab=#net29}
N 4980 -4670 4990 -4680 {
lab=#net30}
N 4990 -4680 5190 -4680 {
lab=#net30}
N 5190 -4680 5200 -4670 {
lab=#net30}
N 5040 -4830 5040 -4810 {
lab=vcom}
N 5080 -4830 5080 -4810 {
lab=ctop}
N 4960 -4730 4980 -4730 {
lab=col_n[14]}
N 4960 -4710 4980 -4710 {
lab=colon_n[14]}
N 4960 -4690 4980 -4690 {
lab=#net29}
N 4960 -4670 4980 -4670 {
lab=#net30}
N 5200 -4670 5220 -4670 {
lab=#net30}
N 5200 -4690 5220 -4690 {
lab=#net29}
N 5200 -4710 5220 -4710 {
lab=colon_n[14]}
N 5200 -4730 5220 -4730 {
lab=col_n[14]}
N 5020 -4590 5020 -4580 {
lab=VSS}
N 5020 -4820 5020 -4810 {
lab=VDD}
N 5360 -4590 5370 -4600 {
lab=row_n[16]}
N 5370 -4800 5370 -4600 {
lab=row_n[16]}
N 5360 -4810 5370 -4800 {
lab=row_n[16]}
N 5360 -4590 5360 -4570 {
lab=row_n[16]}
N 5360 -4830 5360 -4810 {
lab=row_n[16]}
N 5240 -4730 5250 -4740 {
lab=col_n[14]}
N 5250 -4740 5450 -4740 {
lab=col_n[14]}
N 5450 -4740 5460 -4730 {
lab=col_n[14]}
N 5240 -4710 5250 -4720 {
lab=colon_n[14]}
N 5250 -4720 5450 -4720 {
lab=colon_n[14]}
N 5450 -4720 5460 -4710 {
lab=colon_n[14]}
N 5240 -4690 5250 -4700 {
lab=#net29}
N 5250 -4700 5450 -4700 {
lab=#net29}
N 5450 -4700 5460 -4690 {
lab=#net29}
N 5240 -4670 5250 -4680 {
lab=#net30}
N 5250 -4680 5450 -4680 {
lab=#net30}
N 5450 -4680 5460 -4670 {
lab=#net30}
N 5300 -4830 5300 -4810 {
lab=vcom}
N 5340 -4830 5340 -4810 {
lab=ctop}
N 5220 -4730 5240 -4730 {
lab=col_n[14]}
N 5220 -4710 5240 -4710 {
lab=colon_n[14]}
N 5220 -4690 5240 -4690 {
lab=#net29}
N 5220 -4670 5240 -4670 {
lab=#net30}
N 5460 -4670 5480 -4670 {
lab=#net30}
N 5460 -4690 5480 -4690 {
lab=#net29}
N 5460 -4710 5480 -4710 {
lab=colon_n[14]}
N 5460 -4730 5480 -4730 {
lab=col_n[14]}
N 5280 -4590 5280 -4580 {
lab=VSS}
N 5280 -4820 5280 -4810 {
lab=VDD}
N 5620 -4590 5630 -4600 {
lab=row_n[17]}
N 5630 -4800 5630 -4600 {
lab=row_n[17]}
N 5620 -4810 5630 -4800 {
lab=row_n[17]}
N 5620 -4590 5620 -4570 {
lab=row_n[17]}
N 5620 -4830 5620 -4810 {
lab=row_n[17]}
N 5500 -4730 5510 -4740 {
lab=col_n[14]}
N 5510 -4740 5710 -4740 {
lab=col_n[14]}
N 5710 -4740 5720 -4730 {
lab=col_n[14]}
N 5500 -4710 5510 -4720 {
lab=colon_n[14]}
N 5510 -4720 5710 -4720 {
lab=colon_n[14]}
N 5710 -4720 5720 -4710 {
lab=colon_n[14]}
N 5500 -4690 5510 -4700 {
lab=#net29}
N 5510 -4700 5710 -4700 {
lab=#net29}
N 5710 -4700 5720 -4690 {
lab=#net29}
N 5500 -4670 5510 -4680 {
lab=#net30}
N 5510 -4680 5710 -4680 {
lab=#net30}
N 5710 -4680 5720 -4670 {
lab=#net30}
N 5560 -4830 5560 -4810 {
lab=vcom}
N 5600 -4830 5600 -4810 {
lab=ctop}
N 5480 -4730 5500 -4730 {
lab=col_n[14]}
N 5480 -4710 5500 -4710 {
lab=colon_n[14]}
N 5480 -4690 5500 -4690 {
lab=#net29}
N 5480 -4670 5500 -4670 {
lab=#net30}
N 5720 -4670 5740 -4670 {
lab=#net30}
N 5720 -4690 5740 -4690 {
lab=#net29}
N 5720 -4710 5740 -4710 {
lab=colon_n[14]}
N 5720 -4730 5740 -4730 {
lab=col_n[14]}
N 5540 -4590 5540 -4580 {
lab=VSS}
N 5540 -4820 5540 -4810 {
lab=VDD}
N 5880 -4590 5890 -4600 {
lab=row_n[18]}
N 5890 -4800 5890 -4600 {
lab=row_n[18]}
N 5880 -4810 5890 -4800 {
lab=row_n[18]}
N 5880 -4590 5880 -4570 {
lab=row_n[18]}
N 5880 -4830 5880 -4810 {
lab=row_n[18]}
N 5760 -4730 5770 -4740 {
lab=col_n[14]}
N 5770 -4740 5970 -4740 {
lab=col_n[14]}
N 5970 -4740 5980 -4730 {
lab=col_n[14]}
N 5760 -4710 5770 -4720 {
lab=colon_n[14]}
N 5770 -4720 5970 -4720 {
lab=colon_n[14]}
N 5970 -4720 5980 -4710 {
lab=colon_n[14]}
N 5760 -4690 5770 -4700 {
lab=#net29}
N 5770 -4700 5970 -4700 {
lab=#net29}
N 5970 -4700 5980 -4690 {
lab=#net29}
N 5760 -4670 5770 -4680 {
lab=#net30}
N 5770 -4680 5970 -4680 {
lab=#net30}
N 5970 -4680 5980 -4670 {
lab=#net30}
N 5820 -4830 5820 -4810 {
lab=vcom}
N 5860 -4830 5860 -4810 {
lab=ctop}
N 5740 -4730 5760 -4730 {
lab=col_n[14]}
N 5740 -4710 5760 -4710 {
lab=colon_n[14]}
N 5740 -4690 5760 -4690 {
lab=#net29}
N 5740 -4670 5760 -4670 {
lab=#net30}
N 5980 -4670 6000 -4670 {
lab=#net30}
N 5980 -4690 6000 -4690 {
lab=#net29}
N 5980 -4710 6000 -4710 {
lab=colon_n[14]}
N 5980 -4730 6000 -4730 {
lab=col_n[14]}
N 5800 -4590 5800 -4580 {
lab=VSS}
N 5800 -4820 5800 -4810 {
lab=VDD}
N 6140 -4590 6150 -4600 {
lab=row_n[19]}
N 6150 -4800 6150 -4600 {
lab=row_n[19]}
N 6140 -4810 6150 -4800 {
lab=row_n[19]}
N 6140 -4590 6140 -4570 {
lab=row_n[19]}
N 6140 -4830 6140 -4810 {
lab=row_n[19]}
N 6020 -4730 6030 -4740 {
lab=col_n[14]}
N 6030 -4740 6230 -4740 {
lab=col_n[14]}
N 6230 -4740 6240 -4730 {
lab=col_n[14]}
N 6020 -4710 6030 -4720 {
lab=colon_n[14]}
N 6030 -4720 6230 -4720 {
lab=colon_n[14]}
N 6230 -4720 6240 -4710 {
lab=colon_n[14]}
N 6020 -4690 6030 -4700 {
lab=#net29}
N 6030 -4700 6230 -4700 {
lab=#net29}
N 6230 -4700 6240 -4690 {
lab=#net29}
N 6020 -4670 6030 -4680 {
lab=#net30}
N 6030 -4680 6230 -4680 {
lab=#net30}
N 6230 -4680 6240 -4670 {
lab=#net30}
N 6080 -4830 6080 -4810 {
lab=vcom}
N 6120 -4830 6120 -4810 {
lab=ctop}
N 6000 -4730 6020 -4730 {
lab=col_n[14]}
N 6000 -4710 6020 -4710 {
lab=colon_n[14]}
N 6000 -4690 6020 -4690 {
lab=#net29}
N 6000 -4670 6020 -4670 {
lab=#net30}
N 6240 -4670 6260 -4670 {
lab=#net30}
N 6240 -4690 6260 -4690 {
lab=#net29}
N 6240 -4710 6260 -4710 {
lab=colon_n[14]}
N 6240 -4730 6260 -4730 {
lab=col_n[14]}
N 6060 -4590 6060 -4580 {
lab=VSS}
N 6060 -4820 6060 -4810 {
lab=VDD}
N 6400 -4590 6410 -4600 {
lab=row_n[20]}
N 6410 -4800 6410 -4600 {
lab=row_n[20]}
N 6400 -4810 6410 -4800 {
lab=row_n[20]}
N 6400 -4590 6400 -4570 {
lab=row_n[20]}
N 6400 -4830 6400 -4810 {
lab=row_n[20]}
N 6280 -4730 6290 -4740 {
lab=col_n[14]}
N 6290 -4740 6490 -4740 {
lab=col_n[14]}
N 6490 -4740 6500 -4730 {
lab=col_n[14]}
N 6280 -4710 6290 -4720 {
lab=colon_n[14]}
N 6290 -4720 6490 -4720 {
lab=colon_n[14]}
N 6490 -4720 6500 -4710 {
lab=colon_n[14]}
N 6280 -4690 6290 -4700 {
lab=#net29}
N 6290 -4700 6490 -4700 {
lab=#net29}
N 6490 -4700 6500 -4690 {
lab=#net29}
N 6280 -4670 6290 -4680 {
lab=#net30}
N 6290 -4680 6490 -4680 {
lab=#net30}
N 6490 -4680 6500 -4670 {
lab=#net30}
N 6340 -4830 6340 -4810 {
lab=vcom}
N 6380 -4830 6380 -4810 {
lab=ctop}
N 6260 -4730 6280 -4730 {
lab=col_n[14]}
N 6260 -4710 6280 -4710 {
lab=colon_n[14]}
N 6260 -4690 6280 -4690 {
lab=#net29}
N 6260 -4670 6280 -4670 {
lab=#net30}
N 6500 -4670 6520 -4670 {
lab=#net30}
N 6500 -4690 6520 -4690 {
lab=#net29}
N 6500 -4710 6520 -4710 {
lab=colon_n[14]}
N 6500 -4730 6520 -4730 {
lab=col_n[14]}
N 6320 -4590 6320 -4580 {
lab=VSS}
N 6320 -4820 6320 -4810 {
lab=VDD}
N 6660 -4590 6670 -4600 {
lab=row_n[21]}
N 6670 -4800 6670 -4600 {
lab=row_n[21]}
N 6660 -4810 6670 -4800 {
lab=row_n[21]}
N 6660 -4590 6660 -4570 {
lab=row_n[21]}
N 6660 -4830 6660 -4810 {
lab=row_n[21]}
N 6540 -4730 6550 -4740 {
lab=col_n[14]}
N 6550 -4740 6750 -4740 {
lab=col_n[14]}
N 6750 -4740 6760 -4730 {
lab=col_n[14]}
N 6540 -4710 6550 -4720 {
lab=colon_n[14]}
N 6550 -4720 6750 -4720 {
lab=colon_n[14]}
N 6750 -4720 6760 -4710 {
lab=colon_n[14]}
N 6540 -4690 6550 -4700 {
lab=#net29}
N 6550 -4700 6750 -4700 {
lab=#net29}
N 6750 -4700 6760 -4690 {
lab=#net29}
N 6540 -4670 6550 -4680 {
lab=#net30}
N 6550 -4680 6750 -4680 {
lab=#net30}
N 6750 -4680 6760 -4670 {
lab=#net30}
N 6600 -4830 6600 -4810 {
lab=vcom}
N 6640 -4830 6640 -4810 {
lab=ctop}
N 6520 -4730 6540 -4730 {
lab=col_n[14]}
N 6520 -4710 6540 -4710 {
lab=colon_n[14]}
N 6520 -4690 6540 -4690 {
lab=#net29}
N 6520 -4670 6540 -4670 {
lab=#net30}
N 6760 -4670 6780 -4670 {
lab=#net30}
N 6760 -4690 6780 -4690 {
lab=#net29}
N 6760 -4710 6780 -4710 {
lab=colon_n[14]}
N 6760 -4730 6780 -4730 {
lab=col_n[14]}
N 6580 -4590 6580 -4580 {
lab=VSS}
N 6580 -4820 6580 -4810 {
lab=VDD}
N 6920 -4590 6930 -4600 {
lab=row_n[22]}
N 6930 -4800 6930 -4600 {
lab=row_n[22]}
N 6920 -4810 6930 -4800 {
lab=row_n[22]}
N 6920 -4590 6920 -4570 {
lab=row_n[22]}
N 6920 -4830 6920 -4810 {
lab=row_n[22]}
N 6800 -4730 6810 -4740 {
lab=col_n[14]}
N 6810 -4740 7010 -4740 {
lab=col_n[14]}
N 7010 -4740 7020 -4730 {
lab=col_n[14]}
N 6800 -4710 6810 -4720 {
lab=colon_n[14]}
N 6810 -4720 7010 -4720 {
lab=colon_n[14]}
N 7010 -4720 7020 -4710 {
lab=colon_n[14]}
N 6800 -4690 6810 -4700 {
lab=#net29}
N 6810 -4700 7010 -4700 {
lab=#net29}
N 7010 -4700 7020 -4690 {
lab=#net29}
N 6800 -4670 6810 -4680 {
lab=#net30}
N 6810 -4680 7010 -4680 {
lab=#net30}
N 7010 -4680 7020 -4670 {
lab=#net30}
N 6860 -4830 6860 -4810 {
lab=vcom}
N 6900 -4830 6900 -4810 {
lab=ctop}
N 6780 -4730 6800 -4730 {
lab=col_n[14]}
N 6780 -4710 6800 -4710 {
lab=colon_n[14]}
N 6780 -4690 6800 -4690 {
lab=#net29}
N 6780 -4670 6800 -4670 {
lab=#net30}
N 7020 -4670 7040 -4670 {
lab=#net30}
N 7020 -4690 7040 -4690 {
lab=#net29}
N 7020 -4710 7040 -4710 {
lab=colon_n[14]}
N 7020 -4730 7040 -4730 {
lab=col_n[14]}
N 6840 -4590 6840 -4580 {
lab=VSS}
N 6840 -4820 6840 -4810 {
lab=VDD}
N 7180 -4590 7190 -4600 {
lab=row_n[23]}
N 7190 -4800 7190 -4600 {
lab=row_n[23]}
N 7180 -4810 7190 -4800 {
lab=row_n[23]}
N 7180 -4590 7180 -4570 {
lab=row_n[23]}
N 7180 -4830 7180 -4810 {
lab=row_n[23]}
N 7060 -4730 7070 -4740 {
lab=col_n[14]}
N 7070 -4740 7270 -4740 {
lab=col_n[14]}
N 7270 -4740 7280 -4730 {
lab=col_n[14]}
N 7060 -4710 7070 -4720 {
lab=colon_n[14]}
N 7070 -4720 7270 -4720 {
lab=colon_n[14]}
N 7270 -4720 7280 -4710 {
lab=colon_n[14]}
N 7060 -4690 7070 -4700 {
lab=#net29}
N 7070 -4700 7270 -4700 {
lab=#net29}
N 7270 -4700 7280 -4690 {
lab=#net29}
N 7060 -4670 7070 -4680 {
lab=#net30}
N 7070 -4680 7270 -4680 {
lab=#net30}
N 7270 -4680 7280 -4670 {
lab=#net30}
N 7120 -4830 7120 -4810 {
lab=vcom}
N 7160 -4830 7160 -4810 {
lab=ctop}
N 7040 -4730 7060 -4730 {
lab=col_n[14]}
N 7040 -4710 7060 -4710 {
lab=colon_n[14]}
N 7040 -4690 7060 -4690 {
lab=#net29}
N 7040 -4670 7060 -4670 {
lab=#net30}
N 7280 -4670 7300 -4670 {
lab=#net30}
N 7280 -4690 7300 -4690 {
lab=#net29}
N 7280 -4710 7300 -4710 {
lab=colon_n[14]}
N 7280 -4730 7300 -4730 {
lab=col_n[14]}
N 7100 -4590 7100 -4580 {
lab=VSS}
N 7100 -4820 7100 -4810 {
lab=VDD}
N 7440 -4590 7450 -4600 {
lab=row_n[24]}
N 7450 -4800 7450 -4600 {
lab=row_n[24]}
N 7440 -4810 7450 -4800 {
lab=row_n[24]}
N 7440 -4590 7440 -4570 {
lab=row_n[24]}
N 7440 -4830 7440 -4810 {
lab=row_n[24]}
N 7320 -4730 7330 -4740 {
lab=col_n[14]}
N 7330 -4740 7530 -4740 {
lab=col_n[14]}
N 7530 -4740 7540 -4730 {
lab=col_n[14]}
N 7320 -4710 7330 -4720 {
lab=colon_n[14]}
N 7330 -4720 7530 -4720 {
lab=colon_n[14]}
N 7530 -4720 7540 -4710 {
lab=colon_n[14]}
N 7320 -4690 7330 -4700 {
lab=#net29}
N 7330 -4700 7530 -4700 {
lab=#net29}
N 7530 -4700 7540 -4690 {
lab=#net29}
N 7320 -4670 7330 -4680 {
lab=#net30}
N 7330 -4680 7530 -4680 {
lab=#net30}
N 7530 -4680 7540 -4670 {
lab=#net30}
N 7380 -4830 7380 -4810 {
lab=vcom}
N 7420 -4830 7420 -4810 {
lab=ctop}
N 7300 -4730 7320 -4730 {
lab=col_n[14]}
N 7300 -4710 7320 -4710 {
lab=colon_n[14]}
N 7300 -4690 7320 -4690 {
lab=#net29}
N 7300 -4670 7320 -4670 {
lab=#net30}
N 7540 -4670 7560 -4670 {
lab=#net30}
N 7540 -4690 7560 -4690 {
lab=#net29}
N 7540 -4710 7560 -4710 {
lab=colon_n[14]}
N 7540 -4730 7560 -4730 {
lab=col_n[14]}
N 7360 -4590 7360 -4580 {
lab=VSS}
N 7360 -4820 7360 -4810 {
lab=VDD}
N 7700 -4590 7710 -4600 {
lab=row_n[25]}
N 7710 -4800 7710 -4600 {
lab=row_n[25]}
N 7700 -4810 7710 -4800 {
lab=row_n[25]}
N 7700 -4590 7700 -4570 {
lab=row_n[25]}
N 7700 -4830 7700 -4810 {
lab=row_n[25]}
N 7580 -4730 7590 -4740 {
lab=col_n[14]}
N 7590 -4740 7790 -4740 {
lab=col_n[14]}
N 7790 -4740 7800 -4730 {
lab=col_n[14]}
N 7580 -4710 7590 -4720 {
lab=colon_n[14]}
N 7590 -4720 7790 -4720 {
lab=colon_n[14]}
N 7790 -4720 7800 -4710 {
lab=colon_n[14]}
N 7580 -4690 7590 -4700 {
lab=#net29}
N 7590 -4700 7790 -4700 {
lab=#net29}
N 7790 -4700 7800 -4690 {
lab=#net29}
N 7580 -4670 7590 -4680 {
lab=#net30}
N 7590 -4680 7790 -4680 {
lab=#net30}
N 7790 -4680 7800 -4670 {
lab=#net30}
N 7640 -4830 7640 -4810 {
lab=vcom}
N 7680 -4830 7680 -4810 {
lab=ctop}
N 7560 -4730 7580 -4730 {
lab=col_n[14]}
N 7560 -4710 7580 -4710 {
lab=colon_n[14]}
N 7560 -4690 7580 -4690 {
lab=#net29}
N 7560 -4670 7580 -4670 {
lab=#net30}
N 7800 -4670 7820 -4670 {
lab=#net30}
N 7800 -4690 7820 -4690 {
lab=#net29}
N 7800 -4710 7820 -4710 {
lab=colon_n[14]}
N 7800 -4730 7820 -4730 {
lab=col_n[14]}
N 7620 -4590 7620 -4580 {
lab=VSS}
N 7620 -4820 7620 -4810 {
lab=VDD}
N 7960 -4590 7970 -4600 {
lab=row_n[26]}
N 7970 -4800 7970 -4600 {
lab=row_n[26]}
N 7960 -4810 7970 -4800 {
lab=row_n[26]}
N 7960 -4590 7960 -4570 {
lab=row_n[26]}
N 7960 -4830 7960 -4810 {
lab=row_n[26]}
N 7840 -4730 7850 -4740 {
lab=col_n[14]}
N 7850 -4740 8050 -4740 {
lab=col_n[14]}
N 8050 -4740 8060 -4730 {
lab=col_n[14]}
N 7840 -4710 7850 -4720 {
lab=colon_n[14]}
N 7850 -4720 8050 -4720 {
lab=colon_n[14]}
N 8050 -4720 8060 -4710 {
lab=colon_n[14]}
N 7840 -4690 7850 -4700 {
lab=#net29}
N 7850 -4700 8050 -4700 {
lab=#net29}
N 8050 -4700 8060 -4690 {
lab=#net29}
N 7840 -4670 7850 -4680 {
lab=#net30}
N 7850 -4680 8050 -4680 {
lab=#net30}
N 8050 -4680 8060 -4670 {
lab=#net30}
N 7900 -4830 7900 -4810 {
lab=vcom}
N 7940 -4830 7940 -4810 {
lab=ctop}
N 7820 -4730 7840 -4730 {
lab=col_n[14]}
N 7820 -4710 7840 -4710 {
lab=colon_n[14]}
N 7820 -4690 7840 -4690 {
lab=#net29}
N 7820 -4670 7840 -4670 {
lab=#net30}
N 8060 -4670 8080 -4670 {
lab=#net30}
N 8060 -4690 8080 -4690 {
lab=#net29}
N 8060 -4710 8080 -4710 {
lab=colon_n[14]}
N 8060 -4730 8080 -4730 {
lab=col_n[14]}
N 7880 -4590 7880 -4580 {
lab=VSS}
N 7880 -4820 7880 -4810 {
lab=VDD}
N 8220 -4590 8230 -4600 {
lab=row_n[27]}
N 8230 -4800 8230 -4600 {
lab=row_n[27]}
N 8220 -4810 8230 -4800 {
lab=row_n[27]}
N 8220 -4590 8220 -4570 {
lab=row_n[27]}
N 8220 -4830 8220 -4810 {
lab=row_n[27]}
N 8100 -4730 8110 -4740 {
lab=col_n[14]}
N 8110 -4740 8310 -4740 {
lab=col_n[14]}
N 8310 -4740 8320 -4730 {
lab=col_n[14]}
N 8100 -4710 8110 -4720 {
lab=colon_n[14]}
N 8110 -4720 8310 -4720 {
lab=colon_n[14]}
N 8310 -4720 8320 -4710 {
lab=colon_n[14]}
N 8100 -4690 8110 -4700 {
lab=#net29}
N 8110 -4700 8310 -4700 {
lab=#net29}
N 8310 -4700 8320 -4690 {
lab=#net29}
N 8100 -4670 8110 -4680 {
lab=#net30}
N 8110 -4680 8310 -4680 {
lab=#net30}
N 8310 -4680 8320 -4670 {
lab=#net30}
N 8160 -4830 8160 -4810 {
lab=vcom}
N 8200 -4830 8200 -4810 {
lab=ctop}
N 8080 -4730 8100 -4730 {
lab=col_n[14]}
N 8080 -4710 8100 -4710 {
lab=colon_n[14]}
N 8080 -4690 8100 -4690 {
lab=#net29}
N 8080 -4670 8100 -4670 {
lab=#net30}
N 8320 -4670 8340 -4670 {
lab=#net30}
N 8320 -4690 8340 -4690 {
lab=#net29}
N 8320 -4710 8340 -4710 {
lab=colon_n[14]}
N 8320 -4730 8340 -4730 {
lab=col_n[14]}
N 8140 -4590 8140 -4580 {
lab=VSS}
N 8140 -4820 8140 -4810 {
lab=VDD}
N 8480 -4590 8490 -4600 {
lab=row_n[28]}
N 8490 -4800 8490 -4600 {
lab=row_n[28]}
N 8480 -4810 8490 -4800 {
lab=row_n[28]}
N 8480 -4590 8480 -4570 {
lab=row_n[28]}
N 8480 -4830 8480 -4810 {
lab=row_n[28]}
N 8360 -4730 8370 -4740 {
lab=col_n[14]}
N 8370 -4740 8570 -4740 {
lab=col_n[14]}
N 8570 -4740 8580 -4730 {
lab=col_n[14]}
N 8360 -4710 8370 -4720 {
lab=colon_n[14]}
N 8370 -4720 8570 -4720 {
lab=colon_n[14]}
N 8570 -4720 8580 -4710 {
lab=colon_n[14]}
N 8360 -4690 8370 -4700 {
lab=#net29}
N 8370 -4700 8570 -4700 {
lab=#net29}
N 8570 -4700 8580 -4690 {
lab=#net29}
N 8360 -4670 8370 -4680 {
lab=#net30}
N 8370 -4680 8570 -4680 {
lab=#net30}
N 8570 -4680 8580 -4670 {
lab=#net30}
N 8420 -4830 8420 -4810 {
lab=vcom}
N 8460 -4830 8460 -4810 {
lab=ctop}
N 8340 -4730 8360 -4730 {
lab=col_n[14]}
N 8340 -4710 8360 -4710 {
lab=colon_n[14]}
N 8340 -4690 8360 -4690 {
lab=#net29}
N 8340 -4670 8360 -4670 {
lab=#net30}
N 8580 -4670 8600 -4670 {
lab=#net30}
N 8580 -4690 8600 -4690 {
lab=#net29}
N 8580 -4710 8600 -4710 {
lab=colon_n[14]}
N 8580 -4730 8600 -4730 {
lab=col_n[14]}
N 8400 -4590 8400 -4580 {
lab=VSS}
N 8400 -4820 8400 -4810 {
lab=VDD}
N 8740 -4590 8750 -4600 {
lab=row_n[29]}
N 8750 -4800 8750 -4600 {
lab=row_n[29]}
N 8740 -4810 8750 -4800 {
lab=row_n[29]}
N 8740 -4590 8740 -4570 {
lab=row_n[29]}
N 8740 -4830 8740 -4810 {
lab=row_n[29]}
N 8620 -4730 8630 -4740 {
lab=col_n[14]}
N 8630 -4740 8830 -4740 {
lab=col_n[14]}
N 8830 -4740 8840 -4730 {
lab=col_n[14]}
N 8620 -4710 8630 -4720 {
lab=colon_n[14]}
N 8630 -4720 8830 -4720 {
lab=colon_n[14]}
N 8830 -4720 8840 -4710 {
lab=colon_n[14]}
N 8620 -4690 8630 -4700 {
lab=#net29}
N 8630 -4700 8830 -4700 {
lab=#net29}
N 8830 -4700 8840 -4690 {
lab=#net29}
N 8620 -4670 8630 -4680 {
lab=#net30}
N 8630 -4680 8830 -4680 {
lab=#net30}
N 8830 -4680 8840 -4670 {
lab=#net30}
N 8680 -4830 8680 -4810 {
lab=vcom}
N 8720 -4830 8720 -4810 {
lab=ctop}
N 8600 -4730 8620 -4730 {
lab=col_n[14]}
N 8600 -4710 8620 -4710 {
lab=colon_n[14]}
N 8600 -4690 8620 -4690 {
lab=#net29}
N 8600 -4670 8620 -4670 {
lab=#net30}
N 8840 -4670 8860 -4670 {
lab=#net30}
N 8840 -4690 8860 -4690 {
lab=#net29}
N 8840 -4710 8860 -4710 {
lab=colon_n[14]}
N 8840 -4730 8860 -4730 {
lab=col_n[14]}
N 8660 -4590 8660 -4580 {
lab=VSS}
N 8660 -4820 8660 -4810 {
lab=VDD}
N 9000 -4590 9010 -4600 {
lab=row_n[30]}
N 9010 -4800 9010 -4600 {
lab=row_n[30]}
N 9000 -4810 9010 -4800 {
lab=row_n[30]}
N 9000 -4590 9000 -4570 {
lab=row_n[30]}
N 9000 -4830 9000 -4810 {
lab=row_n[30]}
N 8880 -4730 8890 -4740 {
lab=col_n[14]}
N 8890 -4740 9090 -4740 {
lab=col_n[14]}
N 9090 -4740 9100 -4730 {
lab=col_n[14]}
N 8880 -4710 8890 -4720 {
lab=colon_n[14]}
N 8890 -4720 9090 -4720 {
lab=colon_n[14]}
N 9090 -4720 9100 -4710 {
lab=colon_n[14]}
N 8880 -4690 8890 -4700 {
lab=#net29}
N 8890 -4700 9090 -4700 {
lab=#net29}
N 9090 -4700 9100 -4690 {
lab=#net29}
N 8880 -4670 8890 -4680 {
lab=#net30}
N 8890 -4680 9090 -4680 {
lab=#net30}
N 9090 -4680 9100 -4670 {
lab=#net30}
N 8940 -4830 8940 -4810 {
lab=vcom}
N 8980 -4830 8980 -4810 {
lab=ctop}
N 8860 -4730 8880 -4730 {
lab=col_n[14]}
N 8860 -4710 8880 -4710 {
lab=colon_n[14]}
N 8860 -4690 8880 -4690 {
lab=#net29}
N 8860 -4670 8880 -4670 {
lab=#net30}
N 9100 -4670 9120 -4670 {
lab=#net30}
N 9100 -4690 9120 -4690 {
lab=#net29}
N 9100 -4710 9120 -4710 {
lab=colon_n[14]}
N 9100 -4730 9120 -4730 {
lab=col_n[14]}
N 8920 -4590 8920 -4580 {
lab=VSS}
N 8920 -4820 8920 -4810 {
lab=VDD}
N 9260 -4590 9270 -4600 {
lab=row_n[31]}
N 9270 -4800 9270 -4600 {
lab=row_n[31]}
N 9260 -4810 9270 -4800 {
lab=row_n[31]}
N 9260 -4590 9260 -4570 {
lab=row_n[31]}
N 9260 -4830 9260 -4810 {
lab=row_n[31]}
N 9140 -4730 9150 -4740 {
lab=col_n[14]}
N 9150 -4740 9350 -4740 {
lab=col_n[14]}
N 9350 -4740 9360 -4730 {
lab=col_n[14]}
N 9140 -4710 9150 -4720 {
lab=colon_n[14]}
N 9150 -4720 9350 -4720 {
lab=colon_n[14]}
N 9350 -4720 9360 -4710 {
lab=colon_n[14]}
N 9140 -4690 9150 -4700 {
lab=#net29}
N 9150 -4700 9350 -4700 {
lab=#net29}
N 9350 -4700 9360 -4690 {
lab=#net29}
N 9140 -4670 9150 -4680 {
lab=#net30}
N 9150 -4680 9350 -4680 {
lab=#net30}
N 9350 -4680 9360 -4670 {
lab=#net30}
N 9200 -4830 9200 -4810 {
lab=vcom}
N 9240 -4830 9240 -4810 {
lab=ctop}
N 9120 -4730 9140 -4730 {
lab=col_n[14]}
N 9120 -4710 9140 -4710 {
lab=colon_n[14]}
N 9120 -4690 9140 -4690 {
lab=#net29}
N 9120 -4670 9140 -4670 {
lab=#net30}
N 9360 -4670 9380 -4670 {
lab=#net30}
N 9360 -4690 9380 -4690 {
lab=#net29}
N 9360 -4710 9380 -4710 {
lab=colon_n[14]}
N 9360 -4730 9380 -4730 {
lab=col_n[14]}
N 9180 -4590 9180 -4580 {
lab=VSS}
N 9180 -4820 9180 -4810 {
lab=VDD}
N 1200 -4850 1210 -4860 {
lab=row_n[0]}
N 1210 -5060 1210 -4860 {
lab=row_n[0]}
N 1200 -5070 1210 -5060 {
lab=row_n[0]}
N 1200 -4850 1200 -4830 {
lab=row_n[0]}
N 1200 -5090 1200 -5070 {
lab=row_n[0]}
N 1080 -4990 1090 -5000 {
lab=col_n[15]}
N 1090 -5000 1290 -5000 {
lab=col_n[15]}
N 1290 -5000 1300 -4990 {
lab=col_n[15]}
N 1080 -4970 1090 -4980 {
lab=colon_n[15]}
N 1090 -4980 1290 -4980 {
lab=colon_n[15]}
N 1290 -4980 1300 -4970 {
lab=colon_n[15]}
N 1080 -4950 1090 -4960 {
lab=#net31}
N 1090 -4960 1290 -4960 {
lab=#net31}
N 1290 -4960 1300 -4950 {
lab=#net31}
N 1080 -4930 1090 -4940 {
lab=#net32}
N 1090 -4940 1290 -4940 {
lab=#net32}
N 1290 -4940 1300 -4930 {
lab=#net32}
N 1140 -5090 1140 -5070 {
lab=vcom}
N 1180 -5090 1180 -5070 {
lab=ctop}
N 1060 -4990 1080 -4990 {
lab=col_n[15]}
N 1060 -4970 1080 -4970 {
lab=colon_n[15]}
N 1060 -4950 1080 -4950 {
lab=#net31}
N 1060 -4930 1080 -4930 {
lab=#net32}
N 1300 -4930 1320 -4930 {
lab=#net32}
N 1300 -4950 1320 -4950 {
lab=#net31}
N 1300 -4970 1320 -4970 {
lab=colon_n[15]}
N 1300 -4990 1320 -4990 {
lab=col_n[15]}
N 1120 -4850 1120 -4840 {
lab=VSS}
N 1120 -5080 1120 -5070 {
lab=VDD}
N 1460 -4850 1470 -4860 {
lab=row_n[1]}
N 1470 -5060 1470 -4860 {
lab=row_n[1]}
N 1460 -5070 1470 -5060 {
lab=row_n[1]}
N 1460 -4850 1460 -4830 {
lab=row_n[1]}
N 1460 -5090 1460 -5070 {
lab=row_n[1]}
N 1340 -4990 1350 -5000 {
lab=col_n[15]}
N 1350 -5000 1550 -5000 {
lab=col_n[15]}
N 1550 -5000 1560 -4990 {
lab=col_n[15]}
N 1340 -4970 1350 -4980 {
lab=colon_n[15]}
N 1350 -4980 1550 -4980 {
lab=colon_n[15]}
N 1550 -4980 1560 -4970 {
lab=colon_n[15]}
N 1340 -4950 1350 -4960 {
lab=#net31}
N 1350 -4960 1550 -4960 {
lab=#net31}
N 1550 -4960 1560 -4950 {
lab=#net31}
N 1340 -4930 1350 -4940 {
lab=#net32}
N 1350 -4940 1550 -4940 {
lab=#net32}
N 1550 -4940 1560 -4930 {
lab=#net32}
N 1400 -5090 1400 -5070 {
lab=vcom}
N 1440 -5090 1440 -5070 {
lab=ctop}
N 1320 -4990 1340 -4990 {
lab=col_n[15]}
N 1320 -4970 1340 -4970 {
lab=colon_n[15]}
N 1320 -4950 1340 -4950 {
lab=#net31}
N 1320 -4930 1340 -4930 {
lab=#net32}
N 1560 -4930 1580 -4930 {
lab=#net32}
N 1560 -4950 1580 -4950 {
lab=#net31}
N 1560 -4970 1580 -4970 {
lab=colon_n[15]}
N 1560 -4990 1580 -4990 {
lab=col_n[15]}
N 1380 -4850 1380 -4840 {
lab=VSS}
N 1380 -5080 1380 -5070 {
lab=VDD}
N 1720 -4850 1730 -4860 {
lab=row_n[2]}
N 1730 -5060 1730 -4860 {
lab=row_n[2]}
N 1720 -5070 1730 -5060 {
lab=row_n[2]}
N 1720 -4850 1720 -4830 {
lab=row_n[2]}
N 1720 -5090 1720 -5070 {
lab=row_n[2]}
N 1600 -4990 1610 -5000 {
lab=col_n[15]}
N 1610 -5000 1810 -5000 {
lab=col_n[15]}
N 1810 -5000 1820 -4990 {
lab=col_n[15]}
N 1600 -4970 1610 -4980 {
lab=colon_n[15]}
N 1610 -4980 1810 -4980 {
lab=colon_n[15]}
N 1810 -4980 1820 -4970 {
lab=colon_n[15]}
N 1600 -4950 1610 -4960 {
lab=#net31}
N 1610 -4960 1810 -4960 {
lab=#net31}
N 1810 -4960 1820 -4950 {
lab=#net31}
N 1600 -4930 1610 -4940 {
lab=#net32}
N 1610 -4940 1810 -4940 {
lab=#net32}
N 1810 -4940 1820 -4930 {
lab=#net32}
N 1660 -5090 1660 -5070 {
lab=vcom}
N 1700 -5090 1700 -5070 {
lab=ctop}
N 1580 -4990 1600 -4990 {
lab=col_n[15]}
N 1580 -4970 1600 -4970 {
lab=colon_n[15]}
N 1580 -4950 1600 -4950 {
lab=#net31}
N 1580 -4930 1600 -4930 {
lab=#net32}
N 1820 -4930 1840 -4930 {
lab=#net32}
N 1820 -4950 1840 -4950 {
lab=#net31}
N 1820 -4970 1840 -4970 {
lab=colon_n[15]}
N 1820 -4990 1840 -4990 {
lab=col_n[15]}
N 1640 -4850 1640 -4840 {
lab=VSS}
N 1640 -5080 1640 -5070 {
lab=VDD}
N 1980 -4850 1990 -4860 {
lab=row_n[3]}
N 1990 -5060 1990 -4860 {
lab=row_n[3]}
N 1980 -5070 1990 -5060 {
lab=row_n[3]}
N 1980 -4850 1980 -4830 {
lab=row_n[3]}
N 1980 -5090 1980 -5070 {
lab=row_n[3]}
N 1860 -4990 1870 -5000 {
lab=col_n[15]}
N 1870 -5000 2070 -5000 {
lab=col_n[15]}
N 2070 -5000 2080 -4990 {
lab=col_n[15]}
N 1860 -4970 1870 -4980 {
lab=colon_n[15]}
N 1870 -4980 2070 -4980 {
lab=colon_n[15]}
N 2070 -4980 2080 -4970 {
lab=colon_n[15]}
N 1860 -4950 1870 -4960 {
lab=#net31}
N 1870 -4960 2070 -4960 {
lab=#net31}
N 2070 -4960 2080 -4950 {
lab=#net31}
N 1860 -4930 1870 -4940 {
lab=#net32}
N 1870 -4940 2070 -4940 {
lab=#net32}
N 2070 -4940 2080 -4930 {
lab=#net32}
N 1920 -5090 1920 -5070 {
lab=vcom}
N 1960 -5090 1960 -5070 {
lab=ctop}
N 1840 -4990 1860 -4990 {
lab=col_n[15]}
N 1840 -4970 1860 -4970 {
lab=colon_n[15]}
N 1840 -4950 1860 -4950 {
lab=#net31}
N 1840 -4930 1860 -4930 {
lab=#net32}
N 2080 -4930 2100 -4930 {
lab=#net32}
N 2080 -4950 2100 -4950 {
lab=#net31}
N 2080 -4970 2100 -4970 {
lab=colon_n[15]}
N 2080 -4990 2100 -4990 {
lab=col_n[15]}
N 1900 -4850 1900 -4840 {
lab=VSS}
N 1900 -5080 1900 -5070 {
lab=VDD}
N 2240 -4850 2250 -4860 {
lab=row_n[4]}
N 2250 -5060 2250 -4860 {
lab=row_n[4]}
N 2240 -5070 2250 -5060 {
lab=row_n[4]}
N 2240 -4850 2240 -4830 {
lab=row_n[4]}
N 2240 -5090 2240 -5070 {
lab=row_n[4]}
N 2120 -4990 2130 -5000 {
lab=col_n[15]}
N 2130 -5000 2330 -5000 {
lab=col_n[15]}
N 2330 -5000 2340 -4990 {
lab=col_n[15]}
N 2120 -4970 2130 -4980 {
lab=colon_n[15]}
N 2130 -4980 2330 -4980 {
lab=colon_n[15]}
N 2330 -4980 2340 -4970 {
lab=colon_n[15]}
N 2120 -4950 2130 -4960 {
lab=#net31}
N 2130 -4960 2330 -4960 {
lab=#net31}
N 2330 -4960 2340 -4950 {
lab=#net31}
N 2120 -4930 2130 -4940 {
lab=#net32}
N 2130 -4940 2330 -4940 {
lab=#net32}
N 2330 -4940 2340 -4930 {
lab=#net32}
N 2180 -5090 2180 -5070 {
lab=vcom}
N 2220 -5090 2220 -5070 {
lab=ctop}
N 2100 -4990 2120 -4990 {
lab=col_n[15]}
N 2100 -4970 2120 -4970 {
lab=colon_n[15]}
N 2100 -4950 2120 -4950 {
lab=#net31}
N 2100 -4930 2120 -4930 {
lab=#net32}
N 2340 -4930 2360 -4930 {
lab=#net32}
N 2340 -4950 2360 -4950 {
lab=#net31}
N 2340 -4970 2360 -4970 {
lab=colon_n[15]}
N 2340 -4990 2360 -4990 {
lab=col_n[15]}
N 2160 -4850 2160 -4840 {
lab=VSS}
N 2160 -5080 2160 -5070 {
lab=VDD}
N 2500 -4850 2510 -4860 {
lab=row_n[5]}
N 2510 -5060 2510 -4860 {
lab=row_n[5]}
N 2500 -5070 2510 -5060 {
lab=row_n[5]}
N 2500 -4850 2500 -4830 {
lab=row_n[5]}
N 2500 -5090 2500 -5070 {
lab=row_n[5]}
N 2380 -4990 2390 -5000 {
lab=col_n[15]}
N 2390 -5000 2590 -5000 {
lab=col_n[15]}
N 2590 -5000 2600 -4990 {
lab=col_n[15]}
N 2380 -4970 2390 -4980 {
lab=colon_n[15]}
N 2390 -4980 2590 -4980 {
lab=colon_n[15]}
N 2590 -4980 2600 -4970 {
lab=colon_n[15]}
N 2380 -4950 2390 -4960 {
lab=#net31}
N 2390 -4960 2590 -4960 {
lab=#net31}
N 2590 -4960 2600 -4950 {
lab=#net31}
N 2380 -4930 2390 -4940 {
lab=#net32}
N 2390 -4940 2590 -4940 {
lab=#net32}
N 2590 -4940 2600 -4930 {
lab=#net32}
N 2440 -5090 2440 -5070 {
lab=vcom}
N 2480 -5090 2480 -5070 {
lab=ctop}
N 2360 -4990 2380 -4990 {
lab=col_n[15]}
N 2360 -4970 2380 -4970 {
lab=colon_n[15]}
N 2360 -4950 2380 -4950 {
lab=#net31}
N 2360 -4930 2380 -4930 {
lab=#net32}
N 2600 -4930 2620 -4930 {
lab=#net32}
N 2600 -4950 2620 -4950 {
lab=#net31}
N 2600 -4970 2620 -4970 {
lab=colon_n[15]}
N 2600 -4990 2620 -4990 {
lab=col_n[15]}
N 2420 -4850 2420 -4840 {
lab=VSS}
N 2420 -5080 2420 -5070 {
lab=VDD}
N 2760 -4850 2770 -4860 {
lab=row_n[6]}
N 2770 -5060 2770 -4860 {
lab=row_n[6]}
N 2760 -5070 2770 -5060 {
lab=row_n[6]}
N 2760 -4850 2760 -4830 {
lab=row_n[6]}
N 2760 -5090 2760 -5070 {
lab=row_n[6]}
N 2640 -4990 2650 -5000 {
lab=col_n[15]}
N 2650 -5000 2850 -5000 {
lab=col_n[15]}
N 2850 -5000 2860 -4990 {
lab=col_n[15]}
N 2640 -4970 2650 -4980 {
lab=colon_n[15]}
N 2650 -4980 2850 -4980 {
lab=colon_n[15]}
N 2850 -4980 2860 -4970 {
lab=colon_n[15]}
N 2640 -4950 2650 -4960 {
lab=#net31}
N 2650 -4960 2850 -4960 {
lab=#net31}
N 2850 -4960 2860 -4950 {
lab=#net31}
N 2640 -4930 2650 -4940 {
lab=#net32}
N 2650 -4940 2850 -4940 {
lab=#net32}
N 2850 -4940 2860 -4930 {
lab=#net32}
N 2700 -5090 2700 -5070 {
lab=vcom}
N 2740 -5090 2740 -5070 {
lab=ctop}
N 2620 -4990 2640 -4990 {
lab=col_n[15]}
N 2620 -4970 2640 -4970 {
lab=colon_n[15]}
N 2620 -4950 2640 -4950 {
lab=#net31}
N 2620 -4930 2640 -4930 {
lab=#net32}
N 2860 -4930 2880 -4930 {
lab=#net32}
N 2860 -4950 2880 -4950 {
lab=#net31}
N 2860 -4970 2880 -4970 {
lab=colon_n[15]}
N 2860 -4990 2880 -4990 {
lab=col_n[15]}
N 2680 -4850 2680 -4840 {
lab=VSS}
N 2680 -5080 2680 -5070 {
lab=VDD}
N 3020 -4850 3030 -4860 {
lab=row_n[7]}
N 3030 -5060 3030 -4860 {
lab=row_n[7]}
N 3020 -5070 3030 -5060 {
lab=row_n[7]}
N 3020 -4850 3020 -4830 {
lab=row_n[7]}
N 3020 -5090 3020 -5070 {
lab=row_n[7]}
N 2900 -4990 2910 -5000 {
lab=col_n[15]}
N 2910 -5000 3110 -5000 {
lab=col_n[15]}
N 3110 -5000 3120 -4990 {
lab=col_n[15]}
N 2900 -4970 2910 -4980 {
lab=colon_n[15]}
N 2910 -4980 3110 -4980 {
lab=colon_n[15]}
N 3110 -4980 3120 -4970 {
lab=colon_n[15]}
N 2900 -4950 2910 -4960 {
lab=#net31}
N 2910 -4960 3110 -4960 {
lab=#net31}
N 3110 -4960 3120 -4950 {
lab=#net31}
N 2900 -4930 2910 -4940 {
lab=#net32}
N 2910 -4940 3110 -4940 {
lab=#net32}
N 3110 -4940 3120 -4930 {
lab=#net32}
N 2960 -5090 2960 -5070 {
lab=vcom}
N 3000 -5090 3000 -5070 {
lab=ctop}
N 2880 -4990 2900 -4990 {
lab=col_n[15]}
N 2880 -4970 2900 -4970 {
lab=colon_n[15]}
N 2880 -4950 2900 -4950 {
lab=#net31}
N 2880 -4930 2900 -4930 {
lab=#net32}
N 3120 -4930 3140 -4930 {
lab=#net32}
N 3120 -4950 3140 -4950 {
lab=#net31}
N 3120 -4970 3140 -4970 {
lab=colon_n[15]}
N 3120 -4990 3140 -4990 {
lab=col_n[15]}
N 2940 -4850 2940 -4840 {
lab=VSS}
N 2940 -5080 2940 -5070 {
lab=VDD}
N 3280 -4850 3290 -4860 {
lab=row_n[8]}
N 3290 -5060 3290 -4860 {
lab=row_n[8]}
N 3280 -5070 3290 -5060 {
lab=row_n[8]}
N 3280 -4850 3280 -4830 {
lab=row_n[8]}
N 3280 -5090 3280 -5070 {
lab=row_n[8]}
N 3160 -4990 3170 -5000 {
lab=col_n[15]}
N 3170 -5000 3370 -5000 {
lab=col_n[15]}
N 3370 -5000 3380 -4990 {
lab=col_n[15]}
N 3160 -4970 3170 -4980 {
lab=colon_n[15]}
N 3170 -4980 3370 -4980 {
lab=colon_n[15]}
N 3370 -4980 3380 -4970 {
lab=colon_n[15]}
N 3160 -4950 3170 -4960 {
lab=#net31}
N 3170 -4960 3370 -4960 {
lab=#net31}
N 3370 -4960 3380 -4950 {
lab=#net31}
N 3160 -4930 3170 -4940 {
lab=#net32}
N 3170 -4940 3370 -4940 {
lab=#net32}
N 3370 -4940 3380 -4930 {
lab=#net32}
N 3220 -5090 3220 -5070 {
lab=vcom}
N 3260 -5090 3260 -5070 {
lab=ctop}
N 3140 -4990 3160 -4990 {
lab=col_n[15]}
N 3140 -4970 3160 -4970 {
lab=colon_n[15]}
N 3140 -4950 3160 -4950 {
lab=#net31}
N 3140 -4930 3160 -4930 {
lab=#net32}
N 3380 -4930 3400 -4930 {
lab=#net32}
N 3380 -4950 3400 -4950 {
lab=#net31}
N 3380 -4970 3400 -4970 {
lab=colon_n[15]}
N 3380 -4990 3400 -4990 {
lab=col_n[15]}
N 3200 -4850 3200 -4840 {
lab=VSS}
N 3200 -5080 3200 -5070 {
lab=VDD}
N 3540 -4850 3550 -4860 {
lab=row_n[9]}
N 3550 -5060 3550 -4860 {
lab=row_n[9]}
N 3540 -5070 3550 -5060 {
lab=row_n[9]}
N 3540 -4850 3540 -4830 {
lab=row_n[9]}
N 3540 -5090 3540 -5070 {
lab=row_n[9]}
N 3420 -4990 3430 -5000 {
lab=col_n[15]}
N 3430 -5000 3630 -5000 {
lab=col_n[15]}
N 3630 -5000 3640 -4990 {
lab=col_n[15]}
N 3420 -4970 3430 -4980 {
lab=colon_n[15]}
N 3430 -4980 3630 -4980 {
lab=colon_n[15]}
N 3630 -4980 3640 -4970 {
lab=colon_n[15]}
N 3420 -4950 3430 -4960 {
lab=#net31}
N 3430 -4960 3630 -4960 {
lab=#net31}
N 3630 -4960 3640 -4950 {
lab=#net31}
N 3420 -4930 3430 -4940 {
lab=#net32}
N 3430 -4940 3630 -4940 {
lab=#net32}
N 3630 -4940 3640 -4930 {
lab=#net32}
N 3480 -5090 3480 -5070 {
lab=vcom}
N 3520 -5090 3520 -5070 {
lab=ctop}
N 3400 -4990 3420 -4990 {
lab=col_n[15]}
N 3400 -4970 3420 -4970 {
lab=colon_n[15]}
N 3400 -4950 3420 -4950 {
lab=#net31}
N 3400 -4930 3420 -4930 {
lab=#net32}
N 3640 -4930 3660 -4930 {
lab=#net32}
N 3640 -4950 3660 -4950 {
lab=#net31}
N 3640 -4970 3660 -4970 {
lab=colon_n[15]}
N 3640 -4990 3660 -4990 {
lab=col_n[15]}
N 3460 -4850 3460 -4840 {
lab=VSS}
N 3460 -5080 3460 -5070 {
lab=VDD}
N 3800 -4850 3810 -4860 {
lab=row_n[10]}
N 3810 -5060 3810 -4860 {
lab=row_n[10]}
N 3800 -5070 3810 -5060 {
lab=row_n[10]}
N 3800 -4850 3800 -4830 {
lab=row_n[10]}
N 3800 -5090 3800 -5070 {
lab=row_n[10]}
N 3680 -4990 3690 -5000 {
lab=col_n[15]}
N 3690 -5000 3890 -5000 {
lab=col_n[15]}
N 3890 -5000 3900 -4990 {
lab=col_n[15]}
N 3680 -4970 3690 -4980 {
lab=colon_n[15]}
N 3690 -4980 3890 -4980 {
lab=colon_n[15]}
N 3890 -4980 3900 -4970 {
lab=colon_n[15]}
N 3680 -4950 3690 -4960 {
lab=#net31}
N 3690 -4960 3890 -4960 {
lab=#net31}
N 3890 -4960 3900 -4950 {
lab=#net31}
N 3680 -4930 3690 -4940 {
lab=#net32}
N 3690 -4940 3890 -4940 {
lab=#net32}
N 3890 -4940 3900 -4930 {
lab=#net32}
N 3740 -5090 3740 -5070 {
lab=vcom}
N 3780 -5090 3780 -5070 {
lab=ctop}
N 3660 -4990 3680 -4990 {
lab=col_n[15]}
N 3660 -4970 3680 -4970 {
lab=colon_n[15]}
N 3660 -4950 3680 -4950 {
lab=#net31}
N 3660 -4930 3680 -4930 {
lab=#net32}
N 3900 -4930 3920 -4930 {
lab=#net32}
N 3900 -4950 3920 -4950 {
lab=#net31}
N 3900 -4970 3920 -4970 {
lab=colon_n[15]}
N 3900 -4990 3920 -4990 {
lab=col_n[15]}
N 3720 -4850 3720 -4840 {
lab=VSS}
N 3720 -5080 3720 -5070 {
lab=VDD}
N 4060 -4850 4070 -4860 {
lab=row_n[11]}
N 4070 -5060 4070 -4860 {
lab=row_n[11]}
N 4060 -5070 4070 -5060 {
lab=row_n[11]}
N 4060 -4850 4060 -4830 {
lab=row_n[11]}
N 4060 -5090 4060 -5070 {
lab=row_n[11]}
N 3940 -4990 3950 -5000 {
lab=col_n[15]}
N 3950 -5000 4150 -5000 {
lab=col_n[15]}
N 4150 -5000 4160 -4990 {
lab=col_n[15]}
N 3940 -4970 3950 -4980 {
lab=colon_n[15]}
N 3950 -4980 4150 -4980 {
lab=colon_n[15]}
N 4150 -4980 4160 -4970 {
lab=colon_n[15]}
N 3940 -4950 3950 -4960 {
lab=#net31}
N 3950 -4960 4150 -4960 {
lab=#net31}
N 4150 -4960 4160 -4950 {
lab=#net31}
N 3940 -4930 3950 -4940 {
lab=#net32}
N 3950 -4940 4150 -4940 {
lab=#net32}
N 4150 -4940 4160 -4930 {
lab=#net32}
N 4000 -5090 4000 -5070 {
lab=vcom}
N 4040 -5090 4040 -5070 {
lab=ctop}
N 3920 -4990 3940 -4990 {
lab=col_n[15]}
N 3920 -4970 3940 -4970 {
lab=colon_n[15]}
N 3920 -4950 3940 -4950 {
lab=#net31}
N 3920 -4930 3940 -4930 {
lab=#net32}
N 4160 -4930 4180 -4930 {
lab=#net32}
N 4160 -4950 4180 -4950 {
lab=#net31}
N 4160 -4970 4180 -4970 {
lab=colon_n[15]}
N 4160 -4990 4180 -4990 {
lab=col_n[15]}
N 3980 -4850 3980 -4840 {
lab=VSS}
N 3980 -5080 3980 -5070 {
lab=VDD}
N 4320 -4850 4330 -4860 {
lab=row_n[12]}
N 4330 -5060 4330 -4860 {
lab=row_n[12]}
N 4320 -5070 4330 -5060 {
lab=row_n[12]}
N 4320 -4850 4320 -4830 {
lab=row_n[12]}
N 4320 -5090 4320 -5070 {
lab=row_n[12]}
N 4200 -4990 4210 -5000 {
lab=col_n[15]}
N 4210 -5000 4410 -5000 {
lab=col_n[15]}
N 4410 -5000 4420 -4990 {
lab=col_n[15]}
N 4200 -4970 4210 -4980 {
lab=colon_n[15]}
N 4210 -4980 4410 -4980 {
lab=colon_n[15]}
N 4410 -4980 4420 -4970 {
lab=colon_n[15]}
N 4200 -4950 4210 -4960 {
lab=#net31}
N 4210 -4960 4410 -4960 {
lab=#net31}
N 4410 -4960 4420 -4950 {
lab=#net31}
N 4200 -4930 4210 -4940 {
lab=#net32}
N 4210 -4940 4410 -4940 {
lab=#net32}
N 4410 -4940 4420 -4930 {
lab=#net32}
N 4260 -5090 4260 -5070 {
lab=vcom}
N 4300 -5090 4300 -5070 {
lab=ctop}
N 4180 -4990 4200 -4990 {
lab=col_n[15]}
N 4180 -4970 4200 -4970 {
lab=colon_n[15]}
N 4180 -4950 4200 -4950 {
lab=#net31}
N 4180 -4930 4200 -4930 {
lab=#net32}
N 4420 -4930 4440 -4930 {
lab=#net32}
N 4420 -4950 4440 -4950 {
lab=#net31}
N 4420 -4970 4440 -4970 {
lab=colon_n[15]}
N 4420 -4990 4440 -4990 {
lab=col_n[15]}
N 4240 -4850 4240 -4840 {
lab=VSS}
N 4240 -5080 4240 -5070 {
lab=VDD}
N 4580 -4850 4590 -4860 {
lab=row_n[13]}
N 4590 -5060 4590 -4860 {
lab=row_n[13]}
N 4580 -5070 4590 -5060 {
lab=row_n[13]}
N 4580 -4850 4580 -4830 {
lab=row_n[13]}
N 4580 -5090 4580 -5070 {
lab=row_n[13]}
N 4460 -4990 4470 -5000 {
lab=col_n[15]}
N 4470 -5000 4670 -5000 {
lab=col_n[15]}
N 4670 -5000 4680 -4990 {
lab=col_n[15]}
N 4460 -4970 4470 -4980 {
lab=colon_n[15]}
N 4470 -4980 4670 -4980 {
lab=colon_n[15]}
N 4670 -4980 4680 -4970 {
lab=colon_n[15]}
N 4460 -4950 4470 -4960 {
lab=#net31}
N 4470 -4960 4670 -4960 {
lab=#net31}
N 4670 -4960 4680 -4950 {
lab=#net31}
N 4460 -4930 4470 -4940 {
lab=#net32}
N 4470 -4940 4670 -4940 {
lab=#net32}
N 4670 -4940 4680 -4930 {
lab=#net32}
N 4520 -5090 4520 -5070 {
lab=vcom}
N 4560 -5090 4560 -5070 {
lab=ctop}
N 4440 -4990 4460 -4990 {
lab=col_n[15]}
N 4440 -4970 4460 -4970 {
lab=colon_n[15]}
N 4440 -4950 4460 -4950 {
lab=#net31}
N 4440 -4930 4460 -4930 {
lab=#net32}
N 4680 -4930 4700 -4930 {
lab=#net32}
N 4680 -4950 4700 -4950 {
lab=#net31}
N 4680 -4970 4700 -4970 {
lab=colon_n[15]}
N 4680 -4990 4700 -4990 {
lab=col_n[15]}
N 4500 -4850 4500 -4840 {
lab=VSS}
N 4500 -5080 4500 -5070 {
lab=VDD}
N 4840 -4850 4850 -4860 {
lab=row_n[14]}
N 4850 -5060 4850 -4860 {
lab=row_n[14]}
N 4840 -5070 4850 -5060 {
lab=row_n[14]}
N 4840 -4850 4840 -4830 {
lab=row_n[14]}
N 4840 -5090 4840 -5070 {
lab=row_n[14]}
N 4720 -4990 4730 -5000 {
lab=col_n[15]}
N 4730 -5000 4930 -5000 {
lab=col_n[15]}
N 4930 -5000 4940 -4990 {
lab=col_n[15]}
N 4720 -4970 4730 -4980 {
lab=colon_n[15]}
N 4730 -4980 4930 -4980 {
lab=colon_n[15]}
N 4930 -4980 4940 -4970 {
lab=colon_n[15]}
N 4720 -4950 4730 -4960 {
lab=#net31}
N 4730 -4960 4930 -4960 {
lab=#net31}
N 4930 -4960 4940 -4950 {
lab=#net31}
N 4720 -4930 4730 -4940 {
lab=#net32}
N 4730 -4940 4930 -4940 {
lab=#net32}
N 4930 -4940 4940 -4930 {
lab=#net32}
N 4780 -5090 4780 -5070 {
lab=vcom}
N 4820 -5090 4820 -5070 {
lab=ctop}
N 4700 -4990 4720 -4990 {
lab=col_n[15]}
N 4700 -4970 4720 -4970 {
lab=colon_n[15]}
N 4700 -4950 4720 -4950 {
lab=#net31}
N 4700 -4930 4720 -4930 {
lab=#net32}
N 4940 -4930 4960 -4930 {
lab=#net32}
N 4940 -4950 4960 -4950 {
lab=#net31}
N 4940 -4970 4960 -4970 {
lab=colon_n[15]}
N 4940 -4990 4960 -4990 {
lab=col_n[15]}
N 4760 -4850 4760 -4840 {
lab=VSS}
N 4760 -5080 4760 -5070 {
lab=VDD}
N 5100 -4850 5110 -4860 {
lab=row_n[15]}
N 5110 -5060 5110 -4860 {
lab=row_n[15]}
N 5100 -5070 5110 -5060 {
lab=row_n[15]}
N 5100 -4850 5100 -4830 {
lab=row_n[15]}
N 5100 -5090 5100 -5070 {
lab=row_n[15]}
N 4980 -4990 4990 -5000 {
lab=col_n[15]}
N 4990 -5000 5190 -5000 {
lab=col_n[15]}
N 5190 -5000 5200 -4990 {
lab=col_n[15]}
N 4980 -4970 4990 -4980 {
lab=colon_n[15]}
N 4990 -4980 5190 -4980 {
lab=colon_n[15]}
N 5190 -4980 5200 -4970 {
lab=colon_n[15]}
N 4980 -4950 4990 -4960 {
lab=#net31}
N 4990 -4960 5190 -4960 {
lab=#net31}
N 5190 -4960 5200 -4950 {
lab=#net31}
N 4980 -4930 4990 -4940 {
lab=#net32}
N 4990 -4940 5190 -4940 {
lab=#net32}
N 5190 -4940 5200 -4930 {
lab=#net32}
N 5040 -5090 5040 -5070 {
lab=vcom}
N 5080 -5090 5080 -5070 {
lab=ctop}
N 4960 -4990 4980 -4990 {
lab=col_n[15]}
N 4960 -4970 4980 -4970 {
lab=colon_n[15]}
N 4960 -4950 4980 -4950 {
lab=#net31}
N 4960 -4930 4980 -4930 {
lab=#net32}
N 5200 -4930 5220 -4930 {
lab=#net32}
N 5200 -4950 5220 -4950 {
lab=#net31}
N 5200 -4970 5220 -4970 {
lab=colon_n[15]}
N 5200 -4990 5220 -4990 {
lab=col_n[15]}
N 5020 -4850 5020 -4840 {
lab=VSS}
N 5020 -5080 5020 -5070 {
lab=VDD}
N 5360 -4850 5370 -4860 {
lab=row_n[16]}
N 5370 -5060 5370 -4860 {
lab=row_n[16]}
N 5360 -5070 5370 -5060 {
lab=row_n[16]}
N 5360 -4850 5360 -4830 {
lab=row_n[16]}
N 5360 -5090 5360 -5070 {
lab=row_n[16]}
N 5240 -4990 5250 -5000 {
lab=col_n[15]}
N 5250 -5000 5450 -5000 {
lab=col_n[15]}
N 5450 -5000 5460 -4990 {
lab=col_n[15]}
N 5240 -4970 5250 -4980 {
lab=colon_n[15]}
N 5250 -4980 5450 -4980 {
lab=colon_n[15]}
N 5450 -4980 5460 -4970 {
lab=colon_n[15]}
N 5240 -4950 5250 -4960 {
lab=#net31}
N 5250 -4960 5450 -4960 {
lab=#net31}
N 5450 -4960 5460 -4950 {
lab=#net31}
N 5240 -4930 5250 -4940 {
lab=#net32}
N 5250 -4940 5450 -4940 {
lab=#net32}
N 5450 -4940 5460 -4930 {
lab=#net32}
N 5300 -5090 5300 -5070 {
lab=vcom}
N 5340 -5090 5340 -5070 {
lab=ctop}
N 5220 -4990 5240 -4990 {
lab=col_n[15]}
N 5220 -4970 5240 -4970 {
lab=colon_n[15]}
N 5220 -4950 5240 -4950 {
lab=#net31}
N 5220 -4930 5240 -4930 {
lab=#net32}
N 5460 -4930 5480 -4930 {
lab=#net32}
N 5460 -4950 5480 -4950 {
lab=#net31}
N 5460 -4970 5480 -4970 {
lab=colon_n[15]}
N 5460 -4990 5480 -4990 {
lab=col_n[15]}
N 5280 -4850 5280 -4840 {
lab=VSS}
N 5280 -5080 5280 -5070 {
lab=VDD}
N 5620 -4850 5630 -4860 {
lab=row_n[17]}
N 5630 -5060 5630 -4860 {
lab=row_n[17]}
N 5620 -5070 5630 -5060 {
lab=row_n[17]}
N 5620 -4850 5620 -4830 {
lab=row_n[17]}
N 5620 -5090 5620 -5070 {
lab=row_n[17]}
N 5500 -4990 5510 -5000 {
lab=col_n[15]}
N 5510 -5000 5710 -5000 {
lab=col_n[15]}
N 5710 -5000 5720 -4990 {
lab=col_n[15]}
N 5500 -4970 5510 -4980 {
lab=colon_n[15]}
N 5510 -4980 5710 -4980 {
lab=colon_n[15]}
N 5710 -4980 5720 -4970 {
lab=colon_n[15]}
N 5500 -4950 5510 -4960 {
lab=#net31}
N 5510 -4960 5710 -4960 {
lab=#net31}
N 5710 -4960 5720 -4950 {
lab=#net31}
N 5500 -4930 5510 -4940 {
lab=#net32}
N 5510 -4940 5710 -4940 {
lab=#net32}
N 5710 -4940 5720 -4930 {
lab=#net32}
N 5560 -5090 5560 -5070 {
lab=vcom}
N 5600 -5090 5600 -5070 {
lab=ctop}
N 5480 -4990 5500 -4990 {
lab=col_n[15]}
N 5480 -4970 5500 -4970 {
lab=colon_n[15]}
N 5480 -4950 5500 -4950 {
lab=#net31}
N 5480 -4930 5500 -4930 {
lab=#net32}
N 5720 -4930 5740 -4930 {
lab=#net32}
N 5720 -4950 5740 -4950 {
lab=#net31}
N 5720 -4970 5740 -4970 {
lab=colon_n[15]}
N 5720 -4990 5740 -4990 {
lab=col_n[15]}
N 5540 -4850 5540 -4840 {
lab=VSS}
N 5540 -5080 5540 -5070 {
lab=VDD}
N 5880 -4850 5890 -4860 {
lab=row_n[18]}
N 5890 -5060 5890 -4860 {
lab=row_n[18]}
N 5880 -5070 5890 -5060 {
lab=row_n[18]}
N 5880 -4850 5880 -4830 {
lab=row_n[18]}
N 5880 -5090 5880 -5070 {
lab=row_n[18]}
N 5760 -4990 5770 -5000 {
lab=col_n[15]}
N 5770 -5000 5970 -5000 {
lab=col_n[15]}
N 5970 -5000 5980 -4990 {
lab=col_n[15]}
N 5760 -4970 5770 -4980 {
lab=colon_n[15]}
N 5770 -4980 5970 -4980 {
lab=colon_n[15]}
N 5970 -4980 5980 -4970 {
lab=colon_n[15]}
N 5760 -4950 5770 -4960 {
lab=#net31}
N 5770 -4960 5970 -4960 {
lab=#net31}
N 5970 -4960 5980 -4950 {
lab=#net31}
N 5760 -4930 5770 -4940 {
lab=#net32}
N 5770 -4940 5970 -4940 {
lab=#net32}
N 5970 -4940 5980 -4930 {
lab=#net32}
N 5820 -5090 5820 -5070 {
lab=vcom}
N 5860 -5090 5860 -5070 {
lab=ctop}
N 5740 -4990 5760 -4990 {
lab=col_n[15]}
N 5740 -4970 5760 -4970 {
lab=colon_n[15]}
N 5740 -4950 5760 -4950 {
lab=#net31}
N 5740 -4930 5760 -4930 {
lab=#net32}
N 5980 -4930 6000 -4930 {
lab=#net32}
N 5980 -4950 6000 -4950 {
lab=#net31}
N 5980 -4970 6000 -4970 {
lab=colon_n[15]}
N 5980 -4990 6000 -4990 {
lab=col_n[15]}
N 5800 -4850 5800 -4840 {
lab=VSS}
N 5800 -5080 5800 -5070 {
lab=VDD}
N 6140 -4850 6150 -4860 {
lab=row_n[19]}
N 6150 -5060 6150 -4860 {
lab=row_n[19]}
N 6140 -5070 6150 -5060 {
lab=row_n[19]}
N 6140 -4850 6140 -4830 {
lab=row_n[19]}
N 6140 -5090 6140 -5070 {
lab=row_n[19]}
N 6020 -4990 6030 -5000 {
lab=col_n[15]}
N 6030 -5000 6230 -5000 {
lab=col_n[15]}
N 6230 -5000 6240 -4990 {
lab=col_n[15]}
N 6020 -4970 6030 -4980 {
lab=colon_n[15]}
N 6030 -4980 6230 -4980 {
lab=colon_n[15]}
N 6230 -4980 6240 -4970 {
lab=colon_n[15]}
N 6020 -4950 6030 -4960 {
lab=#net31}
N 6030 -4960 6230 -4960 {
lab=#net31}
N 6230 -4960 6240 -4950 {
lab=#net31}
N 6020 -4930 6030 -4940 {
lab=#net32}
N 6030 -4940 6230 -4940 {
lab=#net32}
N 6230 -4940 6240 -4930 {
lab=#net32}
N 6080 -5090 6080 -5070 {
lab=vcom}
N 6120 -5090 6120 -5070 {
lab=ctop}
N 6000 -4990 6020 -4990 {
lab=col_n[15]}
N 6000 -4970 6020 -4970 {
lab=colon_n[15]}
N 6000 -4950 6020 -4950 {
lab=#net31}
N 6000 -4930 6020 -4930 {
lab=#net32}
N 6240 -4930 6260 -4930 {
lab=#net32}
N 6240 -4950 6260 -4950 {
lab=#net31}
N 6240 -4970 6260 -4970 {
lab=colon_n[15]}
N 6240 -4990 6260 -4990 {
lab=col_n[15]}
N 6060 -4850 6060 -4840 {
lab=VSS}
N 6060 -5080 6060 -5070 {
lab=VDD}
N 6400 -4850 6410 -4860 {
lab=row_n[20]}
N 6410 -5060 6410 -4860 {
lab=row_n[20]}
N 6400 -5070 6410 -5060 {
lab=row_n[20]}
N 6400 -4850 6400 -4830 {
lab=row_n[20]}
N 6400 -5090 6400 -5070 {
lab=row_n[20]}
N 6280 -4990 6290 -5000 {
lab=col_n[15]}
N 6290 -5000 6490 -5000 {
lab=col_n[15]}
N 6490 -5000 6500 -4990 {
lab=col_n[15]}
N 6280 -4970 6290 -4980 {
lab=colon_n[15]}
N 6290 -4980 6490 -4980 {
lab=colon_n[15]}
N 6490 -4980 6500 -4970 {
lab=colon_n[15]}
N 6280 -4950 6290 -4960 {
lab=#net31}
N 6290 -4960 6490 -4960 {
lab=#net31}
N 6490 -4960 6500 -4950 {
lab=#net31}
N 6280 -4930 6290 -4940 {
lab=#net32}
N 6290 -4940 6490 -4940 {
lab=#net32}
N 6490 -4940 6500 -4930 {
lab=#net32}
N 6340 -5090 6340 -5070 {
lab=vcom}
N 6380 -5090 6380 -5070 {
lab=ctop}
N 6260 -4990 6280 -4990 {
lab=col_n[15]}
N 6260 -4970 6280 -4970 {
lab=colon_n[15]}
N 6260 -4950 6280 -4950 {
lab=#net31}
N 6260 -4930 6280 -4930 {
lab=#net32}
N 6500 -4930 6520 -4930 {
lab=#net32}
N 6500 -4950 6520 -4950 {
lab=#net31}
N 6500 -4970 6520 -4970 {
lab=colon_n[15]}
N 6500 -4990 6520 -4990 {
lab=col_n[15]}
N 6320 -4850 6320 -4840 {
lab=VSS}
N 6320 -5080 6320 -5070 {
lab=VDD}
N 6660 -4850 6670 -4860 {
lab=row_n[21]}
N 6670 -5060 6670 -4860 {
lab=row_n[21]}
N 6660 -5070 6670 -5060 {
lab=row_n[21]}
N 6660 -4850 6660 -4830 {
lab=row_n[21]}
N 6660 -5090 6660 -5070 {
lab=row_n[21]}
N 6540 -4990 6550 -5000 {
lab=col_n[15]}
N 6550 -5000 6750 -5000 {
lab=col_n[15]}
N 6750 -5000 6760 -4990 {
lab=col_n[15]}
N 6540 -4970 6550 -4980 {
lab=colon_n[15]}
N 6550 -4980 6750 -4980 {
lab=colon_n[15]}
N 6750 -4980 6760 -4970 {
lab=colon_n[15]}
N 6540 -4950 6550 -4960 {
lab=#net31}
N 6550 -4960 6750 -4960 {
lab=#net31}
N 6750 -4960 6760 -4950 {
lab=#net31}
N 6540 -4930 6550 -4940 {
lab=#net32}
N 6550 -4940 6750 -4940 {
lab=#net32}
N 6750 -4940 6760 -4930 {
lab=#net32}
N 6600 -5090 6600 -5070 {
lab=vcom}
N 6640 -5090 6640 -5070 {
lab=ctop}
N 6520 -4990 6540 -4990 {
lab=col_n[15]}
N 6520 -4970 6540 -4970 {
lab=colon_n[15]}
N 6520 -4950 6540 -4950 {
lab=#net31}
N 6520 -4930 6540 -4930 {
lab=#net32}
N 6760 -4930 6780 -4930 {
lab=#net32}
N 6760 -4950 6780 -4950 {
lab=#net31}
N 6760 -4970 6780 -4970 {
lab=colon_n[15]}
N 6760 -4990 6780 -4990 {
lab=col_n[15]}
N 6580 -4850 6580 -4840 {
lab=VSS}
N 6580 -5080 6580 -5070 {
lab=VDD}
N 6920 -4850 6930 -4860 {
lab=row_n[22]}
N 6930 -5060 6930 -4860 {
lab=row_n[22]}
N 6920 -5070 6930 -5060 {
lab=row_n[22]}
N 6920 -4850 6920 -4830 {
lab=row_n[22]}
N 6920 -5090 6920 -5070 {
lab=row_n[22]}
N 6800 -4990 6810 -5000 {
lab=col_n[15]}
N 6810 -5000 7010 -5000 {
lab=col_n[15]}
N 7010 -5000 7020 -4990 {
lab=col_n[15]}
N 6800 -4970 6810 -4980 {
lab=colon_n[15]}
N 6810 -4980 7010 -4980 {
lab=colon_n[15]}
N 7010 -4980 7020 -4970 {
lab=colon_n[15]}
N 6800 -4950 6810 -4960 {
lab=#net31}
N 6810 -4960 7010 -4960 {
lab=#net31}
N 7010 -4960 7020 -4950 {
lab=#net31}
N 6800 -4930 6810 -4940 {
lab=#net32}
N 6810 -4940 7010 -4940 {
lab=#net32}
N 7010 -4940 7020 -4930 {
lab=#net32}
N 6860 -5090 6860 -5070 {
lab=vcom}
N 6900 -5090 6900 -5070 {
lab=ctop}
N 6780 -4990 6800 -4990 {
lab=col_n[15]}
N 6780 -4970 6800 -4970 {
lab=colon_n[15]}
N 6780 -4950 6800 -4950 {
lab=#net31}
N 6780 -4930 6800 -4930 {
lab=#net32}
N 7020 -4930 7040 -4930 {
lab=#net32}
N 7020 -4950 7040 -4950 {
lab=#net31}
N 7020 -4970 7040 -4970 {
lab=colon_n[15]}
N 7020 -4990 7040 -4990 {
lab=col_n[15]}
N 6840 -4850 6840 -4840 {
lab=VSS}
N 6840 -5080 6840 -5070 {
lab=VDD}
N 7180 -4850 7190 -4860 {
lab=row_n[23]}
N 7190 -5060 7190 -4860 {
lab=row_n[23]}
N 7180 -5070 7190 -5060 {
lab=row_n[23]}
N 7180 -4850 7180 -4830 {
lab=row_n[23]}
N 7180 -5090 7180 -5070 {
lab=row_n[23]}
N 7060 -4990 7070 -5000 {
lab=col_n[15]}
N 7070 -5000 7270 -5000 {
lab=col_n[15]}
N 7270 -5000 7280 -4990 {
lab=col_n[15]}
N 7060 -4970 7070 -4980 {
lab=colon_n[15]}
N 7070 -4980 7270 -4980 {
lab=colon_n[15]}
N 7270 -4980 7280 -4970 {
lab=colon_n[15]}
N 7060 -4950 7070 -4960 {
lab=#net31}
N 7070 -4960 7270 -4960 {
lab=#net31}
N 7270 -4960 7280 -4950 {
lab=#net31}
N 7060 -4930 7070 -4940 {
lab=#net32}
N 7070 -4940 7270 -4940 {
lab=#net32}
N 7270 -4940 7280 -4930 {
lab=#net32}
N 7120 -5090 7120 -5070 {
lab=vcom}
N 7160 -5090 7160 -5070 {
lab=ctop}
N 7040 -4990 7060 -4990 {
lab=col_n[15]}
N 7040 -4970 7060 -4970 {
lab=colon_n[15]}
N 7040 -4950 7060 -4950 {
lab=#net31}
N 7040 -4930 7060 -4930 {
lab=#net32}
N 7280 -4930 7300 -4930 {
lab=#net32}
N 7280 -4950 7300 -4950 {
lab=#net31}
N 7280 -4970 7300 -4970 {
lab=colon_n[15]}
N 7280 -4990 7300 -4990 {
lab=col_n[15]}
N 7100 -4850 7100 -4840 {
lab=VSS}
N 7100 -5080 7100 -5070 {
lab=VDD}
N 7440 -4850 7450 -4860 {
lab=row_n[24]}
N 7450 -5060 7450 -4860 {
lab=row_n[24]}
N 7440 -5070 7450 -5060 {
lab=row_n[24]}
N 7440 -4850 7440 -4830 {
lab=row_n[24]}
N 7440 -5090 7440 -5070 {
lab=row_n[24]}
N 7320 -4990 7330 -5000 {
lab=col_n[15]}
N 7330 -5000 7530 -5000 {
lab=col_n[15]}
N 7530 -5000 7540 -4990 {
lab=col_n[15]}
N 7320 -4970 7330 -4980 {
lab=colon_n[15]}
N 7330 -4980 7530 -4980 {
lab=colon_n[15]}
N 7530 -4980 7540 -4970 {
lab=colon_n[15]}
N 7320 -4950 7330 -4960 {
lab=#net31}
N 7330 -4960 7530 -4960 {
lab=#net31}
N 7530 -4960 7540 -4950 {
lab=#net31}
N 7320 -4930 7330 -4940 {
lab=#net32}
N 7330 -4940 7530 -4940 {
lab=#net32}
N 7530 -4940 7540 -4930 {
lab=#net32}
N 7380 -5090 7380 -5070 {
lab=vcom}
N 7420 -5090 7420 -5070 {
lab=ctop}
N 7300 -4990 7320 -4990 {
lab=col_n[15]}
N 7300 -4970 7320 -4970 {
lab=colon_n[15]}
N 7300 -4950 7320 -4950 {
lab=#net31}
N 7300 -4930 7320 -4930 {
lab=#net32}
N 7540 -4930 7560 -4930 {
lab=#net32}
N 7540 -4950 7560 -4950 {
lab=#net31}
N 7540 -4970 7560 -4970 {
lab=colon_n[15]}
N 7540 -4990 7560 -4990 {
lab=col_n[15]}
N 7360 -4850 7360 -4840 {
lab=VSS}
N 7360 -5080 7360 -5070 {
lab=VDD}
N 7700 -4850 7710 -4860 {
lab=row_n[25]}
N 7710 -5060 7710 -4860 {
lab=row_n[25]}
N 7700 -5070 7710 -5060 {
lab=row_n[25]}
N 7700 -4850 7700 -4830 {
lab=row_n[25]}
N 7700 -5090 7700 -5070 {
lab=row_n[25]}
N 7580 -4990 7590 -5000 {
lab=col_n[15]}
N 7590 -5000 7790 -5000 {
lab=col_n[15]}
N 7790 -5000 7800 -4990 {
lab=col_n[15]}
N 7580 -4970 7590 -4980 {
lab=colon_n[15]}
N 7590 -4980 7790 -4980 {
lab=colon_n[15]}
N 7790 -4980 7800 -4970 {
lab=colon_n[15]}
N 7580 -4950 7590 -4960 {
lab=#net31}
N 7590 -4960 7790 -4960 {
lab=#net31}
N 7790 -4960 7800 -4950 {
lab=#net31}
N 7580 -4930 7590 -4940 {
lab=#net32}
N 7590 -4940 7790 -4940 {
lab=#net32}
N 7790 -4940 7800 -4930 {
lab=#net32}
N 7640 -5090 7640 -5070 {
lab=vcom}
N 7680 -5090 7680 -5070 {
lab=ctop}
N 7560 -4990 7580 -4990 {
lab=col_n[15]}
N 7560 -4970 7580 -4970 {
lab=colon_n[15]}
N 7560 -4950 7580 -4950 {
lab=#net31}
N 7560 -4930 7580 -4930 {
lab=#net32}
N 7800 -4930 7820 -4930 {
lab=#net32}
N 7800 -4950 7820 -4950 {
lab=#net31}
N 7800 -4970 7820 -4970 {
lab=colon_n[15]}
N 7800 -4990 7820 -4990 {
lab=col_n[15]}
N 7620 -4850 7620 -4840 {
lab=VSS}
N 7620 -5080 7620 -5070 {
lab=VDD}
N 7960 -4850 7970 -4860 {
lab=row_n[26]}
N 7970 -5060 7970 -4860 {
lab=row_n[26]}
N 7960 -5070 7970 -5060 {
lab=row_n[26]}
N 7960 -4850 7960 -4830 {
lab=row_n[26]}
N 7960 -5090 7960 -5070 {
lab=row_n[26]}
N 7840 -4990 7850 -5000 {
lab=col_n[15]}
N 7850 -5000 8050 -5000 {
lab=col_n[15]}
N 8050 -5000 8060 -4990 {
lab=col_n[15]}
N 7840 -4970 7850 -4980 {
lab=colon_n[15]}
N 7850 -4980 8050 -4980 {
lab=colon_n[15]}
N 8050 -4980 8060 -4970 {
lab=colon_n[15]}
N 7840 -4950 7850 -4960 {
lab=#net31}
N 7850 -4960 8050 -4960 {
lab=#net31}
N 8050 -4960 8060 -4950 {
lab=#net31}
N 7840 -4930 7850 -4940 {
lab=#net32}
N 7850 -4940 8050 -4940 {
lab=#net32}
N 8050 -4940 8060 -4930 {
lab=#net32}
N 7900 -5090 7900 -5070 {
lab=vcom}
N 7940 -5090 7940 -5070 {
lab=ctop}
N 7820 -4990 7840 -4990 {
lab=col_n[15]}
N 7820 -4970 7840 -4970 {
lab=colon_n[15]}
N 7820 -4950 7840 -4950 {
lab=#net31}
N 7820 -4930 7840 -4930 {
lab=#net32}
N 8060 -4930 8080 -4930 {
lab=#net32}
N 8060 -4950 8080 -4950 {
lab=#net31}
N 8060 -4970 8080 -4970 {
lab=colon_n[15]}
N 8060 -4990 8080 -4990 {
lab=col_n[15]}
N 7880 -4850 7880 -4840 {
lab=VSS}
N 7880 -5080 7880 -5070 {
lab=VDD}
N 8220 -4850 8230 -4860 {
lab=row_n[27]}
N 8230 -5060 8230 -4860 {
lab=row_n[27]}
N 8220 -5070 8230 -5060 {
lab=row_n[27]}
N 8220 -4850 8220 -4830 {
lab=row_n[27]}
N 8220 -5090 8220 -5070 {
lab=row_n[27]}
N 8100 -4990 8110 -5000 {
lab=col_n[15]}
N 8110 -5000 8310 -5000 {
lab=col_n[15]}
N 8310 -5000 8320 -4990 {
lab=col_n[15]}
N 8100 -4970 8110 -4980 {
lab=colon_n[15]}
N 8110 -4980 8310 -4980 {
lab=colon_n[15]}
N 8310 -4980 8320 -4970 {
lab=colon_n[15]}
N 8100 -4950 8110 -4960 {
lab=#net31}
N 8110 -4960 8310 -4960 {
lab=#net31}
N 8310 -4960 8320 -4950 {
lab=#net31}
N 8100 -4930 8110 -4940 {
lab=#net32}
N 8110 -4940 8310 -4940 {
lab=#net32}
N 8310 -4940 8320 -4930 {
lab=#net32}
N 8160 -5090 8160 -5070 {
lab=vcom}
N 8200 -5090 8200 -5070 {
lab=ctop}
N 8080 -4990 8100 -4990 {
lab=col_n[15]}
N 8080 -4970 8100 -4970 {
lab=colon_n[15]}
N 8080 -4950 8100 -4950 {
lab=#net31}
N 8080 -4930 8100 -4930 {
lab=#net32}
N 8320 -4930 8340 -4930 {
lab=#net32}
N 8320 -4950 8340 -4950 {
lab=#net31}
N 8320 -4970 8340 -4970 {
lab=colon_n[15]}
N 8320 -4990 8340 -4990 {
lab=col_n[15]}
N 8140 -4850 8140 -4840 {
lab=VSS}
N 8140 -5080 8140 -5070 {
lab=VDD}
N 8480 -4850 8490 -4860 {
lab=row_n[28]}
N 8490 -5060 8490 -4860 {
lab=row_n[28]}
N 8480 -5070 8490 -5060 {
lab=row_n[28]}
N 8480 -4850 8480 -4830 {
lab=row_n[28]}
N 8480 -5090 8480 -5070 {
lab=row_n[28]}
N 8360 -4990 8370 -5000 {
lab=col_n[15]}
N 8370 -5000 8570 -5000 {
lab=col_n[15]}
N 8570 -5000 8580 -4990 {
lab=col_n[15]}
N 8360 -4970 8370 -4980 {
lab=colon_n[15]}
N 8370 -4980 8570 -4980 {
lab=colon_n[15]}
N 8570 -4980 8580 -4970 {
lab=colon_n[15]}
N 8360 -4950 8370 -4960 {
lab=#net31}
N 8370 -4960 8570 -4960 {
lab=#net31}
N 8570 -4960 8580 -4950 {
lab=#net31}
N 8360 -4930 8370 -4940 {
lab=#net32}
N 8370 -4940 8570 -4940 {
lab=#net32}
N 8570 -4940 8580 -4930 {
lab=#net32}
N 8420 -5090 8420 -5070 {
lab=vcom}
N 8460 -5090 8460 -5070 {
lab=ctop}
N 8340 -4990 8360 -4990 {
lab=col_n[15]}
N 8340 -4970 8360 -4970 {
lab=colon_n[15]}
N 8340 -4950 8360 -4950 {
lab=#net31}
N 8340 -4930 8360 -4930 {
lab=#net32}
N 8580 -4930 8600 -4930 {
lab=#net32}
N 8580 -4950 8600 -4950 {
lab=#net31}
N 8580 -4970 8600 -4970 {
lab=colon_n[15]}
N 8580 -4990 8600 -4990 {
lab=col_n[15]}
N 8400 -4850 8400 -4840 {
lab=VSS}
N 8400 -5080 8400 -5070 {
lab=VDD}
N 8740 -4850 8750 -4860 {
lab=row_n[29]}
N 8750 -5060 8750 -4860 {
lab=row_n[29]}
N 8740 -5070 8750 -5060 {
lab=row_n[29]}
N 8740 -4850 8740 -4830 {
lab=row_n[29]}
N 8740 -5090 8740 -5070 {
lab=row_n[29]}
N 8620 -4990 8630 -5000 {
lab=col_n[15]}
N 8630 -5000 8830 -5000 {
lab=col_n[15]}
N 8830 -5000 8840 -4990 {
lab=col_n[15]}
N 8620 -4970 8630 -4980 {
lab=colon_n[15]}
N 8630 -4980 8830 -4980 {
lab=colon_n[15]}
N 8830 -4980 8840 -4970 {
lab=colon_n[15]}
N 8620 -4950 8630 -4960 {
lab=#net31}
N 8630 -4960 8830 -4960 {
lab=#net31}
N 8830 -4960 8840 -4950 {
lab=#net31}
N 8620 -4930 8630 -4940 {
lab=#net32}
N 8630 -4940 8830 -4940 {
lab=#net32}
N 8830 -4940 8840 -4930 {
lab=#net32}
N 8680 -5090 8680 -5070 {
lab=vcom}
N 8720 -5090 8720 -5070 {
lab=ctop}
N 8600 -4990 8620 -4990 {
lab=col_n[15]}
N 8600 -4970 8620 -4970 {
lab=colon_n[15]}
N 8600 -4950 8620 -4950 {
lab=#net31}
N 8600 -4930 8620 -4930 {
lab=#net32}
N 8840 -4930 8860 -4930 {
lab=#net32}
N 8840 -4950 8860 -4950 {
lab=#net31}
N 8840 -4970 8860 -4970 {
lab=colon_n[15]}
N 8840 -4990 8860 -4990 {
lab=col_n[15]}
N 8660 -4850 8660 -4840 {
lab=VSS}
N 8660 -5080 8660 -5070 {
lab=VDD}
N 9000 -4850 9010 -4860 {
lab=row_n[30]}
N 9010 -5060 9010 -4860 {
lab=row_n[30]}
N 9000 -5070 9010 -5060 {
lab=row_n[30]}
N 9000 -4850 9000 -4830 {
lab=row_n[30]}
N 9000 -5090 9000 -5070 {
lab=row_n[30]}
N 8880 -4990 8890 -5000 {
lab=col_n[15]}
N 8890 -5000 9090 -5000 {
lab=col_n[15]}
N 9090 -5000 9100 -4990 {
lab=col_n[15]}
N 8880 -4970 8890 -4980 {
lab=colon_n[15]}
N 8890 -4980 9090 -4980 {
lab=colon_n[15]}
N 9090 -4980 9100 -4970 {
lab=colon_n[15]}
N 8880 -4950 8890 -4960 {
lab=#net31}
N 8890 -4960 9090 -4960 {
lab=#net31}
N 9090 -4960 9100 -4950 {
lab=#net31}
N 8880 -4930 8890 -4940 {
lab=#net32}
N 8890 -4940 9090 -4940 {
lab=#net32}
N 9090 -4940 9100 -4930 {
lab=#net32}
N 8940 -5090 8940 -5070 {
lab=vcom}
N 8980 -5090 8980 -5070 {
lab=ctop}
N 8860 -4990 8880 -4990 {
lab=col_n[15]}
N 8860 -4970 8880 -4970 {
lab=colon_n[15]}
N 8860 -4950 8880 -4950 {
lab=#net31}
N 8860 -4930 8880 -4930 {
lab=#net32}
N 9100 -4930 9120 -4930 {
lab=#net32}
N 9100 -4950 9120 -4950 {
lab=#net31}
N 9100 -4970 9120 -4970 {
lab=colon_n[15]}
N 9100 -4990 9120 -4990 {
lab=col_n[15]}
N 8920 -4850 8920 -4840 {
lab=VSS}
N 8920 -5080 8920 -5070 {
lab=VDD}
N 9260 -4850 9270 -4860 {
lab=row_n[31]}
N 9270 -5060 9270 -4860 {
lab=row_n[31]}
N 9260 -5070 9270 -5060 {
lab=row_n[31]}
N 9260 -4850 9260 -4830 {
lab=row_n[31]}
N 9260 -5090 9260 -5070 {
lab=row_n[31]}
N 9140 -4990 9150 -5000 {
lab=col_n[15]}
N 9150 -5000 9350 -5000 {
lab=col_n[15]}
N 9350 -5000 9360 -4990 {
lab=col_n[15]}
N 9140 -4970 9150 -4980 {
lab=colon_n[15]}
N 9150 -4980 9350 -4980 {
lab=colon_n[15]}
N 9350 -4980 9360 -4970 {
lab=colon_n[15]}
N 9140 -4950 9150 -4960 {
lab=#net31}
N 9150 -4960 9350 -4960 {
lab=#net31}
N 9350 -4960 9360 -4950 {
lab=#net31}
N 9140 -4930 9150 -4940 {
lab=#net32}
N 9150 -4940 9350 -4940 {
lab=#net32}
N 9350 -4940 9360 -4930 {
lab=#net32}
N 9200 -5090 9200 -5070 {
lab=vcom}
N 9240 -5090 9240 -5070 {
lab=ctop}
N 9120 -4990 9140 -4990 {
lab=col_n[15]}
N 9120 -4970 9140 -4970 {
lab=colon_n[15]}
N 9120 -4950 9140 -4950 {
lab=#net31}
N 9120 -4930 9140 -4930 {
lab=#net32}
N 9360 -4930 9380 -4930 {
lab=#net32}
N 9360 -4950 9380 -4950 {
lab=#net31}
N 9360 -4970 9380 -4970 {
lab=colon_n[15]}
N 9360 -4990 9380 -4990 {
lab=col_n[15]}
N 9180 -4850 9180 -4840 {
lab=VSS}
N 9180 -5080 9180 -5070 {
lab=VDD}
N 6400 -5110 6400 -5090 {
lab=row_n[20]}
N 1040 -1050 1060 -1050 {
lab=#net1}
N 1040 -1030 1060 -1030 {
lab=#net2}
N 800 -1030 820 -1030 {
lab=sample_n}
N 800 -1050 820 -1050 {
lab=sample}
N 800 -1070 820 -1070 {
lab=colon_n[0]}
N 800 -1090 820 -1090 {
lab=col_n[0]}
N 880 -1190 880 -1170 {
lab=vcom}
N 920 -1190 920 -1170 {
lab=ctop}
N 860 -1180 860 -1170 {
lab=VDD}
N 940 -950 940 -930 {
lab=VDD}
N 940 -950 950 -960 {
lab=VDD}
N 950 -1160 950 -960 {
lab=VDD}
N 940 -1170 950 -1160 {
lab=VDD}
N 940 -1190 940 -1170 {
lab=VDD}
N 860 -950 860 -940 {
lab=VSS}
N 820 -1090 830 -1100 {
lab=col_n[0]}
N 830 -1100 1030 -1100 {
lab=col_n[0]}
N 1030 -1100 1040 -1090 {
lab=col_n[0]}
N 1040 -1090 1060 -1090 {
lab=col_n[0]}
N 820 -1070 830 -1080 {
lab=colon_n[0]}
N 830 -1080 1030 -1080 {
lab=colon_n[0]}
N 1030 -1080 1040 -1070 {
lab=colon_n[0]}
N 1040 -1070 1060 -1070 {
lab=colon_n[0]}
N 1040 -1310 1060 -1310 {
lab=#net3}
N 1040 -1290 1060 -1290 {
lab=#net4}
N 800 -1290 820 -1290 {
lab=sample_n}
N 800 -1310 820 -1310 {
lab=sample}
N 800 -1330 820 -1330 {
lab=colon_n[1]}
N 800 -1350 820 -1350 {
lab=col_n[1]}
N 880 -1450 880 -1430 {
lab=vcom}
N 920 -1450 920 -1430 {
lab=ctop}
N 860 -1440 860 -1430 {
lab=VDD}
N 940 -1210 940 -1190 {
lab=VDD}
N 940 -1210 950 -1220 {
lab=VDD}
N 950 -1420 950 -1220 {
lab=VDD}
N 940 -1430 950 -1420 {
lab=VDD}
N 940 -1450 940 -1430 {
lab=VDD}
N 860 -1210 860 -1200 {
lab=VSS}
N 820 -1350 830 -1360 {
lab=col_n[1]}
N 830 -1360 1030 -1360 {
lab=col_n[1]}
N 1030 -1360 1040 -1350 {
lab=col_n[1]}
N 1040 -1350 1060 -1350 {
lab=col_n[1]}
N 820 -1330 830 -1340 {
lab=colon_n[1]}
N 830 -1340 1030 -1340 {
lab=colon_n[1]}
N 1030 -1340 1040 -1330 {
lab=colon_n[1]}
N 1040 -1330 1060 -1330 {
lab=colon_n[1]}
N 1040 -1570 1060 -1570 {
lab=#net5}
N 1040 -1550 1060 -1550 {
lab=#net6}
N 800 -1550 820 -1550 {
lab=sample_n}
N 800 -1570 820 -1570 {
lab=sample}
N 800 -1590 820 -1590 {
lab=colon_n[2]}
N 800 -1610 820 -1610 {
lab=col_n[2]}
N 880 -1710 880 -1690 {
lab=vcom}
N 920 -1710 920 -1690 {
lab=ctop}
N 860 -1700 860 -1690 {
lab=VDD}
N 940 -1470 940 -1450 {
lab=VDD}
N 940 -1470 950 -1480 {
lab=VDD}
N 950 -1680 950 -1480 {
lab=VDD}
N 940 -1690 950 -1680 {
lab=VDD}
N 940 -1710 940 -1690 {
lab=VDD}
N 860 -1470 860 -1460 {
lab=VSS}
N 820 -1610 830 -1620 {
lab=col_n[2]}
N 830 -1620 1030 -1620 {
lab=col_n[2]}
N 1030 -1620 1040 -1610 {
lab=col_n[2]}
N 1040 -1610 1060 -1610 {
lab=col_n[2]}
N 820 -1590 830 -1600 {
lab=colon_n[2]}
N 830 -1600 1030 -1600 {
lab=colon_n[2]}
N 1030 -1600 1040 -1590 {
lab=colon_n[2]}
N 1040 -1590 1060 -1590 {
lab=colon_n[2]}
N 1040 -1830 1060 -1830 {
lab=#net7}
N 1040 -1810 1060 -1810 {
lab=#net8}
N 800 -1810 820 -1810 {
lab=sample_n}
N 800 -1830 820 -1830 {
lab=sample}
N 800 -1850 820 -1850 {
lab=colon_n[3]}
N 800 -1870 820 -1870 {
lab=col_n[3]}
N 880 -1970 880 -1950 {
lab=vcom}
N 920 -1970 920 -1950 {
lab=ctop}
N 860 -1960 860 -1950 {
lab=VDD}
N 940 -1730 950 -1740 {
lab=VDD}
N 950 -1940 950 -1740 {
lab=VDD}
N 940 -1950 950 -1940 {
lab=VDD}
N 940 -1970 940 -1950 {
lab=VDD}
N 860 -1730 860 -1720 {
lab=VSS}
N 820 -1870 830 -1880 {
lab=col_n[3]}
N 830 -1880 1030 -1880 {
lab=col_n[3]}
N 1030 -1880 1040 -1870 {
lab=col_n[3]}
N 1040 -1870 1060 -1870 {
lab=col_n[3]}
N 820 -1850 830 -1860 {
lab=colon_n[3]}
N 830 -1860 1030 -1860 {
lab=colon_n[3]}
N 1030 -1860 1040 -1850 {
lab=colon_n[3]}
N 1040 -1850 1060 -1850 {
lab=colon_n[3]}
N 1040 -2090 1060 -2090 {
lab=#net9}
N 1040 -2070 1060 -2070 {
lab=#net10}
N 800 -2070 820 -2070 {
lab=sample_n}
N 800 -2090 820 -2090 {
lab=sample}
N 800 -2110 820 -2110 {
lab=colon_n[4]}
N 800 -2130 820 -2130 {
lab=col_n[4]}
N 880 -2230 880 -2210 {
lab=vcom}
N 920 -2230 920 -2210 {
lab=ctop}
N 860 -2220 860 -2210 {
lab=VDD}
N 940 -1990 940 -1970 {
lab=VDD}
N 940 -1990 950 -2000 {
lab=VDD}
N 950 -2200 950 -2000 {
lab=VDD}
N 940 -2210 950 -2200 {
lab=VDD}
N 940 -2230 940 -2210 {
lab=VDD}
N 860 -1990 860 -1980 {
lab=VSS}
N 820 -2130 830 -2140 {
lab=col_n[4]}
N 830 -2140 1030 -2140 {
lab=col_n[4]}
N 1030 -2140 1040 -2130 {
lab=col_n[4]}
N 1040 -2130 1060 -2130 {
lab=col_n[4]}
N 820 -2110 830 -2120 {
lab=colon_n[4]}
N 830 -2120 1030 -2120 {
lab=colon_n[4]}
N 1030 -2120 1040 -2110 {
lab=colon_n[4]}
N 1040 -2110 1060 -2110 {
lab=colon_n[4]}
N 940 -1730 940 -1710 {
lab=VDD}
N 1040 -2350 1060 -2350 {
lab=#net11}
N 1040 -2330 1060 -2330 {
lab=#net12}
N 800 -2330 820 -2330 {
lab=sample_n}
N 800 -2350 820 -2350 {
lab=sample}
N 800 -2370 820 -2370 {
lab=colon_n[5]}
N 800 -2390 820 -2390 {
lab=col_n[5]}
N 880 -2490 880 -2470 {
lab=vcom}
N 920 -2490 920 -2470 {
lab=ctop}
N 860 -2480 860 -2470 {
lab=VDD}
N 940 -2250 940 -2230 {
lab=VDD}
N 940 -2250 950 -2260 {
lab=VDD}
N 950 -2460 950 -2260 {
lab=VDD}
N 940 -2470 950 -2460 {
lab=VDD}
N 940 -2490 940 -2470 {
lab=VDD}
N 860 -2250 860 -2240 {
lab=VSS}
N 820 -2390 830 -2400 {
lab=col_n[5]}
N 830 -2400 1030 -2400 {
lab=col_n[5]}
N 1030 -2400 1040 -2390 {
lab=col_n[5]}
N 1040 -2390 1060 -2390 {
lab=col_n[5]}
N 820 -2370 830 -2380 {
lab=colon_n[5]}
N 830 -2380 1030 -2380 {
lab=colon_n[5]}
N 1030 -2380 1040 -2370 {
lab=colon_n[5]}
N 1040 -2370 1060 -2370 {
lab=colon_n[5]}
N 1040 -2610 1060 -2610 {
lab=#net13}
N 1040 -2590 1060 -2590 {
lab=#net14}
N 800 -2590 820 -2590 {
lab=sample_n}
N 800 -2610 820 -2610 {
lab=sample}
N 800 -2630 820 -2630 {
lab=colon_n[6]}
N 800 -2650 820 -2650 {
lab=col_n[6]}
N 880 -2750 880 -2730 {
lab=vcom}
N 920 -2750 920 -2730 {
lab=ctop}
N 860 -2740 860 -2730 {
lab=VDD}
N 940 -2510 940 -2490 {
lab=VDD}
N 940 -2510 950 -2520 {
lab=VDD}
N 950 -2720 950 -2520 {
lab=VDD}
N 940 -2730 950 -2720 {
lab=VDD}
N 940 -2750 940 -2730 {
lab=VDD}
N 860 -2510 860 -2500 {
lab=VSS}
N 820 -2650 830 -2660 {
lab=col_n[6]}
N 830 -2660 1030 -2660 {
lab=col_n[6]}
N 1030 -2660 1040 -2650 {
lab=col_n[6]}
N 1040 -2650 1060 -2650 {
lab=col_n[6]}
N 820 -2630 830 -2640 {
lab=colon_n[6]}
N 830 -2640 1030 -2640 {
lab=colon_n[6]}
N 1030 -2640 1040 -2630 {
lab=colon_n[6]}
N 1040 -2630 1060 -2630 {
lab=colon_n[6]}
N 1040 -2870 1060 -2870 {
lab=#net15}
N 1040 -2850 1060 -2850 {
lab=#net16}
N 800 -2850 820 -2850 {
lab=sample_n}
N 800 -2870 820 -2870 {
lab=sample}
N 800 -2890 820 -2890 {
lab=colon_n[7]}
N 800 -2910 820 -2910 {
lab=col_n[7]}
N 880 -3010 880 -2990 {
lab=vcom}
N 920 -3010 920 -2990 {
lab=ctop}
N 860 -3000 860 -2990 {
lab=VDD}
N 940 -2770 940 -2750 {
lab=VDD}
N 940 -2770 950 -2780 {
lab=VDD}
N 950 -2980 950 -2780 {
lab=VDD}
N 940 -2990 950 -2980 {
lab=VDD}
N 940 -3010 940 -2990 {
lab=VDD}
N 860 -2770 860 -2760 {
lab=VSS}
N 820 -2910 830 -2920 {
lab=col_n[7]}
N 830 -2920 1030 -2920 {
lab=col_n[7]}
N 1030 -2920 1040 -2910 {
lab=col_n[7]}
N 1040 -2910 1060 -2910 {
lab=col_n[7]}
N 820 -2890 830 -2900 {
lab=colon_n[7]}
N 830 -2900 1030 -2900 {
lab=colon_n[7]}
N 1030 -2900 1040 -2890 {
lab=colon_n[7]}
N 1040 -2890 1060 -2890 {
lab=colon_n[7]}
N 1040 -3130 1060 -3130 {
lab=#net17}
N 1040 -3110 1060 -3110 {
lab=#net18}
N 800 -3110 820 -3110 {
lab=sample_n}
N 800 -3130 820 -3130 {
lab=sample}
N 800 -3150 820 -3150 {
lab=colon_n[8]}
N 800 -3170 820 -3170 {
lab=col_n[8]}
N 880 -3270 880 -3250 {
lab=vcom}
N 920 -3270 920 -3250 {
lab=ctop}
N 860 -3260 860 -3250 {
lab=VDD}
N 940 -3030 950 -3040 {
lab=VDD}
N 950 -3240 950 -3040 {
lab=VDD}
N 940 -3250 950 -3240 {
lab=VDD}
N 940 -3270 940 -3250 {
lab=VDD}
N 860 -3030 860 -3020 {
lab=VSS}
N 820 -3170 830 -3180 {
lab=col_n[8]}
N 830 -3180 1030 -3180 {
lab=col_n[8]}
N 1030 -3180 1040 -3170 {
lab=col_n[8]}
N 1040 -3170 1060 -3170 {
lab=col_n[8]}
N 820 -3150 830 -3160 {
lab=colon_n[8]}
N 830 -3160 1030 -3160 {
lab=colon_n[8]}
N 1030 -3160 1040 -3150 {
lab=colon_n[8]}
N 1040 -3150 1060 -3150 {
lab=colon_n[8]}
N 1040 -3390 1060 -3390 {
lab=#net19}
N 1040 -3370 1060 -3370 {
lab=#net20}
N 800 -3370 820 -3370 {
lab=sample_n}
N 800 -3390 820 -3390 {
lab=sample}
N 800 -3410 820 -3410 {
lab=colon_n[9]}
N 800 -3430 820 -3430 {
lab=col_n[9]}
N 880 -3530 880 -3510 {
lab=vcom}
N 920 -3530 920 -3510 {
lab=ctop}
N 860 -3520 860 -3510 {
lab=VDD}
N 940 -3290 940 -3270 {
lab=VDD}
N 940 -3290 950 -3300 {
lab=VDD}
N 950 -3500 950 -3300 {
lab=VDD}
N 940 -3510 950 -3500 {
lab=VDD}
N 940 -3530 940 -3510 {
lab=VDD}
N 860 -3290 860 -3280 {
lab=VSS}
N 820 -3430 830 -3440 {
lab=col_n[9]}
N 830 -3440 1030 -3440 {
lab=col_n[9]}
N 1030 -3440 1040 -3430 {
lab=col_n[9]}
N 1040 -3430 1060 -3430 {
lab=col_n[9]}
N 820 -3410 830 -3420 {
lab=colon_n[9]}
N 830 -3420 1030 -3420 {
lab=colon_n[9]}
N 1030 -3420 1040 -3410 {
lab=colon_n[9]}
N 1040 -3410 1060 -3410 {
lab=colon_n[9]}
N 940 -3030 940 -3010 {
lab=VDD}
N 1040 -3650 1060 -3650 {
lab=#net21}
N 1040 -3630 1060 -3630 {
lab=#net22}
N 800 -3630 820 -3630 {
lab=sample_n}
N 800 -3650 820 -3650 {
lab=sample}
N 800 -3670 820 -3670 {
lab=colon_n[10]}
N 800 -3690 820 -3690 {
lab=col_n[10]}
N 880 -3790 880 -3770 {
lab=vcom}
N 920 -3790 920 -3770 {
lab=ctop}
N 860 -3780 860 -3770 {
lab=VDD}
N 940 -3550 940 -3530 {
lab=VDD}
N 940 -3550 950 -3560 {
lab=VDD}
N 950 -3760 950 -3560 {
lab=VDD}
N 940 -3770 950 -3760 {
lab=VDD}
N 940 -3790 940 -3770 {
lab=VDD}
N 860 -3550 860 -3540 {
lab=VSS}
N 820 -3690 830 -3700 {
lab=col_n[10]}
N 830 -3700 1030 -3700 {
lab=col_n[10]}
N 1030 -3700 1040 -3690 {
lab=col_n[10]}
N 1040 -3690 1060 -3690 {
lab=col_n[10]}
N 820 -3670 830 -3680 {
lab=colon_n[10]}
N 830 -3680 1030 -3680 {
lab=colon_n[10]}
N 1030 -3680 1040 -3670 {
lab=colon_n[10]}
N 1040 -3670 1060 -3670 {
lab=colon_n[10]}
N 1040 -3910 1060 -3910 {
lab=#net23}
N 1040 -3890 1060 -3890 {
lab=#net24}
N 800 -3890 820 -3890 {
lab=sample_n}
N 800 -3910 820 -3910 {
lab=sample}
N 800 -3930 820 -3930 {
lab=colon_n[11]}
N 800 -3950 820 -3950 {
lab=col_n[11]}
N 880 -4050 880 -4030 {
lab=vcom}
N 920 -4050 920 -4030 {
lab=ctop}
N 860 -4040 860 -4030 {
lab=VDD}
N 940 -3810 940 -3790 {
lab=VDD}
N 940 -3810 950 -3820 {
lab=VDD}
N 950 -4020 950 -3820 {
lab=VDD}
N 940 -4030 950 -4020 {
lab=VDD}
N 940 -4050 940 -4030 {
lab=VDD}
N 860 -3810 860 -3800 {
lab=VSS}
N 820 -3950 830 -3960 {
lab=col_n[11]}
N 830 -3960 1030 -3960 {
lab=col_n[11]}
N 1030 -3960 1040 -3950 {
lab=col_n[11]}
N 1040 -3950 1060 -3950 {
lab=col_n[11]}
N 820 -3930 830 -3940 {
lab=colon_n[11]}
N 830 -3940 1030 -3940 {
lab=colon_n[11]}
N 1030 -3940 1040 -3930 {
lab=colon_n[11]}
N 1040 -3930 1060 -3930 {
lab=colon_n[11]}
N 1040 -4170 1060 -4170 {
lab=#net25}
N 1040 -4150 1060 -4150 {
lab=#net26}
N 800 -4150 820 -4150 {
lab=sample_n}
N 800 -4170 820 -4170 {
lab=sample}
N 800 -4190 820 -4190 {
lab=colon_n[12]}
N 800 -4210 820 -4210 {
lab=col_n[12]}
N 880 -4310 880 -4290 {
lab=vcom}
N 920 -4310 920 -4290 {
lab=ctop}
N 860 -4300 860 -4290 {
lab=VDD}
N 940 -4070 940 -4050 {
lab=VDD}
N 940 -4070 950 -4080 {
lab=VDD}
N 950 -4280 950 -4080 {
lab=VDD}
N 940 -4290 950 -4280 {
lab=VDD}
N 940 -4310 940 -4290 {
lab=VDD}
N 860 -4070 860 -4060 {
lab=VSS}
N 820 -4210 830 -4220 {
lab=col_n[12]}
N 830 -4220 1030 -4220 {
lab=col_n[12]}
N 1030 -4220 1040 -4210 {
lab=col_n[12]}
N 1040 -4210 1060 -4210 {
lab=col_n[12]}
N 820 -4190 830 -4200 {
lab=colon_n[12]}
N 830 -4200 1030 -4200 {
lab=colon_n[12]}
N 1030 -4200 1040 -4190 {
lab=colon_n[12]}
N 1040 -4190 1060 -4190 {
lab=colon_n[12]}
N 1040 -4430 1060 -4430 {
lab=#net27}
N 1040 -4410 1060 -4410 {
lab=#net28}
N 800 -4410 820 -4410 {
lab=sample_n}
N 800 -4430 820 -4430 {
lab=sample}
N 800 -4450 820 -4450 {
lab=colon_n[13]}
N 800 -4470 820 -4470 {
lab=col_n[13]}
N 880 -4570 880 -4550 {
lab=vcom}
N 920 -4570 920 -4550 {
lab=ctop}
N 860 -4560 860 -4550 {
lab=VDD}
N 940 -4330 950 -4340 {
lab=VDD}
N 950 -4540 950 -4340 {
lab=VDD}
N 940 -4550 950 -4540 {
lab=VDD}
N 940 -4570 940 -4550 {
lab=VDD}
N 860 -4330 860 -4320 {
lab=VSS}
N 820 -4470 830 -4480 {
lab=col_n[13]}
N 830 -4480 1030 -4480 {
lab=col_n[13]}
N 1030 -4480 1040 -4470 {
lab=col_n[13]}
N 1040 -4470 1060 -4470 {
lab=col_n[13]}
N 820 -4450 830 -4460 {
lab=colon_n[13]}
N 830 -4460 1030 -4460 {
lab=colon_n[13]}
N 1030 -4460 1040 -4450 {
lab=colon_n[13]}
N 1040 -4450 1060 -4450 {
lab=colon_n[13]}
N 1040 -4690 1060 -4690 {
lab=#net29}
N 1040 -4670 1060 -4670 {
lab=#net30}
N 800 -4670 820 -4670 {
lab=sample_n}
N 800 -4690 820 -4690 {
lab=sample}
N 800 -4710 820 -4710 {
lab=colon_n[14]}
N 800 -4730 820 -4730 {
lab=col_n[14]}
N 880 -4830 880 -4810 {
lab=vcom}
N 920 -4830 920 -4810 {
lab=ctop}
N 860 -4820 860 -4810 {
lab=VDD}
N 940 -4590 940 -4570 {
lab=VDD}
N 940 -4590 950 -4600 {
lab=VDD}
N 950 -4800 950 -4600 {
lab=VDD}
N 940 -4810 950 -4800 {
lab=VDD}
N 940 -4830 940 -4810 {
lab=VDD}
N 860 -4590 860 -4580 {
lab=VSS}
N 820 -4730 830 -4740 {
lab=col_n[14]}
N 830 -4740 1030 -4740 {
lab=col_n[14]}
N 1030 -4740 1040 -4730 {
lab=col_n[14]}
N 1040 -4730 1060 -4730 {
lab=col_n[14]}
N 820 -4710 830 -4720 {
lab=colon_n[14]}
N 830 -4720 1030 -4720 {
lab=colon_n[14]}
N 1030 -4720 1040 -4710 {
lab=colon_n[14]}
N 1040 -4710 1060 -4710 {
lab=colon_n[14]}
N 940 -4330 940 -4310 {
lab=VDD}
N 1040 -4950 1060 -4950 {
lab=#net31}
N 1040 -4930 1060 -4930 {
lab=#net32}
N 800 -4930 820 -4930 {
lab=sample_n}
N 800 -4950 820 -4950 {
lab=sample}
N 800 -4970 820 -4970 {
lab=colon_n[15]}
N 800 -4990 820 -4990 {
lab=col_n[15]}
N 880 -5090 880 -5070 {
lab=vcom}
N 920 -5090 920 -5070 {
lab=ctop}
N 860 -5080 860 -5070 {
lab=VDD}
N 940 -4850 940 -4830 {
lab=VDD}
N 940 -4850 950 -4860 {
lab=VDD}
N 950 -5060 950 -4860 {
lab=VDD}
N 940 -5070 950 -5060 {
lab=VDD}
N 940 -5090 940 -5070 {
lab=VDD}
N 860 -4850 860 -4840 {
lab=VSS}
N 820 -4990 830 -5000 {
lab=col_n[15]}
N 830 -5000 1030 -5000 {
lab=col_n[15]}
N 1030 -5000 1040 -4990 {
lab=col_n[15]}
N 1040 -4990 1060 -4990 {
lab=col_n[15]}
N 820 -4970 830 -4980 {
lab=colon_n[15]}
N 830 -4980 1030 -4980 {
lab=colon_n[15]}
N 1030 -4980 1040 -4970 {
lab=colon_n[15]}
N 1040 -4970 1060 -4970 {
lab=colon_n[15]}
N 940 -690 950 -700 {
lab=VDD}
N 950 -900 950 -700 {
lab=VDD}
N 940 -910 950 -900 {
lab=VDD}
N 940 -930 940 -910 {
lab=VDD}
N 820 -830 830 -840 {
lab=VDD}
N 830 -840 1030 -840 {
lab=VDD}
N 1030 -840 1040 -830 {
lab=VDD}
N 820 -810 830 -820 {
lab=VDD}
N 830 -820 1030 -820 {
lab=VDD}
N 1030 -820 1040 -810 {
lab=VDD}
N 820 -790 830 -800 {
lab=VSS}
N 830 -800 1030 -800 {
lab=VSS}
N 1030 -800 1040 -790 {
lab=VSS}
N 820 -770 830 -780 {
lab=VDD}
N 830 -780 1030 -780 {
lab=VDD}
N 1030 -780 1040 -770 {
lab=VDD}
N 1040 -770 1060 -770 {
lab=VDD}
N 1040 -790 1060 -790 {
lab=VSS}
N 1040 -810 1060 -810 {
lab=VDD}
N 1040 -830 1060 -830 {
lab=VDD}
N 800 -830 820 -830 {
lab=VDD}
N 800 -810 820 -810 {
lab=VDD}
N 800 -790 820 -790 {
lab=VSS}
N 800 -770 820 -770 {
lab=VDD}
N 860 -690 860 -680 {
lab=VSS}
N 880 -930 880 -910 {
lab=vcom}
N 860 -920 860 -910 {
lab=VDD}
N 1200 -690 1210 -700 {
lab=row_n[0]}
N 1210 -900 1210 -700 {
lab=row_n[0]}
N 1200 -910 1210 -900 {
lab=row_n[0]}
N 1200 -930 1200 -910 {
lab=row_n[0]}
N 1080 -830 1090 -840 {
lab=VDD}
N 1090 -840 1290 -840 {
lab=VDD}
N 1290 -840 1300 -830 {
lab=VDD}
N 1080 -810 1090 -820 {
lab=VDD}
N 1090 -820 1290 -820 {
lab=VDD}
N 1290 -820 1300 -810 {
lab=VDD}
N 1080 -790 1090 -800 {
lab=VSS}
N 1090 -800 1290 -800 {
lab=VSS}
N 1290 -800 1300 -790 {
lab=VSS}
N 1080 -770 1090 -780 {
lab=VDD}
N 1090 -780 1290 -780 {
lab=VDD}
N 1290 -780 1300 -770 {
lab=VDD}
N 1300 -770 1320 -770 {
lab=VDD}
N 1300 -790 1320 -790 {
lab=VSS}
N 1300 -810 1320 -810 {
lab=VDD}
N 1300 -830 1320 -830 {
lab=VDD}
N 1060 -830 1080 -830 {
lab=VDD}
N 1060 -810 1080 -810 {
lab=VDD}
N 1060 -790 1080 -790 {
lab=VSS}
N 1060 -770 1080 -770 {
lab=VDD}
N 1120 -690 1120 -680 {
lab=VSS}
N 1140 -930 1140 -910 {
lab=vcom}
N 1120 -920 1120 -910 {
lab=VDD}
N 1200 -690 1200 -670 {
lab=row_n[0]}
N 920 -930 920 -910 {
lab=ctop}
N 1180 -930 1180 -910 {
lab=ctop}
N 1460 -690 1470 -700 {
lab=row_n[1]}
N 1470 -900 1470 -700 {
lab=row_n[1]}
N 1460 -910 1470 -900 {
lab=row_n[1]}
N 1460 -930 1460 -910 {
lab=row_n[1]}
N 1340 -830 1350 -840 {
lab=VDD}
N 1350 -840 1550 -840 {
lab=VDD}
N 1550 -840 1560 -830 {
lab=VDD}
N 1340 -810 1350 -820 {
lab=VDD}
N 1350 -820 1550 -820 {
lab=VDD}
N 1550 -820 1560 -810 {
lab=VDD}
N 1340 -790 1350 -800 {
lab=VSS}
N 1350 -800 1550 -800 {
lab=VSS}
N 1550 -800 1560 -790 {
lab=VSS}
N 1340 -770 1350 -780 {
lab=VDD}
N 1350 -780 1550 -780 {
lab=VDD}
N 1550 -780 1560 -770 {
lab=VDD}
N 1560 -770 1580 -770 {
lab=VDD}
N 1560 -790 1580 -790 {
lab=VSS}
N 1560 -810 1580 -810 {
lab=VDD}
N 1560 -830 1580 -830 {
lab=VDD}
N 1320 -830 1340 -830 {
lab=VDD}
N 1320 -810 1340 -810 {
lab=VDD}
N 1320 -790 1340 -790 {
lab=VSS}
N 1320 -770 1340 -770 {
lab=VDD}
N 1380 -690 1380 -680 {
lab=VSS}
N 1400 -930 1400 -910 {
lab=vcom}
N 1380 -920 1380 -910 {
lab=VDD}
N 1460 -690 1460 -670 {
lab=row_n[1]}
N 1720 -690 1730 -700 {
lab=row_n[2]}
N 1730 -900 1730 -700 {
lab=row_n[2]}
N 1720 -910 1730 -900 {
lab=row_n[2]}
N 1720 -930 1720 -910 {
lab=row_n[2]}
N 1600 -830 1610 -840 {
lab=VDD}
N 1610 -840 1810 -840 {
lab=VDD}
N 1810 -840 1820 -830 {
lab=VDD}
N 1600 -810 1610 -820 {
lab=VDD}
N 1610 -820 1810 -820 {
lab=VDD}
N 1810 -820 1820 -810 {
lab=VDD}
N 1600 -790 1610 -800 {
lab=VSS}
N 1610 -800 1810 -800 {
lab=VSS}
N 1810 -800 1820 -790 {
lab=VSS}
N 1600 -770 1610 -780 {
lab=VDD}
N 1610 -780 1810 -780 {
lab=VDD}
N 1810 -780 1820 -770 {
lab=VDD}
N 1820 -770 1840 -770 {
lab=VDD}
N 1820 -790 1840 -790 {
lab=VSS}
N 1820 -810 1840 -810 {
lab=VDD}
N 1820 -830 1840 -830 {
lab=VDD}
N 1580 -830 1600 -830 {
lab=VDD}
N 1580 -810 1600 -810 {
lab=VDD}
N 1580 -790 1600 -790 {
lab=VSS}
N 1580 -770 1600 -770 {
lab=VDD}
N 1640 -690 1640 -680 {
lab=VSS}
N 1660 -930 1660 -910 {
lab=vcom}
N 1640 -920 1640 -910 {
lab=VDD}
N 1720 -690 1720 -670 {
lab=row_n[2]}
N 1440 -930 1440 -910 {
lab=ctop}
N 1700 -930 1700 -910 {
lab=ctop}
N 1980 -690 1990 -700 {
lab=row_n[3]}
N 1990 -900 1990 -700 {
lab=row_n[3]}
N 1980 -910 1990 -900 {
lab=row_n[3]}
N 1980 -930 1980 -910 {
lab=row_n[3]}
N 1860 -830 1870 -840 {
lab=VDD}
N 1870 -840 2070 -840 {
lab=VDD}
N 2070 -840 2080 -830 {
lab=VDD}
N 1860 -810 1870 -820 {
lab=VDD}
N 1870 -820 2070 -820 {
lab=VDD}
N 2070 -820 2080 -810 {
lab=VDD}
N 1860 -790 1870 -800 {
lab=VSS}
N 1870 -800 2070 -800 {
lab=VSS}
N 2070 -800 2080 -790 {
lab=VSS}
N 1860 -770 1870 -780 {
lab=VDD}
N 1870 -780 2070 -780 {
lab=VDD}
N 2070 -780 2080 -770 {
lab=VDD}
N 2080 -770 2100 -770 {
lab=VDD}
N 2080 -790 2100 -790 {
lab=VSS}
N 2080 -810 2100 -810 {
lab=VDD}
N 2080 -830 2100 -830 {
lab=VDD}
N 1840 -830 1860 -830 {
lab=VDD}
N 1840 -810 1860 -810 {
lab=VDD}
N 1840 -790 1860 -790 {
lab=VSS}
N 1840 -770 1860 -770 {
lab=VDD}
N 1900 -690 1900 -680 {
lab=VSS}
N 1920 -930 1920 -910 {
lab=vcom}
N 1900 -920 1900 -910 {
lab=VDD}
N 1980 -690 1980 -670 {
lab=row_n[3]}
N 2240 -690 2250 -700 {
lab=row_n[4]}
N 2250 -900 2250 -700 {
lab=row_n[4]}
N 2240 -910 2250 -900 {
lab=row_n[4]}
N 2240 -930 2240 -910 {
lab=row_n[4]}
N 2120 -830 2130 -840 {
lab=VDD}
N 2130 -840 2330 -840 {
lab=VDD}
N 2330 -840 2340 -830 {
lab=VDD}
N 2120 -810 2130 -820 {
lab=VDD}
N 2130 -820 2330 -820 {
lab=VDD}
N 2330 -820 2340 -810 {
lab=VDD}
N 2120 -790 2130 -800 {
lab=VSS}
N 2130 -800 2330 -800 {
lab=VSS}
N 2330 -800 2340 -790 {
lab=VSS}
N 2120 -770 2130 -780 {
lab=VDD}
N 2130 -780 2330 -780 {
lab=VDD}
N 2330 -780 2340 -770 {
lab=VDD}
N 2340 -770 2360 -770 {
lab=VDD}
N 2340 -790 2360 -790 {
lab=VSS}
N 2340 -810 2360 -810 {
lab=VDD}
N 2340 -830 2360 -830 {
lab=VDD}
N 2100 -830 2120 -830 {
lab=VDD}
N 2100 -810 2120 -810 {
lab=VDD}
N 2100 -790 2120 -790 {
lab=VSS}
N 2100 -770 2120 -770 {
lab=VDD}
N 2160 -690 2160 -680 {
lab=VSS}
N 2180 -930 2180 -910 {
lab=vcom}
N 2160 -920 2160 -910 {
lab=VDD}
N 2240 -690 2240 -670 {
lab=row_n[4]}
N 1960 -930 1960 -910 {
lab=ctop}
N 2220 -930 2220 -910 {
lab=ctop}
N 2500 -690 2510 -700 {
lab=row_n[5]}
N 2510 -900 2510 -700 {
lab=row_n[5]}
N 2500 -910 2510 -900 {
lab=row_n[5]}
N 2500 -930 2500 -910 {
lab=row_n[5]}
N 2380 -830 2390 -840 {
lab=VDD}
N 2390 -840 2590 -840 {
lab=VDD}
N 2590 -840 2600 -830 {
lab=VDD}
N 2380 -810 2390 -820 {
lab=VDD}
N 2390 -820 2590 -820 {
lab=VDD}
N 2590 -820 2600 -810 {
lab=VDD}
N 2380 -790 2390 -800 {
lab=VSS}
N 2390 -800 2590 -800 {
lab=VSS}
N 2590 -800 2600 -790 {
lab=VSS}
N 2380 -770 2390 -780 {
lab=VDD}
N 2390 -780 2590 -780 {
lab=VDD}
N 2590 -780 2600 -770 {
lab=VDD}
N 2600 -770 2620 -770 {
lab=VDD}
N 2600 -790 2620 -790 {
lab=VSS}
N 2600 -810 2620 -810 {
lab=VDD}
N 2600 -830 2620 -830 {
lab=VDD}
N 2360 -830 2380 -830 {
lab=VDD}
N 2360 -810 2380 -810 {
lab=VDD}
N 2360 -790 2380 -790 {
lab=VSS}
N 2360 -770 2380 -770 {
lab=VDD}
N 2420 -690 2420 -680 {
lab=VSS}
N 2440 -930 2440 -910 {
lab=vcom}
N 2420 -920 2420 -910 {
lab=VDD}
N 2500 -690 2500 -670 {
lab=row_n[5]}
N 2760 -690 2770 -700 {
lab=row_n[6]}
N 2770 -900 2770 -700 {
lab=row_n[6]}
N 2760 -910 2770 -900 {
lab=row_n[6]}
N 2760 -930 2760 -910 {
lab=row_n[6]}
N 2640 -830 2650 -840 {
lab=VDD}
N 2650 -840 2850 -840 {
lab=VDD}
N 2850 -840 2860 -830 {
lab=VDD}
N 2640 -810 2650 -820 {
lab=VDD}
N 2650 -820 2850 -820 {
lab=VDD}
N 2850 -820 2860 -810 {
lab=VDD}
N 2640 -790 2650 -800 {
lab=VSS}
N 2650 -800 2850 -800 {
lab=VSS}
N 2850 -800 2860 -790 {
lab=VSS}
N 2640 -770 2650 -780 {
lab=VDD}
N 2650 -780 2850 -780 {
lab=VDD}
N 2850 -780 2860 -770 {
lab=VDD}
N 2860 -770 2880 -770 {
lab=VDD}
N 2860 -790 2880 -790 {
lab=VSS}
N 2860 -810 2880 -810 {
lab=VDD}
N 2860 -830 2880 -830 {
lab=VDD}
N 2620 -830 2640 -830 {
lab=VDD}
N 2620 -810 2640 -810 {
lab=VDD}
N 2620 -790 2640 -790 {
lab=VSS}
N 2620 -770 2640 -770 {
lab=VDD}
N 2680 -690 2680 -680 {
lab=VSS}
N 2700 -930 2700 -910 {
lab=vcom}
N 2680 -920 2680 -910 {
lab=VDD}
N 2760 -690 2760 -670 {
lab=row_n[6]}
N 2480 -930 2480 -910 {
lab=ctop}
N 2740 -930 2740 -910 {
lab=ctop}
N 3020 -690 3030 -700 {
lab=row_n[7]}
N 3030 -900 3030 -700 {
lab=row_n[7]}
N 3020 -910 3030 -900 {
lab=row_n[7]}
N 3020 -930 3020 -910 {
lab=row_n[7]}
N 2900 -830 2910 -840 {
lab=VDD}
N 2910 -840 3110 -840 {
lab=VDD}
N 3110 -840 3120 -830 {
lab=VDD}
N 2900 -810 2910 -820 {
lab=VDD}
N 2910 -820 3110 -820 {
lab=VDD}
N 3110 -820 3120 -810 {
lab=VDD}
N 2900 -790 2910 -800 {
lab=VSS}
N 2910 -800 3110 -800 {
lab=VSS}
N 3110 -800 3120 -790 {
lab=VSS}
N 2900 -770 2910 -780 {
lab=VDD}
N 2910 -780 3110 -780 {
lab=VDD}
N 3110 -780 3120 -770 {
lab=VDD}
N 3120 -770 3140 -770 {
lab=VDD}
N 3120 -790 3140 -790 {
lab=VSS}
N 3120 -810 3140 -810 {
lab=VDD}
N 3120 -830 3140 -830 {
lab=VDD}
N 2880 -830 2900 -830 {
lab=VDD}
N 2880 -810 2900 -810 {
lab=VDD}
N 2880 -790 2900 -790 {
lab=VSS}
N 2880 -770 2900 -770 {
lab=VDD}
N 2940 -690 2940 -680 {
lab=VSS}
N 2960 -930 2960 -910 {
lab=vcom}
N 2940 -920 2940 -910 {
lab=VDD}
N 3020 -690 3020 -670 {
lab=row_n[7]}
N 3280 -690 3290 -700 {
lab=row_n[8]}
N 3290 -900 3290 -700 {
lab=row_n[8]}
N 3280 -910 3290 -900 {
lab=row_n[8]}
N 3280 -930 3280 -910 {
lab=row_n[8]}
N 3160 -830 3170 -840 {
lab=VDD}
N 3170 -840 3370 -840 {
lab=VDD}
N 3370 -840 3380 -830 {
lab=VDD}
N 3160 -810 3170 -820 {
lab=VDD}
N 3170 -820 3370 -820 {
lab=VDD}
N 3370 -820 3380 -810 {
lab=VDD}
N 3160 -790 3170 -800 {
lab=VSS}
N 3170 -800 3370 -800 {
lab=VSS}
N 3370 -800 3380 -790 {
lab=VSS}
N 3160 -770 3170 -780 {
lab=VDD}
N 3170 -780 3370 -780 {
lab=VDD}
N 3370 -780 3380 -770 {
lab=VDD}
N 3380 -770 3400 -770 {
lab=VDD}
N 3380 -790 3400 -790 {
lab=VSS}
N 3380 -810 3400 -810 {
lab=VDD}
N 3380 -830 3400 -830 {
lab=VDD}
N 3140 -830 3160 -830 {
lab=VDD}
N 3140 -810 3160 -810 {
lab=VDD}
N 3140 -790 3160 -790 {
lab=VSS}
N 3140 -770 3160 -770 {
lab=VDD}
N 3200 -690 3200 -680 {
lab=VSS}
N 3220 -930 3220 -910 {
lab=vcom}
N 3200 -920 3200 -910 {
lab=VDD}
N 3280 -690 3280 -670 {
lab=row_n[8]}
N 3000 -930 3000 -910 {
lab=ctop}
N 3260 -930 3260 -910 {
lab=ctop}
N 3540 -690 3550 -700 {
lab=row_n[9]}
N 3550 -900 3550 -700 {
lab=row_n[9]}
N 3540 -910 3550 -900 {
lab=row_n[9]}
N 3540 -930 3540 -910 {
lab=row_n[9]}
N 3420 -830 3430 -840 {
lab=VDD}
N 3430 -840 3630 -840 {
lab=VDD}
N 3630 -840 3640 -830 {
lab=VDD}
N 3420 -810 3430 -820 {
lab=VDD}
N 3430 -820 3630 -820 {
lab=VDD}
N 3630 -820 3640 -810 {
lab=VDD}
N 3420 -790 3430 -800 {
lab=VSS}
N 3430 -800 3630 -800 {
lab=VSS}
N 3630 -800 3640 -790 {
lab=VSS}
N 3420 -770 3430 -780 {
lab=VDD}
N 3430 -780 3630 -780 {
lab=VDD}
N 3630 -780 3640 -770 {
lab=VDD}
N 3640 -770 3660 -770 {
lab=VDD}
N 3640 -790 3660 -790 {
lab=VSS}
N 3640 -810 3660 -810 {
lab=VDD}
N 3640 -830 3660 -830 {
lab=VDD}
N 3400 -830 3420 -830 {
lab=VDD}
N 3400 -810 3420 -810 {
lab=VDD}
N 3400 -790 3420 -790 {
lab=VSS}
N 3400 -770 3420 -770 {
lab=VDD}
N 3460 -690 3460 -680 {
lab=VSS}
N 3480 -930 3480 -910 {
lab=vcom}
N 3460 -920 3460 -910 {
lab=VDD}
N 3540 -690 3540 -670 {
lab=row_n[9]}
N 3800 -690 3810 -700 {
lab=row_n[10]}
N 3810 -900 3810 -700 {
lab=row_n[10]}
N 3800 -910 3810 -900 {
lab=row_n[10]}
N 3800 -930 3800 -910 {
lab=row_n[10]}
N 3680 -830 3690 -840 {
lab=VDD}
N 3690 -840 3890 -840 {
lab=VDD}
N 3890 -840 3900 -830 {
lab=VDD}
N 3680 -810 3690 -820 {
lab=VDD}
N 3690 -820 3890 -820 {
lab=VDD}
N 3890 -820 3900 -810 {
lab=VDD}
N 3680 -790 3690 -800 {
lab=VSS}
N 3690 -800 3890 -800 {
lab=VSS}
N 3890 -800 3900 -790 {
lab=VSS}
N 3680 -770 3690 -780 {
lab=VDD}
N 3690 -780 3890 -780 {
lab=VDD}
N 3890 -780 3900 -770 {
lab=VDD}
N 3900 -770 3920 -770 {
lab=VDD}
N 3900 -790 3920 -790 {
lab=VSS}
N 3900 -810 3920 -810 {
lab=VDD}
N 3900 -830 3920 -830 {
lab=VDD}
N 3660 -830 3680 -830 {
lab=VDD}
N 3660 -810 3680 -810 {
lab=VDD}
N 3660 -790 3680 -790 {
lab=VSS}
N 3660 -770 3680 -770 {
lab=VDD}
N 3720 -690 3720 -680 {
lab=VSS}
N 3740 -930 3740 -910 {
lab=vcom}
N 3720 -920 3720 -910 {
lab=VDD}
N 3800 -690 3800 -670 {
lab=row_n[10]}
N 3520 -930 3520 -910 {
lab=ctop}
N 3780 -930 3780 -910 {
lab=ctop}
N 4060 -690 4070 -700 {
lab=row_n[11]}
N 4070 -900 4070 -700 {
lab=row_n[11]}
N 4060 -910 4070 -900 {
lab=row_n[11]}
N 4060 -930 4060 -910 {
lab=row_n[11]}
N 3940 -830 3950 -840 {
lab=VDD}
N 3950 -840 4150 -840 {
lab=VDD}
N 4150 -840 4160 -830 {
lab=VDD}
N 3940 -810 3950 -820 {
lab=VDD}
N 3950 -820 4150 -820 {
lab=VDD}
N 4150 -820 4160 -810 {
lab=VDD}
N 3940 -790 3950 -800 {
lab=VSS}
N 3950 -800 4150 -800 {
lab=VSS}
N 4150 -800 4160 -790 {
lab=VSS}
N 3940 -770 3950 -780 {
lab=VDD}
N 3950 -780 4150 -780 {
lab=VDD}
N 4150 -780 4160 -770 {
lab=VDD}
N 4160 -770 4180 -770 {
lab=VDD}
N 4160 -790 4180 -790 {
lab=VSS}
N 4160 -810 4180 -810 {
lab=VDD}
N 4160 -830 4180 -830 {
lab=VDD}
N 3920 -830 3940 -830 {
lab=VDD}
N 3920 -810 3940 -810 {
lab=VDD}
N 3920 -790 3940 -790 {
lab=VSS}
N 3920 -770 3940 -770 {
lab=VDD}
N 3980 -690 3980 -680 {
lab=VSS}
N 4000 -930 4000 -910 {
lab=vcom}
N 3980 -920 3980 -910 {
lab=VDD}
N 4060 -690 4060 -670 {
lab=row_n[11]}
N 4320 -690 4330 -700 {
lab=row_n[12]}
N 4330 -900 4330 -700 {
lab=row_n[12]}
N 4320 -910 4330 -900 {
lab=row_n[12]}
N 4320 -930 4320 -910 {
lab=row_n[12]}
N 4200 -830 4210 -840 {
lab=VDD}
N 4210 -840 4410 -840 {
lab=VDD}
N 4410 -840 4420 -830 {
lab=VDD}
N 4200 -810 4210 -820 {
lab=VDD}
N 4210 -820 4410 -820 {
lab=VDD}
N 4410 -820 4420 -810 {
lab=VDD}
N 4200 -790 4210 -800 {
lab=VSS}
N 4210 -800 4410 -800 {
lab=VSS}
N 4410 -800 4420 -790 {
lab=VSS}
N 4200 -770 4210 -780 {
lab=VDD}
N 4210 -780 4410 -780 {
lab=VDD}
N 4410 -780 4420 -770 {
lab=VDD}
N 4420 -770 4440 -770 {
lab=VDD}
N 4420 -790 4440 -790 {
lab=VSS}
N 4420 -810 4440 -810 {
lab=VDD}
N 4420 -830 4440 -830 {
lab=VDD}
N 4180 -830 4200 -830 {
lab=VDD}
N 4180 -810 4200 -810 {
lab=VDD}
N 4180 -790 4200 -790 {
lab=VSS}
N 4180 -770 4200 -770 {
lab=VDD}
N 4240 -690 4240 -680 {
lab=VSS}
N 4260 -930 4260 -910 {
lab=vcom}
N 4240 -920 4240 -910 {
lab=VDD}
N 4320 -690 4320 -670 {
lab=row_n[12]}
N 4040 -930 4040 -910 {
lab=ctop}
N 4300 -930 4300 -910 {
lab=ctop}
N 4580 -690 4590 -700 {
lab=row_n[13]}
N 4590 -900 4590 -700 {
lab=row_n[13]}
N 4580 -910 4590 -900 {
lab=row_n[13]}
N 4580 -930 4580 -910 {
lab=row_n[13]}
N 4460 -830 4470 -840 {
lab=VDD}
N 4470 -840 4670 -840 {
lab=VDD}
N 4670 -840 4680 -830 {
lab=VDD}
N 4460 -810 4470 -820 {
lab=VDD}
N 4470 -820 4670 -820 {
lab=VDD}
N 4670 -820 4680 -810 {
lab=VDD}
N 4460 -790 4470 -800 {
lab=VSS}
N 4470 -800 4670 -800 {
lab=VSS}
N 4670 -800 4680 -790 {
lab=VSS}
N 4460 -770 4470 -780 {
lab=VDD}
N 4470 -780 4670 -780 {
lab=VDD}
N 4670 -780 4680 -770 {
lab=VDD}
N 4680 -770 4700 -770 {
lab=VDD}
N 4680 -790 4700 -790 {
lab=VSS}
N 4680 -810 4700 -810 {
lab=VDD}
N 4680 -830 4700 -830 {
lab=VDD}
N 4440 -830 4460 -830 {
lab=VDD}
N 4440 -810 4460 -810 {
lab=VDD}
N 4440 -790 4460 -790 {
lab=VSS}
N 4440 -770 4460 -770 {
lab=VDD}
N 4500 -690 4500 -680 {
lab=VSS}
N 4520 -930 4520 -910 {
lab=vcom}
N 4500 -920 4500 -910 {
lab=VDD}
N 4580 -690 4580 -670 {
lab=row_n[13]}
N 4840 -690 4850 -700 {
lab=row_n[14]}
N 4850 -900 4850 -700 {
lab=row_n[14]}
N 4840 -910 4850 -900 {
lab=row_n[14]}
N 4840 -930 4840 -910 {
lab=row_n[14]}
N 4720 -830 4730 -840 {
lab=VDD}
N 4730 -840 4930 -840 {
lab=VDD}
N 4930 -840 4940 -830 {
lab=VDD}
N 4720 -810 4730 -820 {
lab=VDD}
N 4730 -820 4930 -820 {
lab=VDD}
N 4930 -820 4940 -810 {
lab=VDD}
N 4720 -790 4730 -800 {
lab=VSS}
N 4730 -800 4930 -800 {
lab=VSS}
N 4930 -800 4940 -790 {
lab=VSS}
N 4720 -770 4730 -780 {
lab=VDD}
N 4730 -780 4930 -780 {
lab=VDD}
N 4930 -780 4940 -770 {
lab=VDD}
N 4940 -770 4960 -770 {
lab=VDD}
N 4940 -790 4960 -790 {
lab=VSS}
N 4940 -810 4960 -810 {
lab=VDD}
N 4940 -830 4960 -830 {
lab=VDD}
N 4700 -830 4720 -830 {
lab=VDD}
N 4700 -810 4720 -810 {
lab=VDD}
N 4700 -790 4720 -790 {
lab=VSS}
N 4700 -770 4720 -770 {
lab=VDD}
N 4760 -690 4760 -680 {
lab=VSS}
N 4780 -930 4780 -910 {
lab=vcom}
N 4760 -920 4760 -910 {
lab=VDD}
N 4840 -690 4840 -670 {
lab=row_n[14]}
N 4560 -930 4560 -910 {
lab=ctop}
N 4820 -930 4820 -910 {
lab=ctop}
N 5100 -690 5110 -700 {
lab=row_n[15]}
N 5110 -900 5110 -700 {
lab=row_n[15]}
N 5100 -910 5110 -900 {
lab=row_n[15]}
N 5100 -930 5100 -910 {
lab=row_n[15]}
N 4980 -830 4990 -840 {
lab=VDD}
N 4990 -840 5190 -840 {
lab=VDD}
N 5190 -840 5200 -830 {
lab=VDD}
N 4980 -810 4990 -820 {
lab=VDD}
N 4990 -820 5190 -820 {
lab=VDD}
N 5190 -820 5200 -810 {
lab=VDD}
N 4980 -790 4990 -800 {
lab=VSS}
N 4990 -800 5190 -800 {
lab=VSS}
N 5190 -800 5200 -790 {
lab=VSS}
N 4980 -770 4990 -780 {
lab=VDD}
N 4990 -780 5190 -780 {
lab=VDD}
N 5190 -780 5200 -770 {
lab=VDD}
N 5200 -770 5220 -770 {
lab=VDD}
N 5200 -790 5220 -790 {
lab=VSS}
N 5200 -810 5220 -810 {
lab=VDD}
N 5200 -830 5220 -830 {
lab=VDD}
N 4960 -830 4980 -830 {
lab=VDD}
N 4960 -810 4980 -810 {
lab=VDD}
N 4960 -790 4980 -790 {
lab=VSS}
N 4960 -770 4980 -770 {
lab=VDD}
N 5020 -690 5020 -680 {
lab=VSS}
N 5040 -930 5040 -910 {
lab=vcom}
N 5020 -920 5020 -910 {
lab=VDD}
N 5100 -690 5100 -670 {
lab=row_n[15]}
N 5360 -690 5370 -700 {
lab=row_n[16]}
N 5370 -900 5370 -700 {
lab=row_n[16]}
N 5360 -910 5370 -900 {
lab=row_n[16]}
N 5360 -930 5360 -910 {
lab=row_n[16]}
N 5240 -830 5250 -840 {
lab=VDD}
N 5250 -840 5450 -840 {
lab=VDD}
N 5450 -840 5460 -830 {
lab=VDD}
N 5240 -810 5250 -820 {
lab=VDD}
N 5250 -820 5450 -820 {
lab=VDD}
N 5450 -820 5460 -810 {
lab=VDD}
N 5240 -790 5250 -800 {
lab=VSS}
N 5250 -800 5450 -800 {
lab=VSS}
N 5450 -800 5460 -790 {
lab=VSS}
N 5240 -770 5250 -780 {
lab=VDD}
N 5250 -780 5450 -780 {
lab=VDD}
N 5450 -780 5460 -770 {
lab=VDD}
N 5460 -770 5480 -770 {
lab=VDD}
N 5460 -790 5480 -790 {
lab=VSS}
N 5460 -810 5480 -810 {
lab=VDD}
N 5460 -830 5480 -830 {
lab=VDD}
N 5220 -830 5240 -830 {
lab=VDD}
N 5220 -810 5240 -810 {
lab=VDD}
N 5220 -790 5240 -790 {
lab=VSS}
N 5220 -770 5240 -770 {
lab=VDD}
N 5280 -690 5280 -680 {
lab=VSS}
N 5300 -930 5300 -910 {
lab=vcom}
N 5280 -920 5280 -910 {
lab=VDD}
N 5360 -690 5360 -670 {
lab=row_n[16]}
N 5080 -930 5080 -910 {
lab=ctop}
N 5340 -930 5340 -910 {
lab=ctop}
N 5620 -690 5630 -700 {
lab=row_n[17]}
N 5630 -900 5630 -700 {
lab=row_n[17]}
N 5620 -910 5630 -900 {
lab=row_n[17]}
N 5620 -930 5620 -910 {
lab=row_n[17]}
N 5500 -830 5510 -840 {
lab=VDD}
N 5510 -840 5710 -840 {
lab=VDD}
N 5710 -840 5720 -830 {
lab=VDD}
N 5500 -810 5510 -820 {
lab=VDD}
N 5510 -820 5710 -820 {
lab=VDD}
N 5710 -820 5720 -810 {
lab=VDD}
N 5500 -790 5510 -800 {
lab=VSS}
N 5510 -800 5710 -800 {
lab=VSS}
N 5710 -800 5720 -790 {
lab=VSS}
N 5500 -770 5510 -780 {
lab=VDD}
N 5510 -780 5710 -780 {
lab=VDD}
N 5710 -780 5720 -770 {
lab=VDD}
N 5720 -770 5740 -770 {
lab=VDD}
N 5720 -790 5740 -790 {
lab=VSS}
N 5720 -810 5740 -810 {
lab=VDD}
N 5720 -830 5740 -830 {
lab=VDD}
N 5480 -830 5500 -830 {
lab=VDD}
N 5480 -810 5500 -810 {
lab=VDD}
N 5480 -790 5500 -790 {
lab=VSS}
N 5480 -770 5500 -770 {
lab=VDD}
N 5540 -690 5540 -680 {
lab=VSS}
N 5560 -930 5560 -910 {
lab=vcom}
N 5540 -920 5540 -910 {
lab=VDD}
N 5620 -690 5620 -670 {
lab=row_n[17]}
N 5880 -690 5890 -700 {
lab=row_n[18]}
N 5890 -900 5890 -700 {
lab=row_n[18]}
N 5880 -910 5890 -900 {
lab=row_n[18]}
N 5880 -930 5880 -910 {
lab=row_n[18]}
N 5760 -830 5770 -840 {
lab=VDD}
N 5770 -840 5970 -840 {
lab=VDD}
N 5970 -840 5980 -830 {
lab=VDD}
N 5760 -810 5770 -820 {
lab=VDD}
N 5770 -820 5970 -820 {
lab=VDD}
N 5970 -820 5980 -810 {
lab=VDD}
N 5760 -790 5770 -800 {
lab=VSS}
N 5770 -800 5970 -800 {
lab=VSS}
N 5970 -800 5980 -790 {
lab=VSS}
N 5760 -770 5770 -780 {
lab=VDD}
N 5770 -780 5970 -780 {
lab=VDD}
N 5970 -780 5980 -770 {
lab=VDD}
N 5980 -770 6000 -770 {
lab=VDD}
N 5980 -790 6000 -790 {
lab=VSS}
N 5980 -810 6000 -810 {
lab=VDD}
N 5980 -830 6000 -830 {
lab=VDD}
N 5740 -830 5760 -830 {
lab=VDD}
N 5740 -810 5760 -810 {
lab=VDD}
N 5740 -790 5760 -790 {
lab=VSS}
N 5740 -770 5760 -770 {
lab=VDD}
N 5800 -690 5800 -680 {
lab=VSS}
N 5820 -930 5820 -910 {
lab=vcom}
N 5800 -920 5800 -910 {
lab=VDD}
N 5880 -690 5880 -670 {
lab=row_n[18]}
N 5600 -930 5600 -910 {
lab=ctop}
N 5860 -930 5860 -910 {
lab=ctop}
N 6140 -690 6150 -700 {
lab=row_n[19]}
N 6150 -900 6150 -700 {
lab=row_n[19]}
N 6140 -910 6150 -900 {
lab=row_n[19]}
N 6140 -930 6140 -910 {
lab=row_n[19]}
N 6020 -830 6030 -840 {
lab=VDD}
N 6030 -840 6230 -840 {
lab=VDD}
N 6230 -840 6240 -830 {
lab=VDD}
N 6020 -810 6030 -820 {
lab=VDD}
N 6030 -820 6230 -820 {
lab=VDD}
N 6230 -820 6240 -810 {
lab=VDD}
N 6020 -790 6030 -800 {
lab=VSS}
N 6030 -800 6230 -800 {
lab=VSS}
N 6230 -800 6240 -790 {
lab=VSS}
N 6020 -770 6030 -780 {
lab=VDD}
N 6030 -780 6230 -780 {
lab=VDD}
N 6230 -780 6240 -770 {
lab=VDD}
N 6240 -770 6260 -770 {
lab=VDD}
N 6240 -790 6260 -790 {
lab=VSS}
N 6240 -810 6260 -810 {
lab=VDD}
N 6240 -830 6260 -830 {
lab=VDD}
N 6000 -830 6020 -830 {
lab=VDD}
N 6000 -810 6020 -810 {
lab=VDD}
N 6000 -790 6020 -790 {
lab=VSS}
N 6000 -770 6020 -770 {
lab=VDD}
N 6060 -690 6060 -680 {
lab=VSS}
N 6080 -930 6080 -910 {
lab=vcom}
N 6060 -920 6060 -910 {
lab=VDD}
N 6140 -690 6140 -670 {
lab=row_n[19]}
N 6400 -690 6410 -700 {
lab=row_n[20]}
N 6410 -900 6410 -700 {
lab=row_n[20]}
N 6400 -910 6410 -900 {
lab=row_n[20]}
N 6400 -930 6400 -910 {
lab=row_n[20]}
N 6280 -830 6290 -840 {
lab=VDD}
N 6290 -840 6490 -840 {
lab=VDD}
N 6490 -840 6500 -830 {
lab=VDD}
N 6280 -810 6290 -820 {
lab=VDD}
N 6290 -820 6490 -820 {
lab=VDD}
N 6490 -820 6500 -810 {
lab=VDD}
N 6280 -790 6290 -800 {
lab=VSS}
N 6290 -800 6490 -800 {
lab=VSS}
N 6490 -800 6500 -790 {
lab=VSS}
N 6280 -770 6290 -780 {
lab=VDD}
N 6290 -780 6490 -780 {
lab=VDD}
N 6490 -780 6500 -770 {
lab=VDD}
N 6500 -770 6520 -770 {
lab=VDD}
N 6500 -790 6520 -790 {
lab=VSS}
N 6500 -810 6520 -810 {
lab=VDD}
N 6500 -830 6520 -830 {
lab=VDD}
N 6260 -830 6280 -830 {
lab=VDD}
N 6260 -810 6280 -810 {
lab=VDD}
N 6260 -790 6280 -790 {
lab=VSS}
N 6260 -770 6280 -770 {
lab=VDD}
N 6320 -690 6320 -680 {
lab=VSS}
N 6340 -930 6340 -910 {
lab=vcom}
N 6320 -920 6320 -910 {
lab=VDD}
N 6400 -690 6400 -670 {
lab=row_n[20]}
N 6120 -930 6120 -910 {
lab=ctop}
N 6380 -930 6380 -910 {
lab=ctop}
N 6660 -690 6670 -700 {
lab=row_n[21]}
N 6670 -900 6670 -700 {
lab=row_n[21]}
N 6660 -910 6670 -900 {
lab=row_n[21]}
N 6660 -930 6660 -910 {
lab=row_n[21]}
N 6540 -830 6550 -840 {
lab=VDD}
N 6550 -840 6750 -840 {
lab=VDD}
N 6750 -840 6760 -830 {
lab=VDD}
N 6540 -810 6550 -820 {
lab=VDD}
N 6550 -820 6750 -820 {
lab=VDD}
N 6750 -820 6760 -810 {
lab=VDD}
N 6540 -790 6550 -800 {
lab=VSS}
N 6550 -800 6750 -800 {
lab=VSS}
N 6750 -800 6760 -790 {
lab=VSS}
N 6540 -770 6550 -780 {
lab=VDD}
N 6550 -780 6750 -780 {
lab=VDD}
N 6750 -780 6760 -770 {
lab=VDD}
N 6760 -770 6780 -770 {
lab=VDD}
N 6760 -790 6780 -790 {
lab=VSS}
N 6760 -810 6780 -810 {
lab=VDD}
N 6760 -830 6780 -830 {
lab=VDD}
N 6520 -830 6540 -830 {
lab=VDD}
N 6520 -810 6540 -810 {
lab=VDD}
N 6520 -790 6540 -790 {
lab=VSS}
N 6520 -770 6540 -770 {
lab=VDD}
N 6580 -690 6580 -680 {
lab=VSS}
N 6600 -930 6600 -910 {
lab=vcom}
N 6580 -920 6580 -910 {
lab=VDD}
N 6660 -690 6660 -670 {
lab=row_n[21]}
N 6920 -690 6930 -700 {
lab=row_n[22]}
N 6930 -900 6930 -700 {
lab=row_n[22]}
N 6920 -910 6930 -900 {
lab=row_n[22]}
N 6920 -930 6920 -910 {
lab=row_n[22]}
N 6800 -830 6810 -840 {
lab=VDD}
N 6810 -840 7010 -840 {
lab=VDD}
N 7010 -840 7020 -830 {
lab=VDD}
N 6800 -810 6810 -820 {
lab=VDD}
N 6810 -820 7010 -820 {
lab=VDD}
N 7010 -820 7020 -810 {
lab=VDD}
N 6800 -790 6810 -800 {
lab=VSS}
N 6810 -800 7010 -800 {
lab=VSS}
N 7010 -800 7020 -790 {
lab=VSS}
N 6800 -770 6810 -780 {
lab=VDD}
N 6810 -780 7010 -780 {
lab=VDD}
N 7010 -780 7020 -770 {
lab=VDD}
N 7020 -770 7040 -770 {
lab=VDD}
N 7020 -790 7040 -790 {
lab=VSS}
N 7020 -810 7040 -810 {
lab=VDD}
N 7020 -830 7040 -830 {
lab=VDD}
N 6780 -830 6800 -830 {
lab=VDD}
N 6780 -810 6800 -810 {
lab=VDD}
N 6780 -790 6800 -790 {
lab=VSS}
N 6780 -770 6800 -770 {
lab=VDD}
N 6840 -690 6840 -680 {
lab=VSS}
N 6860 -930 6860 -910 {
lab=vcom}
N 6840 -920 6840 -910 {
lab=VDD}
N 6920 -690 6920 -670 {
lab=row_n[22]}
N 6640 -930 6640 -910 {
lab=ctop}
N 6900 -930 6900 -910 {
lab=ctop}
N 7180 -690 7190 -700 {
lab=row_n[23]}
N 7190 -900 7190 -700 {
lab=row_n[23]}
N 7180 -910 7190 -900 {
lab=row_n[23]}
N 7180 -930 7180 -910 {
lab=row_n[23]}
N 7060 -830 7070 -840 {
lab=VDD}
N 7070 -840 7270 -840 {
lab=VDD}
N 7270 -840 7280 -830 {
lab=VDD}
N 7060 -810 7070 -820 {
lab=VDD}
N 7070 -820 7270 -820 {
lab=VDD}
N 7270 -820 7280 -810 {
lab=VDD}
N 7060 -790 7070 -800 {
lab=VSS}
N 7070 -800 7270 -800 {
lab=VSS}
N 7270 -800 7280 -790 {
lab=VSS}
N 7060 -770 7070 -780 {
lab=VDD}
N 7070 -780 7270 -780 {
lab=VDD}
N 7270 -780 7280 -770 {
lab=VDD}
N 7280 -770 7300 -770 {
lab=VDD}
N 7280 -790 7300 -790 {
lab=VSS}
N 7280 -810 7300 -810 {
lab=VDD}
N 7280 -830 7300 -830 {
lab=VDD}
N 7040 -830 7060 -830 {
lab=VDD}
N 7040 -810 7060 -810 {
lab=VDD}
N 7040 -790 7060 -790 {
lab=VSS}
N 7040 -770 7060 -770 {
lab=VDD}
N 7100 -690 7100 -680 {
lab=VSS}
N 7120 -930 7120 -910 {
lab=vcom}
N 7100 -920 7100 -910 {
lab=VDD}
N 7180 -690 7180 -670 {
lab=row_n[23]}
N 7440 -690 7450 -700 {
lab=row_n[24]}
N 7450 -900 7450 -700 {
lab=row_n[24]}
N 7440 -910 7450 -900 {
lab=row_n[24]}
N 7440 -930 7440 -910 {
lab=row_n[24]}
N 7320 -830 7330 -840 {
lab=VDD}
N 7330 -840 7530 -840 {
lab=VDD}
N 7530 -840 7540 -830 {
lab=VDD}
N 7320 -810 7330 -820 {
lab=VDD}
N 7330 -820 7530 -820 {
lab=VDD}
N 7530 -820 7540 -810 {
lab=VDD}
N 7320 -790 7330 -800 {
lab=VSS}
N 7330 -800 7530 -800 {
lab=VSS}
N 7530 -800 7540 -790 {
lab=VSS}
N 7320 -770 7330 -780 {
lab=VDD}
N 7330 -780 7530 -780 {
lab=VDD}
N 7530 -780 7540 -770 {
lab=VDD}
N 7540 -770 7560 -770 {
lab=VDD}
N 7540 -790 7560 -790 {
lab=VSS}
N 7540 -810 7560 -810 {
lab=VDD}
N 7540 -830 7560 -830 {
lab=VDD}
N 7300 -830 7320 -830 {
lab=VDD}
N 7300 -810 7320 -810 {
lab=VDD}
N 7300 -790 7320 -790 {
lab=VSS}
N 7300 -770 7320 -770 {
lab=VDD}
N 7360 -690 7360 -680 {
lab=VSS}
N 7380 -930 7380 -910 {
lab=vcom}
N 7360 -920 7360 -910 {
lab=VDD}
N 7440 -690 7440 -670 {
lab=row_n[24]}
N 7160 -930 7160 -910 {
lab=ctop}
N 7420 -930 7420 -910 {
lab=ctop}
N 7700 -690 7710 -700 {
lab=row_n[25]}
N 7710 -900 7710 -700 {
lab=row_n[25]}
N 7700 -910 7710 -900 {
lab=row_n[25]}
N 7700 -930 7700 -910 {
lab=row_n[25]}
N 7580 -830 7590 -840 {
lab=VDD}
N 7590 -840 7790 -840 {
lab=VDD}
N 7790 -840 7800 -830 {
lab=VDD}
N 7580 -810 7590 -820 {
lab=VDD}
N 7590 -820 7790 -820 {
lab=VDD}
N 7790 -820 7800 -810 {
lab=VDD}
N 7580 -790 7590 -800 {
lab=VSS}
N 7590 -800 7790 -800 {
lab=VSS}
N 7790 -800 7800 -790 {
lab=VSS}
N 7580 -770 7590 -780 {
lab=VDD}
N 7590 -780 7790 -780 {
lab=VDD}
N 7790 -780 7800 -770 {
lab=VDD}
N 7800 -770 7820 -770 {
lab=VDD}
N 7800 -790 7820 -790 {
lab=VSS}
N 7800 -810 7820 -810 {
lab=VDD}
N 7800 -830 7820 -830 {
lab=VDD}
N 7560 -830 7580 -830 {
lab=VDD}
N 7560 -810 7580 -810 {
lab=VDD}
N 7560 -790 7580 -790 {
lab=VSS}
N 7560 -770 7580 -770 {
lab=VDD}
N 7620 -690 7620 -680 {
lab=VSS}
N 7640 -930 7640 -910 {
lab=vcom}
N 7620 -920 7620 -910 {
lab=VDD}
N 7700 -690 7700 -670 {
lab=row_n[25]}
N 7960 -690 7970 -700 {
lab=row_n[26]}
N 7970 -900 7970 -700 {
lab=row_n[26]}
N 7960 -910 7970 -900 {
lab=row_n[26]}
N 7960 -930 7960 -910 {
lab=row_n[26]}
N 7840 -830 7850 -840 {
lab=VDD}
N 7850 -840 8050 -840 {
lab=VDD}
N 8050 -840 8060 -830 {
lab=VDD}
N 7840 -810 7850 -820 {
lab=VDD}
N 7850 -820 8050 -820 {
lab=VDD}
N 8050 -820 8060 -810 {
lab=VDD}
N 7840 -790 7850 -800 {
lab=VSS}
N 7850 -800 8050 -800 {
lab=VSS}
N 8050 -800 8060 -790 {
lab=VSS}
N 7840 -770 7850 -780 {
lab=VDD}
N 7850 -780 8050 -780 {
lab=VDD}
N 8050 -780 8060 -770 {
lab=VDD}
N 8060 -770 8080 -770 {
lab=VDD}
N 8060 -790 8080 -790 {
lab=VSS}
N 8060 -810 8080 -810 {
lab=VDD}
N 8060 -830 8080 -830 {
lab=VDD}
N 7820 -830 7840 -830 {
lab=VDD}
N 7820 -810 7840 -810 {
lab=VDD}
N 7820 -790 7840 -790 {
lab=VSS}
N 7820 -770 7840 -770 {
lab=VDD}
N 7880 -690 7880 -680 {
lab=VSS}
N 7900 -930 7900 -910 {
lab=vcom}
N 7880 -920 7880 -910 {
lab=VDD}
N 7960 -690 7960 -670 {
lab=row_n[26]}
N 7680 -930 7680 -910 {
lab=ctop}
N 7940 -930 7940 -910 {
lab=ctop}
N 8220 -690 8230 -700 {
lab=row_n[27]}
N 8230 -900 8230 -700 {
lab=row_n[27]}
N 8220 -910 8230 -900 {
lab=row_n[27]}
N 8220 -930 8220 -910 {
lab=row_n[27]}
N 8100 -830 8110 -840 {
lab=VDD}
N 8110 -840 8310 -840 {
lab=VDD}
N 8310 -840 8320 -830 {
lab=VDD}
N 8100 -810 8110 -820 {
lab=VDD}
N 8110 -820 8310 -820 {
lab=VDD}
N 8310 -820 8320 -810 {
lab=VDD}
N 8100 -790 8110 -800 {
lab=VSS}
N 8110 -800 8310 -800 {
lab=VSS}
N 8310 -800 8320 -790 {
lab=VSS}
N 8100 -770 8110 -780 {
lab=VDD}
N 8110 -780 8310 -780 {
lab=VDD}
N 8310 -780 8320 -770 {
lab=VDD}
N 8320 -770 8340 -770 {
lab=VDD}
N 8320 -790 8340 -790 {
lab=VSS}
N 8320 -810 8340 -810 {
lab=VDD}
N 8320 -830 8340 -830 {
lab=VDD}
N 8080 -830 8100 -830 {
lab=VDD}
N 8080 -810 8100 -810 {
lab=VDD}
N 8080 -790 8100 -790 {
lab=VSS}
N 8080 -770 8100 -770 {
lab=VDD}
N 8140 -690 8140 -680 {
lab=VSS}
N 8160 -930 8160 -910 {
lab=vcom}
N 8140 -920 8140 -910 {
lab=VDD}
N 8220 -690 8220 -670 {
lab=row_n[27]}
N 8480 -690 8490 -700 {
lab=row_n[28]}
N 8490 -900 8490 -700 {
lab=row_n[28]}
N 8480 -910 8490 -900 {
lab=row_n[28]}
N 8480 -930 8480 -910 {
lab=row_n[28]}
N 8360 -830 8370 -840 {
lab=VDD}
N 8370 -840 8570 -840 {
lab=VDD}
N 8570 -840 8580 -830 {
lab=VDD}
N 8360 -810 8370 -820 {
lab=VDD}
N 8370 -820 8570 -820 {
lab=VDD}
N 8570 -820 8580 -810 {
lab=VDD}
N 8360 -790 8370 -800 {
lab=VSS}
N 8370 -800 8570 -800 {
lab=VSS}
N 8570 -800 8580 -790 {
lab=VSS}
N 8360 -770 8370 -780 {
lab=VDD}
N 8370 -780 8570 -780 {
lab=VDD}
N 8570 -780 8580 -770 {
lab=VDD}
N 8580 -770 8600 -770 {
lab=VDD}
N 8580 -790 8600 -790 {
lab=VSS}
N 8580 -810 8600 -810 {
lab=VDD}
N 8580 -830 8600 -830 {
lab=VDD}
N 8340 -830 8360 -830 {
lab=VDD}
N 8340 -810 8360 -810 {
lab=VDD}
N 8340 -790 8360 -790 {
lab=VSS}
N 8340 -770 8360 -770 {
lab=VDD}
N 8400 -690 8400 -680 {
lab=VSS}
N 8420 -930 8420 -910 {
lab=vcom}
N 8400 -920 8400 -910 {
lab=VDD}
N 8480 -690 8480 -670 {
lab=row_n[28]}
N 8200 -930 8200 -910 {
lab=ctop}
N 8460 -930 8460 -910 {
lab=ctop}
N 8740 -690 8750 -700 {
lab=row_n[29]}
N 8750 -900 8750 -700 {
lab=row_n[29]}
N 8740 -910 8750 -900 {
lab=row_n[29]}
N 8740 -930 8740 -910 {
lab=row_n[29]}
N 8620 -830 8630 -840 {
lab=VDD}
N 8630 -840 8830 -840 {
lab=VDD}
N 8830 -840 8840 -830 {
lab=VDD}
N 8620 -810 8630 -820 {
lab=VDD}
N 8630 -820 8830 -820 {
lab=VDD}
N 8830 -820 8840 -810 {
lab=VDD}
N 8620 -790 8630 -800 {
lab=VSS}
N 8630 -800 8830 -800 {
lab=VSS}
N 8830 -800 8840 -790 {
lab=VSS}
N 8620 -770 8630 -780 {
lab=VDD}
N 8630 -780 8830 -780 {
lab=VDD}
N 8830 -780 8840 -770 {
lab=VDD}
N 8840 -770 8860 -770 {
lab=VDD}
N 8840 -790 8860 -790 {
lab=VSS}
N 8840 -810 8860 -810 {
lab=VDD}
N 8840 -830 8860 -830 {
lab=VDD}
N 8600 -830 8620 -830 {
lab=VDD}
N 8600 -810 8620 -810 {
lab=VDD}
N 8600 -790 8620 -790 {
lab=VSS}
N 8600 -770 8620 -770 {
lab=VDD}
N 8660 -690 8660 -680 {
lab=VSS}
N 8680 -930 8680 -910 {
lab=vcom}
N 8660 -920 8660 -910 {
lab=VDD}
N 8740 -690 8740 -670 {
lab=row_n[29]}
N 9000 -690 9010 -700 {
lab=row_n[30]}
N 9010 -900 9010 -700 {
lab=row_n[30]}
N 9000 -910 9010 -900 {
lab=row_n[30]}
N 9000 -930 9000 -910 {
lab=row_n[30]}
N 8880 -830 8890 -840 {
lab=VDD}
N 8890 -840 9090 -840 {
lab=VDD}
N 9090 -840 9100 -830 {
lab=VDD}
N 8880 -810 8890 -820 {
lab=VDD}
N 8890 -820 9090 -820 {
lab=VDD}
N 9090 -820 9100 -810 {
lab=VDD}
N 8880 -790 8890 -800 {
lab=VSS}
N 8890 -800 9090 -800 {
lab=VSS}
N 9090 -800 9100 -790 {
lab=VSS}
N 8880 -770 8890 -780 {
lab=VDD}
N 8890 -780 9090 -780 {
lab=VDD}
N 9090 -780 9100 -770 {
lab=VDD}
N 9100 -770 9120 -770 {
lab=VDD}
N 9100 -790 9120 -790 {
lab=VSS}
N 9100 -810 9120 -810 {
lab=VDD}
N 9100 -830 9120 -830 {
lab=VDD}
N 8860 -830 8880 -830 {
lab=VDD}
N 8860 -810 8880 -810 {
lab=VDD}
N 8860 -790 8880 -790 {
lab=VSS}
N 8860 -770 8880 -770 {
lab=VDD}
N 8920 -690 8920 -680 {
lab=VSS}
N 8940 -930 8940 -910 {
lab=vcom}
N 8920 -920 8920 -910 {
lab=VDD}
N 9000 -690 9000 -670 {
lab=row_n[30]}
N 8720 -930 8720 -910 {
lab=ctop}
N 8980 -930 8980 -910 {
lab=ctop}
N 9260 -690 9270 -700 {
lab=row_n[31]}
N 9270 -900 9270 -700 {
lab=row_n[31]}
N 9260 -910 9270 -900 {
lab=row_n[31]}
N 9260 -930 9260 -910 {
lab=row_n[31]}
N 9140 -830 9150 -840 {
lab=VDD}
N 9150 -840 9350 -840 {
lab=VDD}
N 9350 -840 9360 -830 {
lab=VDD}
N 9140 -810 9150 -820 {
lab=VDD}
N 9150 -820 9350 -820 {
lab=VDD}
N 9350 -820 9360 -810 {
lab=VDD}
N 9140 -790 9150 -800 {
lab=VSS}
N 9150 -800 9350 -800 {
lab=VSS}
N 9350 -800 9360 -790 {
lab=VSS}
N 9140 -770 9150 -780 {
lab=VDD}
N 9150 -780 9350 -780 {
lab=VDD}
N 9350 -780 9360 -770 {
lab=VDD}
N 9360 -770 9380 -770 {
lab=VDD}
N 9360 -790 9380 -790 {
lab=VSS}
N 9360 -810 9380 -810 {
lab=VDD}
N 9360 -830 9380 -830 {
lab=VDD}
N 9120 -830 9140 -830 {
lab=VDD}
N 9120 -810 9140 -810 {
lab=VDD}
N 9120 -790 9140 -790 {
lab=VSS}
N 9120 -770 9140 -770 {
lab=VDD}
N 9180 -690 9180 -680 {
lab=VSS}
N 9200 -930 9200 -910 {
lab=vcom}
N 9180 -920 9180 -910 {
lab=VDD}
N 9260 -690 9260 -670 {
lab=row_n[31]}
N 9240 -930 9240 -910 {
lab=ctop}
N 9520 -690 9530 -700 {
lab=VDD}
N 9530 -900 9530 -700 {
lab=VDD}
N 9520 -910 9530 -900 {
lab=VDD}
N 9520 -930 9520 -910 {
lab=VDD}
N 9400 -830 9410 -840 {
lab=VDD}
N 9410 -840 9610 -840 {
lab=VDD}
N 9610 -840 9620 -830 {
lab=VDD}
N 9400 -810 9410 -820 {
lab=VDD}
N 9410 -820 9610 -820 {
lab=VDD}
N 9610 -820 9620 -810 {
lab=VDD}
N 9400 -790 9410 -800 {
lab=VSS}
N 9410 -800 9610 -800 {
lab=VSS}
N 9610 -800 9620 -790 {
lab=VSS}
N 9400 -770 9410 -780 {
lab=VDD}
N 9410 -780 9610 -780 {
lab=VDD}
N 9610 -780 9620 -770 {
lab=VDD}
N 9620 -770 9640 -770 {
lab=VDD}
N 9620 -790 9640 -790 {
lab=VSS}
N 9620 -810 9640 -810 {
lab=VDD}
N 9620 -830 9640 -830 {
lab=VDD}
N 9380 -830 9400 -830 {
lab=VDD}
N 9380 -810 9400 -810 {
lab=VDD}
N 9380 -790 9400 -790 {
lab=VSS}
N 9380 -770 9400 -770 {
lab=VDD}
N 9440 -690 9440 -680 {
lab=VSS}
N 9460 -930 9460 -910 {
lab=vcom}
N 9440 -920 9440 -910 {
lab=VDD}
N 9520 -690 9520 -670 {
lab=VDD}
N 9500 -930 9500 -910 {
lab=ctop}
N 940 -5110 950 -5120 {
lab=VDD}
N 950 -5320 950 -5120 {
lab=VDD}
N 940 -5330 950 -5320 {
lab=VDD}
N 940 -5350 940 -5330 {
lab=VDD}
N 820 -5250 830 -5260 {
lab=VDD}
N 830 -5260 1030 -5260 {
lab=VDD}
N 1030 -5260 1040 -5250 {
lab=VDD}
N 820 -5230 830 -5240 {
lab=VDD}
N 830 -5240 1030 -5240 {
lab=VDD}
N 1030 -5240 1040 -5230 {
lab=VDD}
N 820 -5210 830 -5220 {
lab=VSS}
N 830 -5220 1030 -5220 {
lab=VSS}
N 1030 -5220 1040 -5210 {
lab=VSS}
N 820 -5190 830 -5200 {
lab=VDD}
N 830 -5200 1030 -5200 {
lab=VDD}
N 1030 -5200 1040 -5190 {
lab=VDD}
N 1040 -5190 1060 -5190 {
lab=VDD}
N 1040 -5210 1060 -5210 {
lab=VSS}
N 1040 -5230 1060 -5230 {
lab=VDD}
N 1040 -5250 1060 -5250 {
lab=VDD}
N 800 -5250 820 -5250 {
lab=VDD}
N 800 -5230 820 -5230 {
lab=VDD}
N 800 -5210 820 -5210 {
lab=VSS}
N 800 -5190 820 -5190 {
lab=VDD}
N 860 -5110 860 -5100 {
lab=VSS}
N 880 -5350 880 -5330 {
lab=vcom}
N 860 -5340 860 -5330 {
lab=VDD}
N 940 -5110 940 -5090 {
lab=VDD}
N 1200 -5110 1210 -5120 {
lab=row_n[0]}
N 1210 -5320 1210 -5120 {
lab=row_n[0]}
N 1200 -5330 1210 -5320 {
lab=row_n[0]}
N 1200 -5350 1200 -5330 {
lab=row_n[0]}
N 1080 -5250 1090 -5260 {
lab=VDD}
N 1090 -5260 1290 -5260 {
lab=VDD}
N 1290 -5260 1300 -5250 {
lab=VDD}
N 1080 -5230 1090 -5240 {
lab=VDD}
N 1090 -5240 1290 -5240 {
lab=VDD}
N 1290 -5240 1300 -5230 {
lab=VDD}
N 1080 -5210 1090 -5220 {
lab=VSS}
N 1090 -5220 1290 -5220 {
lab=VSS}
N 1290 -5220 1300 -5210 {
lab=VSS}
N 1080 -5190 1090 -5200 {
lab=VDD}
N 1090 -5200 1290 -5200 {
lab=VDD}
N 1290 -5200 1300 -5190 {
lab=VDD}
N 1300 -5190 1320 -5190 {
lab=VDD}
N 1300 -5210 1320 -5210 {
lab=VSS}
N 1300 -5230 1320 -5230 {
lab=VDD}
N 1300 -5250 1320 -5250 {
lab=VDD}
N 1060 -5250 1080 -5250 {
lab=VDD}
N 1060 -5230 1080 -5230 {
lab=VDD}
N 1060 -5210 1080 -5210 {
lab=VSS}
N 1060 -5190 1080 -5190 {
lab=VDD}
N 1120 -5110 1120 -5100 {
lab=VSS}
N 1140 -5350 1140 -5330 {
lab=vcom}
N 1120 -5340 1120 -5330 {
lab=VDD}
N 1200 -5110 1200 -5090 {
lab=row_n[0]}
N 920 -5350 920 -5330 {
lab=ctop}
N 1180 -5350 1180 -5330 {
lab=ctop}
N 1460 -5110 1470 -5120 {
lab=row_n[1]}
N 1470 -5320 1470 -5120 {
lab=row_n[1]}
N 1460 -5330 1470 -5320 {
lab=row_n[1]}
N 1460 -5350 1460 -5330 {
lab=row_n[1]}
N 1340 -5250 1350 -5260 {
lab=VDD}
N 1350 -5260 1550 -5260 {
lab=VDD}
N 1550 -5260 1560 -5250 {
lab=VDD}
N 1340 -5230 1350 -5240 {
lab=VDD}
N 1350 -5240 1550 -5240 {
lab=VDD}
N 1550 -5240 1560 -5230 {
lab=VDD}
N 1340 -5210 1350 -5220 {
lab=VSS}
N 1350 -5220 1550 -5220 {
lab=VSS}
N 1550 -5220 1560 -5210 {
lab=VSS}
N 1340 -5190 1350 -5200 {
lab=VDD}
N 1350 -5200 1550 -5200 {
lab=VDD}
N 1550 -5200 1560 -5190 {
lab=VDD}
N 1560 -5190 1580 -5190 {
lab=VDD}
N 1560 -5210 1580 -5210 {
lab=VSS}
N 1560 -5230 1580 -5230 {
lab=VDD}
N 1560 -5250 1580 -5250 {
lab=VDD}
N 1320 -5250 1340 -5250 {
lab=VDD}
N 1320 -5230 1340 -5230 {
lab=VDD}
N 1320 -5210 1340 -5210 {
lab=VSS}
N 1320 -5190 1340 -5190 {
lab=VDD}
N 1380 -5110 1380 -5100 {
lab=VSS}
N 1400 -5350 1400 -5330 {
lab=vcom}
N 1380 -5340 1380 -5330 {
lab=VDD}
N 1460 -5110 1460 -5090 {
lab=row_n[1]}
N 1720 -5110 1730 -5120 {
lab=row_n[2]}
N 1730 -5320 1730 -5120 {
lab=row_n[2]}
N 1720 -5330 1730 -5320 {
lab=row_n[2]}
N 1720 -5350 1720 -5330 {
lab=row_n[2]}
N 1600 -5250 1610 -5260 {
lab=VDD}
N 1610 -5260 1810 -5260 {
lab=VDD}
N 1810 -5260 1820 -5250 {
lab=VDD}
N 1600 -5230 1610 -5240 {
lab=VDD}
N 1610 -5240 1810 -5240 {
lab=VDD}
N 1810 -5240 1820 -5230 {
lab=VDD}
N 1600 -5210 1610 -5220 {
lab=VSS}
N 1610 -5220 1810 -5220 {
lab=VSS}
N 1810 -5220 1820 -5210 {
lab=VSS}
N 1600 -5190 1610 -5200 {
lab=VDD}
N 1610 -5200 1810 -5200 {
lab=VDD}
N 1810 -5200 1820 -5190 {
lab=VDD}
N 1820 -5190 1840 -5190 {
lab=VDD}
N 1820 -5210 1840 -5210 {
lab=VSS}
N 1820 -5230 1840 -5230 {
lab=VDD}
N 1820 -5250 1840 -5250 {
lab=VDD}
N 1580 -5250 1600 -5250 {
lab=VDD}
N 1580 -5230 1600 -5230 {
lab=VDD}
N 1580 -5210 1600 -5210 {
lab=VSS}
N 1580 -5190 1600 -5190 {
lab=VDD}
N 1640 -5110 1640 -5100 {
lab=VSS}
N 1660 -5350 1660 -5330 {
lab=vcom}
N 1640 -5340 1640 -5330 {
lab=VDD}
N 1720 -5110 1720 -5090 {
lab=row_n[2]}
N 1440 -5350 1440 -5330 {
lab=ctop}
N 1700 -5350 1700 -5330 {
lab=ctop}
N 1980 -5110 1990 -5120 {
lab=row_n[3]}
N 1990 -5320 1990 -5120 {
lab=row_n[3]}
N 1980 -5330 1990 -5320 {
lab=row_n[3]}
N 1980 -5350 1980 -5330 {
lab=row_n[3]}
N 1860 -5250 1870 -5260 {
lab=VDD}
N 1870 -5260 2070 -5260 {
lab=VDD}
N 2070 -5260 2080 -5250 {
lab=VDD}
N 1860 -5230 1870 -5240 {
lab=VDD}
N 1870 -5240 2070 -5240 {
lab=VDD}
N 2070 -5240 2080 -5230 {
lab=VDD}
N 1860 -5210 1870 -5220 {
lab=VSS}
N 1870 -5220 2070 -5220 {
lab=VSS}
N 2070 -5220 2080 -5210 {
lab=VSS}
N 1860 -5190 1870 -5200 {
lab=VDD}
N 1870 -5200 2070 -5200 {
lab=VDD}
N 2070 -5200 2080 -5190 {
lab=VDD}
N 2080 -5190 2100 -5190 {
lab=VDD}
N 2080 -5210 2100 -5210 {
lab=VSS}
N 2080 -5230 2100 -5230 {
lab=VDD}
N 2080 -5250 2100 -5250 {
lab=VDD}
N 1840 -5250 1860 -5250 {
lab=VDD}
N 1840 -5230 1860 -5230 {
lab=VDD}
N 1840 -5210 1860 -5210 {
lab=VSS}
N 1840 -5190 1860 -5190 {
lab=VDD}
N 1900 -5110 1900 -5100 {
lab=VSS}
N 1920 -5350 1920 -5330 {
lab=vcom}
N 1900 -5340 1900 -5330 {
lab=VDD}
N 1980 -5110 1980 -5090 {
lab=row_n[3]}
N 2240 -5110 2250 -5120 {
lab=row_n[4]}
N 2250 -5320 2250 -5120 {
lab=row_n[4]}
N 2240 -5330 2250 -5320 {
lab=row_n[4]}
N 2240 -5350 2240 -5330 {
lab=row_n[4]}
N 2120 -5250 2130 -5260 {
lab=VDD}
N 2130 -5260 2330 -5260 {
lab=VDD}
N 2330 -5260 2340 -5250 {
lab=VDD}
N 2120 -5230 2130 -5240 {
lab=VDD}
N 2130 -5240 2330 -5240 {
lab=VDD}
N 2330 -5240 2340 -5230 {
lab=VDD}
N 2120 -5210 2130 -5220 {
lab=VSS}
N 2130 -5220 2330 -5220 {
lab=VSS}
N 2330 -5220 2340 -5210 {
lab=VSS}
N 2120 -5190 2130 -5200 {
lab=VDD}
N 2130 -5200 2330 -5200 {
lab=VDD}
N 2330 -5200 2340 -5190 {
lab=VDD}
N 2340 -5190 2360 -5190 {
lab=VDD}
N 2340 -5210 2360 -5210 {
lab=VSS}
N 2340 -5230 2360 -5230 {
lab=VDD}
N 2340 -5250 2360 -5250 {
lab=VDD}
N 2100 -5250 2120 -5250 {
lab=VDD}
N 2100 -5230 2120 -5230 {
lab=VDD}
N 2100 -5210 2120 -5210 {
lab=VSS}
N 2100 -5190 2120 -5190 {
lab=VDD}
N 2160 -5110 2160 -5100 {
lab=VSS}
N 2180 -5350 2180 -5330 {
lab=vcom}
N 2160 -5340 2160 -5330 {
lab=VDD}
N 2240 -5110 2240 -5090 {
lab=row_n[4]}
N 1960 -5350 1960 -5330 {
lab=ctop}
N 2220 -5350 2220 -5330 {
lab=ctop}
N 2500 -5110 2510 -5120 {
lab=row_n[5]}
N 2510 -5320 2510 -5120 {
lab=row_n[5]}
N 2500 -5330 2510 -5320 {
lab=row_n[5]}
N 2500 -5350 2500 -5330 {
lab=row_n[5]}
N 2380 -5250 2390 -5260 {
lab=VDD}
N 2390 -5260 2590 -5260 {
lab=VDD}
N 2590 -5260 2600 -5250 {
lab=VDD}
N 2380 -5230 2390 -5240 {
lab=VDD}
N 2390 -5240 2590 -5240 {
lab=VDD}
N 2590 -5240 2600 -5230 {
lab=VDD}
N 2380 -5210 2390 -5220 {
lab=VSS}
N 2390 -5220 2590 -5220 {
lab=VSS}
N 2590 -5220 2600 -5210 {
lab=VSS}
N 2380 -5190 2390 -5200 {
lab=VDD}
N 2390 -5200 2590 -5200 {
lab=VDD}
N 2590 -5200 2600 -5190 {
lab=VDD}
N 2600 -5190 2620 -5190 {
lab=VDD}
N 2600 -5210 2620 -5210 {
lab=VSS}
N 2600 -5230 2620 -5230 {
lab=VDD}
N 2600 -5250 2620 -5250 {
lab=VDD}
N 2360 -5250 2380 -5250 {
lab=VDD}
N 2360 -5230 2380 -5230 {
lab=VDD}
N 2360 -5210 2380 -5210 {
lab=VSS}
N 2360 -5190 2380 -5190 {
lab=VDD}
N 2420 -5110 2420 -5100 {
lab=VSS}
N 2440 -5350 2440 -5330 {
lab=vcom}
N 2420 -5340 2420 -5330 {
lab=VDD}
N 2500 -5110 2500 -5090 {
lab=row_n[5]}
N 2760 -5110 2770 -5120 {
lab=row_n[6]}
N 2770 -5320 2770 -5120 {
lab=row_n[6]}
N 2760 -5330 2770 -5320 {
lab=row_n[6]}
N 2760 -5350 2760 -5330 {
lab=row_n[6]}
N 2640 -5250 2650 -5260 {
lab=VDD}
N 2650 -5260 2850 -5260 {
lab=VDD}
N 2850 -5260 2860 -5250 {
lab=VDD}
N 2640 -5230 2650 -5240 {
lab=VDD}
N 2650 -5240 2850 -5240 {
lab=VDD}
N 2850 -5240 2860 -5230 {
lab=VDD}
N 2640 -5210 2650 -5220 {
lab=VSS}
N 2650 -5220 2850 -5220 {
lab=VSS}
N 2850 -5220 2860 -5210 {
lab=VSS}
N 2640 -5190 2650 -5200 {
lab=VDD}
N 2650 -5200 2850 -5200 {
lab=VDD}
N 2850 -5200 2860 -5190 {
lab=VDD}
N 2860 -5190 2880 -5190 {
lab=VDD}
N 2860 -5210 2880 -5210 {
lab=VSS}
N 2860 -5230 2880 -5230 {
lab=VDD}
N 2860 -5250 2880 -5250 {
lab=VDD}
N 2620 -5250 2640 -5250 {
lab=VDD}
N 2620 -5230 2640 -5230 {
lab=VDD}
N 2620 -5210 2640 -5210 {
lab=VSS}
N 2620 -5190 2640 -5190 {
lab=VDD}
N 2680 -5110 2680 -5100 {
lab=VSS}
N 2700 -5350 2700 -5330 {
lab=vcom}
N 2680 -5340 2680 -5330 {
lab=VDD}
N 2760 -5110 2760 -5090 {
lab=row_n[6]}
N 2480 -5350 2480 -5330 {
lab=ctop}
N 2740 -5350 2740 -5330 {
lab=ctop}
N 3020 -5110 3030 -5120 {
lab=row_n[7]}
N 3030 -5320 3030 -5120 {
lab=row_n[7]}
N 3020 -5330 3030 -5320 {
lab=row_n[7]}
N 3020 -5350 3020 -5330 {
lab=row_n[7]}
N 2900 -5250 2910 -5260 {
lab=VDD}
N 2910 -5260 3110 -5260 {
lab=VDD}
N 3110 -5260 3120 -5250 {
lab=VDD}
N 2900 -5230 2910 -5240 {
lab=VDD}
N 2910 -5240 3110 -5240 {
lab=VDD}
N 3110 -5240 3120 -5230 {
lab=VDD}
N 2900 -5210 2910 -5220 {
lab=VSS}
N 2910 -5220 3110 -5220 {
lab=VSS}
N 3110 -5220 3120 -5210 {
lab=VSS}
N 2900 -5190 2910 -5200 {
lab=VDD}
N 2910 -5200 3110 -5200 {
lab=VDD}
N 3110 -5200 3120 -5190 {
lab=VDD}
N 3120 -5190 3140 -5190 {
lab=VDD}
N 3120 -5210 3140 -5210 {
lab=VSS}
N 3120 -5230 3140 -5230 {
lab=VDD}
N 3120 -5250 3140 -5250 {
lab=VDD}
N 2880 -5250 2900 -5250 {
lab=VDD}
N 2880 -5230 2900 -5230 {
lab=VDD}
N 2880 -5210 2900 -5210 {
lab=VSS}
N 2880 -5190 2900 -5190 {
lab=VDD}
N 2940 -5110 2940 -5100 {
lab=VSS}
N 2960 -5350 2960 -5330 {
lab=vcom}
N 2940 -5340 2940 -5330 {
lab=VDD}
N 3020 -5110 3020 -5090 {
lab=row_n[7]}
N 3280 -5110 3290 -5120 {
lab=row_n[8]}
N 3290 -5320 3290 -5120 {
lab=row_n[8]}
N 3280 -5330 3290 -5320 {
lab=row_n[8]}
N 3280 -5350 3280 -5330 {
lab=row_n[8]}
N 3160 -5250 3170 -5260 {
lab=VDD}
N 3170 -5260 3370 -5260 {
lab=VDD}
N 3370 -5260 3380 -5250 {
lab=VDD}
N 3160 -5230 3170 -5240 {
lab=VDD}
N 3170 -5240 3370 -5240 {
lab=VDD}
N 3370 -5240 3380 -5230 {
lab=VDD}
N 3160 -5210 3170 -5220 {
lab=VSS}
N 3170 -5220 3370 -5220 {
lab=VSS}
N 3370 -5220 3380 -5210 {
lab=VSS}
N 3160 -5190 3170 -5200 {
lab=VDD}
N 3170 -5200 3370 -5200 {
lab=VDD}
N 3370 -5200 3380 -5190 {
lab=VDD}
N 3380 -5190 3400 -5190 {
lab=VDD}
N 3380 -5210 3400 -5210 {
lab=VSS}
N 3380 -5230 3400 -5230 {
lab=VDD}
N 3380 -5250 3400 -5250 {
lab=VDD}
N 3140 -5250 3160 -5250 {
lab=VDD}
N 3140 -5230 3160 -5230 {
lab=VDD}
N 3140 -5210 3160 -5210 {
lab=VSS}
N 3140 -5190 3160 -5190 {
lab=VDD}
N 3200 -5110 3200 -5100 {
lab=VSS}
N 3220 -5350 3220 -5330 {
lab=vcom}
N 3200 -5340 3200 -5330 {
lab=VDD}
N 3280 -5110 3280 -5090 {
lab=row_n[8]}
N 3000 -5350 3000 -5330 {
lab=ctop}
N 3260 -5350 3260 -5330 {
lab=ctop}
N 3540 -5110 3550 -5120 {
lab=row_n[9]}
N 3550 -5320 3550 -5120 {
lab=row_n[9]}
N 3540 -5330 3550 -5320 {
lab=row_n[9]}
N 3540 -5350 3540 -5330 {
lab=row_n[9]}
N 3420 -5250 3430 -5260 {
lab=VDD}
N 3430 -5260 3630 -5260 {
lab=VDD}
N 3630 -5260 3640 -5250 {
lab=VDD}
N 3420 -5230 3430 -5240 {
lab=VDD}
N 3430 -5240 3630 -5240 {
lab=VDD}
N 3630 -5240 3640 -5230 {
lab=VDD}
N 3420 -5210 3430 -5220 {
lab=VSS}
N 3430 -5220 3630 -5220 {
lab=VSS}
N 3630 -5220 3640 -5210 {
lab=VSS}
N 3420 -5190 3430 -5200 {
lab=VDD}
N 3430 -5200 3630 -5200 {
lab=VDD}
N 3630 -5200 3640 -5190 {
lab=VDD}
N 3640 -5190 3660 -5190 {
lab=VDD}
N 3640 -5210 3660 -5210 {
lab=VSS}
N 3640 -5230 3660 -5230 {
lab=VDD}
N 3640 -5250 3660 -5250 {
lab=VDD}
N 3400 -5250 3420 -5250 {
lab=VDD}
N 3400 -5230 3420 -5230 {
lab=VDD}
N 3400 -5210 3420 -5210 {
lab=VSS}
N 3400 -5190 3420 -5190 {
lab=VDD}
N 3460 -5110 3460 -5100 {
lab=VSS}
N 3480 -5350 3480 -5330 {
lab=vcom}
N 3460 -5340 3460 -5330 {
lab=VDD}
N 3540 -5110 3540 -5090 {
lab=row_n[9]}
N 3800 -5110 3810 -5120 {
lab=row_n[10]}
N 3810 -5320 3810 -5120 {
lab=row_n[10]}
N 3800 -5330 3810 -5320 {
lab=row_n[10]}
N 3800 -5350 3800 -5330 {
lab=row_n[10]}
N 3680 -5250 3690 -5260 {
lab=VDD}
N 3690 -5260 3890 -5260 {
lab=VDD}
N 3890 -5260 3900 -5250 {
lab=VDD}
N 3680 -5230 3690 -5240 {
lab=VDD}
N 3690 -5240 3890 -5240 {
lab=VDD}
N 3890 -5240 3900 -5230 {
lab=VDD}
N 3680 -5210 3690 -5220 {
lab=VSS}
N 3690 -5220 3890 -5220 {
lab=VSS}
N 3890 -5220 3900 -5210 {
lab=VSS}
N 3680 -5190 3690 -5200 {
lab=VDD}
N 3690 -5200 3890 -5200 {
lab=VDD}
N 3890 -5200 3900 -5190 {
lab=VDD}
N 3900 -5190 3920 -5190 {
lab=VDD}
N 3900 -5210 3920 -5210 {
lab=VSS}
N 3900 -5230 3920 -5230 {
lab=VDD}
N 3900 -5250 3920 -5250 {
lab=VDD}
N 3660 -5250 3680 -5250 {
lab=VDD}
N 3660 -5230 3680 -5230 {
lab=VDD}
N 3660 -5210 3680 -5210 {
lab=VSS}
N 3660 -5190 3680 -5190 {
lab=VDD}
N 3720 -5110 3720 -5100 {
lab=VSS}
N 3740 -5350 3740 -5330 {
lab=vcom}
N 3720 -5340 3720 -5330 {
lab=VDD}
N 3800 -5110 3800 -5090 {
lab=row_n[10]}
N 3520 -5350 3520 -5330 {
lab=ctop}
N 3780 -5350 3780 -5330 {
lab=ctop}
N 4060 -5110 4070 -5120 {
lab=row_n[11]}
N 4070 -5320 4070 -5120 {
lab=row_n[11]}
N 4060 -5330 4070 -5320 {
lab=row_n[11]}
N 4060 -5350 4060 -5330 {
lab=row_n[11]}
N 3940 -5250 3950 -5260 {
lab=VDD}
N 3950 -5260 4150 -5260 {
lab=VDD}
N 4150 -5260 4160 -5250 {
lab=VDD}
N 3940 -5230 3950 -5240 {
lab=VDD}
N 3950 -5240 4150 -5240 {
lab=VDD}
N 4150 -5240 4160 -5230 {
lab=VDD}
N 3940 -5210 3950 -5220 {
lab=VSS}
N 3950 -5220 4150 -5220 {
lab=VSS}
N 4150 -5220 4160 -5210 {
lab=VSS}
N 3940 -5190 3950 -5200 {
lab=VDD}
N 3950 -5200 4150 -5200 {
lab=VDD}
N 4150 -5200 4160 -5190 {
lab=VDD}
N 4160 -5190 4180 -5190 {
lab=VDD}
N 4160 -5210 4180 -5210 {
lab=VSS}
N 4160 -5230 4180 -5230 {
lab=VDD}
N 4160 -5250 4180 -5250 {
lab=VDD}
N 3920 -5250 3940 -5250 {
lab=VDD}
N 3920 -5230 3940 -5230 {
lab=VDD}
N 3920 -5210 3940 -5210 {
lab=VSS}
N 3920 -5190 3940 -5190 {
lab=VDD}
N 3980 -5110 3980 -5100 {
lab=VSS}
N 4000 -5350 4000 -5330 {
lab=vcom}
N 3980 -5340 3980 -5330 {
lab=VDD}
N 4060 -5110 4060 -5090 {
lab=row_n[11]}
N 4320 -5110 4330 -5120 {
lab=row_n[12]}
N 4330 -5320 4330 -5120 {
lab=row_n[12]}
N 4320 -5330 4330 -5320 {
lab=row_n[12]}
N 4320 -5350 4320 -5330 {
lab=row_n[12]}
N 4200 -5250 4210 -5260 {
lab=VDD}
N 4210 -5260 4410 -5260 {
lab=VDD}
N 4410 -5260 4420 -5250 {
lab=VDD}
N 4200 -5230 4210 -5240 {
lab=VDD}
N 4210 -5240 4410 -5240 {
lab=VDD}
N 4410 -5240 4420 -5230 {
lab=VDD}
N 4200 -5210 4210 -5220 {
lab=VSS}
N 4210 -5220 4410 -5220 {
lab=VSS}
N 4410 -5220 4420 -5210 {
lab=VSS}
N 4200 -5190 4210 -5200 {
lab=VDD}
N 4210 -5200 4410 -5200 {
lab=VDD}
N 4410 -5200 4420 -5190 {
lab=VDD}
N 4420 -5190 4440 -5190 {
lab=VDD}
N 4420 -5210 4440 -5210 {
lab=VSS}
N 4420 -5230 4440 -5230 {
lab=VDD}
N 4420 -5250 4440 -5250 {
lab=VDD}
N 4180 -5250 4200 -5250 {
lab=VDD}
N 4180 -5230 4200 -5230 {
lab=VDD}
N 4180 -5210 4200 -5210 {
lab=VSS}
N 4180 -5190 4200 -5190 {
lab=VDD}
N 4240 -5110 4240 -5100 {
lab=VSS}
N 4260 -5350 4260 -5330 {
lab=vcom}
N 4240 -5340 4240 -5330 {
lab=VDD}
N 4320 -5110 4320 -5090 {
lab=row_n[12]}
N 4040 -5350 4040 -5330 {
lab=ctop}
N 4300 -5350 4300 -5330 {
lab=ctop}
N 4580 -5110 4590 -5120 {
lab=row_n[13]}
N 4590 -5320 4590 -5120 {
lab=row_n[13]}
N 4580 -5330 4590 -5320 {
lab=row_n[13]}
N 4580 -5350 4580 -5330 {
lab=row_n[13]}
N 4460 -5250 4470 -5260 {
lab=VDD}
N 4470 -5260 4670 -5260 {
lab=VDD}
N 4670 -5260 4680 -5250 {
lab=VDD}
N 4460 -5230 4470 -5240 {
lab=VDD}
N 4470 -5240 4670 -5240 {
lab=VDD}
N 4670 -5240 4680 -5230 {
lab=VDD}
N 4460 -5210 4470 -5220 {
lab=VSS}
N 4470 -5220 4670 -5220 {
lab=VSS}
N 4670 -5220 4680 -5210 {
lab=VSS}
N 4460 -5190 4470 -5200 {
lab=VDD}
N 4470 -5200 4670 -5200 {
lab=VDD}
N 4670 -5200 4680 -5190 {
lab=VDD}
N 4680 -5190 4700 -5190 {
lab=VDD}
N 4680 -5210 4700 -5210 {
lab=VSS}
N 4680 -5230 4700 -5230 {
lab=VDD}
N 4680 -5250 4700 -5250 {
lab=VDD}
N 4440 -5250 4460 -5250 {
lab=VDD}
N 4440 -5230 4460 -5230 {
lab=VDD}
N 4440 -5210 4460 -5210 {
lab=VSS}
N 4440 -5190 4460 -5190 {
lab=VDD}
N 4500 -5110 4500 -5100 {
lab=VSS}
N 4520 -5350 4520 -5330 {
lab=vcom}
N 4500 -5340 4500 -5330 {
lab=VDD}
N 4580 -5110 4580 -5090 {
lab=row_n[13]}
N 4840 -5110 4850 -5120 {
lab=row_n[14]}
N 4850 -5320 4850 -5120 {
lab=row_n[14]}
N 4840 -5330 4850 -5320 {
lab=row_n[14]}
N 4840 -5350 4840 -5330 {
lab=row_n[14]}
N 4720 -5250 4730 -5260 {
lab=VDD}
N 4730 -5260 4930 -5260 {
lab=VDD}
N 4930 -5260 4940 -5250 {
lab=VDD}
N 4720 -5230 4730 -5240 {
lab=VDD}
N 4730 -5240 4930 -5240 {
lab=VDD}
N 4930 -5240 4940 -5230 {
lab=VDD}
N 4720 -5210 4730 -5220 {
lab=VSS}
N 4730 -5220 4930 -5220 {
lab=VSS}
N 4930 -5220 4940 -5210 {
lab=VSS}
N 4720 -5190 4730 -5200 {
lab=VDD}
N 4730 -5200 4930 -5200 {
lab=VDD}
N 4930 -5200 4940 -5190 {
lab=VDD}
N 4940 -5190 4960 -5190 {
lab=VDD}
N 4940 -5210 4960 -5210 {
lab=VSS}
N 4940 -5230 4960 -5230 {
lab=VDD}
N 4940 -5250 4960 -5250 {
lab=VDD}
N 4700 -5250 4720 -5250 {
lab=VDD}
N 4700 -5230 4720 -5230 {
lab=VDD}
N 4700 -5210 4720 -5210 {
lab=VSS}
N 4700 -5190 4720 -5190 {
lab=VDD}
N 4760 -5110 4760 -5100 {
lab=VSS}
N 4780 -5350 4780 -5330 {
lab=vcom}
N 4760 -5340 4760 -5330 {
lab=VDD}
N 4840 -5110 4840 -5090 {
lab=row_n[14]}
N 4560 -5350 4560 -5330 {
lab=ctop}
N 4820 -5350 4820 -5330 {
lab=ctop}
N 5100 -5110 5110 -5120 {
lab=row_n[15]}
N 5110 -5320 5110 -5120 {
lab=row_n[15]}
N 5100 -5330 5110 -5320 {
lab=row_n[15]}
N 5100 -5350 5100 -5330 {
lab=row_n[15]}
N 4980 -5250 4990 -5260 {
lab=VDD}
N 4990 -5260 5190 -5260 {
lab=VDD}
N 5190 -5260 5200 -5250 {
lab=VDD}
N 4980 -5230 4990 -5240 {
lab=VDD}
N 4990 -5240 5190 -5240 {
lab=VDD}
N 5190 -5240 5200 -5230 {
lab=VDD}
N 4980 -5210 4990 -5220 {
lab=VSS}
N 4990 -5220 5190 -5220 {
lab=VSS}
N 5190 -5220 5200 -5210 {
lab=VSS}
N 4980 -5190 4990 -5200 {
lab=VDD}
N 4990 -5200 5190 -5200 {
lab=VDD}
N 5190 -5200 5200 -5190 {
lab=VDD}
N 5200 -5190 5220 -5190 {
lab=VDD}
N 5200 -5210 5220 -5210 {
lab=VSS}
N 5200 -5230 5220 -5230 {
lab=VDD}
N 5200 -5250 5220 -5250 {
lab=VDD}
N 4960 -5250 4980 -5250 {
lab=VDD}
N 4960 -5230 4980 -5230 {
lab=VDD}
N 4960 -5210 4980 -5210 {
lab=VSS}
N 4960 -5190 4980 -5190 {
lab=VDD}
N 5020 -5110 5020 -5100 {
lab=VSS}
N 5040 -5350 5040 -5330 {
lab=vcom}
N 5020 -5340 5020 -5330 {
lab=VDD}
N 5100 -5110 5100 -5090 {
lab=row_n[15]}
N 5360 -5110 5370 -5120 {
lab=row_n[16]}
N 5370 -5320 5370 -5120 {
lab=row_n[16]}
N 5360 -5330 5370 -5320 {
lab=row_n[16]}
N 5360 -5350 5360 -5330 {
lab=row_n[16]}
N 5240 -5250 5250 -5260 {
lab=VDD}
N 5250 -5260 5450 -5260 {
lab=VDD}
N 5450 -5260 5460 -5250 {
lab=VDD}
N 5240 -5230 5250 -5240 {
lab=VDD}
N 5250 -5240 5450 -5240 {
lab=VDD}
N 5450 -5240 5460 -5230 {
lab=VDD}
N 5240 -5210 5250 -5220 {
lab=VSS}
N 5250 -5220 5450 -5220 {
lab=VSS}
N 5450 -5220 5460 -5210 {
lab=VSS}
N 5240 -5190 5250 -5200 {
lab=VDD}
N 5250 -5200 5450 -5200 {
lab=VDD}
N 5450 -5200 5460 -5190 {
lab=VDD}
N 5460 -5190 5480 -5190 {
lab=VDD}
N 5460 -5210 5480 -5210 {
lab=VSS}
N 5460 -5230 5480 -5230 {
lab=VDD}
N 5460 -5250 5480 -5250 {
lab=VDD}
N 5220 -5250 5240 -5250 {
lab=VDD}
N 5220 -5230 5240 -5230 {
lab=VDD}
N 5220 -5210 5240 -5210 {
lab=VSS}
N 5220 -5190 5240 -5190 {
lab=VDD}
N 5280 -5110 5280 -5100 {
lab=VSS}
N 5300 -5350 5300 -5330 {
lab=vcom}
N 5280 -5340 5280 -5330 {
lab=VDD}
N 5360 -5110 5360 -5090 {
lab=row_n[16]}
N 5080 -5350 5080 -5330 {
lab=ctop}
N 5340 -5350 5340 -5330 {
lab=ctop}
N 5620 -5110 5630 -5120 {
lab=row_n[17]}
N 5630 -5320 5630 -5120 {
lab=row_n[17]}
N 5620 -5330 5630 -5320 {
lab=row_n[17]}
N 5620 -5350 5620 -5330 {
lab=row_n[17]}
N 5500 -5250 5510 -5260 {
lab=VDD}
N 5510 -5260 5710 -5260 {
lab=VDD}
N 5710 -5260 5720 -5250 {
lab=VDD}
N 5500 -5230 5510 -5240 {
lab=VDD}
N 5510 -5240 5710 -5240 {
lab=VDD}
N 5710 -5240 5720 -5230 {
lab=VDD}
N 5500 -5210 5510 -5220 {
lab=VSS}
N 5510 -5220 5710 -5220 {
lab=VSS}
N 5710 -5220 5720 -5210 {
lab=VSS}
N 5500 -5190 5510 -5200 {
lab=VDD}
N 5510 -5200 5710 -5200 {
lab=VDD}
N 5710 -5200 5720 -5190 {
lab=VDD}
N 5720 -5190 5740 -5190 {
lab=VDD}
N 5720 -5210 5740 -5210 {
lab=VSS}
N 5720 -5230 5740 -5230 {
lab=VDD}
N 5720 -5250 5740 -5250 {
lab=VDD}
N 5480 -5250 5500 -5250 {
lab=VDD}
N 5480 -5230 5500 -5230 {
lab=VDD}
N 5480 -5210 5500 -5210 {
lab=VSS}
N 5480 -5190 5500 -5190 {
lab=VDD}
N 5540 -5110 5540 -5100 {
lab=VSS}
N 5560 -5350 5560 -5330 {
lab=vcom}
N 5540 -5340 5540 -5330 {
lab=VDD}
N 5620 -5110 5620 -5090 {
lab=row_n[17]}
N 5880 -5110 5890 -5120 {
lab=row_n[18]}
N 5890 -5320 5890 -5120 {
lab=row_n[18]}
N 5880 -5330 5890 -5320 {
lab=row_n[18]}
N 5880 -5350 5880 -5330 {
lab=row_n[18]}
N 5760 -5250 5770 -5260 {
lab=VDD}
N 5770 -5260 5970 -5260 {
lab=VDD}
N 5970 -5260 5980 -5250 {
lab=VDD}
N 5760 -5230 5770 -5240 {
lab=VDD}
N 5770 -5240 5970 -5240 {
lab=VDD}
N 5970 -5240 5980 -5230 {
lab=VDD}
N 5760 -5210 5770 -5220 {
lab=VSS}
N 5770 -5220 5970 -5220 {
lab=VSS}
N 5970 -5220 5980 -5210 {
lab=VSS}
N 5760 -5190 5770 -5200 {
lab=VDD}
N 5770 -5200 5970 -5200 {
lab=VDD}
N 5970 -5200 5980 -5190 {
lab=VDD}
N 5980 -5190 6000 -5190 {
lab=VDD}
N 5980 -5210 6000 -5210 {
lab=VSS}
N 5980 -5230 6000 -5230 {
lab=VDD}
N 5980 -5250 6000 -5250 {
lab=VDD}
N 5740 -5250 5760 -5250 {
lab=VDD}
N 5740 -5230 5760 -5230 {
lab=VDD}
N 5740 -5210 5760 -5210 {
lab=VSS}
N 5740 -5190 5760 -5190 {
lab=VDD}
N 5800 -5110 5800 -5100 {
lab=VSS}
N 5820 -5350 5820 -5330 {
lab=vcom}
N 5800 -5340 5800 -5330 {
lab=VDD}
N 5880 -5110 5880 -5090 {
lab=row_n[18]}
N 5600 -5350 5600 -5330 {
lab=ctop}
N 5860 -5350 5860 -5330 {
lab=ctop}
N 6140 -5110 6150 -5120 {
lab=row_n[19]}
N 6150 -5320 6150 -5120 {
lab=row_n[19]}
N 6140 -5330 6150 -5320 {
lab=row_n[19]}
N 6140 -5350 6140 -5330 {
lab=row_n[19]}
N 6020 -5250 6030 -5260 {
lab=VDD}
N 6030 -5260 6230 -5260 {
lab=VDD}
N 6230 -5260 6240 -5250 {
lab=VDD}
N 6020 -5230 6030 -5240 {
lab=VDD}
N 6030 -5240 6230 -5240 {
lab=VDD}
N 6230 -5240 6240 -5230 {
lab=VDD}
N 6020 -5210 6030 -5220 {
lab=VSS}
N 6030 -5220 6230 -5220 {
lab=VSS}
N 6230 -5220 6240 -5210 {
lab=VSS}
N 6020 -5190 6030 -5200 {
lab=VDD}
N 6030 -5200 6230 -5200 {
lab=VDD}
N 6230 -5200 6240 -5190 {
lab=VDD}
N 6240 -5190 6260 -5190 {
lab=VDD}
N 6240 -5210 6260 -5210 {
lab=VSS}
N 6240 -5230 6260 -5230 {
lab=VDD}
N 6240 -5250 6260 -5250 {
lab=VDD}
N 6000 -5250 6020 -5250 {
lab=VDD}
N 6000 -5230 6020 -5230 {
lab=VDD}
N 6000 -5210 6020 -5210 {
lab=VSS}
N 6000 -5190 6020 -5190 {
lab=VDD}
N 6060 -5110 6060 -5100 {
lab=VSS}
N 6080 -5350 6080 -5330 {
lab=vcom}
N 6060 -5340 6060 -5330 {
lab=VDD}
N 6140 -5110 6140 -5090 {
lab=row_n[19]}
N 6400 -5110 6410 -5120 {
lab=row_n[20]}
N 6410 -5320 6410 -5120 {
lab=row_n[20]}
N 6400 -5330 6410 -5320 {
lab=row_n[20]}
N 6400 -5350 6400 -5330 {
lab=row_n[20]}
N 6280 -5250 6290 -5260 {
lab=VDD}
N 6290 -5260 6490 -5260 {
lab=VDD}
N 6490 -5260 6500 -5250 {
lab=VDD}
N 6280 -5230 6290 -5240 {
lab=VDD}
N 6290 -5240 6490 -5240 {
lab=VDD}
N 6490 -5240 6500 -5230 {
lab=VDD}
N 6280 -5210 6290 -5220 {
lab=VSS}
N 6290 -5220 6490 -5220 {
lab=VSS}
N 6490 -5220 6500 -5210 {
lab=VSS}
N 6280 -5190 6290 -5200 {
lab=VDD}
N 6290 -5200 6490 -5200 {
lab=VDD}
N 6490 -5200 6500 -5190 {
lab=VDD}
N 6500 -5190 6520 -5190 {
lab=VDD}
N 6500 -5210 6520 -5210 {
lab=VSS}
N 6500 -5230 6520 -5230 {
lab=VDD}
N 6500 -5250 6520 -5250 {
lab=VDD}
N 6260 -5250 6280 -5250 {
lab=VDD}
N 6260 -5230 6280 -5230 {
lab=VDD}
N 6260 -5210 6280 -5210 {
lab=VSS}
N 6260 -5190 6280 -5190 {
lab=VDD}
N 6320 -5110 6320 -5100 {
lab=VSS}
N 6340 -5350 6340 -5330 {
lab=vcom}
N 6320 -5340 6320 -5330 {
lab=VDD}
N 6400 -5110 6400 -5090 {
lab=row_n[20]}
N 6120 -5350 6120 -5330 {
lab=ctop}
N 6380 -5350 6380 -5330 {
lab=ctop}
N 6660 -5110 6670 -5120 {
lab=row_n[21]}
N 6670 -5320 6670 -5120 {
lab=row_n[21]}
N 6660 -5330 6670 -5320 {
lab=row_n[21]}
N 6660 -5350 6660 -5330 {
lab=row_n[21]}
N 6540 -5250 6550 -5260 {
lab=VDD}
N 6550 -5260 6750 -5260 {
lab=VDD}
N 6750 -5260 6760 -5250 {
lab=VDD}
N 6540 -5230 6550 -5240 {
lab=VDD}
N 6550 -5240 6750 -5240 {
lab=VDD}
N 6750 -5240 6760 -5230 {
lab=VDD}
N 6540 -5210 6550 -5220 {
lab=VSS}
N 6550 -5220 6750 -5220 {
lab=VSS}
N 6750 -5220 6760 -5210 {
lab=VSS}
N 6540 -5190 6550 -5200 {
lab=VDD}
N 6550 -5200 6750 -5200 {
lab=VDD}
N 6750 -5200 6760 -5190 {
lab=VDD}
N 6760 -5190 6780 -5190 {
lab=VDD}
N 6760 -5210 6780 -5210 {
lab=VSS}
N 6760 -5230 6780 -5230 {
lab=VDD}
N 6760 -5250 6780 -5250 {
lab=VDD}
N 6520 -5250 6540 -5250 {
lab=VDD}
N 6520 -5230 6540 -5230 {
lab=VDD}
N 6520 -5210 6540 -5210 {
lab=VSS}
N 6520 -5190 6540 -5190 {
lab=VDD}
N 6580 -5110 6580 -5100 {
lab=VSS}
N 6600 -5350 6600 -5330 {
lab=vcom}
N 6580 -5340 6580 -5330 {
lab=VDD}
N 6660 -5110 6660 -5090 {
lab=row_n[21]}
N 6920 -5110 6930 -5120 {
lab=row_n[22]}
N 6930 -5320 6930 -5120 {
lab=row_n[22]}
N 6920 -5330 6930 -5320 {
lab=row_n[22]}
N 6920 -5350 6920 -5330 {
lab=row_n[22]}
N 6800 -5250 6810 -5260 {
lab=VDD}
N 6810 -5260 7010 -5260 {
lab=VDD}
N 7010 -5260 7020 -5250 {
lab=VDD}
N 6800 -5230 6810 -5240 {
lab=VDD}
N 6810 -5240 7010 -5240 {
lab=VDD}
N 7010 -5240 7020 -5230 {
lab=VDD}
N 6800 -5210 6810 -5220 {
lab=VSS}
N 6810 -5220 7010 -5220 {
lab=VSS}
N 7010 -5220 7020 -5210 {
lab=VSS}
N 6800 -5190 6810 -5200 {
lab=VDD}
N 6810 -5200 7010 -5200 {
lab=VDD}
N 7010 -5200 7020 -5190 {
lab=VDD}
N 7020 -5190 7040 -5190 {
lab=VDD}
N 7020 -5210 7040 -5210 {
lab=VSS}
N 7020 -5230 7040 -5230 {
lab=VDD}
N 7020 -5250 7040 -5250 {
lab=VDD}
N 6780 -5250 6800 -5250 {
lab=VDD}
N 6780 -5230 6800 -5230 {
lab=VDD}
N 6780 -5210 6800 -5210 {
lab=VSS}
N 6780 -5190 6800 -5190 {
lab=VDD}
N 6840 -5110 6840 -5100 {
lab=VSS}
N 6860 -5350 6860 -5330 {
lab=vcom}
N 6840 -5340 6840 -5330 {
lab=VDD}
N 6920 -5110 6920 -5090 {
lab=row_n[22]}
N 6640 -5350 6640 -5330 {
lab=ctop}
N 6900 -5350 6900 -5330 {
lab=ctop}
N 7180 -5110 7190 -5120 {
lab=row_n[23]}
N 7190 -5320 7190 -5120 {
lab=row_n[23]}
N 7180 -5330 7190 -5320 {
lab=row_n[23]}
N 7180 -5350 7180 -5330 {
lab=row_n[23]}
N 7060 -5250 7070 -5260 {
lab=VDD}
N 7070 -5260 7270 -5260 {
lab=VDD}
N 7270 -5260 7280 -5250 {
lab=VDD}
N 7060 -5230 7070 -5240 {
lab=VDD}
N 7070 -5240 7270 -5240 {
lab=VDD}
N 7270 -5240 7280 -5230 {
lab=VDD}
N 7060 -5210 7070 -5220 {
lab=VSS}
N 7070 -5220 7270 -5220 {
lab=VSS}
N 7270 -5220 7280 -5210 {
lab=VSS}
N 7060 -5190 7070 -5200 {
lab=VDD}
N 7070 -5200 7270 -5200 {
lab=VDD}
N 7270 -5200 7280 -5190 {
lab=VDD}
N 7280 -5190 7300 -5190 {
lab=VDD}
N 7280 -5210 7300 -5210 {
lab=VSS}
N 7280 -5230 7300 -5230 {
lab=VDD}
N 7280 -5250 7300 -5250 {
lab=VDD}
N 7040 -5250 7060 -5250 {
lab=VDD}
N 7040 -5230 7060 -5230 {
lab=VDD}
N 7040 -5210 7060 -5210 {
lab=VSS}
N 7040 -5190 7060 -5190 {
lab=VDD}
N 7100 -5110 7100 -5100 {
lab=VSS}
N 7120 -5350 7120 -5330 {
lab=vcom}
N 7100 -5340 7100 -5330 {
lab=VDD}
N 7180 -5110 7180 -5090 {
lab=row_n[23]}
N 7440 -5110 7450 -5120 {
lab=row_n[24]}
N 7450 -5320 7450 -5120 {
lab=row_n[24]}
N 7440 -5330 7450 -5320 {
lab=row_n[24]}
N 7440 -5350 7440 -5330 {
lab=row_n[24]}
N 7320 -5250 7330 -5260 {
lab=VDD}
N 7330 -5260 7530 -5260 {
lab=VDD}
N 7530 -5260 7540 -5250 {
lab=VDD}
N 7320 -5230 7330 -5240 {
lab=VDD}
N 7330 -5240 7530 -5240 {
lab=VDD}
N 7530 -5240 7540 -5230 {
lab=VDD}
N 7320 -5210 7330 -5220 {
lab=VSS}
N 7330 -5220 7530 -5220 {
lab=VSS}
N 7530 -5220 7540 -5210 {
lab=VSS}
N 7320 -5190 7330 -5200 {
lab=VDD}
N 7330 -5200 7530 -5200 {
lab=VDD}
N 7530 -5200 7540 -5190 {
lab=VDD}
N 7540 -5190 7560 -5190 {
lab=VDD}
N 7540 -5210 7560 -5210 {
lab=VSS}
N 7540 -5230 7560 -5230 {
lab=VDD}
N 7540 -5250 7560 -5250 {
lab=VDD}
N 7300 -5250 7320 -5250 {
lab=VDD}
N 7300 -5230 7320 -5230 {
lab=VDD}
N 7300 -5210 7320 -5210 {
lab=VSS}
N 7300 -5190 7320 -5190 {
lab=VDD}
N 7360 -5110 7360 -5100 {
lab=VSS}
N 7380 -5350 7380 -5330 {
lab=vcom}
N 7360 -5340 7360 -5330 {
lab=VDD}
N 7440 -5110 7440 -5090 {
lab=row_n[24]}
N 7160 -5350 7160 -5330 {
lab=ctop}
N 7420 -5350 7420 -5330 {
lab=ctop}
N 7700 -5110 7710 -5120 {
lab=row_n[25]}
N 7710 -5320 7710 -5120 {
lab=row_n[25]}
N 7700 -5330 7710 -5320 {
lab=row_n[25]}
N 7700 -5350 7700 -5330 {
lab=row_n[25]}
N 7580 -5250 7590 -5260 {
lab=VDD}
N 7590 -5260 7790 -5260 {
lab=VDD}
N 7790 -5260 7800 -5250 {
lab=VDD}
N 7580 -5230 7590 -5240 {
lab=VDD}
N 7590 -5240 7790 -5240 {
lab=VDD}
N 7790 -5240 7800 -5230 {
lab=VDD}
N 7580 -5210 7590 -5220 {
lab=VSS}
N 7590 -5220 7790 -5220 {
lab=VSS}
N 7790 -5220 7800 -5210 {
lab=VSS}
N 7580 -5190 7590 -5200 {
lab=VDD}
N 7590 -5200 7790 -5200 {
lab=VDD}
N 7790 -5200 7800 -5190 {
lab=VDD}
N 7800 -5190 7820 -5190 {
lab=VDD}
N 7800 -5210 7820 -5210 {
lab=VSS}
N 7800 -5230 7820 -5230 {
lab=VDD}
N 7800 -5250 7820 -5250 {
lab=VDD}
N 7560 -5250 7580 -5250 {
lab=VDD}
N 7560 -5230 7580 -5230 {
lab=VDD}
N 7560 -5210 7580 -5210 {
lab=VSS}
N 7560 -5190 7580 -5190 {
lab=VDD}
N 7620 -5110 7620 -5100 {
lab=VSS}
N 7640 -5350 7640 -5330 {
lab=vcom}
N 7620 -5340 7620 -5330 {
lab=VDD}
N 7700 -5110 7700 -5090 {
lab=row_n[25]}
N 7960 -5110 7970 -5120 {
lab=row_n[26]}
N 7970 -5320 7970 -5120 {
lab=row_n[26]}
N 7960 -5330 7970 -5320 {
lab=row_n[26]}
N 7960 -5350 7960 -5330 {
lab=row_n[26]}
N 7840 -5250 7850 -5260 {
lab=VDD}
N 7850 -5260 8050 -5260 {
lab=VDD}
N 8050 -5260 8060 -5250 {
lab=VDD}
N 7840 -5230 7850 -5240 {
lab=VDD}
N 7850 -5240 8050 -5240 {
lab=VDD}
N 8050 -5240 8060 -5230 {
lab=VDD}
N 7840 -5210 7850 -5220 {
lab=VSS}
N 7850 -5220 8050 -5220 {
lab=VSS}
N 8050 -5220 8060 -5210 {
lab=VSS}
N 7840 -5190 7850 -5200 {
lab=VDD}
N 7850 -5200 8050 -5200 {
lab=VDD}
N 8050 -5200 8060 -5190 {
lab=VDD}
N 8060 -5190 8080 -5190 {
lab=VDD}
N 8060 -5210 8080 -5210 {
lab=VSS}
N 8060 -5230 8080 -5230 {
lab=VDD}
N 8060 -5250 8080 -5250 {
lab=VDD}
N 7820 -5250 7840 -5250 {
lab=VDD}
N 7820 -5230 7840 -5230 {
lab=VDD}
N 7820 -5210 7840 -5210 {
lab=VSS}
N 7820 -5190 7840 -5190 {
lab=VDD}
N 7880 -5110 7880 -5100 {
lab=VSS}
N 7900 -5350 7900 -5330 {
lab=vcom}
N 7880 -5340 7880 -5330 {
lab=VDD}
N 7960 -5110 7960 -5090 {
lab=row_n[26]}
N 7680 -5350 7680 -5330 {
lab=ctop}
N 7940 -5350 7940 -5330 {
lab=ctop}
N 8220 -5110 8230 -5120 {
lab=row_n[27]}
N 8230 -5320 8230 -5120 {
lab=row_n[27]}
N 8220 -5330 8230 -5320 {
lab=row_n[27]}
N 8220 -5350 8220 -5330 {
lab=row_n[27]}
N 8100 -5250 8110 -5260 {
lab=VDD}
N 8110 -5260 8310 -5260 {
lab=VDD}
N 8310 -5260 8320 -5250 {
lab=VDD}
N 8100 -5230 8110 -5240 {
lab=VDD}
N 8110 -5240 8310 -5240 {
lab=VDD}
N 8310 -5240 8320 -5230 {
lab=VDD}
N 8100 -5210 8110 -5220 {
lab=VSS}
N 8110 -5220 8310 -5220 {
lab=VSS}
N 8310 -5220 8320 -5210 {
lab=VSS}
N 8100 -5190 8110 -5200 {
lab=VDD}
N 8110 -5200 8310 -5200 {
lab=VDD}
N 8310 -5200 8320 -5190 {
lab=VDD}
N 8320 -5190 8340 -5190 {
lab=VDD}
N 8320 -5210 8340 -5210 {
lab=VSS}
N 8320 -5230 8340 -5230 {
lab=VDD}
N 8320 -5250 8340 -5250 {
lab=VDD}
N 8080 -5250 8100 -5250 {
lab=VDD}
N 8080 -5230 8100 -5230 {
lab=VDD}
N 8080 -5210 8100 -5210 {
lab=VSS}
N 8080 -5190 8100 -5190 {
lab=VDD}
N 8140 -5110 8140 -5100 {
lab=VSS}
N 8160 -5350 8160 -5330 {
lab=vcom}
N 8140 -5340 8140 -5330 {
lab=VDD}
N 8220 -5110 8220 -5090 {
lab=row_n[27]}
N 8480 -5110 8490 -5120 {
lab=row_n[28]}
N 8490 -5320 8490 -5120 {
lab=row_n[28]}
N 8480 -5330 8490 -5320 {
lab=row_n[28]}
N 8480 -5350 8480 -5330 {
lab=row_n[28]}
N 8360 -5250 8370 -5260 {
lab=VDD}
N 8370 -5260 8570 -5260 {
lab=VDD}
N 8570 -5260 8580 -5250 {
lab=VDD}
N 8360 -5230 8370 -5240 {
lab=VDD}
N 8370 -5240 8570 -5240 {
lab=VDD}
N 8570 -5240 8580 -5230 {
lab=VDD}
N 8360 -5210 8370 -5220 {
lab=VSS}
N 8370 -5220 8570 -5220 {
lab=VSS}
N 8570 -5220 8580 -5210 {
lab=VSS}
N 8360 -5190 8370 -5200 {
lab=VDD}
N 8370 -5200 8570 -5200 {
lab=VDD}
N 8570 -5200 8580 -5190 {
lab=VDD}
N 8580 -5190 8600 -5190 {
lab=VDD}
N 8580 -5210 8600 -5210 {
lab=VSS}
N 8580 -5230 8600 -5230 {
lab=VDD}
N 8580 -5250 8600 -5250 {
lab=VDD}
N 8340 -5250 8360 -5250 {
lab=VDD}
N 8340 -5230 8360 -5230 {
lab=VDD}
N 8340 -5210 8360 -5210 {
lab=VSS}
N 8340 -5190 8360 -5190 {
lab=VDD}
N 8400 -5110 8400 -5100 {
lab=VSS}
N 8420 -5350 8420 -5330 {
lab=vcom}
N 8400 -5340 8400 -5330 {
lab=VDD}
N 8480 -5110 8480 -5090 {
lab=row_n[28]}
N 8200 -5350 8200 -5330 {
lab=ctop}
N 8460 -5350 8460 -5330 {
lab=ctop}
N 8740 -5110 8750 -5120 {
lab=row_n[29]}
N 8750 -5320 8750 -5120 {
lab=row_n[29]}
N 8740 -5330 8750 -5320 {
lab=row_n[29]}
N 8740 -5350 8740 -5330 {
lab=row_n[29]}
N 8620 -5250 8630 -5260 {
lab=VDD}
N 8630 -5260 8830 -5260 {
lab=VDD}
N 8830 -5260 8840 -5250 {
lab=VDD}
N 8620 -5230 8630 -5240 {
lab=VDD}
N 8630 -5240 8830 -5240 {
lab=VDD}
N 8830 -5240 8840 -5230 {
lab=VDD}
N 8620 -5210 8630 -5220 {
lab=VSS}
N 8630 -5220 8830 -5220 {
lab=VSS}
N 8830 -5220 8840 -5210 {
lab=VSS}
N 8620 -5190 8630 -5200 {
lab=VDD}
N 8630 -5200 8830 -5200 {
lab=VDD}
N 8830 -5200 8840 -5190 {
lab=VDD}
N 8840 -5190 8860 -5190 {
lab=VDD}
N 8840 -5210 8860 -5210 {
lab=VSS}
N 8840 -5230 8860 -5230 {
lab=VDD}
N 8840 -5250 8860 -5250 {
lab=VDD}
N 8600 -5250 8620 -5250 {
lab=VDD}
N 8600 -5230 8620 -5230 {
lab=VDD}
N 8600 -5210 8620 -5210 {
lab=VSS}
N 8600 -5190 8620 -5190 {
lab=VDD}
N 8660 -5110 8660 -5100 {
lab=VSS}
N 8680 -5350 8680 -5330 {
lab=vcom}
N 8660 -5340 8660 -5330 {
lab=VDD}
N 8740 -5110 8740 -5090 {
lab=row_n[29]}
N 9000 -5110 9010 -5120 {
lab=row_n[30]}
N 9010 -5320 9010 -5120 {
lab=row_n[30]}
N 9000 -5330 9010 -5320 {
lab=row_n[30]}
N 9000 -5350 9000 -5330 {
lab=row_n[30]}
N 8880 -5250 8890 -5260 {
lab=VDD}
N 8890 -5260 9090 -5260 {
lab=VDD}
N 9090 -5260 9100 -5250 {
lab=VDD}
N 8880 -5230 8890 -5240 {
lab=VDD}
N 8890 -5240 9090 -5240 {
lab=VDD}
N 9090 -5240 9100 -5230 {
lab=VDD}
N 8880 -5210 8890 -5220 {
lab=VSS}
N 8890 -5220 9090 -5220 {
lab=VSS}
N 9090 -5220 9100 -5210 {
lab=VSS}
N 8880 -5190 8890 -5200 {
lab=VDD}
N 8890 -5200 9090 -5200 {
lab=VDD}
N 9090 -5200 9100 -5190 {
lab=VDD}
N 9100 -5190 9120 -5190 {
lab=VDD}
N 9100 -5210 9120 -5210 {
lab=VSS}
N 9100 -5230 9120 -5230 {
lab=VDD}
N 9100 -5250 9120 -5250 {
lab=VDD}
N 8860 -5250 8880 -5250 {
lab=VDD}
N 8860 -5230 8880 -5230 {
lab=VDD}
N 8860 -5210 8880 -5210 {
lab=VSS}
N 8860 -5190 8880 -5190 {
lab=VDD}
N 8920 -5110 8920 -5100 {
lab=VSS}
N 8940 -5350 8940 -5330 {
lab=vcom}
N 8920 -5340 8920 -5330 {
lab=VDD}
N 9000 -5110 9000 -5090 {
lab=row_n[30]}
N 8720 -5350 8720 -5330 {
lab=ctop}
N 8980 -5350 8980 -5330 {
lab=ctop}
N 9260 -5110 9270 -5120 {
lab=row_n[31]}
N 9270 -5320 9270 -5120 {
lab=row_n[31]}
N 9260 -5330 9270 -5320 {
lab=row_n[31]}
N 9260 -5350 9260 -5330 {
lab=row_n[31]}
N 9140 -5250 9150 -5260 {
lab=VDD}
N 9150 -5260 9350 -5260 {
lab=VDD}
N 9350 -5260 9360 -5250 {
lab=VDD}
N 9140 -5230 9150 -5240 {
lab=VDD}
N 9150 -5240 9350 -5240 {
lab=VDD}
N 9350 -5240 9360 -5230 {
lab=VDD}
N 9140 -5210 9150 -5220 {
lab=VSS}
N 9150 -5220 9350 -5220 {
lab=VSS}
N 9350 -5220 9360 -5210 {
lab=VSS}
N 9140 -5190 9150 -5200 {
lab=VDD}
N 9150 -5200 9350 -5200 {
lab=VDD}
N 9350 -5200 9360 -5190 {
lab=VDD}
N 9360 -5190 9380 -5190 {
lab=VDD}
N 9360 -5210 9380 -5210 {
lab=VSS}
N 9360 -5230 9380 -5230 {
lab=VDD}
N 9360 -5250 9380 -5250 {
lab=VDD}
N 9120 -5250 9140 -5250 {
lab=VDD}
N 9120 -5230 9140 -5230 {
lab=VDD}
N 9120 -5210 9140 -5210 {
lab=VSS}
N 9120 -5190 9140 -5190 {
lab=VDD}
N 9180 -5110 9180 -5100 {
lab=VSS}
N 9200 -5350 9200 -5330 {
lab=vcom}
N 9180 -5340 9180 -5330 {
lab=VDD}
N 9260 -5110 9260 -5090 {
lab=row_n[31]}
N 9240 -5350 9240 -5330 {
lab=ctop}
N 9520 -5110 9530 -5120 {
lab=VDD}
N 9530 -5320 9530 -5120 {
lab=VDD}
N 9520 -5330 9530 -5320 {
lab=VDD}
N 9520 -5350 9520 -5330 {
lab=VDD}
N 9400 -5250 9410 -5260 {
lab=VDD}
N 9410 -5260 9610 -5260 {
lab=VDD}
N 9610 -5260 9620 -5250 {
lab=VDD}
N 9400 -5230 9410 -5240 {
lab=VDD}
N 9410 -5240 9610 -5240 {
lab=VDD}
N 9610 -5240 9620 -5230 {
lab=VDD}
N 9400 -5210 9410 -5220 {
lab=VSS}
N 9410 -5220 9610 -5220 {
lab=VSS}
N 9610 -5220 9620 -5210 {
lab=VSS}
N 9400 -5190 9410 -5200 {
lab=VDD}
N 9410 -5200 9610 -5200 {
lab=VDD}
N 9610 -5200 9620 -5190 {
lab=VDD}
N 9620 -5190 9640 -5190 {
lab=VDD}
N 9620 -5210 9640 -5210 {
lab=VSS}
N 9620 -5230 9640 -5230 {
lab=VDD}
N 9620 -5250 9640 -5250 {
lab=VDD}
N 9380 -5250 9400 -5250 {
lab=VDD}
N 9380 -5230 9400 -5230 {
lab=VDD}
N 9380 -5210 9400 -5210 {
lab=VSS}
N 9380 -5190 9400 -5190 {
lab=VDD}
N 9440 -5110 9440 -5100 {
lab=VSS}
N 9460 -5350 9460 -5330 {
lab=vcom}
N 9440 -5340 9440 -5330 {
lab=VDD}
N 9520 -5110 9520 -5090 {
lab=VDD}
N 9500 -5350 9500 -5330 {
lab=ctop}
N 9520 -950 9530 -960 {
lab=VDD}
N 9530 -1160 9530 -960 {
lab=VDD}
N 9520 -1170 9530 -1160 {
lab=VDD}
N 9520 -1190 9520 -1170 {
lab=VDD}
N 9400 -1090 9410 -1100 {
lab=col_n[0]}
N 9410 -1100 9610 -1100 {
lab=col_n[0]}
N 9610 -1100 9620 -1090 {
lab=col_n[0]}
N 9400 -1070 9410 -1080 {
lab=colon_n[0]}
N 9410 -1080 9610 -1080 {
lab=colon_n[0]}
N 9610 -1080 9620 -1070 {
lab=colon_n[0]}
N 9400 -1050 9410 -1060 {
lab=#net1}
N 9410 -1060 9610 -1060 {
lab=#net1}
N 9610 -1060 9620 -1050 {
lab=#net1}
N 9400 -1030 9410 -1040 {
lab=#net2}
N 9410 -1040 9610 -1040 {
lab=#net2}
N 9610 -1040 9620 -1030 {
lab=#net2}
N 9620 -1030 9640 -1030 {
lab=#net2}
N 9620 -1050 9640 -1050 {
lab=#net1}
N 9620 -1070 9640 -1070 {
lab=colon_n[0]}
N 9620 -1090 9640 -1090 {
lab=col_n[0]}
N 9380 -1090 9400 -1090 {
lab=col_n[0]}
N 9380 -1070 9400 -1070 {
lab=colon_n[0]}
N 9380 -1050 9400 -1050 {
lab=#net1}
N 9380 -1030 9400 -1030 {
lab=#net2}
N 9440 -950 9440 -940 {
lab=VSS}
N 9460 -1190 9460 -1170 {
lab=vcom}
N 9440 -1180 9440 -1170 {
lab=VDD}
N 9500 -1190 9500 -1170 {
lab=ctop}
N 9520 -950 9520 -930 {
lab=VDD}
N 9520 -1210 9530 -1220 {
lab=VDD}
N 9530 -1420 9530 -1220 {
lab=VDD}
N 9520 -1430 9530 -1420 {
lab=VDD}
N 9520 -1450 9520 -1430 {
lab=VDD}
N 9400 -1350 9410 -1360 {
lab=col_n[1]}
N 9410 -1360 9610 -1360 {
lab=col_n[1]}
N 9610 -1360 9620 -1350 {
lab=col_n[1]}
N 9400 -1330 9410 -1340 {
lab=colon_n[1]}
N 9410 -1340 9610 -1340 {
lab=colon_n[1]}
N 9610 -1340 9620 -1330 {
lab=colon_n[1]}
N 9400 -1310 9410 -1320 {
lab=#net3}
N 9410 -1320 9610 -1320 {
lab=#net3}
N 9610 -1320 9620 -1310 {
lab=#net3}
N 9400 -1290 9410 -1300 {
lab=#net4}
N 9410 -1300 9610 -1300 {
lab=#net4}
N 9610 -1300 9620 -1290 {
lab=#net4}
N 9620 -1290 9640 -1290 {
lab=#net4}
N 9620 -1310 9640 -1310 {
lab=#net3}
N 9620 -1330 9640 -1330 {
lab=colon_n[1]}
N 9620 -1350 9640 -1350 {
lab=col_n[1]}
N 9380 -1350 9400 -1350 {
lab=col_n[1]}
N 9380 -1330 9400 -1330 {
lab=colon_n[1]}
N 9380 -1310 9400 -1310 {
lab=#net3}
N 9380 -1290 9400 -1290 {
lab=#net4}
N 9440 -1210 9440 -1200 {
lab=VSS}
N 9460 -1450 9460 -1430 {
lab=vcom}
N 9440 -1440 9440 -1430 {
lab=VDD}
N 9500 -1450 9500 -1430 {
lab=ctop}
N 9520 -1210 9520 -1190 {
lab=VDD}
N 9520 -1470 9530 -1480 {
lab=VDD}
N 9530 -1680 9530 -1480 {
lab=VDD}
N 9520 -1690 9530 -1680 {
lab=VDD}
N 9520 -1710 9520 -1690 {
lab=VDD}
N 9400 -1610 9410 -1620 {
lab=col_n[2]}
N 9410 -1620 9610 -1620 {
lab=col_n[2]}
N 9610 -1620 9620 -1610 {
lab=col_n[2]}
N 9400 -1590 9410 -1600 {
lab=colon_n[2]}
N 9410 -1600 9610 -1600 {
lab=colon_n[2]}
N 9610 -1600 9620 -1590 {
lab=colon_n[2]}
N 9400 -1570 9410 -1580 {
lab=#net5}
N 9410 -1580 9610 -1580 {
lab=#net5}
N 9610 -1580 9620 -1570 {
lab=#net5}
N 9400 -1550 9410 -1560 {
lab=#net6}
N 9410 -1560 9610 -1560 {
lab=#net6}
N 9610 -1560 9620 -1550 {
lab=#net6}
N 9620 -1550 9640 -1550 {
lab=#net6}
N 9620 -1570 9640 -1570 {
lab=#net5}
N 9620 -1590 9640 -1590 {
lab=colon_n[2]}
N 9620 -1610 9640 -1610 {
lab=col_n[2]}
N 9380 -1610 9400 -1610 {
lab=col_n[2]}
N 9380 -1590 9400 -1590 {
lab=colon_n[2]}
N 9380 -1570 9400 -1570 {
lab=#net5}
N 9380 -1550 9400 -1550 {
lab=#net6}
N 9440 -1470 9440 -1460 {
lab=VSS}
N 9460 -1710 9460 -1690 {
lab=vcom}
N 9440 -1700 9440 -1690 {
lab=VDD}
N 9500 -1710 9500 -1690 {
lab=ctop}
N 9520 -1470 9520 -1450 {
lab=VDD}
N 9520 -1730 9530 -1740 {
lab=VDD}
N 9530 -1940 9530 -1740 {
lab=VDD}
N 9520 -1950 9530 -1940 {
lab=VDD}
N 9520 -1970 9520 -1950 {
lab=VDD}
N 9400 -1870 9410 -1880 {
lab=col_n[3]}
N 9410 -1880 9610 -1880 {
lab=col_n[3]}
N 9610 -1880 9620 -1870 {
lab=col_n[3]}
N 9400 -1850 9410 -1860 {
lab=colon_n[3]}
N 9410 -1860 9610 -1860 {
lab=colon_n[3]}
N 9610 -1860 9620 -1850 {
lab=colon_n[3]}
N 9400 -1830 9410 -1840 {
lab=#net7}
N 9410 -1840 9610 -1840 {
lab=#net7}
N 9610 -1840 9620 -1830 {
lab=#net7}
N 9400 -1810 9410 -1820 {
lab=#net8}
N 9410 -1820 9610 -1820 {
lab=#net8}
N 9610 -1820 9620 -1810 {
lab=#net8}
N 9620 -1810 9640 -1810 {
lab=#net8}
N 9620 -1830 9640 -1830 {
lab=#net7}
N 9620 -1850 9640 -1850 {
lab=colon_n[3]}
N 9620 -1870 9640 -1870 {
lab=col_n[3]}
N 9380 -1870 9400 -1870 {
lab=col_n[3]}
N 9380 -1850 9400 -1850 {
lab=colon_n[3]}
N 9380 -1830 9400 -1830 {
lab=#net7}
N 9380 -1810 9400 -1810 {
lab=#net8}
N 9440 -1730 9440 -1720 {
lab=VSS}
N 9460 -1970 9460 -1950 {
lab=vcom}
N 9440 -1960 9440 -1950 {
lab=VDD}
N 9500 -1970 9500 -1950 {
lab=ctop}
N 9520 -1730 9520 -1710 {
lab=VDD}
N 9520 -1990 9530 -2000 {
lab=VDD}
N 9530 -2200 9530 -2000 {
lab=VDD}
N 9520 -2210 9530 -2200 {
lab=VDD}
N 9520 -2230 9520 -2210 {
lab=VDD}
N 9400 -2130 9410 -2140 {
lab=col_n[4]}
N 9410 -2140 9610 -2140 {
lab=col_n[4]}
N 9610 -2140 9620 -2130 {
lab=col_n[4]}
N 9400 -2110 9410 -2120 {
lab=colon_n[4]}
N 9410 -2120 9610 -2120 {
lab=colon_n[4]}
N 9610 -2120 9620 -2110 {
lab=colon_n[4]}
N 9400 -2090 9410 -2100 {
lab=#net9}
N 9410 -2100 9610 -2100 {
lab=#net9}
N 9610 -2100 9620 -2090 {
lab=#net9}
N 9400 -2070 9410 -2080 {
lab=#net10}
N 9410 -2080 9610 -2080 {
lab=#net10}
N 9610 -2080 9620 -2070 {
lab=#net10}
N 9620 -2070 9640 -2070 {
lab=#net10}
N 9620 -2090 9640 -2090 {
lab=#net9}
N 9620 -2110 9640 -2110 {
lab=colon_n[4]}
N 9620 -2130 9640 -2130 {
lab=col_n[4]}
N 9380 -2130 9400 -2130 {
lab=col_n[4]}
N 9380 -2110 9400 -2110 {
lab=colon_n[4]}
N 9380 -2090 9400 -2090 {
lab=#net9}
N 9380 -2070 9400 -2070 {
lab=#net10}
N 9440 -1990 9440 -1980 {
lab=VSS}
N 9460 -2230 9460 -2210 {
lab=vcom}
N 9440 -2220 9440 -2210 {
lab=VDD}
N 9500 -2230 9500 -2210 {
lab=ctop}
N 9520 -1990 9520 -1970 {
lab=VDD}
N 9520 -2250 9530 -2260 {
lab=VDD}
N 9530 -2460 9530 -2260 {
lab=VDD}
N 9520 -2470 9530 -2460 {
lab=VDD}
N 9520 -2490 9520 -2470 {
lab=VDD}
N 9400 -2390 9410 -2400 {
lab=col_n[5]}
N 9410 -2400 9610 -2400 {
lab=col_n[5]}
N 9610 -2400 9620 -2390 {
lab=col_n[5]}
N 9400 -2370 9410 -2380 {
lab=colon_n[5]}
N 9410 -2380 9610 -2380 {
lab=colon_n[5]}
N 9610 -2380 9620 -2370 {
lab=colon_n[5]}
N 9400 -2350 9410 -2360 {
lab=#net11}
N 9410 -2360 9610 -2360 {
lab=#net11}
N 9610 -2360 9620 -2350 {
lab=#net11}
N 9400 -2330 9410 -2340 {
lab=#net12}
N 9410 -2340 9610 -2340 {
lab=#net12}
N 9610 -2340 9620 -2330 {
lab=#net12}
N 9620 -2330 9640 -2330 {
lab=#net12}
N 9620 -2350 9640 -2350 {
lab=#net11}
N 9620 -2370 9640 -2370 {
lab=colon_n[5]}
N 9620 -2390 9640 -2390 {
lab=col_n[5]}
N 9380 -2390 9400 -2390 {
lab=col_n[5]}
N 9380 -2370 9400 -2370 {
lab=colon_n[5]}
N 9380 -2350 9400 -2350 {
lab=#net11}
N 9380 -2330 9400 -2330 {
lab=#net12}
N 9440 -2250 9440 -2240 {
lab=VSS}
N 9460 -2490 9460 -2470 {
lab=vcom}
N 9440 -2480 9440 -2470 {
lab=VDD}
N 9500 -2490 9500 -2470 {
lab=ctop}
N 9520 -2250 9520 -2230 {
lab=VDD}
N 9520 -2510 9530 -2520 {
lab=VDD}
N 9530 -2720 9530 -2520 {
lab=VDD}
N 9520 -2730 9530 -2720 {
lab=VDD}
N 9520 -2750 9520 -2730 {
lab=VDD}
N 9400 -2650 9410 -2660 {
lab=col_n[6]}
N 9410 -2660 9610 -2660 {
lab=col_n[6]}
N 9610 -2660 9620 -2650 {
lab=col_n[6]}
N 9400 -2630 9410 -2640 {
lab=colon_n[6]}
N 9410 -2640 9610 -2640 {
lab=colon_n[6]}
N 9610 -2640 9620 -2630 {
lab=colon_n[6]}
N 9400 -2610 9410 -2620 {
lab=#net13}
N 9410 -2620 9610 -2620 {
lab=#net13}
N 9610 -2620 9620 -2610 {
lab=#net13}
N 9400 -2590 9410 -2600 {
lab=#net14}
N 9410 -2600 9610 -2600 {
lab=#net14}
N 9610 -2600 9620 -2590 {
lab=#net14}
N 9620 -2590 9640 -2590 {
lab=#net14}
N 9620 -2610 9640 -2610 {
lab=#net13}
N 9620 -2630 9640 -2630 {
lab=colon_n[6]}
N 9620 -2650 9640 -2650 {
lab=col_n[6]}
N 9380 -2650 9400 -2650 {
lab=col_n[6]}
N 9380 -2630 9400 -2630 {
lab=colon_n[6]}
N 9380 -2610 9400 -2610 {
lab=#net13}
N 9380 -2590 9400 -2590 {
lab=#net14}
N 9440 -2510 9440 -2500 {
lab=VSS}
N 9460 -2750 9460 -2730 {
lab=vcom}
N 9440 -2740 9440 -2730 {
lab=VDD}
N 9500 -2750 9500 -2730 {
lab=ctop}
N 9520 -2510 9520 -2490 {
lab=VDD}
N 9520 -2770 9530 -2780 {
lab=VDD}
N 9530 -2980 9530 -2780 {
lab=VDD}
N 9520 -2990 9530 -2980 {
lab=VDD}
N 9520 -3010 9520 -2990 {
lab=VDD}
N 9400 -2910 9410 -2920 {
lab=col_n[7]}
N 9410 -2920 9610 -2920 {
lab=col_n[7]}
N 9610 -2920 9620 -2910 {
lab=col_n[7]}
N 9400 -2890 9410 -2900 {
lab=colon_n[7]}
N 9410 -2900 9610 -2900 {
lab=colon_n[7]}
N 9610 -2900 9620 -2890 {
lab=colon_n[7]}
N 9400 -2870 9410 -2880 {
lab=#net15}
N 9410 -2880 9610 -2880 {
lab=#net15}
N 9610 -2880 9620 -2870 {
lab=#net15}
N 9400 -2850 9410 -2860 {
lab=#net16}
N 9410 -2860 9610 -2860 {
lab=#net16}
N 9610 -2860 9620 -2850 {
lab=#net16}
N 9620 -2850 9640 -2850 {
lab=#net16}
N 9620 -2870 9640 -2870 {
lab=#net15}
N 9620 -2890 9640 -2890 {
lab=colon_n[7]}
N 9620 -2910 9640 -2910 {
lab=col_n[7]}
N 9380 -2910 9400 -2910 {
lab=col_n[7]}
N 9380 -2890 9400 -2890 {
lab=colon_n[7]}
N 9380 -2870 9400 -2870 {
lab=#net15}
N 9380 -2850 9400 -2850 {
lab=#net16}
N 9440 -2770 9440 -2760 {
lab=VSS}
N 9460 -3010 9460 -2990 {
lab=vcom}
N 9440 -3000 9440 -2990 {
lab=VDD}
N 9500 -3010 9500 -2990 {
lab=ctop}
N 9520 -2770 9520 -2750 {
lab=VDD}
N 9520 -3030 9530 -3040 {
lab=VDD}
N 9530 -3240 9530 -3040 {
lab=VDD}
N 9520 -3250 9530 -3240 {
lab=VDD}
N 9520 -3270 9520 -3250 {
lab=VDD}
N 9400 -3170 9410 -3180 {
lab=col_n[8]}
N 9410 -3180 9610 -3180 {
lab=col_n[8]}
N 9610 -3180 9620 -3170 {
lab=col_n[8]}
N 9400 -3150 9410 -3160 {
lab=colon_n[8]}
N 9410 -3160 9610 -3160 {
lab=colon_n[8]}
N 9610 -3160 9620 -3150 {
lab=colon_n[8]}
N 9400 -3130 9410 -3140 {
lab=#net17}
N 9410 -3140 9610 -3140 {
lab=#net17}
N 9610 -3140 9620 -3130 {
lab=#net17}
N 9400 -3110 9410 -3120 {
lab=#net18}
N 9410 -3120 9610 -3120 {
lab=#net18}
N 9610 -3120 9620 -3110 {
lab=#net18}
N 9620 -3110 9640 -3110 {
lab=#net18}
N 9620 -3130 9640 -3130 {
lab=#net17}
N 9620 -3150 9640 -3150 {
lab=colon_n[8]}
N 9620 -3170 9640 -3170 {
lab=col_n[8]}
N 9380 -3170 9400 -3170 {
lab=col_n[8]}
N 9380 -3150 9400 -3150 {
lab=colon_n[8]}
N 9380 -3130 9400 -3130 {
lab=#net17}
N 9380 -3110 9400 -3110 {
lab=#net18}
N 9440 -3030 9440 -3020 {
lab=VSS}
N 9460 -3270 9460 -3250 {
lab=vcom}
N 9440 -3260 9440 -3250 {
lab=VDD}
N 9500 -3270 9500 -3250 {
lab=ctop}
N 9520 -3030 9520 -3010 {
lab=VDD}
N 9520 -3290 9530 -3300 {
lab=VDD}
N 9530 -3500 9530 -3300 {
lab=VDD}
N 9520 -3510 9530 -3500 {
lab=VDD}
N 9520 -3530 9520 -3510 {
lab=VDD}
N 9400 -3430 9410 -3440 {
lab=col_n[9]}
N 9410 -3440 9610 -3440 {
lab=col_n[9]}
N 9610 -3440 9620 -3430 {
lab=col_n[9]}
N 9400 -3410 9410 -3420 {
lab=colon_n[9]}
N 9410 -3420 9610 -3420 {
lab=colon_n[9]}
N 9610 -3420 9620 -3410 {
lab=colon_n[9]}
N 9400 -3390 9410 -3400 {
lab=#net19}
N 9410 -3400 9610 -3400 {
lab=#net19}
N 9610 -3400 9620 -3390 {
lab=#net19}
N 9400 -3370 9410 -3380 {
lab=#net20}
N 9410 -3380 9610 -3380 {
lab=#net20}
N 9610 -3380 9620 -3370 {
lab=#net20}
N 9620 -3370 9640 -3370 {
lab=#net20}
N 9620 -3390 9640 -3390 {
lab=#net19}
N 9620 -3410 9640 -3410 {
lab=colon_n[9]}
N 9620 -3430 9640 -3430 {
lab=col_n[9]}
N 9380 -3430 9400 -3430 {
lab=col_n[9]}
N 9380 -3410 9400 -3410 {
lab=colon_n[9]}
N 9380 -3390 9400 -3390 {
lab=#net19}
N 9380 -3370 9400 -3370 {
lab=#net20}
N 9440 -3290 9440 -3280 {
lab=VSS}
N 9460 -3530 9460 -3510 {
lab=vcom}
N 9440 -3520 9440 -3510 {
lab=VDD}
N 9500 -3530 9500 -3510 {
lab=ctop}
N 9520 -3290 9520 -3270 {
lab=VDD}
N 9520 -3550 9530 -3560 {
lab=VDD}
N 9530 -3760 9530 -3560 {
lab=VDD}
N 9520 -3770 9530 -3760 {
lab=VDD}
N 9520 -3790 9520 -3770 {
lab=VDD}
N 9400 -3690 9410 -3700 {
lab=col_n[10]}
N 9410 -3700 9610 -3700 {
lab=col_n[10]}
N 9610 -3700 9620 -3690 {
lab=col_n[10]}
N 9400 -3670 9410 -3680 {
lab=colon_n[10]}
N 9410 -3680 9610 -3680 {
lab=colon_n[10]}
N 9610 -3680 9620 -3670 {
lab=colon_n[10]}
N 9400 -3650 9410 -3660 {
lab=#net21}
N 9410 -3660 9610 -3660 {
lab=#net21}
N 9610 -3660 9620 -3650 {
lab=#net21}
N 9400 -3630 9410 -3640 {
lab=#net22}
N 9410 -3640 9610 -3640 {
lab=#net22}
N 9610 -3640 9620 -3630 {
lab=#net22}
N 9620 -3630 9640 -3630 {
lab=#net22}
N 9620 -3650 9640 -3650 {
lab=#net21}
N 9620 -3670 9640 -3670 {
lab=colon_n[10]}
N 9620 -3690 9640 -3690 {
lab=col_n[10]}
N 9380 -3690 9400 -3690 {
lab=col_n[10]}
N 9380 -3670 9400 -3670 {
lab=colon_n[10]}
N 9380 -3650 9400 -3650 {
lab=#net21}
N 9380 -3630 9400 -3630 {
lab=#net22}
N 9440 -3550 9440 -3540 {
lab=VSS}
N 9460 -3790 9460 -3770 {
lab=vcom}
N 9440 -3780 9440 -3770 {
lab=VDD}
N 9500 -3790 9500 -3770 {
lab=ctop}
N 9520 -3550 9520 -3530 {
lab=VDD}
N 9520 -3810 9530 -3820 {
lab=VDD}
N 9530 -4020 9530 -3820 {
lab=VDD}
N 9520 -4030 9530 -4020 {
lab=VDD}
N 9520 -4050 9520 -4030 {
lab=VDD}
N 9400 -3950 9410 -3960 {
lab=col_n[11]}
N 9410 -3960 9610 -3960 {
lab=col_n[11]}
N 9610 -3960 9620 -3950 {
lab=col_n[11]}
N 9400 -3930 9410 -3940 {
lab=colon_n[11]}
N 9410 -3940 9610 -3940 {
lab=colon_n[11]}
N 9610 -3940 9620 -3930 {
lab=colon_n[11]}
N 9400 -3910 9410 -3920 {
lab=#net23}
N 9410 -3920 9610 -3920 {
lab=#net23}
N 9610 -3920 9620 -3910 {
lab=#net23}
N 9400 -3890 9410 -3900 {
lab=#net24}
N 9410 -3900 9610 -3900 {
lab=#net24}
N 9610 -3900 9620 -3890 {
lab=#net24}
N 9620 -3890 9640 -3890 {
lab=#net24}
N 9620 -3910 9640 -3910 {
lab=#net23}
N 9620 -3930 9640 -3930 {
lab=colon_n[11]}
N 9620 -3950 9640 -3950 {
lab=col_n[11]}
N 9380 -3950 9400 -3950 {
lab=col_n[11]}
N 9380 -3930 9400 -3930 {
lab=colon_n[11]}
N 9380 -3910 9400 -3910 {
lab=#net23}
N 9380 -3890 9400 -3890 {
lab=#net24}
N 9440 -3810 9440 -3800 {
lab=VSS}
N 9460 -4050 9460 -4030 {
lab=vcom}
N 9440 -4040 9440 -4030 {
lab=VDD}
N 9500 -4050 9500 -4030 {
lab=ctop}
N 9520 -3810 9520 -3790 {
lab=VDD}
N 9520 -4070 9530 -4080 {
lab=VDD}
N 9530 -4280 9530 -4080 {
lab=VDD}
N 9520 -4290 9530 -4280 {
lab=VDD}
N 9520 -4310 9520 -4290 {
lab=VDD}
N 9400 -4210 9410 -4220 {
lab=col_n[12]}
N 9410 -4220 9610 -4220 {
lab=col_n[12]}
N 9610 -4220 9620 -4210 {
lab=col_n[12]}
N 9400 -4190 9410 -4200 {
lab=colon_n[12]}
N 9410 -4200 9610 -4200 {
lab=colon_n[12]}
N 9610 -4200 9620 -4190 {
lab=colon_n[12]}
N 9400 -4170 9410 -4180 {
lab=#net25}
N 9410 -4180 9610 -4180 {
lab=#net25}
N 9610 -4180 9620 -4170 {
lab=#net25}
N 9400 -4150 9410 -4160 {
lab=#net26}
N 9410 -4160 9610 -4160 {
lab=#net26}
N 9610 -4160 9620 -4150 {
lab=#net26}
N 9620 -4150 9640 -4150 {
lab=#net26}
N 9620 -4170 9640 -4170 {
lab=#net25}
N 9620 -4190 9640 -4190 {
lab=colon_n[12]}
N 9620 -4210 9640 -4210 {
lab=col_n[12]}
N 9380 -4210 9400 -4210 {
lab=col_n[12]}
N 9380 -4190 9400 -4190 {
lab=colon_n[12]}
N 9380 -4170 9400 -4170 {
lab=#net25}
N 9380 -4150 9400 -4150 {
lab=#net26}
N 9460 -4310 9460 -4290 {
lab=vcom}
N 9440 -4300 9440 -4290 {
lab=VDD}
N 9500 -4310 9500 -4290 {
lab=ctop}
N 9520 -4070 9520 -4050 {
lab=VDD}
N 9520 -4330 9530 -4340 {
lab=VDD}
N 9530 -4540 9530 -4340 {
lab=VDD}
N 9520 -4550 9530 -4540 {
lab=VDD}
N 9520 -4570 9520 -4550 {
lab=VDD}
N 9400 -4470 9410 -4480 {
lab=col_n[13]}
N 9410 -4480 9610 -4480 {
lab=col_n[13]}
N 9610 -4480 9620 -4470 {
lab=col_n[13]}
N 9400 -4450 9410 -4460 {
lab=colon_n[13]}
N 9410 -4460 9610 -4460 {
lab=colon_n[13]}
N 9610 -4460 9620 -4450 {
lab=colon_n[13]}
N 9400 -4430 9410 -4440 {
lab=#net27}
N 9410 -4440 9610 -4440 {
lab=#net27}
N 9610 -4440 9620 -4430 {
lab=#net27}
N 9400 -4410 9410 -4420 {
lab=#net28}
N 9410 -4420 9610 -4420 {
lab=#net28}
N 9610 -4420 9620 -4410 {
lab=#net28}
N 9620 -4410 9640 -4410 {
lab=#net28}
N 9620 -4430 9640 -4430 {
lab=#net27}
N 9620 -4450 9640 -4450 {
lab=colon_n[13]}
N 9620 -4470 9640 -4470 {
lab=col_n[13]}
N 9380 -4470 9400 -4470 {
lab=col_n[13]}
N 9380 -4450 9400 -4450 {
lab=colon_n[13]}
N 9380 -4430 9400 -4430 {
lab=#net27}
N 9380 -4410 9400 -4410 {
lab=#net28}
N 9440 -4330 9440 -4320 {
lab=VSS}
N 9460 -4570 9460 -4550 {
lab=vcom}
N 9440 -4560 9440 -4550 {
lab=VDD}
N 9500 -4570 9500 -4550 {
lab=ctop}
N 9520 -4330 9520 -4310 {
lab=VDD}
N 9520 -4590 9530 -4600 {
lab=VDD}
N 9530 -4800 9530 -4600 {
lab=VDD}
N 9520 -4810 9530 -4800 {
lab=VDD}
N 9520 -4830 9520 -4810 {
lab=VDD}
N 9400 -4730 9410 -4740 {
lab=col_n[14]}
N 9410 -4740 9610 -4740 {
lab=col_n[14]}
N 9610 -4740 9620 -4730 {
lab=col_n[14]}
N 9400 -4710 9410 -4720 {
lab=colon_n[14]}
N 9410 -4720 9610 -4720 {
lab=colon_n[14]}
N 9610 -4720 9620 -4710 {
lab=colon_n[14]}
N 9400 -4690 9410 -4700 {
lab=#net29}
N 9410 -4700 9610 -4700 {
lab=#net29}
N 9610 -4700 9620 -4690 {
lab=#net29}
N 9400 -4670 9410 -4680 {
lab=#net30}
N 9410 -4680 9610 -4680 {
lab=#net30}
N 9610 -4680 9620 -4670 {
lab=#net30}
N 9620 -4670 9640 -4670 {
lab=#net30}
N 9620 -4690 9640 -4690 {
lab=#net29}
N 9620 -4710 9640 -4710 {
lab=colon_n[14]}
N 9620 -4730 9640 -4730 {
lab=col_n[14]}
N 9380 -4730 9400 -4730 {
lab=col_n[14]}
N 9380 -4710 9400 -4710 {
lab=colon_n[14]}
N 9380 -4690 9400 -4690 {
lab=#net29}
N 9380 -4670 9400 -4670 {
lab=#net30}
N 9440 -4590 9440 -4580 {
lab=VSS}
N 9460 -4830 9460 -4810 {
lab=vcom}
N 9440 -4820 9440 -4810 {
lab=VDD}
N 9500 -4830 9500 -4810 {
lab=ctop}
N 9520 -4590 9520 -4570 {
lab=VDD}
N 9520 -4850 9530 -4860 {
lab=VDD}
N 9530 -5060 9530 -4860 {
lab=VDD}
N 9520 -5070 9530 -5060 {
lab=VDD}
N 9520 -5090 9520 -5070 {
lab=VDD}
N 9400 -4990 9410 -5000 {
lab=col_n[15]}
N 9410 -5000 9610 -5000 {
lab=col_n[15]}
N 9610 -5000 9620 -4990 {
lab=col_n[15]}
N 9400 -4970 9410 -4980 {
lab=colon_n[15]}
N 9410 -4980 9610 -4980 {
lab=colon_n[15]}
N 9610 -4980 9620 -4970 {
lab=colon_n[15]}
N 9400 -4950 9410 -4960 {
lab=#net31}
N 9410 -4960 9610 -4960 {
lab=#net31}
N 9610 -4960 9620 -4950 {
lab=#net31}
N 9400 -4930 9410 -4940 {
lab=#net32}
N 9410 -4940 9610 -4940 {
lab=#net32}
N 9610 -4940 9620 -4930 {
lab=#net32}
N 9620 -4930 9640 -4930 {
lab=#net32}
N 9620 -4950 9640 -4950 {
lab=#net31}
N 9620 -4970 9640 -4970 {
lab=colon_n[15]}
N 9620 -4990 9640 -4990 {
lab=col_n[15]}
N 9380 -4990 9400 -4990 {
lab=col_n[15]}
N 9380 -4970 9400 -4970 {
lab=colon_n[15]}
N 9380 -4950 9400 -4950 {
lab=#net31}
N 9380 -4930 9400 -4930 {
lab=#net32}
N 9440 -4850 9440 -4840 {
lab=VSS}
N 9460 -5090 9460 -5070 {
lab=vcom}
N 9440 -5080 9440 -5070 {
lab=VDD}
N 9500 -5090 9500 -5070 {
lab=ctop}
N 9520 -4850 9520 -4830 {
lab=VDD}
N 940 -690 940 -680 {
lab=VDD}
N 9440 -950 9440 -940 {
lab=VSS}
N 9440 -1210 9440 -1200 {
lab=VSS}
N 9440 -1470 9440 -1460 {
lab=VSS}
N 9440 -1730 9440 -1720 {
lab=VSS}
N 9440 -1990 9440 -1980 {
lab=VSS}
N 9440 -2250 9440 -2240 {
lab=VSS}
N 9440 -2510 9440 -2500 {
lab=VSS}
N 9440 -2770 9440 -2760 {
lab=VSS}
N 9440 -3030 9440 -3020 {
lab=VSS}
N 9440 -3290 9440 -3280 {
lab=VSS}
N 9440 -3550 9440 -3540 {
lab=VSS}
N 9440 -3810 9440 -3800 {
lab=VSS}
N 9440 -4070 9440 -4060 {
lab=VSS}
N 9440 -4070 9440 -4060 {
lab=VSS}
N 7390 -690 7390 -680 {
lab=en_n_bit[0]}
N 5310 -690 5310 -670 {
lab=en_n_bit[1]}
N 3230 -690 3230 -670 {
lab=en_n_bit[2]}
N 4340 -690 4340 -670 {}
N 4380 -690 4380 -670 {}
N 4360 -690 4360 -670 {}
C {devices/title.sym} 170 -40 0 0 {name=l1 author="Manuel Moser"}
C {devices/iopin.sym} 240 -670 1 1 {name=p1 lab=VDD}
C {devices/iopin.sym} 250 -290 3 1 {name=p2 lab=VSS}
C {devices/ipin.sym} 200 -590 0 0 {name=p3 lab=sample}
C {devices/ipin.sym} 200 -570 0 0 {name=p4 lab=sample_n}
C {devices/ipin.sym} 200 -510 0 0 {name=p5 lab=col_n[15:0]}
C {devices/ipin.sym} 200 -490 0 0 {name=p6 lab=colon_n[15:0]}
C {devices/ipin.sym} 200 -470 0 0 {name=p7 lab=row_n[31:0]}
C {devices/iopin.sym} 260 -670 1 1 {name=p9 lab=vcom}
C {devices/ipin.sym} 200 -450 0 0 {name=p10 lab=en_n_bit[2:0]}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1190 -1060 0 0 {name=x1}
C {devices/lab_wire.sym} 1120 -1180 2 1 {name=l2 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -1190 1 1 {name=l3 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -1190 3 0 {name=l4 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -940 0 0 {name=l5 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1450 -1060 0 0 {name=x2}
C {devices/lab_wire.sym} 1380 -1180 2 1 {name=l6 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -1190 1 1 {name=l7 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -1190 3 0 {name=l8 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -940 0 0 {name=l9 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1710 -1060 0 0 {name=x3}
C {devices/lab_wire.sym} 1640 -1180 2 1 {name=l10 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -1190 1 1 {name=l11 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -1190 3 0 {name=l12 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -940 0 0 {name=l13 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1970 -1060 0 0 {name=x4}
C {devices/lab_wire.sym} 1900 -1180 2 1 {name=l14 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -1190 1 1 {name=l15 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -1190 3 0 {name=l16 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -940 0 0 {name=l17 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2230 -1060 0 0 {name=x5}
C {devices/lab_wire.sym} 2160 -1180 2 1 {name=l18 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -1190 1 1 {name=l19 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -1190 3 0 {name=l20 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -940 0 0 {name=l21 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2490 -1060 0 0 {name=x6}
C {devices/lab_wire.sym} 2420 -1180 2 1 {name=l22 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -1190 1 1 {name=l23 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -1190 3 0 {name=l24 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -940 0 0 {name=l25 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2750 -1060 0 0 {name=x7}
C {devices/lab_wire.sym} 2680 -1180 2 1 {name=l26 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -1190 1 1 {name=l27 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -1190 3 0 {name=l28 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -940 0 0 {name=l29 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3010 -1060 0 0 {name=x8}
C {devices/lab_wire.sym} 2940 -1180 2 1 {name=l30 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -1190 1 1 {name=l31 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -1190 3 0 {name=l32 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -940 0 0 {name=l33 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3270 -1060 0 0 {name=x9}
C {devices/lab_wire.sym} 3200 -1180 2 1 {name=l34 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -1190 1 1 {name=l35 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -1190 3 0 {name=l36 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -940 0 0 {name=l37 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3530 -1060 0 0 {name=x10}
C {devices/lab_wire.sym} 3460 -1180 2 1 {name=l38 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -1190 1 1 {name=l39 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -1190 3 0 {name=l40 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -940 0 0 {name=l41 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3790 -1060 0 0 {name=x11}
C {devices/lab_wire.sym} 3720 -1180 2 1 {name=l42 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -1190 1 1 {name=l43 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -1190 3 0 {name=l44 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -940 0 0 {name=l45 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4050 -1060 0 0 {name=x12}
C {devices/lab_wire.sym} 3980 -1180 2 1 {name=l46 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -1190 1 1 {name=l47 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -1190 3 0 {name=l48 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -940 0 0 {name=l49 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4310 -1060 0 0 {name=x13}
C {devices/lab_wire.sym} 4240 -1180 2 1 {name=l50 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -1190 1 1 {name=l51 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -1190 3 0 {name=l52 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -940 0 0 {name=l53 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4570 -1060 0 0 {name=x14}
C {devices/lab_wire.sym} 4500 -1180 2 1 {name=l54 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -1190 1 1 {name=l55 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -1190 3 0 {name=l56 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -940 0 0 {name=l57 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4830 -1060 0 0 {name=x15}
C {devices/lab_wire.sym} 4760 -1180 2 1 {name=l58 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -1190 1 1 {name=l59 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -1190 3 0 {name=l60 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -940 0 0 {name=l61 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5090 -1060 0 0 {name=x16}
C {devices/lab_wire.sym} 5020 -1180 2 1 {name=l62 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -1190 1 1 {name=l63 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -1190 3 0 {name=l64 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -940 0 0 {name=l65 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5350 -1060 0 0 {name=x17}
C {devices/lab_wire.sym} 5280 -1180 2 1 {name=l66 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -1190 1 1 {name=l67 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -1190 3 0 {name=l68 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -940 0 0 {name=l69 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5610 -1060 0 0 {name=x18}
C {devices/lab_wire.sym} 5540 -1180 2 1 {name=l70 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -1190 1 1 {name=l71 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -1190 3 0 {name=l72 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -940 0 0 {name=l73 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5870 -1060 0 0 {name=x19}
C {devices/lab_wire.sym} 5800 -1180 2 1 {name=l74 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -1190 1 1 {name=l75 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -1190 3 0 {name=l76 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -940 0 0 {name=l77 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6130 -1060 0 0 {name=x20}
C {devices/lab_wire.sym} 6060 -1180 2 1 {name=l78 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -1190 1 1 {name=l79 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -1190 3 0 {name=l80 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -940 0 0 {name=l81 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6390 -1060 0 0 {name=x21}
C {devices/lab_wire.sym} 6320 -1180 2 1 {name=l82 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -1190 1 1 {name=l83 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -1190 3 0 {name=l84 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -940 0 0 {name=l85 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6650 -1060 0 0 {name=x22}
C {devices/lab_wire.sym} 6580 -1180 2 1 {name=l86 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -1190 1 1 {name=l87 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -1190 3 0 {name=l88 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -940 0 0 {name=l89 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6910 -1060 0 0 {name=x23}
C {devices/lab_wire.sym} 6840 -1180 2 1 {name=l90 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -1190 1 1 {name=l91 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -1190 3 0 {name=l92 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -940 0 0 {name=l93 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7170 -1060 0 0 {name=x24}
C {devices/lab_wire.sym} 7100 -1180 2 1 {name=l94 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -1190 1 1 {name=l95 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -1190 3 0 {name=l96 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -940 0 0 {name=l97 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7430 -1060 0 0 {name=x25}
C {devices/lab_wire.sym} 7360 -1180 2 1 {name=l98 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -1190 1 1 {name=l99 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -1190 3 0 {name=l100 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -940 0 0 {name=l101 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7690 -1060 0 0 {name=x26}
C {devices/lab_wire.sym} 7620 -1180 2 1 {name=l102 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -1190 1 1 {name=l103 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -1190 3 0 {name=l104 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -940 0 0 {name=l105 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7950 -1060 0 0 {name=x27}
C {devices/lab_wire.sym} 7880 -1180 2 1 {name=l106 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -1190 1 1 {name=l107 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -1190 3 0 {name=l108 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -940 0 0 {name=l109 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8210 -1060 0 0 {name=x28}
C {devices/lab_wire.sym} 8140 -1180 2 1 {name=l110 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -1190 1 1 {name=l111 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -1190 3 0 {name=l112 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -940 0 0 {name=l113 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8470 -1060 0 0 {name=x29}
C {devices/lab_wire.sym} 8400 -1180 2 1 {name=l114 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -1190 1 1 {name=l115 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -1190 3 0 {name=l116 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -940 0 0 {name=l117 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8730 -1060 0 0 {name=x30}
C {devices/lab_wire.sym} 8660 -1180 2 1 {name=l118 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -1190 1 1 {name=l119 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -1190 3 0 {name=l120 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -940 0 0 {name=l121 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8990 -1060 0 0 {name=x31}
C {devices/lab_wire.sym} 8920 -1180 2 1 {name=l122 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -1190 1 1 {name=l123 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -1190 3 0 {name=l124 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -940 0 0 {name=l125 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 9250 -1060 0 0 {name=x32}
C {devices/lab_wire.sym} 9180 -1180 2 1 {name=l126 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -1190 1 1 {name=l127 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -1190 3 0 {name=l128 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -940 0 0 {name=l129 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1190 -1320 0 0 {name=x33}
C {devices/lab_wire.sym} 1120 -1440 2 1 {name=l130 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -1450 1 1 {name=l131 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -1450 3 0 {name=l132 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -1200 0 0 {name=l133 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1450 -1320 0 0 {name=x34}
C {devices/lab_wire.sym} 1380 -1440 2 1 {name=l134 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -1450 1 1 {name=l135 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -1450 3 0 {name=l136 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -1200 0 0 {name=l137 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1710 -1320 0 0 {name=x35}
C {devices/lab_wire.sym} 1640 -1440 2 1 {name=l138 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -1450 1 1 {name=l139 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -1450 3 0 {name=l140 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -1200 0 0 {name=l141 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1970 -1320 0 0 {name=x36}
C {devices/lab_wire.sym} 1900 -1440 2 1 {name=l142 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -1450 1 1 {name=l143 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -1450 3 0 {name=l144 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -1200 0 0 {name=l145 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2230 -1320 0 0 {name=x37}
C {devices/lab_wire.sym} 2160 -1440 2 1 {name=l146 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -1450 1 1 {name=l147 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -1450 3 0 {name=l148 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -1200 0 0 {name=l149 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2490 -1320 0 0 {name=x38}
C {devices/lab_wire.sym} 2420 -1440 2 1 {name=l150 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -1450 1 1 {name=l151 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -1450 3 0 {name=l152 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -1200 0 0 {name=l153 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2750 -1320 0 0 {name=x39}
C {devices/lab_wire.sym} 2680 -1440 2 1 {name=l154 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -1450 1 1 {name=l155 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -1450 3 0 {name=l156 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -1200 0 0 {name=l157 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3010 -1320 0 0 {name=x40}
C {devices/lab_wire.sym} 2940 -1440 2 1 {name=l158 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -1450 1 1 {name=l159 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -1450 3 0 {name=l160 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -1200 0 0 {name=l161 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3270 -1320 0 0 {name=x41}
C {devices/lab_wire.sym} 3200 -1440 2 1 {name=l162 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -1450 1 1 {name=l163 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -1450 3 0 {name=l164 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -1200 0 0 {name=l165 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3530 -1320 0 0 {name=x42}
C {devices/lab_wire.sym} 3460 -1440 2 1 {name=l166 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -1450 1 1 {name=l167 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -1450 3 0 {name=l168 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -1200 0 0 {name=l169 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3790 -1320 0 0 {name=x43}
C {devices/lab_wire.sym} 3720 -1440 2 1 {name=l170 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -1450 1 1 {name=l171 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -1450 3 0 {name=l172 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -1200 0 0 {name=l173 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4050 -1320 0 0 {name=x44}
C {devices/lab_wire.sym} 3980 -1440 2 1 {name=l174 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -1450 1 1 {name=l175 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -1450 3 0 {name=l176 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -1200 0 0 {name=l177 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4310 -1320 0 0 {name=x45}
C {devices/lab_wire.sym} 4240 -1440 2 1 {name=l178 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -1450 1 1 {name=l179 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -1450 3 0 {name=l180 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -1200 0 0 {name=l181 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4570 -1320 0 0 {name=x46}
C {devices/lab_wire.sym} 4500 -1440 2 1 {name=l182 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -1450 1 1 {name=l183 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -1450 3 0 {name=l184 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -1200 0 0 {name=l185 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4830 -1320 0 0 {name=x47}
C {devices/lab_wire.sym} 4760 -1440 2 1 {name=l186 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -1450 1 1 {name=l187 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -1450 3 0 {name=l188 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -1200 0 0 {name=l189 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5090 -1320 0 0 {name=x48}
C {devices/lab_wire.sym} 5020 -1440 2 1 {name=l190 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -1450 1 1 {name=l191 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -1450 3 0 {name=l192 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -1200 0 0 {name=l193 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5350 -1320 0 0 {name=x49}
C {devices/lab_wire.sym} 5280 -1440 2 1 {name=l194 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -1450 1 1 {name=l195 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -1450 3 0 {name=l196 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -1200 0 0 {name=l197 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5610 -1320 0 0 {name=x50}
C {devices/lab_wire.sym} 5540 -1440 2 1 {name=l198 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -1450 1 1 {name=l199 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -1450 3 0 {name=l200 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -1200 0 0 {name=l201 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5870 -1320 0 0 {name=x51}
C {devices/lab_wire.sym} 5800 -1440 2 1 {name=l202 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -1450 1 1 {name=l203 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -1450 3 0 {name=l204 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -1200 0 0 {name=l205 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6130 -1320 0 0 {name=x52}
C {devices/lab_wire.sym} 6060 -1440 2 1 {name=l206 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -1450 1 1 {name=l207 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -1450 3 0 {name=l208 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -1200 0 0 {name=l209 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6390 -1320 0 0 {name=x53}
C {devices/lab_wire.sym} 6320 -1440 2 1 {name=l210 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -1450 1 1 {name=l211 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -1450 3 0 {name=l212 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -1200 0 0 {name=l213 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6650 -1320 0 0 {name=x54}
C {devices/lab_wire.sym} 6580 -1440 2 1 {name=l214 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -1450 1 1 {name=l215 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -1450 3 0 {name=l216 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -1200 0 0 {name=l217 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6910 -1320 0 0 {name=x55}
C {devices/lab_wire.sym} 6840 -1440 2 1 {name=l218 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -1450 1 1 {name=l219 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -1450 3 0 {name=l220 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -1200 0 0 {name=l221 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7170 -1320 0 0 {name=x56}
C {devices/lab_wire.sym} 7100 -1440 2 1 {name=l222 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -1450 1 1 {name=l223 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -1450 3 0 {name=l224 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -1200 0 0 {name=l225 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7430 -1320 0 0 {name=x57}
C {devices/lab_wire.sym} 7360 -1440 2 1 {name=l226 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -1450 1 1 {name=l227 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -1450 3 0 {name=l228 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -1200 0 0 {name=l229 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7690 -1320 0 0 {name=x58}
C {devices/lab_wire.sym} 7620 -1440 2 1 {name=l230 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -1450 1 1 {name=l231 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -1450 3 0 {name=l232 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -1200 0 0 {name=l233 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7950 -1320 0 0 {name=x59}
C {devices/lab_wire.sym} 7880 -1440 2 1 {name=l234 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -1450 1 1 {name=l235 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -1450 3 0 {name=l236 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -1200 0 0 {name=l237 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8210 -1320 0 0 {name=x60}
C {devices/lab_wire.sym} 8140 -1440 2 1 {name=l238 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -1450 1 1 {name=l239 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -1450 3 0 {name=l240 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -1200 0 0 {name=l241 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8470 -1320 0 0 {name=x61}
C {devices/lab_wire.sym} 8400 -1440 2 1 {name=l242 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -1450 1 1 {name=l243 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -1450 3 0 {name=l244 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -1200 0 0 {name=l245 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8730 -1320 0 0 {name=x62}
C {devices/lab_wire.sym} 8660 -1440 2 1 {name=l246 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -1450 1 1 {name=l247 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -1450 3 0 {name=l248 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -1200 0 0 {name=l249 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8990 -1320 0 0 {name=x63}
C {devices/lab_wire.sym} 8920 -1440 2 1 {name=l250 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -1450 1 1 {name=l251 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -1450 3 0 {name=l252 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -1200 0 0 {name=l253 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 9250 -1320 0 0 {name=x64}
C {devices/lab_wire.sym} 9180 -1440 2 1 {name=l254 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -1450 1 1 {name=l255 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -1450 3 0 {name=l256 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -1200 0 0 {name=l257 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1190 -1580 0 0 {name=x65}
C {devices/lab_wire.sym} 1120 -1700 2 1 {name=l258 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -1710 1 1 {name=l259 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -1710 3 0 {name=l260 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -1460 0 0 {name=l261 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1450 -1580 0 0 {name=x66}
C {devices/lab_wire.sym} 1380 -1700 2 1 {name=l262 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -1710 1 1 {name=l263 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -1710 3 0 {name=l264 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -1460 0 0 {name=l265 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1710 -1580 0 0 {name=x67}
C {devices/lab_wire.sym} 1640 -1700 2 1 {name=l266 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -1710 1 1 {name=l267 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -1710 3 0 {name=l268 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -1460 0 0 {name=l269 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1970 -1580 0 0 {name=x68}
C {devices/lab_wire.sym} 1900 -1700 2 1 {name=l270 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -1710 1 1 {name=l271 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -1710 3 0 {name=l272 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -1460 0 0 {name=l273 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2230 -1580 0 0 {name=x69}
C {devices/lab_wire.sym} 2160 -1700 2 1 {name=l274 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -1710 1 1 {name=l275 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -1710 3 0 {name=l276 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -1460 0 0 {name=l277 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2490 -1580 0 0 {name=x70}
C {devices/lab_wire.sym} 2420 -1700 2 1 {name=l278 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -1710 1 1 {name=l279 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -1710 3 0 {name=l280 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -1460 0 0 {name=l281 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2750 -1580 0 0 {name=x71}
C {devices/lab_wire.sym} 2680 -1700 2 1 {name=l282 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -1710 1 1 {name=l283 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -1710 3 0 {name=l284 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -1460 0 0 {name=l285 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3010 -1580 0 0 {name=x72}
C {devices/lab_wire.sym} 2940 -1700 2 1 {name=l286 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -1710 1 1 {name=l287 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -1710 3 0 {name=l288 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -1460 0 0 {name=l289 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3270 -1580 0 0 {name=x73}
C {devices/lab_wire.sym} 3200 -1700 2 1 {name=l290 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -1710 1 1 {name=l291 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -1710 3 0 {name=l292 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -1460 0 0 {name=l293 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3530 -1580 0 0 {name=x74}
C {devices/lab_wire.sym} 3460 -1700 2 1 {name=l294 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -1710 1 1 {name=l295 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -1710 3 0 {name=l296 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -1460 0 0 {name=l297 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3790 -1580 0 0 {name=x75}
C {devices/lab_wire.sym} 3720 -1700 2 1 {name=l298 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -1710 1 1 {name=l299 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -1710 3 0 {name=l300 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -1460 0 0 {name=l301 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4050 -1580 0 0 {name=x76}
C {devices/lab_wire.sym} 3980 -1700 2 1 {name=l302 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -1710 1 1 {name=l303 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -1710 3 0 {name=l304 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -1460 0 0 {name=l305 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4310 -1580 0 0 {name=x77}
C {devices/lab_wire.sym} 4240 -1700 2 1 {name=l306 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -1710 1 1 {name=l307 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -1710 3 0 {name=l308 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -1460 0 0 {name=l309 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4570 -1580 0 0 {name=x78}
C {devices/lab_wire.sym} 4500 -1700 2 1 {name=l310 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -1710 1 1 {name=l311 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -1710 3 0 {name=l312 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -1460 0 0 {name=l313 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4830 -1580 0 0 {name=x79}
C {devices/lab_wire.sym} 4760 -1700 2 1 {name=l314 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -1710 1 1 {name=l315 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -1710 3 0 {name=l316 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -1460 0 0 {name=l317 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5090 -1580 0 0 {name=x80}
C {devices/lab_wire.sym} 5020 -1700 2 1 {name=l318 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -1710 1 1 {name=l319 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -1710 3 0 {name=l320 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -1460 0 0 {name=l321 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5350 -1580 0 0 {name=x81}
C {devices/lab_wire.sym} 5280 -1700 2 1 {name=l322 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -1710 1 1 {name=l323 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -1710 3 0 {name=l324 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -1460 0 0 {name=l325 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5610 -1580 0 0 {name=x82}
C {devices/lab_wire.sym} 5540 -1700 2 1 {name=l326 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -1710 1 1 {name=l327 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -1710 3 0 {name=l328 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -1460 0 0 {name=l329 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5870 -1580 0 0 {name=x83}
C {devices/lab_wire.sym} 5800 -1700 2 1 {name=l330 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -1710 1 1 {name=l331 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -1710 3 0 {name=l332 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -1460 0 0 {name=l333 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6130 -1580 0 0 {name=x84}
C {devices/lab_wire.sym} 6060 -1700 2 1 {name=l334 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -1710 1 1 {name=l335 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -1710 3 0 {name=l336 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -1460 0 0 {name=l337 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6390 -1580 0 0 {name=x85}
C {devices/lab_wire.sym} 6320 -1700 2 1 {name=l338 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -1710 1 1 {name=l339 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -1710 3 0 {name=l340 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -1460 0 0 {name=l341 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6650 -1580 0 0 {name=x86}
C {devices/lab_wire.sym} 6580 -1700 2 1 {name=l342 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -1710 1 1 {name=l343 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -1710 3 0 {name=l344 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -1460 0 0 {name=l345 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6910 -1580 0 0 {name=x87}
C {devices/lab_wire.sym} 6840 -1700 2 1 {name=l346 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -1710 1 1 {name=l347 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -1710 3 0 {name=l348 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -1460 0 0 {name=l349 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7170 -1580 0 0 {name=x88}
C {devices/lab_wire.sym} 7100 -1700 2 1 {name=l350 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -1710 1 1 {name=l351 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -1710 3 0 {name=l352 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -1460 0 0 {name=l353 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7430 -1580 0 0 {name=x89}
C {devices/lab_wire.sym} 7360 -1700 2 1 {name=l354 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -1710 1 1 {name=l355 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -1710 3 0 {name=l356 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -1460 0 0 {name=l357 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7690 -1580 0 0 {name=x90}
C {devices/lab_wire.sym} 7620 -1700 2 1 {name=l358 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -1710 1 1 {name=l359 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -1710 3 0 {name=l360 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -1460 0 0 {name=l361 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7950 -1580 0 0 {name=x91}
C {devices/lab_wire.sym} 7880 -1700 2 1 {name=l362 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -1710 1 1 {name=l363 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -1710 3 0 {name=l364 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -1460 0 0 {name=l365 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8210 -1580 0 0 {name=x92}
C {devices/lab_wire.sym} 8140 -1700 2 1 {name=l366 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -1710 1 1 {name=l367 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -1710 3 0 {name=l368 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -1460 0 0 {name=l369 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8470 -1580 0 0 {name=x93}
C {devices/lab_wire.sym} 8400 -1700 2 1 {name=l370 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -1710 1 1 {name=l371 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -1710 3 0 {name=l372 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -1460 0 0 {name=l373 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8730 -1580 0 0 {name=x94}
C {devices/lab_wire.sym} 8660 -1700 2 1 {name=l374 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -1710 1 1 {name=l375 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -1710 3 0 {name=l376 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -1460 0 0 {name=l377 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8990 -1580 0 0 {name=x95}
C {devices/lab_wire.sym} 8920 -1700 2 1 {name=l378 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -1710 1 1 {name=l379 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -1710 3 0 {name=l380 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -1460 0 0 {name=l381 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 9250 -1580 0 0 {name=x96}
C {devices/lab_wire.sym} 9180 -1700 2 1 {name=l382 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -1710 1 1 {name=l383 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -1710 3 0 {name=l384 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -1460 0 0 {name=l385 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1190 -1840 0 0 {name=x97}
C {devices/lab_wire.sym} 1120 -1960 2 1 {name=l386 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -1970 1 1 {name=l387 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -1970 3 0 {name=l388 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -1720 0 0 {name=l389 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1450 -1840 0 0 {name=x98}
C {devices/lab_wire.sym} 1380 -1960 2 1 {name=l390 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -1970 1 1 {name=l391 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -1970 3 0 {name=l392 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -1720 0 0 {name=l393 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1710 -1840 0 0 {name=x99}
C {devices/lab_wire.sym} 1640 -1960 2 1 {name=l394 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -1970 1 1 {name=l395 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -1970 3 0 {name=l396 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -1720 0 0 {name=l397 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1970 -1840 0 0 {name=x100}
C {devices/lab_wire.sym} 1900 -1960 2 1 {name=l398 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -1970 1 1 {name=l399 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -1970 3 0 {name=l400 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -1720 0 0 {name=l401 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2230 -1840 0 0 {name=x101}
C {devices/lab_wire.sym} 2160 -1960 2 1 {name=l402 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -1970 1 1 {name=l403 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -1970 3 0 {name=l404 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -1720 0 0 {name=l405 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2490 -1840 0 0 {name=x102}
C {devices/lab_wire.sym} 2420 -1960 2 1 {name=l406 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -1970 1 1 {name=l407 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -1970 3 0 {name=l408 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -1720 0 0 {name=l409 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2750 -1840 0 0 {name=x103}
C {devices/lab_wire.sym} 2680 -1960 2 1 {name=l410 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -1970 1 1 {name=l411 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -1970 3 0 {name=l412 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -1720 0 0 {name=l413 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3010 -1840 0 0 {name=x104}
C {devices/lab_wire.sym} 2940 -1960 2 1 {name=l414 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -1970 1 1 {name=l415 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -1970 3 0 {name=l416 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -1720 0 0 {name=l417 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3270 -1840 0 0 {name=x105}
C {devices/lab_wire.sym} 3200 -1960 2 1 {name=l418 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -1970 1 1 {name=l419 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -1970 3 0 {name=l420 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -1720 0 0 {name=l421 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3530 -1840 0 0 {name=x106}
C {devices/lab_wire.sym} 3460 -1960 2 1 {name=l422 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -1970 1 1 {name=l423 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -1970 3 0 {name=l424 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -1720 0 0 {name=l425 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3790 -1840 0 0 {name=x107}
C {devices/lab_wire.sym} 3720 -1960 2 1 {name=l426 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -1970 1 1 {name=l427 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -1970 3 0 {name=l428 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -1720 0 0 {name=l429 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4050 -1840 0 0 {name=x108}
C {devices/lab_wire.sym} 3980 -1960 2 1 {name=l430 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -1970 1 1 {name=l431 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -1970 3 0 {name=l432 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -1720 0 0 {name=l433 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4310 -1840 0 0 {name=x109}
C {devices/lab_wire.sym} 4240 -1960 2 1 {name=l434 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -1970 1 1 {name=l435 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -1970 3 0 {name=l436 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -1720 0 0 {name=l437 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4570 -1840 0 0 {name=x110}
C {devices/lab_wire.sym} 4500 -1960 2 1 {name=l438 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -1970 1 1 {name=l439 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -1970 3 0 {name=l440 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -1720 0 0 {name=l441 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4830 -1840 0 0 {name=x111}
C {devices/lab_wire.sym} 4760 -1960 2 1 {name=l442 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -1970 1 1 {name=l443 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -1970 3 0 {name=l444 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -1720 0 0 {name=l445 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5090 -1840 0 0 {name=x112}
C {devices/lab_wire.sym} 5020 -1960 2 1 {name=l446 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -1970 1 1 {name=l447 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -1970 3 0 {name=l448 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -1720 0 0 {name=l449 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5350 -1840 0 0 {name=x113}
C {devices/lab_wire.sym} 5280 -1960 2 1 {name=l450 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -1970 1 1 {name=l451 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -1970 3 0 {name=l452 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -1720 0 0 {name=l453 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5610 -1840 0 0 {name=x114}
C {devices/lab_wire.sym} 5540 -1960 2 1 {name=l454 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -1970 1 1 {name=l455 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -1970 3 0 {name=l456 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -1720 0 0 {name=l457 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5870 -1840 0 0 {name=x115}
C {devices/lab_wire.sym} 5800 -1960 2 1 {name=l458 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -1970 1 1 {name=l459 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -1970 3 0 {name=l460 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -1720 0 0 {name=l461 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6130 -1840 0 0 {name=x116}
C {devices/lab_wire.sym} 6060 -1960 2 1 {name=l462 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -1970 1 1 {name=l463 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -1970 3 0 {name=l464 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -1720 0 0 {name=l465 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6390 -1840 0 0 {name=x117}
C {devices/lab_wire.sym} 6320 -1960 2 1 {name=l466 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -1970 1 1 {name=l467 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -1970 3 0 {name=l468 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -1720 0 0 {name=l469 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6650 -1840 0 0 {name=x118}
C {devices/lab_wire.sym} 6580 -1960 2 1 {name=l470 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -1970 1 1 {name=l471 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -1970 3 0 {name=l472 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -1720 0 0 {name=l473 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6910 -1840 0 0 {name=x119}
C {devices/lab_wire.sym} 6840 -1960 2 1 {name=l474 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -1970 1 1 {name=l475 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -1970 3 0 {name=l476 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -1720 0 0 {name=l477 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7170 -1840 0 0 {name=x120}
C {devices/lab_wire.sym} 7100 -1960 2 1 {name=l478 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -1970 1 1 {name=l479 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -1970 3 0 {name=l480 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -1720 0 0 {name=l481 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7430 -1840 0 0 {name=x121}
C {devices/lab_wire.sym} 7360 -1960 2 1 {name=l482 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -1970 1 1 {name=l483 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -1970 3 0 {name=l484 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -1720 0 0 {name=l485 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7690 -1840 0 0 {name=x122}
C {devices/lab_wire.sym} 7620 -1960 2 1 {name=l486 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -1970 1 1 {name=l487 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -1970 3 0 {name=l488 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -1720 0 0 {name=l489 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7950 -1840 0 0 {name=x123}
C {devices/lab_wire.sym} 7880 -1960 2 1 {name=l490 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -1970 1 1 {name=l491 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -1970 3 0 {name=l492 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -1720 0 0 {name=l493 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8210 -1840 0 0 {name=x124}
C {devices/lab_wire.sym} 8140 -1960 2 1 {name=l494 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -1970 1 1 {name=l495 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -1970 3 0 {name=l496 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -1720 0 0 {name=l497 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8470 -1840 0 0 {name=x125}
C {devices/lab_wire.sym} 8400 -1960 2 1 {name=l498 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -1970 1 1 {name=l499 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -1970 3 0 {name=l500 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -1720 0 0 {name=l501 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8730 -1840 0 0 {name=x126}
C {devices/lab_wire.sym} 8660 -1960 2 1 {name=l502 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -1970 1 1 {name=l503 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -1970 3 0 {name=l504 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -1720 0 0 {name=l505 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8990 -1840 0 0 {name=x127}
C {devices/lab_wire.sym} 8920 -1960 2 1 {name=l506 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -1970 1 1 {name=l507 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -1970 3 0 {name=l508 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -1720 0 0 {name=l509 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 9250 -1840 0 0 {name=x128}
C {devices/lab_wire.sym} 9180 -1960 2 1 {name=l510 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -1970 1 1 {name=l511 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -1970 3 0 {name=l512 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -1720 0 0 {name=l513 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1190 -2100 0 0 {name=x129}
C {devices/lab_wire.sym} 1120 -2220 2 1 {name=l514 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -2230 1 1 {name=l515 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -2230 3 0 {name=l516 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -1980 0 0 {name=l517 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1450 -2100 0 0 {name=x130}
C {devices/lab_wire.sym} 1380 -2220 2 1 {name=l518 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -2230 1 1 {name=l519 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -2230 3 0 {name=l520 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -1980 0 0 {name=l521 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1710 -2100 0 0 {name=x131}
C {devices/lab_wire.sym} 1640 -2220 2 1 {name=l522 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -2230 1 1 {name=l523 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -2230 3 0 {name=l524 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -1980 0 0 {name=l525 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1970 -2100 0 0 {name=x132}
C {devices/lab_wire.sym} 1900 -2220 2 1 {name=l526 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -2230 1 1 {name=l527 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -2230 3 0 {name=l528 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -1980 0 0 {name=l529 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2230 -2100 0 0 {name=x133}
C {devices/lab_wire.sym} 2160 -2220 2 1 {name=l530 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -2230 1 1 {name=l531 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -2230 3 0 {name=l532 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -1980 0 0 {name=l533 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2490 -2100 0 0 {name=x134}
C {devices/lab_wire.sym} 2420 -2220 2 1 {name=l534 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -2230 1 1 {name=l535 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -2230 3 0 {name=l536 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -1980 0 0 {name=l537 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2750 -2100 0 0 {name=x135}
C {devices/lab_wire.sym} 2680 -2220 2 1 {name=l538 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -2230 1 1 {name=l539 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -2230 3 0 {name=l540 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -1980 0 0 {name=l541 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3010 -2100 0 0 {name=x136}
C {devices/lab_wire.sym} 2940 -2220 2 1 {name=l542 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -2230 1 1 {name=l543 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -2230 3 0 {name=l544 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -1980 0 0 {name=l545 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3270 -2100 0 0 {name=x137}
C {devices/lab_wire.sym} 3200 -2220 2 1 {name=l546 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -2230 1 1 {name=l547 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -2230 3 0 {name=l548 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -1980 0 0 {name=l549 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3530 -2100 0 0 {name=x138}
C {devices/lab_wire.sym} 3460 -2220 2 1 {name=l550 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -2230 1 1 {name=l551 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -2230 3 0 {name=l552 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -1980 0 0 {name=l553 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3790 -2100 0 0 {name=x139}
C {devices/lab_wire.sym} 3720 -2220 2 1 {name=l554 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -2230 1 1 {name=l555 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -2230 3 0 {name=l556 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -1980 0 0 {name=l557 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4050 -2100 0 0 {name=x140}
C {devices/lab_wire.sym} 3980 -2220 2 1 {name=l558 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -2230 1 1 {name=l559 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -2230 3 0 {name=l560 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -1980 0 0 {name=l561 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4310 -2100 0 0 {name=x141}
C {devices/lab_wire.sym} 4240 -2220 2 1 {name=l562 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -2230 1 1 {name=l563 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -2230 3 0 {name=l564 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -1980 0 0 {name=l565 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4570 -2100 0 0 {name=x142}
C {devices/lab_wire.sym} 4500 -2220 2 1 {name=l566 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -2230 1 1 {name=l567 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -2230 3 0 {name=l568 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -1980 0 0 {name=l569 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4830 -2100 0 0 {name=x143}
C {devices/lab_wire.sym} 4760 -2220 2 1 {name=l570 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -2230 1 1 {name=l571 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -2230 3 0 {name=l572 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -1980 0 0 {name=l573 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5090 -2100 0 0 {name=x144}
C {devices/lab_wire.sym} 5020 -2220 2 1 {name=l574 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -2230 1 1 {name=l575 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -2230 3 0 {name=l576 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -1980 0 0 {name=l577 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5350 -2100 0 0 {name=x145}
C {devices/lab_wire.sym} 5280 -2220 2 1 {name=l578 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -2230 1 1 {name=l579 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -2230 3 0 {name=l580 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -1980 0 0 {name=l581 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5610 -2100 0 0 {name=x146}
C {devices/lab_wire.sym} 5540 -2220 2 1 {name=l582 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -2230 1 1 {name=l583 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -2230 3 0 {name=l584 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -1980 0 0 {name=l585 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5870 -2100 0 0 {name=x147}
C {devices/lab_wire.sym} 5800 -2220 2 1 {name=l586 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -2230 1 1 {name=l587 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -2230 3 0 {name=l588 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -1980 0 0 {name=l589 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6130 -2100 0 0 {name=x148}
C {devices/lab_wire.sym} 6060 -2220 2 1 {name=l590 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -2230 1 1 {name=l591 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -2230 3 0 {name=l592 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -1980 0 0 {name=l593 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6390 -2100 0 0 {name=x149}
C {devices/lab_wire.sym} 6320 -2220 2 1 {name=l594 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -2230 1 1 {name=l595 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -2230 3 0 {name=l596 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -1980 0 0 {name=l597 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6650 -2100 0 0 {name=x150}
C {devices/lab_wire.sym} 6580 -2220 2 1 {name=l598 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -2230 1 1 {name=l599 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -2230 3 0 {name=l600 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -1980 0 0 {name=l601 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6910 -2100 0 0 {name=x151}
C {devices/lab_wire.sym} 6840 -2220 2 1 {name=l602 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -2230 1 1 {name=l603 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -2230 3 0 {name=l604 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -1980 0 0 {name=l605 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7170 -2100 0 0 {name=x152}
C {devices/lab_wire.sym} 7100 -2220 2 1 {name=l606 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -2230 1 1 {name=l607 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -2230 3 0 {name=l608 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -1980 0 0 {name=l609 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7430 -2100 0 0 {name=x153}
C {devices/lab_wire.sym} 7360 -2220 2 1 {name=l610 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -2230 1 1 {name=l611 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -2230 3 0 {name=l612 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -1980 0 0 {name=l613 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7690 -2100 0 0 {name=x154}
C {devices/lab_wire.sym} 7620 -2220 2 1 {name=l614 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -2230 1 1 {name=l615 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -2230 3 0 {name=l616 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -1980 0 0 {name=l617 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7950 -2100 0 0 {name=x155}
C {devices/lab_wire.sym} 7880 -2220 2 1 {name=l618 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -2230 1 1 {name=l619 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -2230 3 0 {name=l620 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -1980 0 0 {name=l621 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8210 -2100 0 0 {name=x156}
C {devices/lab_wire.sym} 8140 -2220 2 1 {name=l622 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -2230 1 1 {name=l623 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -2230 3 0 {name=l624 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -1980 0 0 {name=l625 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8470 -2100 0 0 {name=x157}
C {devices/lab_wire.sym} 8400 -2220 2 1 {name=l626 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -2230 1 1 {name=l627 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -2230 3 0 {name=l628 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -1980 0 0 {name=l629 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8730 -2100 0 0 {name=x158}
C {devices/lab_wire.sym} 8660 -2220 2 1 {name=l630 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -2230 1 1 {name=l631 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -2230 3 0 {name=l632 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -1980 0 0 {name=l633 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8990 -2100 0 0 {name=x159}
C {devices/lab_wire.sym} 8920 -2220 2 1 {name=l634 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -2230 1 1 {name=l635 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -2230 3 0 {name=l636 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -1980 0 0 {name=l637 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 9250 -2100 0 0 {name=x160}
C {devices/lab_wire.sym} 9180 -2220 2 1 {name=l638 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -2230 1 1 {name=l639 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -2230 3 0 {name=l640 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -1980 0 0 {name=l641 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1190 -2360 0 0 {name=x161}
C {devices/lab_wire.sym} 1120 -2480 2 1 {name=l642 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -2490 1 1 {name=l643 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -2490 3 0 {name=l644 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -2240 0 0 {name=l645 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1450 -2360 0 0 {name=x162}
C {devices/lab_wire.sym} 1380 -2480 2 1 {name=l646 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -2490 1 1 {name=l647 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -2490 3 0 {name=l648 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -2240 0 0 {name=l649 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1710 -2360 0 0 {name=x163}
C {devices/lab_wire.sym} 1640 -2480 2 1 {name=l650 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -2490 1 1 {name=l651 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -2490 3 0 {name=l652 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -2240 0 0 {name=l653 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1970 -2360 0 0 {name=x164}
C {devices/lab_wire.sym} 1900 -2480 2 1 {name=l654 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -2490 1 1 {name=l655 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -2490 3 0 {name=l656 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -2240 0 0 {name=l657 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2230 -2360 0 0 {name=x165}
C {devices/lab_wire.sym} 2160 -2480 2 1 {name=l658 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -2490 1 1 {name=l659 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -2490 3 0 {name=l660 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -2240 0 0 {name=l661 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2490 -2360 0 0 {name=x166}
C {devices/lab_wire.sym} 2420 -2480 2 1 {name=l662 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -2490 1 1 {name=l663 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -2490 3 0 {name=l664 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -2240 0 0 {name=l665 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2750 -2360 0 0 {name=x167}
C {devices/lab_wire.sym} 2680 -2480 2 1 {name=l666 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -2490 1 1 {name=l667 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -2490 3 0 {name=l668 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -2240 0 0 {name=l669 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3010 -2360 0 0 {name=x168}
C {devices/lab_wire.sym} 2940 -2480 2 1 {name=l670 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -2490 1 1 {name=l671 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -2490 3 0 {name=l672 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -2240 0 0 {name=l673 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3270 -2360 0 0 {name=x169}
C {devices/lab_wire.sym} 3200 -2480 2 1 {name=l674 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -2490 1 1 {name=l675 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -2490 3 0 {name=l676 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -2240 0 0 {name=l677 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3530 -2360 0 0 {name=x170}
C {devices/lab_wire.sym} 3460 -2480 2 1 {name=l678 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -2490 1 1 {name=l679 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -2490 3 0 {name=l680 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -2240 0 0 {name=l681 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3790 -2360 0 0 {name=x171}
C {devices/lab_wire.sym} 3720 -2480 2 1 {name=l682 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -2490 1 1 {name=l683 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -2490 3 0 {name=l684 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -2240 0 0 {name=l685 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4050 -2360 0 0 {name=x172}
C {devices/lab_wire.sym} 3980 -2480 2 1 {name=l686 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -2490 1 1 {name=l687 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -2490 3 0 {name=l688 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -2240 0 0 {name=l689 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4310 -2360 0 0 {name=x173}
C {devices/lab_wire.sym} 4240 -2480 2 1 {name=l690 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -2490 1 1 {name=l691 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -2490 3 0 {name=l692 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -2240 0 0 {name=l693 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4570 -2360 0 0 {name=x174}
C {devices/lab_wire.sym} 4500 -2480 2 1 {name=l694 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -2490 1 1 {name=l695 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -2490 3 0 {name=l696 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -2240 0 0 {name=l697 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4830 -2360 0 0 {name=x175}
C {devices/lab_wire.sym} 4760 -2480 2 1 {name=l698 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -2490 1 1 {name=l699 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -2490 3 0 {name=l700 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -2240 0 0 {name=l701 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5090 -2360 0 0 {name=x176}
C {devices/lab_wire.sym} 5020 -2480 2 1 {name=l702 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -2490 1 1 {name=l703 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -2490 3 0 {name=l704 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -2240 0 0 {name=l705 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5350 -2360 0 0 {name=x177}
C {devices/lab_wire.sym} 5280 -2480 2 1 {name=l706 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -2490 1 1 {name=l707 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -2490 3 0 {name=l708 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -2240 0 0 {name=l709 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5610 -2360 0 0 {name=x178}
C {devices/lab_wire.sym} 5540 -2480 2 1 {name=l710 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -2490 1 1 {name=l711 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -2490 3 0 {name=l712 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -2240 0 0 {name=l713 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5870 -2360 0 0 {name=x179}
C {devices/lab_wire.sym} 5800 -2480 2 1 {name=l714 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -2490 1 1 {name=l715 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -2490 3 0 {name=l716 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -2240 0 0 {name=l717 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6130 -2360 0 0 {name=x180}
C {devices/lab_wire.sym} 6060 -2480 2 1 {name=l718 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -2490 1 1 {name=l719 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -2490 3 0 {name=l720 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -2240 0 0 {name=l721 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6390 -2360 0 0 {name=x181}
C {devices/lab_wire.sym} 6320 -2480 2 1 {name=l722 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -2490 1 1 {name=l723 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -2490 3 0 {name=l724 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -2240 0 0 {name=l725 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6650 -2360 0 0 {name=x182}
C {devices/lab_wire.sym} 6580 -2480 2 1 {name=l726 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -2490 1 1 {name=l727 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -2490 3 0 {name=l728 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -2240 0 0 {name=l729 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6910 -2360 0 0 {name=x183}
C {devices/lab_wire.sym} 6840 -2480 2 1 {name=l730 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -2490 1 1 {name=l731 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -2490 3 0 {name=l732 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -2240 0 0 {name=l733 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7170 -2360 0 0 {name=x184}
C {devices/lab_wire.sym} 7100 -2480 2 1 {name=l734 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -2490 1 1 {name=l735 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -2490 3 0 {name=l736 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -2240 0 0 {name=l737 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7430 -2360 0 0 {name=x185}
C {devices/lab_wire.sym} 7360 -2480 2 1 {name=l738 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -2490 1 1 {name=l739 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -2490 3 0 {name=l740 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -2240 0 0 {name=l741 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7690 -2360 0 0 {name=x186}
C {devices/lab_wire.sym} 7620 -2480 2 1 {name=l742 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -2490 1 1 {name=l743 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -2490 3 0 {name=l744 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -2240 0 0 {name=l745 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7950 -2360 0 0 {name=x187}
C {devices/lab_wire.sym} 7880 -2480 2 1 {name=l746 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -2490 1 1 {name=l747 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -2490 3 0 {name=l748 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -2240 0 0 {name=l749 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8210 -2360 0 0 {name=x188}
C {devices/lab_wire.sym} 8140 -2480 2 1 {name=l750 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -2490 1 1 {name=l751 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -2490 3 0 {name=l752 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -2240 0 0 {name=l753 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8470 -2360 0 0 {name=x189}
C {devices/lab_wire.sym} 8400 -2480 2 1 {name=l754 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -2490 1 1 {name=l755 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -2490 3 0 {name=l756 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -2240 0 0 {name=l757 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8730 -2360 0 0 {name=x190}
C {devices/lab_wire.sym} 8660 -2480 2 1 {name=l758 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -2490 1 1 {name=l759 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -2490 3 0 {name=l760 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -2240 0 0 {name=l761 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8990 -2360 0 0 {name=x191}
C {devices/lab_wire.sym} 8920 -2480 2 1 {name=l762 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -2490 1 1 {name=l763 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -2490 3 0 {name=l764 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -2240 0 0 {name=l765 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 9250 -2360 0 0 {name=x192}
C {devices/lab_wire.sym} 9180 -2480 2 1 {name=l766 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -2490 1 1 {name=l767 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -2490 3 0 {name=l768 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -2240 0 0 {name=l769 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1190 -2620 0 0 {name=x193}
C {devices/lab_wire.sym} 1120 -2740 2 1 {name=l770 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -2750 1 1 {name=l771 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -2750 3 0 {name=l772 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -2500 0 0 {name=l773 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1450 -2620 0 0 {name=x194}
C {devices/lab_wire.sym} 1380 -2740 2 1 {name=l774 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -2750 1 1 {name=l775 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -2750 3 0 {name=l776 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -2500 0 0 {name=l777 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1710 -2620 0 0 {name=x195}
C {devices/lab_wire.sym} 1640 -2740 2 1 {name=l778 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -2750 1 1 {name=l779 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -2750 3 0 {name=l780 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -2500 0 0 {name=l781 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1970 -2620 0 0 {name=x196}
C {devices/lab_wire.sym} 1900 -2740 2 1 {name=l782 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -2750 1 1 {name=l783 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -2750 3 0 {name=l784 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -2500 0 0 {name=l785 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2230 -2620 0 0 {name=x197}
C {devices/lab_wire.sym} 2160 -2740 2 1 {name=l786 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -2750 1 1 {name=l787 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -2750 3 0 {name=l788 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -2500 0 0 {name=l789 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2490 -2620 0 0 {name=x198}
C {devices/lab_wire.sym} 2420 -2740 2 1 {name=l790 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -2750 1 1 {name=l791 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -2750 3 0 {name=l792 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -2500 0 0 {name=l793 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2750 -2620 0 0 {name=x199}
C {devices/lab_wire.sym} 2680 -2740 2 1 {name=l794 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -2750 1 1 {name=l795 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -2750 3 0 {name=l796 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -2500 0 0 {name=l797 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3010 -2620 0 0 {name=x200}
C {devices/lab_wire.sym} 2940 -2740 2 1 {name=l798 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -2750 1 1 {name=l799 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -2750 3 0 {name=l800 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -2500 0 0 {name=l801 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3270 -2620 0 0 {name=x201}
C {devices/lab_wire.sym} 3200 -2740 2 1 {name=l802 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -2750 1 1 {name=l803 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -2750 3 0 {name=l804 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -2500 0 0 {name=l805 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3530 -2620 0 0 {name=x202}
C {devices/lab_wire.sym} 3460 -2740 2 1 {name=l806 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -2750 1 1 {name=l807 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -2750 3 0 {name=l808 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -2500 0 0 {name=l809 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3790 -2620 0 0 {name=x203}
C {devices/lab_wire.sym} 3720 -2740 2 1 {name=l810 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -2750 1 1 {name=l811 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -2750 3 0 {name=l812 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -2500 0 0 {name=l813 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4050 -2620 0 0 {name=x204}
C {devices/lab_wire.sym} 3980 -2740 2 1 {name=l814 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -2750 1 1 {name=l815 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -2750 3 0 {name=l816 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -2500 0 0 {name=l817 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4310 -2620 0 0 {name=x205}
C {devices/lab_wire.sym} 4240 -2740 2 1 {name=l818 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -2750 1 1 {name=l819 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -2750 3 0 {name=l820 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -2500 0 0 {name=l821 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4570 -2620 0 0 {name=x206}
C {devices/lab_wire.sym} 4500 -2740 2 1 {name=l822 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -2750 1 1 {name=l823 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -2750 3 0 {name=l824 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -2500 0 0 {name=l825 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4830 -2620 0 0 {name=x207}
C {devices/lab_wire.sym} 4760 -2740 2 1 {name=l826 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -2750 1 1 {name=l827 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -2750 3 0 {name=l828 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -2500 0 0 {name=l829 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5090 -2620 0 0 {name=x208}
C {devices/lab_wire.sym} 5020 -2740 2 1 {name=l830 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -2750 1 1 {name=l831 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -2750 3 0 {name=l832 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -2500 0 0 {name=l833 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5350 -2620 0 0 {name=x209}
C {devices/lab_wire.sym} 5280 -2740 2 1 {name=l834 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -2750 1 1 {name=l835 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -2750 3 0 {name=l836 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -2500 0 0 {name=l837 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5610 -2620 0 0 {name=x210}
C {devices/lab_wire.sym} 5540 -2740 2 1 {name=l838 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -2750 1 1 {name=l839 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -2750 3 0 {name=l840 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -2500 0 0 {name=l841 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5870 -2620 0 0 {name=x211}
C {devices/lab_wire.sym} 5800 -2740 2 1 {name=l842 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -2750 1 1 {name=l843 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -2750 3 0 {name=l844 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -2500 0 0 {name=l845 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6130 -2620 0 0 {name=x212}
C {devices/lab_wire.sym} 6060 -2740 2 1 {name=l846 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -2750 1 1 {name=l847 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -2750 3 0 {name=l848 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -2500 0 0 {name=l849 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6390 -2620 0 0 {name=x213}
C {devices/lab_wire.sym} 6320 -2740 2 1 {name=l850 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -2750 1 1 {name=l851 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -2750 3 0 {name=l852 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -2500 0 0 {name=l853 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6650 -2620 0 0 {name=x214}
C {devices/lab_wire.sym} 6580 -2740 2 1 {name=l854 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -2750 1 1 {name=l855 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -2750 3 0 {name=l856 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -2500 0 0 {name=l857 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6910 -2620 0 0 {name=x215}
C {devices/lab_wire.sym} 6840 -2740 2 1 {name=l858 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -2750 1 1 {name=l859 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -2750 3 0 {name=l860 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -2500 0 0 {name=l861 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7170 -2620 0 0 {name=x216}
C {devices/lab_wire.sym} 7100 -2740 2 1 {name=l862 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -2750 1 1 {name=l863 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -2750 3 0 {name=l864 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -2500 0 0 {name=l865 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7430 -2620 0 0 {name=x217}
C {devices/lab_wire.sym} 7360 -2740 2 1 {name=l866 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -2750 1 1 {name=l867 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -2750 3 0 {name=l868 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -2500 0 0 {name=l869 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7690 -2620 0 0 {name=x218}
C {devices/lab_wire.sym} 7620 -2740 2 1 {name=l870 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -2750 1 1 {name=l871 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -2750 3 0 {name=l872 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -2500 0 0 {name=l873 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7950 -2620 0 0 {name=x219}
C {devices/lab_wire.sym} 7880 -2740 2 1 {name=l874 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -2750 1 1 {name=l875 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -2750 3 0 {name=l876 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -2500 0 0 {name=l877 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8210 -2620 0 0 {name=x220}
C {devices/lab_wire.sym} 8140 -2740 2 1 {name=l878 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -2750 1 1 {name=l879 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -2750 3 0 {name=l880 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -2500 0 0 {name=l881 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8470 -2620 0 0 {name=x221}
C {devices/lab_wire.sym} 8400 -2740 2 1 {name=l882 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -2750 1 1 {name=l883 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -2750 3 0 {name=l884 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -2500 0 0 {name=l885 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8730 -2620 0 0 {name=x222}
C {devices/lab_wire.sym} 8660 -2740 2 1 {name=l886 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -2750 1 1 {name=l887 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -2750 3 0 {name=l888 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -2500 0 0 {name=l889 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8990 -2620 0 0 {name=x223}
C {devices/lab_wire.sym} 8920 -2740 2 1 {name=l890 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -2750 1 1 {name=l891 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -2750 3 0 {name=l892 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -2500 0 0 {name=l893 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 9250 -2620 0 0 {name=x224}
C {devices/lab_wire.sym} 9180 -2740 2 1 {name=l894 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -2750 1 1 {name=l895 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -2750 3 0 {name=l896 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -2500 0 0 {name=l897 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1190 -2880 0 0 {name=x225}
C {devices/lab_wire.sym} 1120 -3000 2 1 {name=l898 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -3010 1 1 {name=l899 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -3010 3 0 {name=l900 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -2760 0 0 {name=l901 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1450 -2880 0 0 {name=x226}
C {devices/lab_wire.sym} 1380 -3000 2 1 {name=l902 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -3010 1 1 {name=l903 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -3010 3 0 {name=l904 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -2760 0 0 {name=l905 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1710 -2880 0 0 {name=x227}
C {devices/lab_wire.sym} 1640 -3000 2 1 {name=l906 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -3010 1 1 {name=l907 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -3010 3 0 {name=l908 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -2760 0 0 {name=l909 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1970 -2880 0 0 {name=x228}
C {devices/lab_wire.sym} 1900 -3000 2 1 {name=l910 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -3010 1 1 {name=l911 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -3010 3 0 {name=l912 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -2760 0 0 {name=l913 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2230 -2880 0 0 {name=x229}
C {devices/lab_wire.sym} 2160 -3000 2 1 {name=l914 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -3010 1 1 {name=l915 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -3010 3 0 {name=l916 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -2760 0 0 {name=l917 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2490 -2880 0 0 {name=x230}
C {devices/lab_wire.sym} 2420 -3000 2 1 {name=l918 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -3010 1 1 {name=l919 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -3010 3 0 {name=l920 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -2760 0 0 {name=l921 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2750 -2880 0 0 {name=x231}
C {devices/lab_wire.sym} 2680 -3000 2 1 {name=l922 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -3010 1 1 {name=l923 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -3010 3 0 {name=l924 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -2760 0 0 {name=l925 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3010 -2880 0 0 {name=x232}
C {devices/lab_wire.sym} 2940 -3000 2 1 {name=l926 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -3010 1 1 {name=l927 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -3010 3 0 {name=l928 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -2760 0 0 {name=l929 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3270 -2880 0 0 {name=x233}
C {devices/lab_wire.sym} 3200 -3000 2 1 {name=l930 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -3010 1 1 {name=l931 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -3010 3 0 {name=l932 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -2760 0 0 {name=l933 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3530 -2880 0 0 {name=x234}
C {devices/lab_wire.sym} 3460 -3000 2 1 {name=l934 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -3010 1 1 {name=l935 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -3010 3 0 {name=l936 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -2760 0 0 {name=l937 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3790 -2880 0 0 {name=x235}
C {devices/lab_wire.sym} 3720 -3000 2 1 {name=l938 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -3010 1 1 {name=l939 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -3010 3 0 {name=l940 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -2760 0 0 {name=l941 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4050 -2880 0 0 {name=x236}
C {devices/lab_wire.sym} 3980 -3000 2 1 {name=l942 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -3010 1 1 {name=l943 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -3010 3 0 {name=l944 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -2760 0 0 {name=l945 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4310 -2880 0 0 {name=x237}
C {devices/lab_wire.sym} 4240 -3000 2 1 {name=l946 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -3010 1 1 {name=l947 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -3010 3 0 {name=l948 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -2760 0 0 {name=l949 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4570 -2880 0 0 {name=x238}
C {devices/lab_wire.sym} 4500 -3000 2 1 {name=l950 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -3010 1 1 {name=l951 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -3010 3 0 {name=l952 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -2760 0 0 {name=l953 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4830 -2880 0 0 {name=x239}
C {devices/lab_wire.sym} 4760 -3000 2 1 {name=l954 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -3010 1 1 {name=l955 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -3010 3 0 {name=l956 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -2760 0 0 {name=l957 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5090 -2880 0 0 {name=x240}
C {devices/lab_wire.sym} 5020 -3000 2 1 {name=l958 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -3010 1 1 {name=l959 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -3010 3 0 {name=l960 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -2760 0 0 {name=l961 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5350 -2880 0 0 {name=x241}
C {devices/lab_wire.sym} 5280 -3000 2 1 {name=l962 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -3010 1 1 {name=l963 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -3010 3 0 {name=l964 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -2760 0 0 {name=l965 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5610 -2880 0 0 {name=x242}
C {devices/lab_wire.sym} 5540 -3000 2 1 {name=l966 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -3010 1 1 {name=l967 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -3010 3 0 {name=l968 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -2760 0 0 {name=l969 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5870 -2880 0 0 {name=x243}
C {devices/lab_wire.sym} 5800 -3000 2 1 {name=l970 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -3010 1 1 {name=l971 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -3010 3 0 {name=l972 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -2760 0 0 {name=l973 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6130 -2880 0 0 {name=x244}
C {devices/lab_wire.sym} 6060 -3000 2 1 {name=l974 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -3010 1 1 {name=l975 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -3010 3 0 {name=l976 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -2760 0 0 {name=l977 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6390 -2880 0 0 {name=x245}
C {devices/lab_wire.sym} 6320 -3000 2 1 {name=l978 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -3010 1 1 {name=l979 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -3010 3 0 {name=l980 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -2760 0 0 {name=l981 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6650 -2880 0 0 {name=x246}
C {devices/lab_wire.sym} 6580 -3000 2 1 {name=l982 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -3010 1 1 {name=l983 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -3010 3 0 {name=l984 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -2760 0 0 {name=l985 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6910 -2880 0 0 {name=x247}
C {devices/lab_wire.sym} 6840 -3000 2 1 {name=l986 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -3010 1 1 {name=l987 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -3010 3 0 {name=l988 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -2760 0 0 {name=l989 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7170 -2880 0 0 {name=x248}
C {devices/lab_wire.sym} 7100 -3000 2 1 {name=l990 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -3010 1 1 {name=l991 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -3010 3 0 {name=l992 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -2760 0 0 {name=l993 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7430 -2880 0 0 {name=x249}
C {devices/lab_wire.sym} 7360 -3000 2 1 {name=l994 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -3010 1 1 {name=l995 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -3010 3 0 {name=l996 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -2760 0 0 {name=l997 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7690 -2880 0 0 {name=x250}
C {devices/lab_wire.sym} 7620 -3000 2 1 {name=l998 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -3010 1 1 {name=l999 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -3010 3 0 {name=l1000 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -2760 0 0 {name=l1001 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7950 -2880 0 0 {name=x251}
C {devices/lab_wire.sym} 7880 -3000 2 1 {name=l1002 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -3010 1 1 {name=l1003 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -3010 3 0 {name=l1004 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -2760 0 0 {name=l1005 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8210 -2880 0 0 {name=x252}
C {devices/lab_wire.sym} 8140 -3000 2 1 {name=l1006 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -3010 1 1 {name=l1007 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -3010 3 0 {name=l1008 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -2760 0 0 {name=l1009 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8470 -2880 0 0 {name=x253}
C {devices/lab_wire.sym} 8400 -3000 2 1 {name=l1010 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -3010 1 1 {name=l1011 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -3010 3 0 {name=l1012 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -2760 0 0 {name=l1013 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8730 -2880 0 0 {name=x254}
C {devices/lab_wire.sym} 8660 -3000 2 1 {name=l1014 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -3010 1 1 {name=l1015 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -3010 3 0 {name=l1016 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -2760 0 0 {name=l1017 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8990 -2880 0 0 {name=x255}
C {devices/lab_wire.sym} 8920 -3000 2 1 {name=l1018 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -3010 1 1 {name=l1019 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -3010 3 0 {name=l1020 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -2760 0 0 {name=l1021 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 9250 -2880 0 0 {name=x256}
C {devices/lab_wire.sym} 9180 -3000 2 1 {name=l1022 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -3010 1 1 {name=l1023 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -3010 3 0 {name=l1024 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -2760 0 0 {name=l1025 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1190 -3140 0 0 {name=x257}
C {devices/lab_wire.sym} 1120 -3260 2 1 {name=l1026 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -3270 1 1 {name=l1027 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -3270 3 0 {name=l1028 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -3020 0 0 {name=l1029 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1450 -3140 0 0 {name=x258}
C {devices/lab_wire.sym} 1380 -3260 2 1 {name=l1030 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -3270 1 1 {name=l1031 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -3270 3 0 {name=l1032 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -3020 0 0 {name=l1033 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1710 -3140 0 0 {name=x259}
C {devices/lab_wire.sym} 1640 -3260 2 1 {name=l1034 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -3270 1 1 {name=l1035 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -3270 3 0 {name=l1036 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -3020 0 0 {name=l1037 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1970 -3140 0 0 {name=x260}
C {devices/lab_wire.sym} 1900 -3260 2 1 {name=l1038 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -3270 1 1 {name=l1039 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -3270 3 0 {name=l1040 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -3020 0 0 {name=l1041 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2230 -3140 0 0 {name=x261}
C {devices/lab_wire.sym} 2160 -3260 2 1 {name=l1042 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -3270 1 1 {name=l1043 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -3270 3 0 {name=l1044 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -3020 0 0 {name=l1045 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2490 -3140 0 0 {name=x262}
C {devices/lab_wire.sym} 2420 -3260 2 1 {name=l1046 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -3270 1 1 {name=l1047 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -3270 3 0 {name=l1048 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -3020 0 0 {name=l1049 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2750 -3140 0 0 {name=x263}
C {devices/lab_wire.sym} 2680 -3260 2 1 {name=l1050 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -3270 1 1 {name=l1051 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -3270 3 0 {name=l1052 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -3020 0 0 {name=l1053 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3010 -3140 0 0 {name=x264}
C {devices/lab_wire.sym} 2940 -3260 2 1 {name=l1054 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -3270 1 1 {name=l1055 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -3270 3 0 {name=l1056 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -3020 0 0 {name=l1057 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3270 -3140 0 0 {name=x265}
C {devices/lab_wire.sym} 3200 -3260 2 1 {name=l1058 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -3270 1 1 {name=l1059 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -3270 3 0 {name=l1060 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -3020 0 0 {name=l1061 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3530 -3140 0 0 {name=x266}
C {devices/lab_wire.sym} 3460 -3260 2 1 {name=l1062 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -3270 1 1 {name=l1063 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -3270 3 0 {name=l1064 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -3020 0 0 {name=l1065 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3790 -3140 0 0 {name=x267}
C {devices/lab_wire.sym} 3720 -3260 2 1 {name=l1066 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -3270 1 1 {name=l1067 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -3270 3 0 {name=l1068 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -3020 0 0 {name=l1069 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4050 -3140 0 0 {name=x268}
C {devices/lab_wire.sym} 3980 -3260 2 1 {name=l1070 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -3270 1 1 {name=l1071 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -3270 3 0 {name=l1072 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -3020 0 0 {name=l1073 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4310 -3140 0 0 {name=x269}
C {devices/lab_wire.sym} 4240 -3260 2 1 {name=l1074 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -3270 1 1 {name=l1075 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -3270 3 0 {name=l1076 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -3020 0 0 {name=l1077 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4570 -3140 0 0 {name=x270}
C {devices/lab_wire.sym} 4500 -3260 2 1 {name=l1078 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -3270 1 1 {name=l1079 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -3270 3 0 {name=l1080 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -3020 0 0 {name=l1081 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4830 -3140 0 0 {name=x271}
C {devices/lab_wire.sym} 4760 -3260 2 1 {name=l1082 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -3270 1 1 {name=l1083 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -3270 3 0 {name=l1084 sig_type=std_logic lab=ctop}
