C {devices/lab_wire.sym} 4760 -3020 0 0 {name=l1085 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5090 -3140 0 0 {name=x272}
C {devices/lab_wire.sym} 5020 -3260 2 1 {name=l1086 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -3270 1 1 {name=l1087 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -3270 3 0 {name=l1088 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -3020 0 0 {name=l1089 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5350 -3140 0 0 {name=x273}
C {devices/lab_wire.sym} 5280 -3260 2 1 {name=l1090 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -3270 1 1 {name=l1091 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -3270 3 0 {name=l1092 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -3020 0 0 {name=l1093 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5610 -3140 0 0 {name=x274}
C {devices/lab_wire.sym} 5540 -3260 2 1 {name=l1094 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -3270 1 1 {name=l1095 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -3270 3 0 {name=l1096 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -3020 0 0 {name=l1097 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5870 -3140 0 0 {name=x275}
C {devices/lab_wire.sym} 5800 -3260 2 1 {name=l1098 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -3270 1 1 {name=l1099 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -3270 3 0 {name=l1100 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -3020 0 0 {name=l1101 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6130 -3140 0 0 {name=x276}
C {devices/lab_wire.sym} 6060 -3260 2 1 {name=l1102 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -3270 1 1 {name=l1103 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -3270 3 0 {name=l1104 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -3020 0 0 {name=l1105 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6390 -3140 0 0 {name=x277}
C {devices/lab_wire.sym} 6320 -3260 2 1 {name=l1106 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -3270 1 1 {name=l1107 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -3270 3 0 {name=l1108 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -3020 0 0 {name=l1109 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6650 -3140 0 0 {name=x278}
C {devices/lab_wire.sym} 6580 -3260 2 1 {name=l1110 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -3270 1 1 {name=l1111 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -3270 3 0 {name=l1112 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -3020 0 0 {name=l1113 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6910 -3140 0 0 {name=x279}
C {devices/lab_wire.sym} 6840 -3260 2 1 {name=l1114 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -3270 1 1 {name=l1115 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -3270 3 0 {name=l1116 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -3020 0 0 {name=l1117 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7170 -3140 0 0 {name=x280}
C {devices/lab_wire.sym} 7100 -3260 2 1 {name=l1118 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -3270 1 1 {name=l1119 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -3270 3 0 {name=l1120 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -3020 0 0 {name=l1121 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7430 -3140 0 0 {name=x281}
C {devices/lab_wire.sym} 7360 -3260 2 1 {name=l1122 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -3270 1 1 {name=l1123 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -3270 3 0 {name=l1124 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -3020 0 0 {name=l1125 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7690 -3140 0 0 {name=x282}
C {devices/lab_wire.sym} 7620 -3260 2 1 {name=l1126 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -3270 1 1 {name=l1127 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -3270 3 0 {name=l1128 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -3020 0 0 {name=l1129 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7950 -3140 0 0 {name=x283}
C {devices/lab_wire.sym} 7880 -3260 2 1 {name=l1130 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -3270 1 1 {name=l1131 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -3270 3 0 {name=l1132 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -3020 0 0 {name=l1133 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8210 -3140 0 0 {name=x284}
C {devices/lab_wire.sym} 8140 -3260 2 1 {name=l1134 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -3270 1 1 {name=l1135 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -3270 3 0 {name=l1136 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -3020 0 0 {name=l1137 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8470 -3140 0 0 {name=x285}
C {devices/lab_wire.sym} 8400 -3260 2 1 {name=l1138 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -3270 1 1 {name=l1139 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -3270 3 0 {name=l1140 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -3020 0 0 {name=l1141 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8730 -3140 0 0 {name=x286}
C {devices/lab_wire.sym} 8660 -3260 2 1 {name=l1142 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -3270 1 1 {name=l1143 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -3270 3 0 {name=l1144 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -3020 0 0 {name=l1145 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8990 -3140 0 0 {name=x287}
C {devices/lab_wire.sym} 8920 -3260 2 1 {name=l1146 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -3270 1 1 {name=l1147 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -3270 3 0 {name=l1148 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -3020 0 0 {name=l1149 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 9250 -3140 0 0 {name=x288}
C {devices/lab_wire.sym} 9180 -3260 2 1 {name=l1150 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -3270 1 1 {name=l1151 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -3270 3 0 {name=l1152 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -3020 0 0 {name=l1153 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1190 -3400 0 0 {name=x289}
C {devices/lab_wire.sym} 1120 -3520 2 1 {name=l1154 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -3530 1 1 {name=l1155 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -3530 3 0 {name=l1156 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -3280 0 0 {name=l1157 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1450 -3400 0 0 {name=x290}
C {devices/lab_wire.sym} 1380 -3520 2 1 {name=l1158 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -3530 1 1 {name=l1159 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -3530 3 0 {name=l1160 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -3280 0 0 {name=l1161 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1710 -3400 0 0 {name=x291}
C {devices/lab_wire.sym} 1640 -3520 2 1 {name=l1162 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -3530 1 1 {name=l1163 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -3530 3 0 {name=l1164 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -3280 0 0 {name=l1165 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1970 -3400 0 0 {name=x292}
C {devices/lab_wire.sym} 1900 -3520 2 1 {name=l1166 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -3530 1 1 {name=l1167 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -3530 3 0 {name=l1168 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -3280 0 0 {name=l1169 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2230 -3400 0 0 {name=x293}
C {devices/lab_wire.sym} 2160 -3520 2 1 {name=l1170 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -3530 1 1 {name=l1171 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -3530 3 0 {name=l1172 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -3280 0 0 {name=l1173 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2490 -3400 0 0 {name=x294}
C {devices/lab_wire.sym} 2420 -3520 2 1 {name=l1174 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -3530 1 1 {name=l1175 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -3530 3 0 {name=l1176 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -3280 0 0 {name=l1177 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2750 -3400 0 0 {name=x295}
C {devices/lab_wire.sym} 2680 -3520 2 1 {name=l1178 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -3530 1 1 {name=l1179 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -3530 3 0 {name=l1180 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -3280 0 0 {name=l1181 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3010 -3400 0 0 {name=x296}
C {devices/lab_wire.sym} 2940 -3520 2 1 {name=l1182 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -3530 1 1 {name=l1183 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -3530 3 0 {name=l1184 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -3280 0 0 {name=l1185 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3270 -3400 0 0 {name=x297}
C {devices/lab_wire.sym} 3200 -3520 2 1 {name=l1186 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -3530 1 1 {name=l1187 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -3530 3 0 {name=l1188 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -3280 0 0 {name=l1189 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3530 -3400 0 0 {name=x298}
C {devices/lab_wire.sym} 3460 -3520 2 1 {name=l1190 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -3530 1 1 {name=l1191 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -3530 3 0 {name=l1192 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -3280 0 0 {name=l1193 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3790 -3400 0 0 {name=x299}
C {devices/lab_wire.sym} 3720 -3520 2 1 {name=l1194 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -3530 1 1 {name=l1195 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -3530 3 0 {name=l1196 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -3280 0 0 {name=l1197 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4050 -3400 0 0 {name=x300}
C {devices/lab_wire.sym} 3980 -3520 2 1 {name=l1198 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -3530 1 1 {name=l1199 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -3530 3 0 {name=l1200 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -3280 0 0 {name=l1201 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4310 -3400 0 0 {name=x301}
C {devices/lab_wire.sym} 4240 -3520 2 1 {name=l1202 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -3530 1 1 {name=l1203 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -3530 3 0 {name=l1204 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -3280 0 0 {name=l1205 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4570 -3400 0 0 {name=x302}
C {devices/lab_wire.sym} 4500 -3520 2 1 {name=l1206 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -3530 1 1 {name=l1207 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -3530 3 0 {name=l1208 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -3280 0 0 {name=l1209 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4830 -3400 0 0 {name=x303}
C {devices/lab_wire.sym} 4760 -3520 2 1 {name=l1210 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -3530 1 1 {name=l1211 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -3530 3 0 {name=l1212 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -3280 0 0 {name=l1213 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5090 -3400 0 0 {name=x304}
C {devices/lab_wire.sym} 5020 -3520 2 1 {name=l1214 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -3530 1 1 {name=l1215 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -3530 3 0 {name=l1216 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -3280 0 0 {name=l1217 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5350 -3400 0 0 {name=x305}
C {devices/lab_wire.sym} 5280 -3520 2 1 {name=l1218 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -3530 1 1 {name=l1219 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -3530 3 0 {name=l1220 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -3280 0 0 {name=l1221 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5610 -3400 0 0 {name=x306}
C {devices/lab_wire.sym} 5540 -3520 2 1 {name=l1222 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -3530 1 1 {name=l1223 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -3530 3 0 {name=l1224 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -3280 0 0 {name=l1225 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5870 -3400 0 0 {name=x307}
C {devices/lab_wire.sym} 5800 -3520 2 1 {name=l1226 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -3530 1 1 {name=l1227 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -3530 3 0 {name=l1228 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -3280 0 0 {name=l1229 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6130 -3400 0 0 {name=x308}
C {devices/lab_wire.sym} 6060 -3520 2 1 {name=l1230 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -3530 1 1 {name=l1231 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -3530 3 0 {name=l1232 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -3280 0 0 {name=l1233 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6390 -3400 0 0 {name=x309}
C {devices/lab_wire.sym} 6320 -3520 2 1 {name=l1234 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -3530 1 1 {name=l1235 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -3530 3 0 {name=l1236 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -3280 0 0 {name=l1237 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6650 -3400 0 0 {name=x310}
C {devices/lab_wire.sym} 6580 -3520 2 1 {name=l1238 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -3530 1 1 {name=l1239 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -3530 3 0 {name=l1240 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -3280 0 0 {name=l1241 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6910 -3400 0 0 {name=x311}
C {devices/lab_wire.sym} 6840 -3520 2 1 {name=l1242 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -3530 1 1 {name=l1243 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -3530 3 0 {name=l1244 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -3280 0 0 {name=l1245 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7170 -3400 0 0 {name=x312}
C {devices/lab_wire.sym} 7100 -3520 2 1 {name=l1246 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -3530 1 1 {name=l1247 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -3530 3 0 {name=l1248 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -3280 0 0 {name=l1249 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7430 -3400 0 0 {name=x313}
C {devices/lab_wire.sym} 7360 -3520 2 1 {name=l1250 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -3530 1 1 {name=l1251 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -3530 3 0 {name=l1252 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -3280 0 0 {name=l1253 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7690 -3400 0 0 {name=x314}
C {devices/lab_wire.sym} 7620 -3520 2 1 {name=l1254 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -3530 1 1 {name=l1255 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -3530 3 0 {name=l1256 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -3280 0 0 {name=l1257 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7950 -3400 0 0 {name=x315}
C {devices/lab_wire.sym} 7880 -3520 2 1 {name=l1258 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -3530 1 1 {name=l1259 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -3530 3 0 {name=l1260 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -3280 0 0 {name=l1261 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8210 -3400 0 0 {name=x316}
C {devices/lab_wire.sym} 8140 -3520 2 1 {name=l1262 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -3530 1 1 {name=l1263 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -3530 3 0 {name=l1264 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -3280 0 0 {name=l1265 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8470 -3400 0 0 {name=x317}
C {devices/lab_wire.sym} 8400 -3520 2 1 {name=l1266 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -3530 1 1 {name=l1267 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -3530 3 0 {name=l1268 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -3280 0 0 {name=l1269 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8730 -3400 0 0 {name=x318}
C {devices/lab_wire.sym} 8660 -3520 2 1 {name=l1270 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -3530 1 1 {name=l1271 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -3530 3 0 {name=l1272 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -3280 0 0 {name=l1273 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8990 -3400 0 0 {name=x319}
C {devices/lab_wire.sym} 8920 -3520 2 1 {name=l1274 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -3530 1 1 {name=l1275 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -3530 3 0 {name=l1276 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -3280 0 0 {name=l1277 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 9250 -3400 0 0 {name=x320}
C {devices/lab_wire.sym} 9180 -3520 2 1 {name=l1278 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -3530 1 1 {name=l1279 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -3530 3 0 {name=l1280 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -3280 0 0 {name=l1281 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1190 -3660 0 0 {name=x321}
C {devices/lab_wire.sym} 1120 -3780 2 1 {name=l1282 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -3790 1 1 {name=l1283 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -3790 3 0 {name=l1284 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -3540 0 0 {name=l1285 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1450 -3660 0 0 {name=x322}
C {devices/lab_wire.sym} 1380 -3780 2 1 {name=l1286 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -3790 1 1 {name=l1287 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -3790 3 0 {name=l1288 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -3540 0 0 {name=l1289 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1710 -3660 0 0 {name=x323}
C {devices/lab_wire.sym} 1640 -3780 2 1 {name=l1290 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -3790 1 1 {name=l1291 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -3790 3 0 {name=l1292 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -3540 0 0 {name=l1293 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1970 -3660 0 0 {name=x324}
C {devices/lab_wire.sym} 1900 -3780 2 1 {name=l1294 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -3790 1 1 {name=l1295 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -3790 3 0 {name=l1296 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -3540 0 0 {name=l1297 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2230 -3660 0 0 {name=x325}
C {devices/lab_wire.sym} 2160 -3780 2 1 {name=l1298 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -3790 1 1 {name=l1299 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -3790 3 0 {name=l1300 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -3540 0 0 {name=l1301 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2490 -3660 0 0 {name=x326}
C {devices/lab_wire.sym} 2420 -3780 2 1 {name=l1302 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -3790 1 1 {name=l1303 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -3790 3 0 {name=l1304 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -3540 0 0 {name=l1305 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2750 -3660 0 0 {name=x327}
C {devices/lab_wire.sym} 2680 -3780 2 1 {name=l1306 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -3790 1 1 {name=l1307 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -3790 3 0 {name=l1308 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -3540 0 0 {name=l1309 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3010 -3660 0 0 {name=x328}
C {devices/lab_wire.sym} 2940 -3780 2 1 {name=l1310 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -3790 1 1 {name=l1311 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -3790 3 0 {name=l1312 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -3540 0 0 {name=l1313 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3270 -3660 0 0 {name=x329}
C {devices/lab_wire.sym} 3200 -3780 2 1 {name=l1314 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -3790 1 1 {name=l1315 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -3790 3 0 {name=l1316 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -3540 0 0 {name=l1317 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3530 -3660 0 0 {name=x330}
C {devices/lab_wire.sym} 3460 -3780 2 1 {name=l1318 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -3790 1 1 {name=l1319 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -3790 3 0 {name=l1320 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -3540 0 0 {name=l1321 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3790 -3660 0 0 {name=x331}
C {devices/lab_wire.sym} 3720 -3780 2 1 {name=l1322 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -3790 1 1 {name=l1323 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -3790 3 0 {name=l1324 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -3540 0 0 {name=l1325 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4050 -3660 0 0 {name=x332}
C {devices/lab_wire.sym} 3980 -3780 2 1 {name=l1326 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -3790 1 1 {name=l1327 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -3790 3 0 {name=l1328 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -3540 0 0 {name=l1329 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4310 -3660 0 0 {name=x333}
C {devices/lab_wire.sym} 4240 -3780 2 1 {name=l1330 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -3790 1 1 {name=l1331 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -3790 3 0 {name=l1332 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -3540 0 0 {name=l1333 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4570 -3660 0 0 {name=x334}
C {devices/lab_wire.sym} 4500 -3780 2 1 {name=l1334 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -3790 1 1 {name=l1335 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -3790 3 0 {name=l1336 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -3540 0 0 {name=l1337 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4830 -3660 0 0 {name=x335}
C {devices/lab_wire.sym} 4760 -3780 2 1 {name=l1338 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -3790 1 1 {name=l1339 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -3790 3 0 {name=l1340 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -3540 0 0 {name=l1341 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5090 -3660 0 0 {name=x336}
C {devices/lab_wire.sym} 5020 -3780 2 1 {name=l1342 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -3790 1 1 {name=l1343 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -3790 3 0 {name=l1344 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -3540 0 0 {name=l1345 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5350 -3660 0 0 {name=x337}
C {devices/lab_wire.sym} 5280 -3780 2 1 {name=l1346 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -3790 1 1 {name=l1347 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -3790 3 0 {name=l1348 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -3540 0 0 {name=l1349 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5610 -3660 0 0 {name=x338}
C {devices/lab_wire.sym} 5540 -3780 2 1 {name=l1350 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -3790 1 1 {name=l1351 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -3790 3 0 {name=l1352 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -3540 0 0 {name=l1353 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5870 -3660 0 0 {name=x339}
C {devices/lab_wire.sym} 5800 -3780 2 1 {name=l1354 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -3790 1 1 {name=l1355 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -3790 3 0 {name=l1356 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -3540 0 0 {name=l1357 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6130 -3660 0 0 {name=x340}
C {devices/lab_wire.sym} 6060 -3780 2 1 {name=l1358 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -3790 1 1 {name=l1359 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -3790 3 0 {name=l1360 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -3540 0 0 {name=l1361 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6390 -3660 0 0 {name=x341}
C {devices/lab_wire.sym} 6320 -3780 2 1 {name=l1362 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -3790 1 1 {name=l1363 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -3790 3 0 {name=l1364 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -3540 0 0 {name=l1365 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6650 -3660 0 0 {name=x342}
C {devices/lab_wire.sym} 6580 -3780 2 1 {name=l1366 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -3790 1 1 {name=l1367 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -3790 3 0 {name=l1368 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -3540 0 0 {name=l1369 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6910 -3660 0 0 {name=x343}
C {devices/lab_wire.sym} 6840 -3780 2 1 {name=l1370 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -3790 1 1 {name=l1371 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -3790 3 0 {name=l1372 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -3540 0 0 {name=l1373 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7170 -3660 0 0 {name=x344}
C {devices/lab_wire.sym} 7100 -3780 2 1 {name=l1374 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -3790 1 1 {name=l1375 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -3790 3 0 {name=l1376 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -3540 0 0 {name=l1377 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7430 -3660 0 0 {name=x345}
C {devices/lab_wire.sym} 7360 -3780 2 1 {name=l1378 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -3790 1 1 {name=l1379 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -3790 3 0 {name=l1380 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -3540 0 0 {name=l1381 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7690 -3660 0 0 {name=x346}
C {devices/lab_wire.sym} 7620 -3780 2 1 {name=l1382 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -3790 1 1 {name=l1383 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -3790 3 0 {name=l1384 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -3540 0 0 {name=l1385 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7950 -3660 0 0 {name=x347}
C {devices/lab_wire.sym} 7880 -3780 2 1 {name=l1386 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -3790 1 1 {name=l1387 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -3790 3 0 {name=l1388 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -3540 0 0 {name=l1389 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8210 -3660 0 0 {name=x348}
C {devices/lab_wire.sym} 8140 -3780 2 1 {name=l1390 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -3790 1 1 {name=l1391 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -3790 3 0 {name=l1392 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -3540 0 0 {name=l1393 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8470 -3660 0 0 {name=x349}
C {devices/lab_wire.sym} 8400 -3780 2 1 {name=l1394 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -3790 1 1 {name=l1395 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -3790 3 0 {name=l1396 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -3540 0 0 {name=l1397 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8730 -3660 0 0 {name=x350}
C {devices/lab_wire.sym} 8660 -3780 2 1 {name=l1398 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -3790 1 1 {name=l1399 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -3790 3 0 {name=l1400 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -3540 0 0 {name=l1401 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8990 -3660 0 0 {name=x351}
C {devices/lab_wire.sym} 8920 -3780 2 1 {name=l1402 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -3790 1 1 {name=l1403 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -3790 3 0 {name=l1404 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -3540 0 0 {name=l1405 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 9250 -3660 0 0 {name=x352}
C {devices/lab_wire.sym} 9180 -3780 2 1 {name=l1406 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -3790 1 1 {name=l1407 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -3790 3 0 {name=l1408 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -3540 0 0 {name=l1409 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1190 -3920 0 0 {name=x353}
C {devices/lab_wire.sym} 1120 -4040 2 1 {name=l1410 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -4050 1 1 {name=l1411 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -4050 3 0 {name=l1412 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -3800 0 0 {name=l1413 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1450 -3920 0 0 {name=x354}
C {devices/lab_wire.sym} 1380 -4040 2 1 {name=l1414 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -4050 1 1 {name=l1415 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -4050 3 0 {name=l1416 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -3800 0 0 {name=l1417 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1710 -3920 0 0 {name=x355}
C {devices/lab_wire.sym} 1640 -4040 2 1 {name=l1418 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -4050 1 1 {name=l1419 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -4050 3 0 {name=l1420 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -3800 0 0 {name=l1421 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1970 -3920 0 0 {name=x356}
C {devices/lab_wire.sym} 1900 -4040 2 1 {name=l1422 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -4050 1 1 {name=l1423 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -4050 3 0 {name=l1424 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -3800 0 0 {name=l1425 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2230 -3920 0 0 {name=x357}
C {devices/lab_wire.sym} 2160 -4040 2 1 {name=l1426 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -4050 1 1 {name=l1427 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -4050 3 0 {name=l1428 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -3800 0 0 {name=l1429 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2490 -3920 0 0 {name=x358}
C {devices/lab_wire.sym} 2420 -4040 2 1 {name=l1430 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -4050 1 1 {name=l1431 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -4050 3 0 {name=l1432 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -3800 0 0 {name=l1433 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2750 -3920 0 0 {name=x359}
C {devices/lab_wire.sym} 2680 -4040 2 1 {name=l1434 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -4050 1 1 {name=l1435 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -4050 3 0 {name=l1436 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -3800 0 0 {name=l1437 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3010 -3920 0 0 {name=x360}
C {devices/lab_wire.sym} 2940 -4040 2 1 {name=l1438 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -4050 1 1 {name=l1439 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -4050 3 0 {name=l1440 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -3800 0 0 {name=l1441 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3270 -3920 0 0 {name=x361}
C {devices/lab_wire.sym} 3200 -4040 2 1 {name=l1442 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -4050 1 1 {name=l1443 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -4050 3 0 {name=l1444 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -3800 0 0 {name=l1445 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3530 -3920 0 0 {name=x362}
C {devices/lab_wire.sym} 3460 -4040 2 1 {name=l1446 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -4050 1 1 {name=l1447 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -4050 3 0 {name=l1448 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -3800 0 0 {name=l1449 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3790 -3920 0 0 {name=x363}
C {devices/lab_wire.sym} 3720 -4040 2 1 {name=l1450 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -4050 1 1 {name=l1451 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -4050 3 0 {name=l1452 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -3800 0 0 {name=l1453 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4050 -3920 0 0 {name=x364}
C {devices/lab_wire.sym} 3980 -4040 2 1 {name=l1454 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -4050 1 1 {name=l1455 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -4050 3 0 {name=l1456 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -3800 0 0 {name=l1457 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4310 -3920 0 0 {name=x365}
C {devices/lab_wire.sym} 4240 -4040 2 1 {name=l1458 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -4050 1 1 {name=l1459 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -4050 3 0 {name=l1460 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -3800 0 0 {name=l1461 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4570 -3920 0 0 {name=x366}
C {devices/lab_wire.sym} 4500 -4040 2 1 {name=l1462 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -4050 1 1 {name=l1463 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -4050 3 0 {name=l1464 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -3800 0 0 {name=l1465 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4830 -3920 0 0 {name=x367}
C {devices/lab_wire.sym} 4760 -4040 2 1 {name=l1466 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -4050 1 1 {name=l1467 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -4050 3 0 {name=l1468 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -3800 0 0 {name=l1469 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5090 -3920 0 0 {name=x368}
C {devices/lab_wire.sym} 5020 -4040 2 1 {name=l1470 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -4050 1 1 {name=l1471 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -4050 3 0 {name=l1472 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -3800 0 0 {name=l1473 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5350 -3920 0 0 {name=x369}
C {devices/lab_wire.sym} 5280 -4040 2 1 {name=l1474 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -4050 1 1 {name=l1475 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -4050 3 0 {name=l1476 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -3800 0 0 {name=l1477 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5610 -3920 0 0 {name=x370}
C {devices/lab_wire.sym} 5540 -4040 2 1 {name=l1478 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -4050 1 1 {name=l1479 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -4050 3 0 {name=l1480 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -3800 0 0 {name=l1481 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5870 -3920 0 0 {name=x371}
C {devices/lab_wire.sym} 5800 -4040 2 1 {name=l1482 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -4050 1 1 {name=l1483 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -4050 3 0 {name=l1484 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -3800 0 0 {name=l1485 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6130 -3920 0 0 {name=x372}
C {devices/lab_wire.sym} 6060 -4040 2 1 {name=l1486 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -4050 1 1 {name=l1487 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -4050 3 0 {name=l1488 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -3800 0 0 {name=l1489 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6390 -3920 0 0 {name=x373}
C {devices/lab_wire.sym} 6320 -4040 2 1 {name=l1490 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -4050 1 1 {name=l1491 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -4050 3 0 {name=l1492 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -3800 0 0 {name=l1493 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6650 -3920 0 0 {name=x374}
C {devices/lab_wire.sym} 6580 -4040 2 1 {name=l1494 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -4050 1 1 {name=l1495 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -4050 3 0 {name=l1496 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -3800 0 0 {name=l1497 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6910 -3920 0 0 {name=x375}
C {devices/lab_wire.sym} 6840 -4040 2 1 {name=l1498 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -4050 1 1 {name=l1499 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -4050 3 0 {name=l1500 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -3800 0 0 {name=l1501 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7170 -3920 0 0 {name=x376}
C {devices/lab_wire.sym} 7100 -4040 2 1 {name=l1502 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -4050 1 1 {name=l1503 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -4050 3 0 {name=l1504 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -3800 0 0 {name=l1505 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7430 -3920 0 0 {name=x377}
C {devices/lab_wire.sym} 7360 -4040 2 1 {name=l1506 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -4050 1 1 {name=l1507 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -4050 3 0 {name=l1508 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -3800 0 0 {name=l1509 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7690 -3920 0 0 {name=x378}
C {devices/lab_wire.sym} 7620 -4040 2 1 {name=l1510 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -4050 1 1 {name=l1511 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -4050 3 0 {name=l1512 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -3800 0 0 {name=l1513 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7950 -3920 0 0 {name=x379}
C {devices/lab_wire.sym} 7880 -4040 2 1 {name=l1514 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -4050 1 1 {name=l1515 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -4050 3 0 {name=l1516 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -3800 0 0 {name=l1517 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8210 -3920 0 0 {name=x380}
C {devices/lab_wire.sym} 8140 -4040 2 1 {name=l1518 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -4050 1 1 {name=l1519 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -4050 3 0 {name=l1520 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -3800 0 0 {name=l1521 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8470 -3920 0 0 {name=x381}
C {devices/lab_wire.sym} 8400 -4040 2 1 {name=l1522 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -4050 1 1 {name=l1523 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -4050 3 0 {name=l1524 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -3800 0 0 {name=l1525 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8730 -3920 0 0 {name=x382}
C {devices/lab_wire.sym} 8660 -4040 2 1 {name=l1526 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -4050 1 1 {name=l1527 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -4050 3 0 {name=l1528 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -3800 0 0 {name=l1529 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8990 -3920 0 0 {name=x383}
C {devices/lab_wire.sym} 8920 -4040 2 1 {name=l1530 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -4050 1 1 {name=l1531 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -4050 3 0 {name=l1532 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -3800 0 0 {name=l1533 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 9250 -3920 0 0 {name=x384}
C {devices/lab_wire.sym} 9180 -4040 2 1 {name=l1534 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -4050 1 1 {name=l1535 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -4050 3 0 {name=l1536 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -3800 0 0 {name=l1537 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1190 -4180 0 0 {name=x385}
C {devices/lab_wire.sym} 1120 -4300 2 1 {name=l1538 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -4310 1 1 {name=l1539 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -4310 3 0 {name=l1540 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -4060 0 0 {name=l1541 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1450 -4180 0 0 {name=x386}
C {devices/lab_wire.sym} 1380 -4300 2 1 {name=l1542 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -4310 1 1 {name=l1543 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -4310 3 0 {name=l1544 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -4060 0 0 {name=l1545 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1710 -4180 0 0 {name=x387}
C {devices/lab_wire.sym} 1640 -4300 2 1 {name=l1546 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -4310 1 1 {name=l1547 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -4310 3 0 {name=l1548 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -4060 0 0 {name=l1549 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1970 -4180 0 0 {name=x388}
C {devices/lab_wire.sym} 1900 -4300 2 1 {name=l1550 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -4310 1 1 {name=l1551 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -4310 3 0 {name=l1552 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -4060 0 0 {name=l1553 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2230 -4180 0 0 {name=x389}
C {devices/lab_wire.sym} 2160 -4300 2 1 {name=l1554 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -4310 1 1 {name=l1555 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -4310 3 0 {name=l1556 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -4060 0 0 {name=l1557 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2490 -4180 0 0 {name=x390}
C {devices/lab_wire.sym} 2420 -4300 2 1 {name=l1558 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -4310 1 1 {name=l1559 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -4310 3 0 {name=l1560 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -4060 0 0 {name=l1561 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2750 -4180 0 0 {name=x391}
C {devices/lab_wire.sym} 2680 -4300 2 1 {name=l1562 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -4310 1 1 {name=l1563 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -4310 3 0 {name=l1564 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -4060 0 0 {name=l1565 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3010 -4180 0 0 {name=x392}
C {devices/lab_wire.sym} 2940 -4300 2 1 {name=l1566 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -4310 1 1 {name=l1567 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -4310 3 0 {name=l1568 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -4060 0 0 {name=l1569 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3270 -4180 0 0 {name=x393}
C {devices/lab_wire.sym} 3200 -4300 2 1 {name=l1570 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -4310 1 1 {name=l1571 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -4310 3 0 {name=l1572 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -4060 0 0 {name=l1573 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3530 -4180 0 0 {name=x394}
C {devices/lab_wire.sym} 3460 -4300 2 1 {name=l1574 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -4310 1 1 {name=l1575 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -4310 3 0 {name=l1576 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -4060 0 0 {name=l1577 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3790 -4180 0 0 {name=x395}
C {devices/lab_wire.sym} 3720 -4300 2 1 {name=l1578 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -4310 1 1 {name=l1579 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -4310 3 0 {name=l1580 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -4060 0 0 {name=l1581 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4050 -4180 0 0 {name=x396}
C {devices/lab_wire.sym} 3980 -4300 2 1 {name=l1582 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -4310 1 1 {name=l1583 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -4310 3 0 {name=l1584 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -4060 0 0 {name=l1585 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4310 -4180 0 0 {name=x397}
C {devices/lab_wire.sym} 4240 -4300 2 1 {name=l1586 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -4310 1 1 {name=l1587 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -4310 3 0 {name=l1588 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -4060 0 0 {name=l1589 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4570 -4180 0 0 {name=x398}
C {devices/lab_wire.sym} 4500 -4300 2 1 {name=l1590 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -4310 1 1 {name=l1591 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -4310 3 0 {name=l1592 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -4060 0 0 {name=l1593 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4830 -4180 0 0 {name=x399}
C {devices/lab_wire.sym} 4760 -4300 2 1 {name=l1594 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -4310 1 1 {name=l1595 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -4310 3 0 {name=l1596 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -4060 0 0 {name=l1597 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5090 -4180 0 0 {name=x400}
C {devices/lab_wire.sym} 5020 -4300 2 1 {name=l1598 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -4310 1 1 {name=l1599 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -4310 3 0 {name=l1600 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -4060 0 0 {name=l1601 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5350 -4180 0 0 {name=x401}
C {devices/lab_wire.sym} 5280 -4300 2 1 {name=l1602 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -4310 1 1 {name=l1603 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -4310 3 0 {name=l1604 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -4060 0 0 {name=l1605 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5610 -4180 0 0 {name=x402}
C {devices/lab_wire.sym} 5540 -4300 2 1 {name=l1606 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -4310 1 1 {name=l1607 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -4310 3 0 {name=l1608 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -4060 0 0 {name=l1609 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5870 -4180 0 0 {name=x403}
C {devices/lab_wire.sym} 5800 -4300 2 1 {name=l1610 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -4310 1 1 {name=l1611 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -4310 3 0 {name=l1612 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -4060 0 0 {name=l1613 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6130 -4180 0 0 {name=x404}
C {devices/lab_wire.sym} 6060 -4300 2 1 {name=l1614 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -4310 1 1 {name=l1615 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -4310 3 0 {name=l1616 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -4060 0 0 {name=l1617 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6390 -4180 0 0 {name=x405}
C {devices/lab_wire.sym} 6320 -4300 2 1 {name=l1618 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -4310 1 1 {name=l1619 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -4310 3 0 {name=l1620 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -4060 0 0 {name=l1621 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6650 -4180 0 0 {name=x406}
C {devices/lab_wire.sym} 6580 -4300 2 1 {name=l1622 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -4310 1 1 {name=l1623 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -4310 3 0 {name=l1624 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -4060 0 0 {name=l1625 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6910 -4180 0 0 {name=x407}
C {devices/lab_wire.sym} 6840 -4300 2 1 {name=l1626 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -4310 1 1 {name=l1627 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -4310 3 0 {name=l1628 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -4060 0 0 {name=l1629 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7170 -4180 0 0 {name=x408}
C {devices/lab_wire.sym} 7100 -4300 2 1 {name=l1630 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -4310 1 1 {name=l1631 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -4310 3 0 {name=l1632 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -4060 0 0 {name=l1633 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7430 -4180 0 0 {name=x409}
C {devices/lab_wire.sym} 7360 -4300 2 1 {name=l1634 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -4310 1 1 {name=l1635 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -4310 3 0 {name=l1636 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -4060 0 0 {name=l1637 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7690 -4180 0 0 {name=x410}
C {devices/lab_wire.sym} 7620 -4300 2 1 {name=l1638 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -4310 1 1 {name=l1639 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -4310 3 0 {name=l1640 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -4060 0 0 {name=l1641 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7950 -4180 0 0 {name=x411}
C {devices/lab_wire.sym} 7880 -4300 2 1 {name=l1642 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -4310 1 1 {name=l1643 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -4310 3 0 {name=l1644 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -4060 0 0 {name=l1645 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8210 -4180 0 0 {name=x412}
C {devices/lab_wire.sym} 8140 -4300 2 1 {name=l1646 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -4310 1 1 {name=l1647 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -4310 3 0 {name=l1648 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -4060 0 0 {name=l1649 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8470 -4180 0 0 {name=x413}
C {devices/lab_wire.sym} 8400 -4300 2 1 {name=l1650 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -4310 1 1 {name=l1651 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -4310 3 0 {name=l1652 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -4060 0 0 {name=l1653 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8730 -4180 0 0 {name=x414}
C {devices/lab_wire.sym} 8660 -4300 2 1 {name=l1654 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -4310 1 1 {name=l1655 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -4310 3 0 {name=l1656 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -4060 0 0 {name=l1657 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8990 -4180 0 0 {name=x415}
C {devices/lab_wire.sym} 8920 -4300 2 1 {name=l1658 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -4310 1 1 {name=l1659 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -4310 3 0 {name=l1660 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -4060 0 0 {name=l1661 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 9250 -4180 0 0 {name=x416}
C {devices/lab_wire.sym} 9180 -4300 2 1 {name=l1662 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -4310 1 1 {name=l1663 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -4310 3 0 {name=l1664 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -4060 0 0 {name=l1665 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1190 -4440 0 0 {name=x417}
C {devices/lab_wire.sym} 1120 -4560 2 1 {name=l1666 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -4570 1 1 {name=l1667 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -4570 3 0 {name=l1668 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -4320 0 0 {name=l1669 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1450 -4440 0 0 {name=x418}
C {devices/lab_wire.sym} 1380 -4560 2 1 {name=l1670 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -4570 1 1 {name=l1671 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -4570 3 0 {name=l1672 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -4320 0 0 {name=l1673 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1710 -4440 0 0 {name=x419}
C {devices/lab_wire.sym} 1640 -4560 2 1 {name=l1674 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -4570 1 1 {name=l1675 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -4570 3 0 {name=l1676 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -4320 0 0 {name=l1677 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1970 -4440 0 0 {name=x420}
C {devices/lab_wire.sym} 1900 -4560 2 1 {name=l1678 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -4570 1 1 {name=l1679 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -4570 3 0 {name=l1680 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -4320 0 0 {name=l1681 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2230 -4440 0 0 {name=x421}
C {devices/lab_wire.sym} 2160 -4560 2 1 {name=l1682 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -4570 1 1 {name=l1683 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -4570 3 0 {name=l1684 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -4320 0 0 {name=l1685 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2490 -4440 0 0 {name=x422}
C {devices/lab_wire.sym} 2420 -4560 2 1 {name=l1686 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -4570 1 1 {name=l1687 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -4570 3 0 {name=l1688 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -4320 0 0 {name=l1689 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2750 -4440 0 0 {name=x423}
C {devices/lab_wire.sym} 2680 -4560 2 1 {name=l1690 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -4570 1 1 {name=l1691 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -4570 3 0 {name=l1692 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -4320 0 0 {name=l1693 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3010 -4440 0 0 {name=x424}
C {devices/lab_wire.sym} 2940 -4560 2 1 {name=l1694 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -4570 1 1 {name=l1695 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -4570 3 0 {name=l1696 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -4320 0 0 {name=l1697 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3270 -4440 0 0 {name=x425}
C {devices/lab_wire.sym} 3200 -4560 2 1 {name=l1698 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -4570 1 1 {name=l1699 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -4570 3 0 {name=l1700 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -4320 0 0 {name=l1701 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3530 -4440 0 0 {name=x426}
C {devices/lab_wire.sym} 3460 -4560 2 1 {name=l1702 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -4570 1 1 {name=l1703 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -4570 3 0 {name=l1704 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -4320 0 0 {name=l1705 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3790 -4440 0 0 {name=x427}
C {devices/lab_wire.sym} 3720 -4560 2 1 {name=l1706 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -4570 1 1 {name=l1707 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -4570 3 0 {name=l1708 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -4320 0 0 {name=l1709 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4050 -4440 0 0 {name=x428}
C {devices/lab_wire.sym} 3980 -4560 2 1 {name=l1710 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -4570 1 1 {name=l1711 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -4570 3 0 {name=l1712 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -4320 0 0 {name=l1713 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4310 -4440 0 0 {name=x429}
C {devices/lab_wire.sym} 4240 -4560 2 1 {name=l1714 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -4570 1 1 {name=l1715 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -4570 3 0 {name=l1716 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -4320 0 0 {name=l1717 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4570 -4440 0 0 {name=x430}
C {devices/lab_wire.sym} 4500 -4560 2 1 {name=l1718 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -4570 1 1 {name=l1719 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -4570 3 0 {name=l1720 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -4320 0 0 {name=l1721 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4830 -4440 0 0 {name=x431}
C {devices/lab_wire.sym} 4760 -4560 2 1 {name=l1722 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -4570 1 1 {name=l1723 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -4570 3 0 {name=l1724 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -4320 0 0 {name=l1725 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5090 -4440 0 0 {name=x432}
C {devices/lab_wire.sym} 5020 -4560 2 1 {name=l1726 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -4570 1 1 {name=l1727 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -4570 3 0 {name=l1728 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -4320 0 0 {name=l1729 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5350 -4440 0 0 {name=x433}
C {devices/lab_wire.sym} 5280 -4560 2 1 {name=l1730 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -4570 1 1 {name=l1731 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -4570 3 0 {name=l1732 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -4320 0 0 {name=l1733 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5610 -4440 0 0 {name=x434}
C {devices/lab_wire.sym} 5540 -4560 2 1 {name=l1734 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -4570 1 1 {name=l1735 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -4570 3 0 {name=l1736 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -4320 0 0 {name=l1737 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5870 -4440 0 0 {name=x435}
C {devices/lab_wire.sym} 5800 -4560 2 1 {name=l1738 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -4570 1 1 {name=l1739 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -4570 3 0 {name=l1740 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -4320 0 0 {name=l1741 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6130 -4440 0 0 {name=x436}
C {devices/lab_wire.sym} 6060 -4560 2 1 {name=l1742 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -4570 1 1 {name=l1743 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -4570 3 0 {name=l1744 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -4320 0 0 {name=l1745 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6390 -4440 0 0 {name=x437}
C {devices/lab_wire.sym} 6320 -4560 2 1 {name=l1746 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -4570 1 1 {name=l1747 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -4570 3 0 {name=l1748 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -4320 0 0 {name=l1749 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6650 -4440 0 0 {name=x438}
C {devices/lab_wire.sym} 6580 -4560 2 1 {name=l1750 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -4570 1 1 {name=l1751 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -4570 3 0 {name=l1752 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -4320 0 0 {name=l1753 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6910 -4440 0 0 {name=x439}
C {devices/lab_wire.sym} 6840 -4560 2 1 {name=l1754 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -4570 1 1 {name=l1755 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -4570 3 0 {name=l1756 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -4320 0 0 {name=l1757 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7170 -4440 0 0 {name=x440}
C {devices/lab_wire.sym} 7100 -4560 2 1 {name=l1758 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -4570 1 1 {name=l1759 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -4570 3 0 {name=l1760 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -4320 0 0 {name=l1761 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7430 -4440 0 0 {name=x441}
C {devices/lab_wire.sym} 7360 -4560 2 1 {name=l1762 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -4570 1 1 {name=l1763 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -4570 3 0 {name=l1764 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -4320 0 0 {name=l1765 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7690 -4440 0 0 {name=x442}
C {devices/lab_wire.sym} 7620 -4560 2 1 {name=l1766 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -4570 1 1 {name=l1767 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -4570 3 0 {name=l1768 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -4320 0 0 {name=l1769 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7950 -4440 0 0 {name=x443}
C {devices/lab_wire.sym} 7880 -4560 2 1 {name=l1770 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -4570 1 1 {name=l1771 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -4570 3 0 {name=l1772 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -4320 0 0 {name=l1773 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8210 -4440 0 0 {name=x444}
C {devices/lab_wire.sym} 8140 -4560 2 1 {name=l1774 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -4570 1 1 {name=l1775 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -4570 3 0 {name=l1776 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -4320 0 0 {name=l1777 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8470 -4440 0 0 {name=x445}
C {devices/lab_wire.sym} 8400 -4560 2 1 {name=l1778 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -4570 1 1 {name=l1779 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -4570 3 0 {name=l1780 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -4320 0 0 {name=l1781 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8730 -4440 0 0 {name=x446}
C {devices/lab_wire.sym} 8660 -4560 2 1 {name=l1782 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -4570 1 1 {name=l1783 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -4570 3 0 {name=l1784 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -4320 0 0 {name=l1785 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8990 -4440 0 0 {name=x447}
C {devices/lab_wire.sym} 8920 -4560 2 1 {name=l1786 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -4570 1 1 {name=l1787 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -4570 3 0 {name=l1788 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -4320 0 0 {name=l1789 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 9250 -4440 0 0 {name=x448}
C {devices/lab_wire.sym} 9180 -4560 2 1 {name=l1790 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -4570 1 1 {name=l1791 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -4570 3 0 {name=l1792 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -4320 0 0 {name=l1793 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1190 -4700 0 0 {name=x449}
C {devices/lab_wire.sym} 1120 -4820 2 1 {name=l1794 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -4830 1 1 {name=l1795 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -4830 3 0 {name=l1796 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -4580 0 0 {name=l1797 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1450 -4700 0 0 {name=x450}
C {devices/lab_wire.sym} 1380 -4820 2 1 {name=l1798 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -4830 1 1 {name=l1799 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -4830 3 0 {name=l1800 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -4580 0 0 {name=l1801 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1710 -4700 0 0 {name=x451}
C {devices/lab_wire.sym} 1640 -4820 2 1 {name=l1802 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -4830 1 1 {name=l1803 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -4830 3 0 {name=l1804 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -4580 0 0 {name=l1805 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1970 -4700 0 0 {name=x452}
C {devices/lab_wire.sym} 1900 -4820 2 1 {name=l1806 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -4830 1 1 {name=l1807 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -4830 3 0 {name=l1808 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -4580 0 0 {name=l1809 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2230 -4700 0 0 {name=x453}
C {devices/lab_wire.sym} 2160 -4820 2 1 {name=l1810 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -4830 1 1 {name=l1811 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -4830 3 0 {name=l1812 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -4580 0 0 {name=l1813 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2490 -4700 0 0 {name=x454}
C {devices/lab_wire.sym} 2420 -4820 2 1 {name=l1814 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -4830 1 1 {name=l1815 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -4830 3 0 {name=l1816 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -4580 0 0 {name=l1817 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2750 -4700 0 0 {name=x455}
C {devices/lab_wire.sym} 2680 -4820 2 1 {name=l1818 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -4830 1 1 {name=l1819 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -4830 3 0 {name=l1820 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -4580 0 0 {name=l1821 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3010 -4700 0 0 {name=x456}
C {devices/lab_wire.sym} 2940 -4820 2 1 {name=l1822 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -4830 1 1 {name=l1823 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -4830 3 0 {name=l1824 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -4580 0 0 {name=l1825 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3270 -4700 0 0 {name=x457}
C {devices/lab_wire.sym} 3200 -4820 2 1 {name=l1826 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -4830 1 1 {name=l1827 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -4830 3 0 {name=l1828 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -4580 0 0 {name=l1829 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3530 -4700 0 0 {name=x458}
C {devices/lab_wire.sym} 3460 -4820 2 1 {name=l1830 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -4830 1 1 {name=l1831 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -4830 3 0 {name=l1832 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -4580 0 0 {name=l1833 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3790 -4700 0 0 {name=x459}
C {devices/lab_wire.sym} 3720 -4820 2 1 {name=l1834 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -4830 1 1 {name=l1835 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -4830 3 0 {name=l1836 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -4580 0 0 {name=l1837 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4050 -4700 0 0 {name=x460}
C {devices/lab_wire.sym} 3980 -4820 2 1 {name=l1838 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -4830 1 1 {name=l1839 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -4830 3 0 {name=l1840 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -4580 0 0 {name=l1841 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4310 -4700 0 0 {name=x461}
C {devices/lab_wire.sym} 4240 -4820 2 1 {name=l1842 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -4830 1 1 {name=l1843 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -4830 3 0 {name=l1844 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -4580 0 0 {name=l1845 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4570 -4700 0 0 {name=x462}
C {devices/lab_wire.sym} 4500 -4820 2 1 {name=l1846 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -4830 1 1 {name=l1847 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -4830 3 0 {name=l1848 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -4580 0 0 {name=l1849 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4830 -4700 0 0 {name=x463}
C {devices/lab_wire.sym} 4760 -4820 2 1 {name=l1850 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -4830 1 1 {name=l1851 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -4830 3 0 {name=l1852 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -4580 0 0 {name=l1853 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5090 -4700 0 0 {name=x464}
C {devices/lab_wire.sym} 5020 -4820 2 1 {name=l1854 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -4830 1 1 {name=l1855 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -4830 3 0 {name=l1856 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -4580 0 0 {name=l1857 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5350 -4700 0 0 {name=x465}
C {devices/lab_wire.sym} 5280 -4820 2 1 {name=l1858 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -4830 1 1 {name=l1859 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -4830 3 0 {name=l1860 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -4580 0 0 {name=l1861 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5610 -4700 0 0 {name=x466}
C {devices/lab_wire.sym} 5540 -4820 2 1 {name=l1862 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -4830 1 1 {name=l1863 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -4830 3 0 {name=l1864 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -4580 0 0 {name=l1865 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5870 -4700 0 0 {name=x467}
C {devices/lab_wire.sym} 5800 -4820 2 1 {name=l1866 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -4830 1 1 {name=l1867 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -4830 3 0 {name=l1868 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -4580 0 0 {name=l1869 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6130 -4700 0 0 {name=x468}
C {devices/lab_wire.sym} 6060 -4820 2 1 {name=l1870 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -4830 1 1 {name=l1871 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -4830 3 0 {name=l1872 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -4580 0 0 {name=l1873 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6390 -4700 0 0 {name=x469}
C {devices/lab_wire.sym} 6320 -4820 2 1 {name=l1874 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -4830 1 1 {name=l1875 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -4830 3 0 {name=l1876 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -4580 0 0 {name=l1877 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6650 -4700 0 0 {name=x470}
C {devices/lab_wire.sym} 6580 -4820 2 1 {name=l1878 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -4830 1 1 {name=l1879 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -4830 3 0 {name=l1880 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -4580 0 0 {name=l1881 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6910 -4700 0 0 {name=x471}
C {devices/lab_wire.sym} 6840 -4820 2 1 {name=l1882 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -4830 1 1 {name=l1883 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -4830 3 0 {name=l1884 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -4580 0 0 {name=l1885 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7170 -4700 0 0 {name=x472}
C {devices/lab_wire.sym} 7100 -4820 2 1 {name=l1886 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -4830 1 1 {name=l1887 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -4830 3 0 {name=l1888 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -4580 0 0 {name=l1889 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7430 -4700 0 0 {name=x473}
C {devices/lab_wire.sym} 7360 -4820 2 1 {name=l1890 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -4830 1 1 {name=l1891 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -4830 3 0 {name=l1892 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -4580 0 0 {name=l1893 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7690 -4700 0 0 {name=x474}
C {devices/lab_wire.sym} 7620 -4820 2 1 {name=l1894 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -4830 1 1 {name=l1895 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -4830 3 0 {name=l1896 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -4580 0 0 {name=l1897 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7950 -4700 0 0 {name=x475}
C {devices/lab_wire.sym} 7880 -4820 2 1 {name=l1898 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -4830 1 1 {name=l1899 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -4830 3 0 {name=l1900 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -4580 0 0 {name=l1901 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8210 -4700 0 0 {name=x476}
C {devices/lab_wire.sym} 8140 -4820 2 1 {name=l1902 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -4830 1 1 {name=l1903 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -4830 3 0 {name=l1904 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -4580 0 0 {name=l1905 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8470 -4700 0 0 {name=x477}
C {devices/lab_wire.sym} 8400 -4820 2 1 {name=l1906 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -4830 1 1 {name=l1907 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -4830 3 0 {name=l1908 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -4580 0 0 {name=l1909 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8730 -4700 0 0 {name=x478}
C {devices/lab_wire.sym} 8660 -4820 2 1 {name=l1910 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -4830 1 1 {name=l1911 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -4830 3 0 {name=l1912 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -4580 0 0 {name=l1913 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8990 -4700 0 0 {name=x479}
C {devices/lab_wire.sym} 8920 -4820 2 1 {name=l1914 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -4830 1 1 {name=l1915 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -4830 3 0 {name=l1916 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -4580 0 0 {name=l1917 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 9250 -4700 0 0 {name=x480}
C {devices/lab_wire.sym} 9180 -4820 2 1 {name=l1918 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -4830 1 1 {name=l1919 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -4830 3 0 {name=l1920 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -4580 0 0 {name=l1921 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1190 -4960 0 0 {name=x481}
C {devices/lab_wire.sym} 1120 -5080 2 1 {name=l1922 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -5090 1 1 {name=l1923 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1180 -5090 3 0 {name=l1924 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -4840 0 0 {name=l1925 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1450 -4960 0 0 {name=x482}
C {devices/lab_wire.sym} 1380 -5080 2 1 {name=l1926 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -5090 1 1 {name=l1927 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -5090 3 0 {name=l1928 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1380 -4840 0 0 {name=l1929 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1710 -4960 0 0 {name=x483}
C {devices/lab_wire.sym} 1640 -5080 2 1 {name=l1930 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -5090 1 1 {name=l1931 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1700 -5090 3 0 {name=l1932 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1640 -4840 0 0 {name=l1933 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 1970 -4960 0 0 {name=x484}
C {devices/lab_wire.sym} 1900 -5080 2 1 {name=l1934 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -5090 1 1 {name=l1935 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -5090 3 0 {name=l1936 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1900 -4840 0 0 {name=l1937 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2230 -4960 0 0 {name=x485}
C {devices/lab_wire.sym} 2160 -5080 2 1 {name=l1938 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -5090 1 1 {name=l1939 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2220 -5090 3 0 {name=l1940 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2160 -4840 0 0 {name=l1941 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2490 -4960 0 0 {name=x486}
C {devices/lab_wire.sym} 2420 -5080 2 1 {name=l1942 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -5090 1 1 {name=l1943 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -5090 3 0 {name=l1944 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2420 -4840 0 0 {name=l1945 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 2750 -4960 0 0 {name=x487}
C {devices/lab_wire.sym} 2680 -5080 2 1 {name=l1946 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -5090 1 1 {name=l1947 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2740 -5090 3 0 {name=l1948 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2680 -4840 0 0 {name=l1949 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3010 -4960 0 0 {name=x488}
C {devices/lab_wire.sym} 2940 -5080 2 1 {name=l1950 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -5090 1 1 {name=l1951 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -5090 3 0 {name=l1952 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2940 -4840 0 0 {name=l1953 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3270 -4960 0 0 {name=x489}
C {devices/lab_wire.sym} 3200 -5080 2 1 {name=l1954 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -5090 1 1 {name=l1955 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3260 -5090 3 0 {name=l1956 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3200 -4840 0 0 {name=l1957 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3530 -4960 0 0 {name=x490}
C {devices/lab_wire.sym} 3460 -5080 2 1 {name=l1958 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -5090 1 1 {name=l1959 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -5090 3 0 {name=l1960 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3460 -4840 0 0 {name=l1961 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 3790 -4960 0 0 {name=x491}
C {devices/lab_wire.sym} 3720 -5080 2 1 {name=l1962 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -5090 1 1 {name=l1963 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3780 -5090 3 0 {name=l1964 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3720 -4840 0 0 {name=l1965 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4050 -4960 0 0 {name=x492}
C {devices/lab_wire.sym} 3980 -5080 2 1 {name=l1966 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -5090 1 1 {name=l1967 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -5090 3 0 {name=l1968 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3980 -4840 0 0 {name=l1969 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4310 -4960 0 0 {name=x493}
C {devices/lab_wire.sym} 4240 -5080 2 1 {name=l1970 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -5090 1 1 {name=l1971 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4300 -5090 3 0 {name=l1972 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4240 -4840 0 0 {name=l1973 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4570 -4960 0 0 {name=x494}
C {devices/lab_wire.sym} 4500 -5080 2 1 {name=l1974 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -5090 1 1 {name=l1975 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -5090 3 0 {name=l1976 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4500 -4840 0 0 {name=l1977 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 4830 -4960 0 0 {name=x495}
C {devices/lab_wire.sym} 4760 -5080 2 1 {name=l1978 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -5090 1 1 {name=l1979 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4820 -5090 3 0 {name=l1980 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4760 -4840 0 0 {name=l1981 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5090 -4960 0 0 {name=x496}
C {devices/lab_wire.sym} 5020 -5080 2 1 {name=l1982 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -5090 1 1 {name=l1983 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -5090 3 0 {name=l1984 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5020 -4840 0 0 {name=l1985 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5350 -4960 0 0 {name=x497}
C {devices/lab_wire.sym} 5280 -5080 2 1 {name=l1986 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -5090 1 1 {name=l1987 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5340 -5090 3 0 {name=l1988 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5280 -4840 0 0 {name=l1989 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5610 -4960 0 0 {name=x498}
C {devices/lab_wire.sym} 5540 -5080 2 1 {name=l1990 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -5090 1 1 {name=l1991 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -5090 3 0 {name=l1992 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -4840 0 0 {name=l1993 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 5870 -4960 0 0 {name=x499}
C {devices/lab_wire.sym} 5800 -5080 2 1 {name=l1994 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -5090 1 1 {name=l1995 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5860 -5090 3 0 {name=l1996 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5800 -4840 0 0 {name=l1997 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6130 -4960 0 0 {name=x500}
C {devices/lab_wire.sym} 6060 -5080 2 1 {name=l1998 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -5090 1 1 {name=l1999 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -5090 3 0 {name=l2000 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6060 -4840 0 0 {name=l2001 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6390 -4960 0 0 {name=x501}
C {devices/lab_wire.sym} 6320 -5080 2 1 {name=l2002 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -5090 1 1 {name=l2003 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6380 -5090 3 0 {name=l2004 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6320 -4840 0 0 {name=l2005 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6650 -4960 0 0 {name=x502}
C {devices/lab_wire.sym} 6580 -5080 2 1 {name=l2006 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -5090 1 1 {name=l2007 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -5090 3 0 {name=l2008 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6580 -4840 0 0 {name=l2009 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 6910 -4960 0 0 {name=x503}
C {devices/lab_wire.sym} 6840 -5080 2 1 {name=l2010 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -5090 1 1 {name=l2011 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6900 -5090 3 0 {name=l2012 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6840 -4840 0 0 {name=l2013 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7170 -4960 0 0 {name=x504}
C {devices/lab_wire.sym} 7100 -5080 2 1 {name=l2014 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -5090 1 1 {name=l2015 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -5090 3 0 {name=l2016 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7100 -4840 0 0 {name=l2017 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7430 -4960 0 0 {name=x505}
C {devices/lab_wire.sym} 7360 -5080 2 1 {name=l2018 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -5090 1 1 {name=l2019 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7420 -5090 3 0 {name=l2020 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7360 -4840 0 0 {name=l2021 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7690 -4960 0 0 {name=x506}
C {devices/lab_wire.sym} 7620 -5080 2 1 {name=l2022 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -5090 1 1 {name=l2023 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -5090 3 0 {name=l2024 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7620 -4840 0 0 {name=l2025 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 7950 -4960 0 0 {name=x507}
C {devices/lab_wire.sym} 7880 -5080 2 1 {name=l2026 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -5090 1 1 {name=l2027 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7940 -5090 3 0 {name=l2028 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7880 -4840 0 0 {name=l2029 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8210 -4960 0 0 {name=x508}
C {devices/lab_wire.sym} 8140 -5080 2 1 {name=l2030 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -5090 1 1 {name=l2031 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -5090 3 0 {name=l2032 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8140 -4840 0 0 {name=l2033 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8470 -4960 0 0 {name=x509}
C {devices/lab_wire.sym} 8400 -5080 2 1 {name=l2034 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -5090 1 1 {name=l2035 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8460 -5090 3 0 {name=l2036 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8400 -4840 0 0 {name=l2037 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8730 -4960 0 0 {name=x510}
C {devices/lab_wire.sym} 8660 -5080 2 1 {name=l2038 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -5090 1 1 {name=l2039 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -5090 3 0 {name=l2040 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8660 -4840 0 0 {name=l2041 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 8990 -4960 0 0 {name=x511}
C {devices/lab_wire.sym} 8920 -5080 2 1 {name=l2042 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -5090 1 1 {name=l2043 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8980 -5090 3 0 {name=l2044 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8920 -4840 0 0 {name=l2045 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_8.sym} 9250 -4960 0 0 {name=x512}
C {devices/lab_wire.sym} 9180 -5080 2 1 {name=l2046 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -5090 1 1 {name=l2047 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -5090 3 0 {name=l2048 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 9180 -4840 0 0 {name=l2049 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6320 -5100 0 0 {name=l2133 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Drv.sym} 930 -1060 0 0 {name=x1025}
C {devices/lab_wire.sym} 860 -1180 2 1 {name=l4098 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -1190 1 1 {name=l4099 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -1190 3 0 {name=l4100 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -940 0 0 {name=l4101 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -1030 0 0 {name=l4102 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -1090 0 0 {name=l4105 sig_type=std_logic lab=col_n[0]}
C {devices/lab_wire.sym} 800 -1070 0 0 {name=l4104 sig_type=std_logic lab=colon_n[0]}
C {devices/lab_wire.sym} 800 -1050 0 0 {name=l4103 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Drv.sym} 930 -1320 0 0 {name=x1026}
C {devices/lab_wire.sym} 860 -1440 2 1 {name=l4106 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -1450 1 1 {name=l4107 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -1450 3 0 {name=l4108 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -1200 0 0 {name=l4109 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -1290 0 0 {name=l4110 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -1350 0 0 {name=l4111 sig_type=std_logic lab=col_n[1]}
C {devices/lab_wire.sym} 800 -1330 0 0 {name=l4112 sig_type=std_logic lab=colon_n[1]}
C {devices/lab_wire.sym} 800 -1310 0 0 {name=l4113 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Drv.sym} 930 -1580 0 0 {name=x1027}
C {devices/lab_wire.sym} 860 -1700 2 1 {name=l4114 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -1710 1 1 {name=l4115 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -1710 3 0 {name=l4116 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -1460 0 0 {name=l4117 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -1550 0 0 {name=l4118 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -1610 0 0 {name=l4119 sig_type=std_logic lab=col_n[2]}
C {devices/lab_wire.sym} 800 -1590 0 0 {name=l4120 sig_type=std_logic lab=colon_n[2]}
C {devices/lab_wire.sym} 800 -1570 0 0 {name=l4121 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Drv.sym} 930 -1840 0 0 {name=x1028}
C {devices/lab_wire.sym} 860 -1960 2 1 {name=l4122 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -1970 1 1 {name=l4123 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -1970 3 0 {name=l4124 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Drv.sym} 930 -2100 0 0 {name=x1029}
C {devices/lab_wire.sym} 860 -2220 2 1 {name=l4129 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -2230 1 1 {name=l4130 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -2230 3 0 {name=l4131 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -1980 0 0 {name=l4132 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -1810 0 0 {name=l4133 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -1870 0 0 {name=l4134 sig_type=std_logic lab=col_n[3]}
C {devices/lab_wire.sym} 800 -1850 0 0 {name=l4135 sig_type=std_logic lab=colon_n[3]}
C {devices/lab_wire.sym} 800 -1830 0 0 {name=l4136 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 860 -1720 0 0 {name=l4137 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Drv.sym} 930 -2360 0 0 {name=x1030}
C {devices/lab_wire.sym} 860 -2480 2 1 {name=l4138 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -2490 1 1 {name=l4139 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -2490 3 0 {name=l4140 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -2240 0 0 {name=l4141 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -2070 0 0 {name=l4142 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -2130 0 0 {name=l4143 sig_type=std_logic lab=col_n[4]}
C {devices/lab_wire.sym} 800 -2110 0 0 {name=l4144 sig_type=std_logic lab=colon_n[4]}
C {devices/lab_wire.sym} 800 -2090 0 0 {name=l4145 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Drv.sym} 930 -2620 0 0 {name=x1031}
C {devices/lab_wire.sym} 860 -2740 2 1 {name=l4146 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -2750 1 1 {name=l4147 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -2750 3 0 {name=l4148 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -2500 0 0 {name=l4149 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -2330 0 0 {name=l4150 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -2390 0 0 {name=l4151 sig_type=std_logic lab=col_n[5]}
C {devices/lab_wire.sym} 800 -2370 0 0 {name=l4152 sig_type=std_logic lab=colon_n[5]}
C {devices/lab_wire.sym} 800 -2350 0 0 {name=l4153 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Drv.sym} 930 -2880 0 0 {name=x1032}
C {devices/lab_wire.sym} 860 -3000 2 1 {name=l4154 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -3010 1 1 {name=l4155 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -3010 3 0 {name=l4156 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -2760 0 0 {name=l4157 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -2590 0 0 {name=l4158 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -2650 0 0 {name=l4159 sig_type=std_logic lab=col_n[6]}
C {devices/lab_wire.sym} 800 -2630 0 0 {name=l4160 sig_type=std_logic lab=colon_n[6]}
C {devices/lab_wire.sym} 800 -2610 0 0 {name=l4161 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Drv.sym} 930 -3140 0 0 {name=x1033}
C {devices/lab_wire.sym} 860 -3260 2 1 {name=l4162 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -3270 1 1 {name=l4163 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -3270 3 0 {name=l4164 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 800 -2850 0 0 {name=l4165 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -2910 0 0 {name=l4166 sig_type=std_logic lab=col_n[7]}
C {devices/lab_wire.sym} 800 -2890 0 0 {name=l4167 sig_type=std_logic lab=colon_n[7]}
C {devices/lab_wire.sym} 800 -2870 0 0 {name=l4168 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Drv.sym} 930 -3400 0 0 {name=x1034}
C {devices/lab_wire.sym} 860 -3520 2 1 {name=l4169 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -3530 1 1 {name=l4170 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -3530 3 0 {name=l4171 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -3280 0 0 {name=l4172 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -3110 0 0 {name=l4173 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -3170 0 0 {name=l4174 sig_type=std_logic lab=col_n[8]}
C {devices/lab_wire.sym} 800 -3150 0 0 {name=l4175 sig_type=std_logic lab=colon_n[8]}
C {devices/lab_wire.sym} 800 -3130 0 0 {name=l4176 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 860 -3020 0 0 {name=l4177 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Drv.sym} 930 -3660 0 0 {name=x1035}
C {devices/lab_wire.sym} 860 -3780 2 1 {name=l4178 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -3790 1 1 {name=l4179 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -3790 3 0 {name=l4180 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -3540 0 0 {name=l4181 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -3370 0 0 {name=l4182 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -3430 0 0 {name=l4183 sig_type=std_logic lab=col_n[9]}
C {devices/lab_wire.sym} 800 -3410 0 0 {name=l4184 sig_type=std_logic lab=colon_n[9]}
C {devices/lab_wire.sym} 800 -3390 0 0 {name=l4185 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Drv.sym} 930 -3920 0 0 {name=x1036}
C {devices/lab_wire.sym} 860 -4040 2 1 {name=l4186 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -4050 1 1 {name=l4187 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -4050 3 0 {name=l4188 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -3800 0 0 {name=l4189 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -3630 0 0 {name=l4190 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -3690 0 0 {name=l4191 sig_type=std_logic lab=col_n[10]}
C {devices/lab_wire.sym} 800 -3670 0 0 {name=l4192 sig_type=std_logic lab=colon_n[10]}
C {devices/lab_wire.sym} 800 -3650 0 0 {name=l4193 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Drv.sym} 930 -4180 0 0 {name=x1037}
C {devices/lab_wire.sym} 860 -4300 2 1 {name=l4194 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -4310 1 1 {name=l4195 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -4310 3 0 {name=l4196 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -4060 0 0 {name=l4197 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -3890 0 0 {name=l4198 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -3950 0 0 {name=l4199 sig_type=std_logic lab=col_n[11]}
C {devices/lab_wire.sym} 800 -3930 0 0 {name=l4200 sig_type=std_logic lab=colon_n[11]}
C {devices/lab_wire.sym} 800 -3910 0 0 {name=l4201 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Drv.sym} 930 -4440 0 0 {name=x1038}
C {devices/lab_wire.sym} 860 -4560 2 1 {name=l4202 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -4570 1 1 {name=l4203 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -4570 3 0 {name=l4204 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 800 -4150 0 0 {name=l4205 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -4210 0 0 {name=l4206 sig_type=std_logic lab=col_n[12]}
C {devices/lab_wire.sym} 800 -4190 0 0 {name=l4207 sig_type=std_logic lab=colon_n[12]}
C {devices/lab_wire.sym} 800 -4170 0 0 {name=l4208 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Drv.sym} 930 -4700 0 0 {name=x1039}
C {devices/lab_wire.sym} 860 -4820 2 1 {name=l4209 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -4830 1 1 {name=l4210 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -4830 3 0 {name=l4211 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -4580 0 0 {name=l4212 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -4410 0 0 {name=l4213 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -4470 0 0 {name=l4214 sig_type=std_logic lab=col_n[13]}
C {devices/lab_wire.sym} 800 -4450 0 0 {name=l4215 sig_type=std_logic lab=colon_n[13]}
C {devices/lab_wire.sym} 800 -4430 0 0 {name=l4216 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 860 -4320 0 0 {name=l4217 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Drv.sym} 930 -4960 0 0 {name=x1040}
C {devices/lab_wire.sym} 860 -5080 2 1 {name=l4218 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -5090 1 1 {name=l4219 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -5090 3 0 {name=l4220 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 860 -4840 0 0 {name=l4221 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -4670 0 0 {name=l4222 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -4730 0 0 {name=l4223 sig_type=std_logic lab=col_n[14]}
C {devices/lab_wire.sym} 800 -4710 0 0 {name=l4224 sig_type=std_logic lab=colon_n[14]}
C {devices/lab_wire.sym} 800 -4690 0 0 {name=l4225 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 800 -4930 0 0 {name=l4230 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -4990 0 0 {name=l4231 sig_type=std_logic lab=col_n[15]}
C {devices/lab_wire.sym} 800 -4970 0 0 {name=l4232 sig_type=std_logic lab=colon_n[15]}
C {devices/lab_wire.sym} 800 -4950 0 0 {name=l4233 sig_type=std_logic lab=sample}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 930 -800 0 0 {name=x1057}
C {devices/lab_wire.sym} 860 -680 0 0 {name=l4354 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 860 -920 2 1 {name=l4355 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -930 1 1 {name=l4356 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 1190 -800 0 0 {name=x1058}
C {devices/lab_wire.sym} 1120 -680 0 0 {name=l4359 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1120 -920 2 1 {name=l4360 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -930 1 1 {name=l4361 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1200 -670 3 0 {name=l4363 sig_type=std_logic lab=row_n[0]}
C {devices/lab_wire.sym} 920 -930 3 0 {name=l4357 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1180 -930 3 0 {name=l4362 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 1450 -800 0 0 {name=x1059}
C {devices/lab_wire.sym} 1380 -680 0 0 {name=l4364 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1380 -920 2 1 {name=l4365 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -930 1 1 {name=l4366 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1460 -670 3 0 {name=l4367 sig_type=std_logic lab=row_n[1]}
C {devices/lab_wire.sym} 1640 -680 0 0 {name=l4368 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1640 -920 2 1 {name=l4369 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -930 1 1 {name=l4370 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1720 -670 3 0 {name=l4371 sig_type=std_logic lab=row_n[2]}
C {devices/lab_wire.sym} 1440 -930 3 0 {name=l4372 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1700 -930 3 0 {name=l4373 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 1970 -800 0 0 {name=x1061}
C {devices/lab_wire.sym} 1900 -680 0 0 {name=l4374 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1900 -920 2 1 {name=l4375 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -930 1 1 {name=l4376 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1980 -670 3 0 {name=l4377 sig_type=std_logic lab=row_n[3]}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 2230 -800 0 0 {name=x1062}
C {devices/lab_wire.sym} 2160 -680 0 0 {name=l4378 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2160 -920 2 1 {name=l4379 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -930 1 1 {name=l4380 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2240 -670 3 0 {name=l4381 sig_type=std_logic lab=row_n[4]}
C {devices/lab_wire.sym} 1960 -930 3 0 {name=l4382 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2220 -930 3 0 {name=l4383 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 2490 -800 0 0 {name=x1063}
C {devices/lab_wire.sym} 2420 -680 0 0 {name=l4384 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2420 -920 2 1 {name=l4385 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -930 1 1 {name=l4386 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2500 -670 3 0 {name=l4387 sig_type=std_logic lab=row_n[5]}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 2750 -800 0 0 {name=x1064}
C {devices/lab_wire.sym} 2680 -680 0 0 {name=l4388 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2680 -920 2 1 {name=l4389 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -930 1 1 {name=l4390 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2760 -670 3 0 {name=l4391 sig_type=std_logic lab=row_n[6]}
C {devices/lab_wire.sym} 2480 -930 3 0 {name=l4392 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2740 -930 3 0 {name=l4393 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 3010 -800 0 0 {name=x1065}
C {devices/lab_wire.sym} 2940 -680 0 0 {name=l4394 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2940 -920 2 1 {name=l4395 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -930 1 1 {name=l4396 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3020 -670 3 0 {name=l4397 sig_type=std_logic lab=row_n[7]}
C {devices/lab_wire.sym} 3200 -680 0 0 {name=l4398 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3200 -920 2 1 {name=l4399 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -930 1 1 {name=l4400 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3280 -670 3 0 {name=l4401 sig_type=std_logic lab=row_n[8]}
C {devices/lab_wire.sym} 3000 -930 3 0 {name=l4402 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3260 -930 3 0 {name=l4403 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 3530 -800 0 0 {name=x1067}
C {devices/lab_wire.sym} 3460 -680 0 0 {name=l4404 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3460 -920 2 1 {name=l4405 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -930 1 1 {name=l4406 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3540 -670 3 0 {name=l4407 sig_type=std_logic lab=row_n[9]}
C {devices/lab_wire.sym} 3720 -680 0 0 {name=l4408 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3720 -920 2 1 {name=l4409 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -930 1 1 {name=l4410 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3800 -670 3 0 {name=l4411 sig_type=std_logic lab=row_n[10]}
C {devices/lab_wire.sym} 3520 -930 3 0 {name=l4412 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3780 -930 3 0 {name=l4413 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 4050 -800 0 0 {name=x1069}
C {devices/lab_wire.sym} 3980 -680 0 0 {name=l4414 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3980 -920 2 1 {name=l4415 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -930 1 1 {name=l4416 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4060 -670 3 0 {name=l4417 sig_type=std_logic lab=row_n[11]}
C {devices/lab_wire.sym} 4240 -680 0 0 {name=l4418 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4240 -920 2 1 {name=l4419 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -930 1 1 {name=l4420 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4320 -670 3 0 {name=l4421 sig_type=std_logic lab=row_n[12]}
C {devices/lab_wire.sym} 4040 -930 3 0 {name=l4422 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4300 -930 3 0 {name=l4423 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 4570 -800 0 0 {name=x1071}
C {devices/lab_wire.sym} 4500 -680 0 0 {name=l4424 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4500 -920 2 1 {name=l4425 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -930 1 1 {name=l4426 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4580 -670 3 0 {name=l4427 sig_type=std_logic lab=row_n[13]}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 4830 -800 0 0 {name=x1072}
C {devices/lab_wire.sym} 4760 -680 0 0 {name=l4428 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4760 -920 2 1 {name=l4429 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -930 1 1 {name=l4430 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4840 -670 3 0 {name=l4431 sig_type=std_logic lab=row_n[14]}
C {devices/lab_wire.sym} 4560 -930 3 0 {name=l4432 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4820 -930 3 0 {name=l4433 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 5090 -800 0 0 {name=x1073}
C {devices/lab_wire.sym} 5020 -680 0 0 {name=l4434 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5020 -920 2 1 {name=l4435 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -930 1 1 {name=l4436 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5100 -670 3 0 {name=l4437 sig_type=std_logic lab=row_n[15]}
C {devices/lab_wire.sym} 5280 -680 0 0 {name=l4438 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5280 -920 2 1 {name=l4439 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -930 1 1 {name=l4440 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5360 -670 3 0 {name=l4441 sig_type=std_logic lab=row_n[16]}
C {devices/lab_wire.sym} 5080 -930 3 0 {name=l4442 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5340 -930 3 0 {name=l4443 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 5610 -800 0 0 {name=x1075}
C {devices/lab_wire.sym} 5540 -680 0 0 {name=l4444 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5540 -920 2 1 {name=l4445 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -930 1 1 {name=l4446 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5620 -670 3 0 {name=l4447 sig_type=std_logic lab=row_n[17]}
C {devices/lab_wire.sym} 5800 -680 0 0 {name=l4448 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5800 -920 2 1 {name=l4449 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -930 1 1 {name=l4450 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5880 -670 3 0 {name=l4451 sig_type=std_logic lab=row_n[18]}
C {devices/lab_wire.sym} 5600 -930 3 0 {name=l4452 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5860 -930 3 0 {name=l4453 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 6130 -800 0 0 {name=x1077}
C {devices/lab_wire.sym} 6060 -680 0 0 {name=l4454 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6060 -920 2 1 {name=l4455 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -930 1 1 {name=l4456 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6140 -670 3 0 {name=l4457 sig_type=std_logic lab=row_n[19]}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 6390 -800 0 0 {name=x1078}
C {devices/lab_wire.sym} 6320 -680 0 0 {name=l4458 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6320 -920 2 1 {name=l4459 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -930 1 1 {name=l4460 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6400 -670 3 0 {name=l4461 sig_type=std_logic lab=row_n[20]}
C {devices/lab_wire.sym} 6120 -930 3 0 {name=l4462 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6380 -930 3 0 {name=l4463 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 6650 -800 0 0 {name=x1079}
C {devices/lab_wire.sym} 6580 -680 0 0 {name=l4464 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6580 -920 2 1 {name=l4465 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -930 1 1 {name=l4466 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6660 -670 3 0 {name=l4467 sig_type=std_logic lab=row_n[21]}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 6910 -800 0 0 {name=x1080}
C {devices/lab_wire.sym} 6840 -680 0 0 {name=l4468 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6840 -920 2 1 {name=l4469 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -930 1 1 {name=l4470 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6920 -670 3 0 {name=l4471 sig_type=std_logic lab=row_n[22]}
C {devices/lab_wire.sym} 6640 -930 3 0 {name=l4472 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6900 -930 3 0 {name=l4473 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 7170 -800 0 0 {name=x1081}
C {devices/lab_wire.sym} 7100 -680 0 0 {name=l4474 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 7100 -920 2 1 {name=l4475 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -930 1 1 {name=l4476 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7180 -670 3 0 {name=l4477 sig_type=std_logic lab=row_n[23]}
C {devices/lab_wire.sym} 7360 -680 0 0 {name=l4478 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 7360 -920 2 1 {name=l4479 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -930 1 1 {name=l4480 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7440 -670 3 0 {name=l4481 sig_type=std_logic lab=row_n[24]}
C {devices/lab_wire.sym} 7160 -930 3 0 {name=l4482 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7420 -930 3 0 {name=l4483 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 7690 -800 0 0 {name=x1083}
C {devices/lab_wire.sym} 7620 -680 0 0 {name=l4484 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 7620 -920 2 1 {name=l4485 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -930 1 1 {name=l4486 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7700 -670 3 0 {name=l4487 sig_type=std_logic lab=row_n[25]}
C {devices/lab_wire.sym} 7880 -680 0 0 {name=l4488 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 7880 -920 2 1 {name=l4489 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -930 1 1 {name=l4490 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7960 -670 3 0 {name=l4491 sig_type=std_logic lab=row_n[26]}
C {devices/lab_wire.sym} 7680 -930 3 0 {name=l4492 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7940 -930 3 0 {name=l4493 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 8210 -800 0 0 {name=x1085}
C {devices/lab_wire.sym} 8140 -680 0 0 {name=l4494 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8140 -920 2 1 {name=l4495 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -930 1 1 {name=l4496 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8220 -670 3 0 {name=l4497 sig_type=std_logic lab=row_n[27]}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 8470 -800 0 0 {name=x1086}
C {devices/lab_wire.sym} 8400 -680 0 0 {name=l4498 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8400 -920 2 1 {name=l4499 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -930 1 1 {name=l4500 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8480 -670 3 0 {name=l4501 sig_type=std_logic lab=row_n[28]}
C {devices/lab_wire.sym} 8200 -930 3 0 {name=l4502 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8460 -930 3 0 {name=l4503 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 8730 -800 0 0 {name=x1087}
C {devices/lab_wire.sym} 8660 -680 0 0 {name=l4504 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8660 -920 2 1 {name=l4505 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -930 1 1 {name=l4506 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8740 -670 3 0 {name=l4507 sig_type=std_logic lab=row_n[29]}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 8990 -800 0 0 {name=x1088}
C {devices/lab_wire.sym} 8920 -680 0 0 {name=l4508 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8920 -920 2 1 {name=l4509 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -930 1 1 {name=l4510 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9000 -670 3 0 {name=l4511 sig_type=std_logic lab=row_n[30]}
C {devices/lab_wire.sym} 8720 -930 3 0 {name=l4512 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8980 -930 3 0 {name=l4513 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 9250 -800 0 0 {name=x1089}
C {devices/lab_wire.sym} 9180 -680 0 0 {name=l4514 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9180 -920 2 1 {name=l4515 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -930 1 1 {name=l4516 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9260 -670 3 0 {name=l4517 sig_type=std_logic lab=row_n[31]}
C {devices/lab_wire.sym} 9240 -930 3 0 {name=l4518 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 9510 -800 0 0 {name=x1090}
C {devices/lab_wire.sym} 9440 -680 0 0 {name=l4519 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -920 2 1 {name=l4520 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -930 1 1 {name=l4521 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9520 -670 3 0 {name=l4522 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9500 -930 3 0 {name=l4523 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 930 -5220 0 0 {name=x1091}
C {devices/lab_wire.sym} 860 -5100 0 0 {name=l4524 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 860 -5340 2 1 {name=l4525 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -5350 1 1 {name=l4526 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 1190 -5220 0 0 {name=x1092}
C {devices/lab_wire.sym} 1120 -5100 0 0 {name=l4528 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1120 -5340 2 1 {name=l4529 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -5350 1 1 {name=l4530 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 920 -5350 3 0 {name=l4532 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1180 -5350 3 0 {name=l4533 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 1450 -5220 0 0 {name=x1093}
C {devices/lab_wire.sym} 1380 -5100 0 0 {name=l4534 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1380 -5340 2 1 {name=l4535 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1400 -5350 1 1 {name=l4536 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 1710 -5220 0 0 {name=x1094}
C {devices/lab_wire.sym} 1640 -5100 0 0 {name=l4538 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1640 -5340 2 1 {name=l4539 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 -5350 1 1 {name=l4540 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1440 -5350 3 0 {name=l4542 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1700 -5350 3 0 {name=l4543 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 1970 -5220 0 0 {name=x1095}
C {devices/lab_wire.sym} 1900 -5100 0 0 {name=l4544 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1900 -5340 2 1 {name=l4545 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1920 -5350 1 1 {name=l4546 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 2230 -5220 0 0 {name=x1096}
C {devices/lab_wire.sym} 2160 -5100 0 0 {name=l4548 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2160 -5340 2 1 {name=l4549 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2180 -5350 1 1 {name=l4550 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 1960 -5350 3 0 {name=l4552 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2220 -5350 3 0 {name=l4553 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 2490 -5220 0 0 {name=x1097}
C {devices/lab_wire.sym} 2420 -5100 0 0 {name=l4554 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2420 -5340 2 1 {name=l4555 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2440 -5350 1 1 {name=l4556 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 2750 -5220 0 0 {name=x1098}
C {devices/lab_wire.sym} 2680 -5100 0 0 {name=l4558 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2680 -5340 2 1 {name=l4559 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2700 -5350 1 1 {name=l4560 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 2480 -5350 3 0 {name=l4562 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2740 -5350 3 0 {name=l4563 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 3010 -5220 0 0 {name=x1099}
C {devices/lab_wire.sym} 2940 -5100 0 0 {name=l4564 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2940 -5340 2 1 {name=l4565 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -5350 1 1 {name=l4566 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 3270 -5220 0 0 {name=x1100}
C {devices/lab_wire.sym} 3200 -5100 0 0 {name=l4568 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3200 -5340 2 1 {name=l4569 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3220 -5350 1 1 {name=l4570 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3000 -5350 3 0 {name=l4572 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3260 -5350 3 0 {name=l4573 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 3530 -5220 0 0 {name=x1101}
C {devices/lab_wire.sym} 3460 -5100 0 0 {name=l4574 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3460 -5340 2 1 {name=l4575 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3480 -5350 1 1 {name=l4576 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 3790 -5220 0 0 {name=x1102}
C {devices/lab_wire.sym} 3720 -5100 0 0 {name=l4578 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3720 -5340 2 1 {name=l4579 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -5350 1 1 {name=l4580 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 3520 -5350 3 0 {name=l4582 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3780 -5350 3 0 {name=l4583 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 4050 -5220 0 0 {name=x1103}
C {devices/lab_wire.sym} 3980 -5100 0 0 {name=l4584 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3980 -5340 2 1 {name=l4585 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4000 -5350 1 1 {name=l4586 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 4310 -5220 0 0 {name=x1104}
C {devices/lab_wire.sym} 4240 -5100 0 0 {name=l4588 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4240 -5340 2 1 {name=l4589 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -5350 1 1 {name=l4590 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4040 -5350 3 0 {name=l4592 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4300 -5350 3 0 {name=l4593 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 4570 -5220 0 0 {name=x1105}
C {devices/lab_wire.sym} 4500 -5100 0 0 {name=l4594 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4500 -5340 2 1 {name=l4595 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -5350 1 1 {name=l4596 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 4830 -5220 0 0 {name=x1106}
C {devices/lab_wire.sym} 4760 -5100 0 0 {name=l4598 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4760 -5340 2 1 {name=l4599 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4780 -5350 1 1 {name=l4600 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 4560 -5350 3 0 {name=l4602 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4820 -5350 3 0 {name=l4603 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 5090 -5220 0 0 {name=x1107}
C {devices/lab_wire.sym} 5020 -5100 0 0 {name=l4604 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5020 -5340 2 1 {name=l4605 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5040 -5350 1 1 {name=l4606 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 5350 -5220 0 0 {name=x1108}
C {devices/lab_wire.sym} 5280 -5100 0 0 {name=l4608 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5280 -5340 2 1 {name=l4609 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5300 -5350 1 1 {name=l4610 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5080 -5350 3 0 {name=l4612 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5340 -5350 3 0 {name=l4613 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 5610 -5220 0 0 {name=x1109}
C {devices/lab_wire.sym} 5540 -5100 0 0 {name=l4614 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5540 -5340 2 1 {name=l4615 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -5350 1 1 {name=l4616 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 5870 -5220 0 0 {name=x1110}
C {devices/lab_wire.sym} 5800 -5100 0 0 {name=l4618 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5800 -5340 2 1 {name=l4619 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5820 -5350 1 1 {name=l4620 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 5600 -5350 3 0 {name=l4622 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5860 -5350 3 0 {name=l4623 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 6130 -5220 0 0 {name=x1111}
C {devices/lab_wire.sym} 6060 -5100 0 0 {name=l4624 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6060 -5340 2 1 {name=l4625 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6080 -5350 1 1 {name=l4626 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 6390 -5220 0 0 {name=x1112}
C {devices/lab_wire.sym} 6320 -5100 0 0 {name=l4628 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6320 -5340 2 1 {name=l4629 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6340 -5350 1 1 {name=l4630 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6120 -5350 3 0 {name=l4632 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6380 -5350 3 0 {name=l4633 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 6650 -5220 0 0 {name=x1113}
C {devices/lab_wire.sym} 6580 -5100 0 0 {name=l4634 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6580 -5340 2 1 {name=l4635 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6600 -5350 1 1 {name=l4636 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 6910 -5220 0 0 {name=x1114}
C {devices/lab_wire.sym} 6840 -5100 0 0 {name=l4638 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6840 -5340 2 1 {name=l4639 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6860 -5350 1 1 {name=l4640 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 6640 -5350 3 0 {name=l4642 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6900 -5350 3 0 {name=l4643 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 7170 -5220 0 0 {name=x1115}
C {devices/lab_wire.sym} 7100 -5100 0 0 {name=l4644 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 7100 -5340 2 1 {name=l4645 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7120 -5350 1 1 {name=l4646 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 7430 -5220 0 0 {name=x1116}
C {devices/lab_wire.sym} 7360 -5100 0 0 {name=l4648 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 7360 -5340 2 1 {name=l4649 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7380 -5350 1 1 {name=l4650 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7160 -5350 3 0 {name=l4652 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7420 -5350 3 0 {name=l4653 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 7690 -5220 0 0 {name=x1117}
C {devices/lab_wire.sym} 7620 -5100 0 0 {name=l4654 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 7620 -5340 2 1 {name=l4655 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -5350 1 1 {name=l4656 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 7950 -5220 0 0 {name=x1118}
C {devices/lab_wire.sym} 7880 -5100 0 0 {name=l4658 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 7880 -5340 2 1 {name=l4659 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7900 -5350 1 1 {name=l4660 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 7680 -5350 3 0 {name=l4662 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7940 -5350 3 0 {name=l4663 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 8210 -5220 0 0 {name=x1119}
C {devices/lab_wire.sym} 8140 -5100 0 0 {name=l4664 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8140 -5340 2 1 {name=l4665 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8160 -5350 1 1 {name=l4666 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 8470 -5220 0 0 {name=x1120}
C {devices/lab_wire.sym} 8400 -5100 0 0 {name=l4668 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8400 -5340 2 1 {name=l4669 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8420 -5350 1 1 {name=l4670 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8200 -5350 3 0 {name=l4672 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8460 -5350 3 0 {name=l4673 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 8730 -5220 0 0 {name=x1121}
C {devices/lab_wire.sym} 8660 -5100 0 0 {name=l4674 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8660 -5340 2 1 {name=l4675 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8680 -5350 1 1 {name=l4676 sig_type=std_logic lab=vcom}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 8990 -5220 0 0 {name=x1122}
C {devices/lab_wire.sym} 8920 -5100 0 0 {name=l4678 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8920 -5340 2 1 {name=l4679 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -5350 1 1 {name=l4680 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 8720 -5350 3 0 {name=l4682 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8980 -5350 3 0 {name=l4683 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 9250 -5220 0 0 {name=x1123}
C {devices/lab_wire.sym} 9180 -5100 0 0 {name=l4684 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9180 -5340 2 1 {name=l4685 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9200 -5350 1 1 {name=l4686 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9240 -5350 3 0 {name=l4688 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 9510 -5220 0 0 {name=x1124}
C {devices/lab_wire.sym} 9440 -5100 0 0 {name=l4689 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -5340 2 1 {name=l4690 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -5350 1 1 {name=l4691 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -5350 3 0 {name=l4693 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 9510 -1060 0 0 {name=x1125}
C {devices/lab_wire.sym} 9440 -1180 2 1 {name=l4527 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -1190 1 1 {name=l4531 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -1190 3 0 {name=l4537 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 9510 -1320 0 0 {name=x1126}
C {devices/lab_wire.sym} 9440 -1440 2 1 {name=l4541 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -1450 1 1 {name=l4557 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -1450 3 0 {name=l4561 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 9510 -1580 0 0 {name=x1127}
C {devices/lab_wire.sym} 9440 -1700 2 1 {name=l4567 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -1710 1 1 {name=l4571 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -1710 3 0 {name=l4577 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 9510 -1840 0 0 {name=x1128}
C {devices/lab_wire.sym} 9440 -1960 2 1 {name=l4581 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -1970 1 1 {name=l4587 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -1970 3 0 {name=l4591 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 9510 -2100 0 0 {name=x1129}
C {devices/lab_wire.sym} 9440 -2220 2 1 {name=l4547 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -2230 1 1 {name=l4551 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -2230 3 0 {name=l4597 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 9510 -2360 0 0 {name=x1130}
C {devices/lab_wire.sym} 9440 -2480 2 1 {name=l4601 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -2490 1 1 {name=l4607 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -2490 3 0 {name=l4611 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 9510 -2620 0 0 {name=x1131}
C {devices/lab_wire.sym} 9440 -2740 2 1 {name=l4617 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -2750 1 1 {name=l4621 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -2750 3 0 {name=l4627 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 9510 -2880 0 0 {name=x1132}
C {devices/lab_wire.sym} 9440 -3000 2 1 {name=l4631 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -3010 1 1 {name=l4637 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -3010 3 0 {name=l4641 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 9510 -3140 0 0 {name=x1133}
C {devices/lab_wire.sym} 9440 -3260 2 1 {name=l4647 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -3270 1 1 {name=l4651 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -3270 3 0 {name=l4657 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 9510 -3400 0 0 {name=x1134}
C {devices/lab_wire.sym} 9440 -3520 2 1 {name=l4661 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -3530 1 1 {name=l4667 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -3530 3 0 {name=l4671 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 9510 -3660 0 0 {name=x1135}
C {devices/lab_wire.sym} 9440 -3780 2 1 {name=l4677 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -3790 1 1 {name=l4681 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -3790 3 0 {name=l4687 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 9510 -3920 0 0 {name=x1136}
C {devices/lab_wire.sym} 9440 -4040 2 1 {name=l4692 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -4050 1 1 {name=l4694 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -4050 3 0 {name=l4695 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 9510 -4180 0 0 {name=x1137}
C {devices/lab_wire.sym} 9440 -4300 2 1 {name=l4696 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -4310 1 1 {name=l4697 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -4310 3 0 {name=l4698 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 9510 -4440 0 0 {name=x1138}
C {devices/lab_wire.sym} 9440 -4560 2 1 {name=l4699 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -4570 1 1 {name=l4700 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -4570 3 0 {name=l4701 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 9510 -4700 0 0 {name=x1139}
C {devices/lab_wire.sym} 9440 -4820 2 1 {name=l4702 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -4830 1 1 {name=l4703 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -4830 3 0 {name=l4704 sig_type=std_logic lab=ctop}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 9510 -4960 0 0 {name=x1140}
C {devices/lab_wire.sym} 9440 -5080 2 1 {name=l4705 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9460 -5090 1 1 {name=l4706 sig_type=std_logic lab=vcom}
C {devices/lab_wire.sym} 9500 -5090 3 0 {name=l4707 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 800 -770 0 0 {name=l4758 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 800 -790 0 0 {name=l4759 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -5250 0 0 {name=l4760 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 800 -5230 0 0 {name=l4761 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 800 -5190 0 0 {name=l4762 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 800 -5210 0 0 {name=l4763 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 940 -680 0 0 {name=l4358 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9440 -940 0 0 {name=l4764 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -1200 0 0 {name=l4765 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -1460 0 0 {name=l4766 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -1720 0 0 {name=l4767 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -1980 0 0 {name=l4768 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -2240 0 0 {name=l4769 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -2500 0 0 {name=l4770 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -2760 0 0 {name=l4771 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -3020 0 0 {name=l4772 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -3280 0 0 {name=l4773 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -3540 0 0 {name=l4774 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -3800 0 0 {name=l4775 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -4060 0 0 {name=l4776 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -4320 0 0 {name=l4777 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -4580 0 0 {name=l4778 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9440 -4840 0 0 {name=l4779 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 7390 -680 3 0 {name=l4796 sig_type=std_logic lab=en_n_bit[0]}
C {devices/lab_wire.sym} 5310 -670 3 0 {name=l4797 sig_type=std_logic lab=en_n_bit[1]}
C {devices/lab_wire.sym} 3230 -670 3 0 {name=l4798 sig_type=std_logic lab=en_n_bit[2]}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 1710 -800 0 0 {name=x513}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 3790 -800 0 0 {name=x514}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 5870 -800 0 0 {name=x515}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Dummy.sym} 7950 -800 0 0 {name=x516}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_4.sym} 3270 -800 0 0 {name=x517}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_2.sym} 5350 -800 0 0 {name=x518}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_1.sym} 7430 -800 0 0 {name=x519}
C {devices/lab_wire.sym} 800 -810 0 0 {name=l2050 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -830 0 0 {name=l2051 sig_type=std_logic lab=VSS}
C {/foss/designs/SKY130_SAR-ADC/xschem/adc_array_cap/adc_array_wafflecap_8_Gate.sym} 4310 -800 0 0 {name=x520}
C {devices/lab_wire.sym} 4340 -670 3 0 {name=l2052 sig_type=std_logic lab=sw}
C {devices/lab_wire.sym} 4360 -670 3 0 {name=l2053 sig_type=std_logic lab=analog_in}
C {devices/lab_wire.sym} 4380 -670 3 0 {name=l2054 sig_type=std_logic lab=sw_in}
C {devices/ipin.sym} 200 -390 0 0 {name=p8 lab=analog_in}
C {devices/ipin.sym} 200 -370 0 0 {name=p11 lab=sw}
C {devices/ipin.sym} 200 -350 0 0 {name=p12 lab=sw_n}
C {devices/iopin.sym} 300 -630 0 0 {name=p14 lab=ctop}
