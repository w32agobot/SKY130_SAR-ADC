N 8120 -3930 8130 -3940 {
lab=row_n[10]}
N 8130 -3940 8330 -3940 {
lab=row_n[10]}
N 8330 -3940 8340 -3930 {
lab=row_n[10]}
N 8120 -3910 8130 -3920 {
lab=rowon_n[10]}
N 8130 -3920 8330 -3920 {
lab=rowon_n[10]}
N 8330 -3920 8340 -3910 {
lab=rowon_n[10]}
N 8120 -3890 8130 -3900 {
lab=#net21}
N 8130 -3900 8330 -3900 {
lab=#net21}
N 8330 -3900 8340 -3890 {
lab=#net21}
N 8120 -3870 8130 -3880 {
lab=#net22}
N 8130 -3880 8330 -3880 {
lab=#net22}
N 8330 -3880 8340 -3870 {
lab=#net22}
N 8180 -4030 8180 -4010 {
lab=vcm}
N 8220 -4030 8220 -4010 {
lab=ctop}
N 8100 -3930 8120 -3930 {
lab=row_n[10]}
N 8100 -3910 8120 -3910 {
lab=rowon_n[10]}
N 8100 -3890 8120 -3890 {
lab=#net21}
N 8100 -3870 8120 -3870 {
lab=#net22}
N 8340 -3870 8360 -3870 {
lab=#net22}
N 8340 -3890 8360 -3890 {
lab=#net21}
N 8340 -3910 8360 -3910 {
lab=rowon_n[10]}
N 8340 -3930 8360 -3930 {
lab=row_n[10]}
N 8160 -3790 8160 -3780 {
lab=VSS}
N 8160 -4020 8160 -4010 {
lab=VDD}
N 8500 -3790 8510 -3800 {
lab=col_n[30]}
N 8510 -4000 8510 -3800 {
lab=col_n[30]}
N 8500 -4010 8510 -4000 {
lab=col_n[30]}
N 8500 -3790 8500 -3770 {
lab=col_n[30]}
N 8500 -4030 8500 -4010 {
lab=col_n[30]}
N 8380 -3930 8390 -3940 {
lab=row_n[10]}
N 8390 -3940 8590 -3940 {
lab=row_n[10]}
N 8590 -3940 8600 -3930 {
lab=row_n[10]}
N 8380 -3910 8390 -3920 {
lab=rowon_n[10]}
N 8390 -3920 8590 -3920 {
lab=rowon_n[10]}
N 8590 -3920 8600 -3910 {
lab=rowon_n[10]}
N 8380 -3890 8390 -3900 {
lab=#net21}
N 8390 -3900 8590 -3900 {
lab=#net21}
N 8590 -3900 8600 -3890 {
lab=#net21}
N 8380 -3870 8390 -3880 {
lab=#net22}
N 8390 -3880 8590 -3880 {
lab=#net22}
N 8590 -3880 8600 -3870 {
lab=#net22}
N 8440 -4030 8440 -4010 {
lab=vcm}
N 8480 -4030 8480 -4010 {
lab=ctop}
N 8360 -3930 8380 -3930 {
lab=row_n[10]}
N 8360 -3910 8380 -3910 {
lab=rowon_n[10]}
N 8360 -3890 8380 -3890 {
lab=#net21}
N 8360 -3870 8380 -3870 {
lab=#net22}
N 8600 -3870 8620 -3870 {
lab=#net22}
N 8600 -3890 8620 -3890 {
lab=#net21}
N 8600 -3910 8620 -3910 {
lab=rowon_n[10]}
N 8600 -3930 8620 -3930 {
lab=row_n[10]}
N 8420 -3790 8420 -3780 {
lab=VSS}
N 8420 -4020 8420 -4010 {
lab=VDD}
N 8760 -3790 8770 -3800 {
lab=col_n[31]}
N 8770 -4000 8770 -3800 {
lab=col_n[31]}
N 8760 -4010 8770 -4000 {
lab=col_n[31]}
N 8760 -3790 8760 -3770 {
lab=col_n[31]}
N 8760 -4030 8760 -4010 {
lab=col_n[31]}
N 8640 -3930 8650 -3940 {
lab=row_n[10]}
N 8650 -3940 8850 -3940 {
lab=row_n[10]}
N 8850 -3940 8860 -3930 {
lab=row_n[10]}
N 8640 -3910 8650 -3920 {
lab=rowon_n[10]}
N 8650 -3920 8850 -3920 {
lab=rowon_n[10]}
N 8850 -3920 8860 -3910 {
lab=rowon_n[10]}
N 8640 -3890 8650 -3900 {
lab=#net21}
N 8650 -3900 8850 -3900 {
lab=#net21}
N 8850 -3900 8860 -3890 {
lab=#net21}
N 8640 -3870 8650 -3880 {
lab=#net22}
N 8650 -3880 8850 -3880 {
lab=#net22}
N 8850 -3880 8860 -3870 {
lab=#net22}
N 8700 -4030 8700 -4010 {
lab=vcm}
N 8740 -4030 8740 -4010 {
lab=ctop}
N 8620 -3930 8640 -3930 {
lab=row_n[10]}
N 8620 -3910 8640 -3910 {
lab=rowon_n[10]}
N 8620 -3890 8640 -3890 {
lab=#net21}
N 8620 -3870 8640 -3870 {
lab=#net22}
N 8860 -3870 8880 -3870 {
lab=#net22}
N 8860 -3890 8880 -3890 {
lab=#net21}
N 8860 -3910 8880 -3910 {
lab=rowon_n[10]}
N 8860 -3930 8880 -3930 {
lab=row_n[10]}
N 8680 -3790 8680 -3780 {
lab=VSS}
N 8680 -4020 8680 -4010 {
lab=VDD}
N 700 -4050 710 -4060 {
lab=col_n[0]}
N 710 -4260 710 -4060 {
lab=col_n[0]}
N 700 -4270 710 -4260 {
lab=col_n[0]}
N 700 -4050 700 -4030 {
lab=col_n[0]}
N 700 -4290 700 -4270 {
lab=col_n[0]}
N 580 -4190 590 -4200 {
lab=row_n[11]}
N 590 -4200 790 -4200 {
lab=row_n[11]}
N 790 -4200 800 -4190 {
lab=row_n[11]}
N 580 -4170 590 -4180 {
lab=rowon_n[11]}
N 590 -4180 790 -4180 {
lab=rowon_n[11]}
N 790 -4180 800 -4170 {
lab=rowon_n[11]}
N 580 -4150 590 -4160 {
lab=#net23}
N 590 -4160 790 -4160 {
lab=#net23}
N 790 -4160 800 -4150 {
lab=#net23}
N 580 -4130 590 -4140 {
lab=#net24}
N 590 -4140 790 -4140 {
lab=#net24}
N 790 -4140 800 -4130 {
lab=#net24}
N 640 -4290 640 -4270 {
lab=vcm}
N 680 -4290 680 -4270 {
lab=ctop}
N 560 -4190 580 -4190 {
lab=row_n[11]}
N 560 -4170 580 -4170 {
lab=rowon_n[11]}
N 560 -4150 580 -4150 {
lab=#net23}
N 560 -4130 580 -4130 {
lab=#net24}
N 800 -4130 820 -4130 {
lab=#net24}
N 800 -4150 820 -4150 {
lab=#net23}
N 800 -4170 820 -4170 {
lab=rowon_n[11]}
N 800 -4190 820 -4190 {
lab=row_n[11]}
N 620 -4050 620 -4040 {
lab=VSS}
N 620 -4280 620 -4270 {
lab=VDD}
N 960 -4050 970 -4060 {
lab=col_n[1]}
N 970 -4260 970 -4060 {
lab=col_n[1]}
N 960 -4270 970 -4260 {
lab=col_n[1]}
N 960 -4050 960 -4030 {
lab=col_n[1]}
N 960 -4290 960 -4270 {
lab=col_n[1]}
N 840 -4190 850 -4200 {
lab=row_n[11]}
N 850 -4200 1050 -4200 {
lab=row_n[11]}
N 1050 -4200 1060 -4190 {
lab=row_n[11]}
N 840 -4170 850 -4180 {
lab=rowon_n[11]}
N 850 -4180 1050 -4180 {
lab=rowon_n[11]}
N 1050 -4180 1060 -4170 {
lab=rowon_n[11]}
N 840 -4150 850 -4160 {
lab=#net23}
N 850 -4160 1050 -4160 {
lab=#net23}
N 1050 -4160 1060 -4150 {
lab=#net23}
N 840 -4130 850 -4140 {
lab=#net24}
N 850 -4140 1050 -4140 {
lab=#net24}
N 1050 -4140 1060 -4130 {
lab=#net24}
N 900 -4290 900 -4270 {
lab=vcm}
N 940 -4290 940 -4270 {
lab=ctop}
N 820 -4190 840 -4190 {
lab=row_n[11]}
N 820 -4170 840 -4170 {
lab=rowon_n[11]}
N 820 -4150 840 -4150 {
lab=#net23}
N 820 -4130 840 -4130 {
lab=#net24}
N 1060 -4130 1080 -4130 {
lab=#net24}
N 1060 -4150 1080 -4150 {
lab=#net23}
N 1060 -4170 1080 -4170 {
lab=rowon_n[11]}
N 1060 -4190 1080 -4190 {
lab=row_n[11]}
N 880 -4050 880 -4040 {
lab=VSS}
N 880 -4280 880 -4270 {
lab=VDD}
N 1220 -4050 1230 -4060 {
lab=col_n[2]}
N 1230 -4260 1230 -4060 {
lab=col_n[2]}
N 1220 -4270 1230 -4260 {
lab=col_n[2]}
N 1220 -4050 1220 -4030 {
lab=col_n[2]}
N 1220 -4290 1220 -4270 {
lab=col_n[2]}
N 1100 -4190 1110 -4200 {
lab=row_n[11]}
N 1110 -4200 1310 -4200 {
lab=row_n[11]}
N 1310 -4200 1320 -4190 {
lab=row_n[11]}
N 1100 -4170 1110 -4180 {
lab=rowon_n[11]}
N 1110 -4180 1310 -4180 {
lab=rowon_n[11]}
N 1310 -4180 1320 -4170 {
lab=rowon_n[11]}
N 1100 -4150 1110 -4160 {
lab=#net23}
N 1110 -4160 1310 -4160 {
lab=#net23}
N 1310 -4160 1320 -4150 {
lab=#net23}
N 1100 -4130 1110 -4140 {
lab=#net24}
N 1110 -4140 1310 -4140 {
lab=#net24}
N 1310 -4140 1320 -4130 {
lab=#net24}
N 1160 -4290 1160 -4270 {
lab=vcm}
N 1200 -4290 1200 -4270 {
lab=ctop}
N 1080 -4190 1100 -4190 {
lab=row_n[11]}
N 1080 -4170 1100 -4170 {
lab=rowon_n[11]}
N 1080 -4150 1100 -4150 {
lab=#net23}
N 1080 -4130 1100 -4130 {
lab=#net24}
N 1320 -4130 1340 -4130 {
lab=#net24}
N 1320 -4150 1340 -4150 {
lab=#net23}
N 1320 -4170 1340 -4170 {
lab=rowon_n[11]}
N 1320 -4190 1340 -4190 {
lab=row_n[11]}
N 1140 -4050 1140 -4040 {
lab=VSS}
N 1140 -4280 1140 -4270 {
lab=VDD}
N 1480 -4050 1490 -4060 {
lab=col_n[3]}
N 1490 -4260 1490 -4060 {
lab=col_n[3]}
N 1480 -4270 1490 -4260 {
lab=col_n[3]}
N 1480 -4050 1480 -4030 {
lab=col_n[3]}
N 1480 -4290 1480 -4270 {
lab=col_n[3]}
N 1360 -4190 1370 -4200 {
lab=row_n[11]}
N 1370 -4200 1570 -4200 {
lab=row_n[11]}
N 1570 -4200 1580 -4190 {
lab=row_n[11]}
N 1360 -4170 1370 -4180 {
lab=rowon_n[11]}
N 1370 -4180 1570 -4180 {
lab=rowon_n[11]}
N 1570 -4180 1580 -4170 {
lab=rowon_n[11]}
N 1360 -4150 1370 -4160 {
lab=#net23}
N 1370 -4160 1570 -4160 {
lab=#net23}
N 1570 -4160 1580 -4150 {
lab=#net23}
N 1360 -4130 1370 -4140 {
lab=#net24}
N 1370 -4140 1570 -4140 {
lab=#net24}
N 1570 -4140 1580 -4130 {
lab=#net24}
N 1420 -4290 1420 -4270 {
lab=vcm}
N 1460 -4290 1460 -4270 {
lab=ctop}
N 1340 -4190 1360 -4190 {
lab=row_n[11]}
N 1340 -4170 1360 -4170 {
lab=rowon_n[11]}
N 1340 -4150 1360 -4150 {
lab=#net23}
N 1340 -4130 1360 -4130 {
lab=#net24}
N 1580 -4130 1600 -4130 {
lab=#net24}
N 1580 -4150 1600 -4150 {
lab=#net23}
N 1580 -4170 1600 -4170 {
lab=rowon_n[11]}
N 1580 -4190 1600 -4190 {
lab=row_n[11]}
N 1400 -4050 1400 -4040 {
lab=VSS}
N 1400 -4280 1400 -4270 {
lab=VDD}
N 1740 -4050 1750 -4060 {
lab=col_n[4]}
N 1750 -4260 1750 -4060 {
lab=col_n[4]}
N 1740 -4270 1750 -4260 {
lab=col_n[4]}
N 1740 -4050 1740 -4030 {
lab=col_n[4]}
N 1740 -4290 1740 -4270 {
lab=col_n[4]}
N 1620 -4190 1630 -4200 {
lab=row_n[11]}
N 1630 -4200 1830 -4200 {
lab=row_n[11]}
N 1830 -4200 1840 -4190 {
lab=row_n[11]}
N 1620 -4170 1630 -4180 {
lab=rowon_n[11]}
N 1630 -4180 1830 -4180 {
lab=rowon_n[11]}
N 1830 -4180 1840 -4170 {
lab=rowon_n[11]}
N 1620 -4150 1630 -4160 {
lab=#net23}
N 1630 -4160 1830 -4160 {
lab=#net23}
N 1830 -4160 1840 -4150 {
lab=#net23}
N 1620 -4130 1630 -4140 {
lab=#net24}
N 1630 -4140 1830 -4140 {
lab=#net24}
N 1830 -4140 1840 -4130 {
lab=#net24}
N 1680 -4290 1680 -4270 {
lab=vcm}
N 1720 -4290 1720 -4270 {
lab=ctop}
N 1600 -4190 1620 -4190 {
lab=row_n[11]}
N 1600 -4170 1620 -4170 {
lab=rowon_n[11]}
N 1600 -4150 1620 -4150 {
lab=#net23}
N 1600 -4130 1620 -4130 {
lab=#net24}
N 1840 -4130 1860 -4130 {
lab=#net24}
N 1840 -4150 1860 -4150 {
lab=#net23}
N 1840 -4170 1860 -4170 {
lab=rowon_n[11]}
N 1840 -4190 1860 -4190 {
lab=row_n[11]}
N 1660 -4050 1660 -4040 {
lab=VSS}
N 1660 -4280 1660 -4270 {
lab=VDD}
N 2000 -4050 2010 -4060 {
lab=col_n[5]}
N 2010 -4260 2010 -4060 {
lab=col_n[5]}
N 2000 -4270 2010 -4260 {
lab=col_n[5]}
N 2000 -4050 2000 -4030 {
lab=col_n[5]}
N 2000 -4290 2000 -4270 {
lab=col_n[5]}
N 1880 -4190 1890 -4200 {
lab=row_n[11]}
N 1890 -4200 2090 -4200 {
lab=row_n[11]}
N 2090 -4200 2100 -4190 {
lab=row_n[11]}
N 1880 -4170 1890 -4180 {
lab=rowon_n[11]}
N 1890 -4180 2090 -4180 {
lab=rowon_n[11]}
N 2090 -4180 2100 -4170 {
lab=rowon_n[11]}
N 1880 -4150 1890 -4160 {
lab=#net23}
N 1890 -4160 2090 -4160 {
lab=#net23}
N 2090 -4160 2100 -4150 {
lab=#net23}
N 1880 -4130 1890 -4140 {
lab=#net24}
N 1890 -4140 2090 -4140 {
lab=#net24}
N 2090 -4140 2100 -4130 {
lab=#net24}
N 1940 -4290 1940 -4270 {
lab=vcm}
N 1980 -4290 1980 -4270 {
lab=ctop}
N 1860 -4190 1880 -4190 {
lab=row_n[11]}
N 1860 -4170 1880 -4170 {
lab=rowon_n[11]}
N 1860 -4150 1880 -4150 {
lab=#net23}
N 1860 -4130 1880 -4130 {
lab=#net24}
N 2100 -4130 2120 -4130 {
lab=#net24}
N 2100 -4150 2120 -4150 {
lab=#net23}
N 2100 -4170 2120 -4170 {
lab=rowon_n[11]}
N 2100 -4190 2120 -4190 {
lab=row_n[11]}
N 1920 -4050 1920 -4040 {
lab=VSS}
N 1920 -4280 1920 -4270 {
lab=VDD}
N 2260 -4050 2270 -4060 {
lab=col_n[6]}
N 2270 -4260 2270 -4060 {
lab=col_n[6]}
N 2260 -4270 2270 -4260 {
lab=col_n[6]}
N 2260 -4050 2260 -4030 {
lab=col_n[6]}
N 2260 -4290 2260 -4270 {
lab=col_n[6]}
N 2140 -4190 2150 -4200 {
lab=row_n[11]}
N 2150 -4200 2350 -4200 {
lab=row_n[11]}
N 2350 -4200 2360 -4190 {
lab=row_n[11]}
N 2140 -4170 2150 -4180 {
lab=rowon_n[11]}
N 2150 -4180 2350 -4180 {
lab=rowon_n[11]}
N 2350 -4180 2360 -4170 {
lab=rowon_n[11]}
N 2140 -4150 2150 -4160 {
lab=#net23}
N 2150 -4160 2350 -4160 {
lab=#net23}
N 2350 -4160 2360 -4150 {
lab=#net23}
N 2140 -4130 2150 -4140 {
lab=#net24}
N 2150 -4140 2350 -4140 {
lab=#net24}
N 2350 -4140 2360 -4130 {
lab=#net24}
N 2200 -4290 2200 -4270 {
lab=vcm}
N 2240 -4290 2240 -4270 {
lab=ctop}
N 2120 -4190 2140 -4190 {
lab=row_n[11]}
N 2120 -4170 2140 -4170 {
lab=rowon_n[11]}
N 2120 -4150 2140 -4150 {
lab=#net23}
N 2120 -4130 2140 -4130 {
lab=#net24}
N 2360 -4130 2380 -4130 {
lab=#net24}
N 2360 -4150 2380 -4150 {
lab=#net23}
N 2360 -4170 2380 -4170 {
lab=rowon_n[11]}
N 2360 -4190 2380 -4190 {
lab=row_n[11]}
N 2180 -4050 2180 -4040 {
lab=VSS}
N 2180 -4280 2180 -4270 {
lab=VDD}
N 2520 -4050 2530 -4060 {
lab=col_n[7]}
N 2530 -4260 2530 -4060 {
lab=col_n[7]}
N 2520 -4270 2530 -4260 {
lab=col_n[7]}
N 2520 -4050 2520 -4030 {
lab=col_n[7]}
N 2520 -4290 2520 -4270 {
lab=col_n[7]}
N 2400 -4190 2410 -4200 {
lab=row_n[11]}
N 2410 -4200 2610 -4200 {
lab=row_n[11]}
N 2610 -4200 2620 -4190 {
lab=row_n[11]}
N 2400 -4170 2410 -4180 {
lab=rowon_n[11]}
N 2410 -4180 2610 -4180 {
lab=rowon_n[11]}
N 2610 -4180 2620 -4170 {
lab=rowon_n[11]}
N 2400 -4150 2410 -4160 {
lab=#net23}
N 2410 -4160 2610 -4160 {
lab=#net23}
N 2610 -4160 2620 -4150 {
lab=#net23}
N 2400 -4130 2410 -4140 {
lab=#net24}
N 2410 -4140 2610 -4140 {
lab=#net24}
N 2610 -4140 2620 -4130 {
lab=#net24}
N 2460 -4290 2460 -4270 {
lab=vcm}
N 2500 -4290 2500 -4270 {
lab=ctop}
N 2380 -4190 2400 -4190 {
lab=row_n[11]}
N 2380 -4170 2400 -4170 {
lab=rowon_n[11]}
N 2380 -4150 2400 -4150 {
lab=#net23}
N 2380 -4130 2400 -4130 {
lab=#net24}
N 2620 -4130 2640 -4130 {
lab=#net24}
N 2620 -4150 2640 -4150 {
lab=#net23}
N 2620 -4170 2640 -4170 {
lab=rowon_n[11]}
N 2620 -4190 2640 -4190 {
lab=row_n[11]}
N 2440 -4050 2440 -4040 {
lab=VSS}
N 2440 -4280 2440 -4270 {
lab=VDD}
N 2780 -4050 2790 -4060 {
lab=col_n[8]}
N 2790 -4260 2790 -4060 {
lab=col_n[8]}
N 2780 -4270 2790 -4260 {
lab=col_n[8]}
N 2780 -4050 2780 -4030 {
lab=col_n[8]}
N 2780 -4290 2780 -4270 {
lab=col_n[8]}
N 2660 -4190 2670 -4200 {
lab=row_n[11]}
N 2670 -4200 2870 -4200 {
lab=row_n[11]}
N 2870 -4200 2880 -4190 {
lab=row_n[11]}
N 2660 -4170 2670 -4180 {
lab=rowon_n[11]}
N 2670 -4180 2870 -4180 {
lab=rowon_n[11]}
N 2870 -4180 2880 -4170 {
lab=rowon_n[11]}
N 2660 -4150 2670 -4160 {
lab=#net23}
N 2670 -4160 2870 -4160 {
lab=#net23}
N 2870 -4160 2880 -4150 {
lab=#net23}
N 2660 -4130 2670 -4140 {
lab=#net24}
N 2670 -4140 2870 -4140 {
lab=#net24}
N 2870 -4140 2880 -4130 {
lab=#net24}
N 2720 -4290 2720 -4270 {
lab=vcm}
N 2760 -4290 2760 -4270 {
lab=ctop}
N 2640 -4190 2660 -4190 {
lab=row_n[11]}
N 2640 -4170 2660 -4170 {
lab=rowon_n[11]}
N 2640 -4150 2660 -4150 {
lab=#net23}
N 2640 -4130 2660 -4130 {
lab=#net24}
N 2880 -4130 2900 -4130 {
lab=#net24}
N 2880 -4150 2900 -4150 {
lab=#net23}
N 2880 -4170 2900 -4170 {
lab=rowon_n[11]}
N 2880 -4190 2900 -4190 {
lab=row_n[11]}
N 2700 -4050 2700 -4040 {
lab=VSS}
N 2700 -4280 2700 -4270 {
lab=VDD}
N 3040 -4050 3050 -4060 {
lab=col_n[9]}
N 3050 -4260 3050 -4060 {
lab=col_n[9]}
N 3040 -4270 3050 -4260 {
lab=col_n[9]}
N 3040 -4050 3040 -4030 {
lab=col_n[9]}
N 3040 -4290 3040 -4270 {
lab=col_n[9]}
N 2920 -4190 2930 -4200 {
lab=row_n[11]}
N 2930 -4200 3130 -4200 {
lab=row_n[11]}
N 3130 -4200 3140 -4190 {
lab=row_n[11]}
N 2920 -4170 2930 -4180 {
lab=rowon_n[11]}
N 2930 -4180 3130 -4180 {
lab=rowon_n[11]}
N 3130 -4180 3140 -4170 {
lab=rowon_n[11]}
N 2920 -4150 2930 -4160 {
lab=#net23}
N 2930 -4160 3130 -4160 {
lab=#net23}
N 3130 -4160 3140 -4150 {
lab=#net23}
N 2920 -4130 2930 -4140 {
lab=#net24}
N 2930 -4140 3130 -4140 {
lab=#net24}
N 3130 -4140 3140 -4130 {
lab=#net24}
N 2980 -4290 2980 -4270 {
lab=vcm}
N 3020 -4290 3020 -4270 {
lab=ctop}
N 2900 -4190 2920 -4190 {
lab=row_n[11]}
N 2900 -4170 2920 -4170 {
lab=rowon_n[11]}
N 2900 -4150 2920 -4150 {
lab=#net23}
N 2900 -4130 2920 -4130 {
lab=#net24}
N 3140 -4130 3160 -4130 {
lab=#net24}
N 3140 -4150 3160 -4150 {
lab=#net23}
N 3140 -4170 3160 -4170 {
lab=rowon_n[11]}
N 3140 -4190 3160 -4190 {
lab=row_n[11]}
N 2960 -4050 2960 -4040 {
lab=VSS}
N 2960 -4280 2960 -4270 {
lab=VDD}
N 3300 -4050 3310 -4060 {
lab=col_n[10]}
N 3310 -4260 3310 -4060 {
lab=col_n[10]}
N 3300 -4270 3310 -4260 {
lab=col_n[10]}
N 3300 -4050 3300 -4030 {
lab=col_n[10]}
N 3300 -4290 3300 -4270 {
lab=col_n[10]}
N 3180 -4190 3190 -4200 {
lab=row_n[11]}
N 3190 -4200 3390 -4200 {
lab=row_n[11]}
N 3390 -4200 3400 -4190 {
lab=row_n[11]}
N 3180 -4170 3190 -4180 {
lab=rowon_n[11]}
N 3190 -4180 3390 -4180 {
lab=rowon_n[11]}
N 3390 -4180 3400 -4170 {
lab=rowon_n[11]}
N 3180 -4150 3190 -4160 {
lab=#net23}
N 3190 -4160 3390 -4160 {
lab=#net23}
N 3390 -4160 3400 -4150 {
lab=#net23}
N 3180 -4130 3190 -4140 {
lab=#net24}
N 3190 -4140 3390 -4140 {
lab=#net24}
N 3390 -4140 3400 -4130 {
lab=#net24}
N 3240 -4290 3240 -4270 {
lab=vcm}
N 3280 -4290 3280 -4270 {
lab=ctop}
N 3160 -4190 3180 -4190 {
lab=row_n[11]}
N 3160 -4170 3180 -4170 {
lab=rowon_n[11]}
N 3160 -4150 3180 -4150 {
lab=#net23}
N 3160 -4130 3180 -4130 {
lab=#net24}
N 3400 -4130 3420 -4130 {
lab=#net24}
N 3400 -4150 3420 -4150 {
lab=#net23}
N 3400 -4170 3420 -4170 {
lab=rowon_n[11]}
N 3400 -4190 3420 -4190 {
lab=row_n[11]}
N 3220 -4050 3220 -4040 {
lab=VSS}
N 3220 -4280 3220 -4270 {
lab=VDD}
N 3560 -4050 3570 -4060 {
lab=col_n[11]}
N 3570 -4260 3570 -4060 {
lab=col_n[11]}
N 3560 -4270 3570 -4260 {
lab=col_n[11]}
N 3560 -4050 3560 -4030 {
lab=col_n[11]}
N 3560 -4290 3560 -4270 {
lab=col_n[11]}
N 3440 -4190 3450 -4200 {
lab=row_n[11]}
N 3450 -4200 3650 -4200 {
lab=row_n[11]}
N 3650 -4200 3660 -4190 {
lab=row_n[11]}
N 3440 -4170 3450 -4180 {
lab=rowon_n[11]}
N 3450 -4180 3650 -4180 {
lab=rowon_n[11]}
N 3650 -4180 3660 -4170 {
lab=rowon_n[11]}
N 3440 -4150 3450 -4160 {
lab=#net23}
N 3450 -4160 3650 -4160 {
lab=#net23}
N 3650 -4160 3660 -4150 {
lab=#net23}
N 3440 -4130 3450 -4140 {
lab=#net24}
N 3450 -4140 3650 -4140 {
lab=#net24}
N 3650 -4140 3660 -4130 {
lab=#net24}
N 3500 -4290 3500 -4270 {
lab=vcm}
N 3540 -4290 3540 -4270 {
lab=ctop}
N 3420 -4190 3440 -4190 {
lab=row_n[11]}
N 3420 -4170 3440 -4170 {
lab=rowon_n[11]}
N 3420 -4150 3440 -4150 {
lab=#net23}
N 3420 -4130 3440 -4130 {
lab=#net24}
N 3660 -4130 3680 -4130 {
lab=#net24}
N 3660 -4150 3680 -4150 {
lab=#net23}
N 3660 -4170 3680 -4170 {
lab=rowon_n[11]}
N 3660 -4190 3680 -4190 {
lab=row_n[11]}
N 3480 -4050 3480 -4040 {
lab=VSS}
N 3480 -4280 3480 -4270 {
lab=VDD}
N 3820 -4050 3830 -4060 {
lab=col_n[12]}
N 3830 -4260 3830 -4060 {
lab=col_n[12]}
N 3820 -4270 3830 -4260 {
lab=col_n[12]}
N 3820 -4050 3820 -4030 {
lab=col_n[12]}
N 3820 -4290 3820 -4270 {
lab=col_n[12]}
N 3700 -4190 3710 -4200 {
lab=row_n[11]}
N 3710 -4200 3910 -4200 {
lab=row_n[11]}
N 3910 -4200 3920 -4190 {
lab=row_n[11]}
N 3700 -4170 3710 -4180 {
lab=rowon_n[11]}
N 3710 -4180 3910 -4180 {
lab=rowon_n[11]}
N 3910 -4180 3920 -4170 {
lab=rowon_n[11]}
N 3700 -4150 3710 -4160 {
lab=#net23}
N 3710 -4160 3910 -4160 {
lab=#net23}
N 3910 -4160 3920 -4150 {
lab=#net23}
N 3700 -4130 3710 -4140 {
lab=#net24}
N 3710 -4140 3910 -4140 {
lab=#net24}
N 3910 -4140 3920 -4130 {
lab=#net24}
N 3760 -4290 3760 -4270 {
lab=vcm}
N 3800 -4290 3800 -4270 {
lab=ctop}
N 3680 -4190 3700 -4190 {
lab=row_n[11]}
N 3680 -4170 3700 -4170 {
lab=rowon_n[11]}
N 3680 -4150 3700 -4150 {
lab=#net23}
N 3680 -4130 3700 -4130 {
lab=#net24}
N 3920 -4130 3940 -4130 {
lab=#net24}
N 3920 -4150 3940 -4150 {
lab=#net23}
N 3920 -4170 3940 -4170 {
lab=rowon_n[11]}
N 3920 -4190 3940 -4190 {
lab=row_n[11]}
N 3740 -4050 3740 -4040 {
lab=VSS}
N 3740 -4280 3740 -4270 {
lab=VDD}
N 4080 -4050 4090 -4060 {
lab=col_n[13]}
N 4090 -4260 4090 -4060 {
lab=col_n[13]}
N 4080 -4270 4090 -4260 {
lab=col_n[13]}
N 4080 -4050 4080 -4030 {
lab=col_n[13]}
N 4080 -4290 4080 -4270 {
lab=col_n[13]}
N 3960 -4190 3970 -4200 {
lab=row_n[11]}
N 3970 -4200 4170 -4200 {
lab=row_n[11]}
N 4170 -4200 4180 -4190 {
lab=row_n[11]}
N 3960 -4170 3970 -4180 {
lab=rowon_n[11]}
N 3970 -4180 4170 -4180 {
lab=rowon_n[11]}
N 4170 -4180 4180 -4170 {
lab=rowon_n[11]}
N 3960 -4150 3970 -4160 {
lab=#net23}
N 3970 -4160 4170 -4160 {
lab=#net23}
N 4170 -4160 4180 -4150 {
lab=#net23}
N 3960 -4130 3970 -4140 {
lab=#net24}
N 3970 -4140 4170 -4140 {
lab=#net24}
N 4170 -4140 4180 -4130 {
lab=#net24}
N 4020 -4290 4020 -4270 {
lab=vcm}
N 4060 -4290 4060 -4270 {
lab=ctop}
N 3940 -4190 3960 -4190 {
lab=row_n[11]}
N 3940 -4170 3960 -4170 {
lab=rowon_n[11]}
N 3940 -4150 3960 -4150 {
lab=#net23}
N 3940 -4130 3960 -4130 {
lab=#net24}
N 4180 -4130 4200 -4130 {
lab=#net24}
N 4180 -4150 4200 -4150 {
lab=#net23}
N 4180 -4170 4200 -4170 {
lab=rowon_n[11]}
N 4180 -4190 4200 -4190 {
lab=row_n[11]}
N 4000 -4050 4000 -4040 {
lab=VSS}
N 4000 -4280 4000 -4270 {
lab=VDD}
N 4340 -4050 4350 -4060 {
lab=col_n[14]}
N 4350 -4260 4350 -4060 {
lab=col_n[14]}
N 4340 -4270 4350 -4260 {
lab=col_n[14]}
N 4340 -4050 4340 -4030 {
lab=col_n[14]}
N 4340 -4290 4340 -4270 {
lab=col_n[14]}
N 4220 -4190 4230 -4200 {
lab=row_n[11]}
N 4230 -4200 4430 -4200 {
lab=row_n[11]}
N 4430 -4200 4440 -4190 {
lab=row_n[11]}
N 4220 -4170 4230 -4180 {
lab=rowon_n[11]}
N 4230 -4180 4430 -4180 {
lab=rowon_n[11]}
N 4430 -4180 4440 -4170 {
lab=rowon_n[11]}
N 4220 -4150 4230 -4160 {
lab=#net23}
N 4230 -4160 4430 -4160 {
lab=#net23}
N 4430 -4160 4440 -4150 {
lab=#net23}
N 4220 -4130 4230 -4140 {
lab=#net24}
N 4230 -4140 4430 -4140 {
lab=#net24}
N 4430 -4140 4440 -4130 {
lab=#net24}
N 4280 -4290 4280 -4270 {
lab=vcm}
N 4320 -4290 4320 -4270 {
lab=ctop}
N 4200 -4190 4220 -4190 {
lab=row_n[11]}
N 4200 -4170 4220 -4170 {
lab=rowon_n[11]}
N 4200 -4150 4220 -4150 {
lab=#net23}
N 4200 -4130 4220 -4130 {
lab=#net24}
N 4440 -4130 4460 -4130 {
lab=#net24}
N 4440 -4150 4460 -4150 {
lab=#net23}
N 4440 -4170 4460 -4170 {
lab=rowon_n[11]}
N 4440 -4190 4460 -4190 {
lab=row_n[11]}
N 4260 -4050 4260 -4040 {
lab=VSS}
N 4260 -4280 4260 -4270 {
lab=VDD}
N 4600 -4050 4610 -4060 {
lab=col_n[15]}
N 4610 -4260 4610 -4060 {
lab=col_n[15]}
N 4600 -4270 4610 -4260 {
lab=col_n[15]}
N 4600 -4050 4600 -4030 {
lab=col_n[15]}
N 4600 -4290 4600 -4270 {
lab=col_n[15]}
N 4480 -4190 4490 -4200 {
lab=row_n[11]}
N 4490 -4200 4690 -4200 {
lab=row_n[11]}
N 4690 -4200 4700 -4190 {
lab=row_n[11]}
N 4480 -4170 4490 -4180 {
lab=rowon_n[11]}
N 4490 -4180 4690 -4180 {
lab=rowon_n[11]}
N 4690 -4180 4700 -4170 {
lab=rowon_n[11]}
N 4480 -4150 4490 -4160 {
lab=#net23}
N 4490 -4160 4690 -4160 {
lab=#net23}
N 4690 -4160 4700 -4150 {
lab=#net23}
N 4480 -4130 4490 -4140 {
lab=#net24}
N 4490 -4140 4690 -4140 {
lab=#net24}
N 4690 -4140 4700 -4130 {
lab=#net24}
N 4540 -4290 4540 -4270 {
lab=vcm}
N 4580 -4290 4580 -4270 {
lab=ctop}
N 4460 -4190 4480 -4190 {
lab=row_n[11]}
N 4460 -4170 4480 -4170 {
lab=rowon_n[11]}
N 4460 -4150 4480 -4150 {
lab=#net23}
N 4460 -4130 4480 -4130 {
lab=#net24}
N 4700 -4130 4720 -4130 {
lab=#net24}
N 4700 -4150 4720 -4150 {
lab=#net23}
N 4700 -4170 4720 -4170 {
lab=rowon_n[11]}
N 4700 -4190 4720 -4190 {
lab=row_n[11]}
N 4520 -4050 4520 -4040 {
lab=VSS}
N 4520 -4280 4520 -4270 {
lab=VDD}
N 4860 -4050 4870 -4060 {
lab=col_n[16]}
N 4870 -4260 4870 -4060 {
lab=col_n[16]}
N 4860 -4270 4870 -4260 {
lab=col_n[16]}
N 4860 -4050 4860 -4030 {
lab=col_n[16]}
N 4860 -4290 4860 -4270 {
lab=col_n[16]}
N 4740 -4190 4750 -4200 {
lab=row_n[11]}
N 4750 -4200 4950 -4200 {
lab=row_n[11]}
N 4950 -4200 4960 -4190 {
lab=row_n[11]}
N 4740 -4170 4750 -4180 {
lab=rowon_n[11]}
N 4750 -4180 4950 -4180 {
lab=rowon_n[11]}
N 4950 -4180 4960 -4170 {
lab=rowon_n[11]}
N 4740 -4150 4750 -4160 {
lab=#net23}
N 4750 -4160 4950 -4160 {
lab=#net23}
N 4950 -4160 4960 -4150 {
lab=#net23}
N 4740 -4130 4750 -4140 {
lab=#net24}
N 4750 -4140 4950 -4140 {
lab=#net24}
N 4950 -4140 4960 -4130 {
lab=#net24}
N 4800 -4290 4800 -4270 {
lab=vcm}
N 4840 -4290 4840 -4270 {
lab=ctop}
N 4720 -4190 4740 -4190 {
lab=row_n[11]}
N 4720 -4170 4740 -4170 {
lab=rowon_n[11]}
N 4720 -4150 4740 -4150 {
lab=#net23}
N 4720 -4130 4740 -4130 {
lab=#net24}
N 4960 -4130 4980 -4130 {
lab=#net24}
N 4960 -4150 4980 -4150 {
lab=#net23}
N 4960 -4170 4980 -4170 {
lab=rowon_n[11]}
N 4960 -4190 4980 -4190 {
lab=row_n[11]}
N 4780 -4050 4780 -4040 {
lab=VSS}
N 4780 -4280 4780 -4270 {
lab=VDD}
N 5120 -4050 5130 -4060 {
lab=col_n[17]}
N 5130 -4260 5130 -4060 {
lab=col_n[17]}
N 5120 -4270 5130 -4260 {
lab=col_n[17]}
N 5120 -4050 5120 -4030 {
lab=col_n[17]}
N 5120 -4290 5120 -4270 {
lab=col_n[17]}
N 5000 -4190 5010 -4200 {
lab=row_n[11]}
N 5010 -4200 5210 -4200 {
lab=row_n[11]}
N 5210 -4200 5220 -4190 {
lab=row_n[11]}
N 5000 -4170 5010 -4180 {
lab=rowon_n[11]}
N 5010 -4180 5210 -4180 {
lab=rowon_n[11]}
N 5210 -4180 5220 -4170 {
lab=rowon_n[11]}
N 5000 -4150 5010 -4160 {
lab=#net23}
N 5010 -4160 5210 -4160 {
lab=#net23}
N 5210 -4160 5220 -4150 {
lab=#net23}
N 5000 -4130 5010 -4140 {
lab=#net24}
N 5010 -4140 5210 -4140 {
lab=#net24}
N 5210 -4140 5220 -4130 {
lab=#net24}
N 5060 -4290 5060 -4270 {
lab=vcm}
N 5100 -4290 5100 -4270 {
lab=ctop}
N 4980 -4190 5000 -4190 {
lab=row_n[11]}
N 4980 -4170 5000 -4170 {
lab=rowon_n[11]}
N 4980 -4150 5000 -4150 {
lab=#net23}
N 4980 -4130 5000 -4130 {
lab=#net24}
N 5220 -4130 5240 -4130 {
lab=#net24}
N 5220 -4150 5240 -4150 {
lab=#net23}
N 5220 -4170 5240 -4170 {
lab=rowon_n[11]}
N 5220 -4190 5240 -4190 {
lab=row_n[11]}
N 5040 -4050 5040 -4040 {
lab=VSS}
N 5040 -4280 5040 -4270 {
lab=VDD}
N 5380 -4050 5390 -4060 {
lab=col_n[18]}
N 5390 -4260 5390 -4060 {
lab=col_n[18]}
N 5380 -4270 5390 -4260 {
lab=col_n[18]}
N 5380 -4050 5380 -4030 {
lab=col_n[18]}
N 5380 -4290 5380 -4270 {
lab=col_n[18]}
N 5260 -4190 5270 -4200 {
lab=row_n[11]}
N 5270 -4200 5470 -4200 {
lab=row_n[11]}
N 5470 -4200 5480 -4190 {
lab=row_n[11]}
N 5260 -4170 5270 -4180 {
lab=rowon_n[11]}
N 5270 -4180 5470 -4180 {
lab=rowon_n[11]}
N 5470 -4180 5480 -4170 {
lab=rowon_n[11]}
N 5260 -4150 5270 -4160 {
lab=#net23}
N 5270 -4160 5470 -4160 {
lab=#net23}
N 5470 -4160 5480 -4150 {
lab=#net23}
N 5260 -4130 5270 -4140 {
lab=#net24}
N 5270 -4140 5470 -4140 {
lab=#net24}
N 5470 -4140 5480 -4130 {
lab=#net24}
N 5320 -4290 5320 -4270 {
lab=vcm}
N 5360 -4290 5360 -4270 {
lab=ctop}
N 5240 -4190 5260 -4190 {
lab=row_n[11]}
N 5240 -4170 5260 -4170 {
lab=rowon_n[11]}
N 5240 -4150 5260 -4150 {
lab=#net23}
N 5240 -4130 5260 -4130 {
lab=#net24}
N 5480 -4130 5500 -4130 {
lab=#net24}
N 5480 -4150 5500 -4150 {
lab=#net23}
N 5480 -4170 5500 -4170 {
lab=rowon_n[11]}
N 5480 -4190 5500 -4190 {
lab=row_n[11]}
N 5300 -4050 5300 -4040 {
lab=VSS}
N 5300 -4280 5300 -4270 {
lab=VDD}
N 5640 -4050 5650 -4060 {
lab=col_n[19]}
N 5650 -4260 5650 -4060 {
lab=col_n[19]}
N 5640 -4270 5650 -4260 {
lab=col_n[19]}
N 5640 -4050 5640 -4030 {
lab=col_n[19]}
N 5640 -4290 5640 -4270 {
lab=col_n[19]}
N 5520 -4190 5530 -4200 {
lab=row_n[11]}
N 5530 -4200 5730 -4200 {
lab=row_n[11]}
N 5730 -4200 5740 -4190 {
lab=row_n[11]}
N 5520 -4170 5530 -4180 {
lab=rowon_n[11]}
N 5530 -4180 5730 -4180 {
lab=rowon_n[11]}
N 5730 -4180 5740 -4170 {
lab=rowon_n[11]}
N 5520 -4150 5530 -4160 {
lab=#net23}
N 5530 -4160 5730 -4160 {
lab=#net23}
N 5730 -4160 5740 -4150 {
lab=#net23}
N 5520 -4130 5530 -4140 {
lab=#net24}
N 5530 -4140 5730 -4140 {
lab=#net24}
N 5730 -4140 5740 -4130 {
lab=#net24}
N 5580 -4290 5580 -4270 {
lab=vcm}
N 5620 -4290 5620 -4270 {
lab=ctop}
N 5500 -4190 5520 -4190 {
lab=row_n[11]}
N 5500 -4170 5520 -4170 {
lab=rowon_n[11]}
N 5500 -4150 5520 -4150 {
lab=#net23}
N 5500 -4130 5520 -4130 {
lab=#net24}
N 5740 -4130 5760 -4130 {
lab=#net24}
N 5740 -4150 5760 -4150 {
lab=#net23}
N 5740 -4170 5760 -4170 {
lab=rowon_n[11]}
N 5740 -4190 5760 -4190 {
lab=row_n[11]}
N 5560 -4050 5560 -4040 {
lab=VSS}
N 5560 -4280 5560 -4270 {
lab=VDD}
N 5900 -4050 5910 -4060 {
lab=col_n[20]}
N 5910 -4260 5910 -4060 {
lab=col_n[20]}
N 5900 -4270 5910 -4260 {
lab=col_n[20]}
N 5900 -4050 5900 -4030 {
lab=col_n[20]}
N 5900 -4290 5900 -4270 {
lab=col_n[20]}
N 5780 -4190 5790 -4200 {
lab=row_n[11]}
N 5790 -4200 5990 -4200 {
lab=row_n[11]}
N 5990 -4200 6000 -4190 {
lab=row_n[11]}
N 5780 -4170 5790 -4180 {
lab=rowon_n[11]}
N 5790 -4180 5990 -4180 {
lab=rowon_n[11]}
N 5990 -4180 6000 -4170 {
lab=rowon_n[11]}
N 5780 -4150 5790 -4160 {
lab=#net23}
N 5790 -4160 5990 -4160 {
lab=#net23}
N 5990 -4160 6000 -4150 {
lab=#net23}
N 5780 -4130 5790 -4140 {
lab=#net24}
N 5790 -4140 5990 -4140 {
lab=#net24}
N 5990 -4140 6000 -4130 {
lab=#net24}
N 5840 -4290 5840 -4270 {
lab=vcm}
N 5880 -4290 5880 -4270 {
lab=ctop}
N 5760 -4190 5780 -4190 {
lab=row_n[11]}
N 5760 -4170 5780 -4170 {
lab=rowon_n[11]}
N 5760 -4150 5780 -4150 {
lab=#net23}
N 5760 -4130 5780 -4130 {
lab=#net24}
N 6000 -4130 6020 -4130 {
lab=#net24}
N 6000 -4150 6020 -4150 {
lab=#net23}
N 6000 -4170 6020 -4170 {
lab=rowon_n[11]}
N 6000 -4190 6020 -4190 {
lab=row_n[11]}
N 5820 -4050 5820 -4040 {
lab=VSS}
N 5820 -4280 5820 -4270 {
lab=VDD}
N 6160 -4050 6170 -4060 {
lab=col_n[21]}
N 6170 -4260 6170 -4060 {
lab=col_n[21]}
N 6160 -4270 6170 -4260 {
lab=col_n[21]}
N 6160 -4050 6160 -4030 {
lab=col_n[21]}
N 6160 -4290 6160 -4270 {
lab=col_n[21]}
N 6040 -4190 6050 -4200 {
lab=row_n[11]}
N 6050 -4200 6250 -4200 {
lab=row_n[11]}
N 6250 -4200 6260 -4190 {
lab=row_n[11]}
N 6040 -4170 6050 -4180 {
lab=rowon_n[11]}
N 6050 -4180 6250 -4180 {
lab=rowon_n[11]}
N 6250 -4180 6260 -4170 {
lab=rowon_n[11]}
N 6040 -4150 6050 -4160 {
lab=#net23}
N 6050 -4160 6250 -4160 {
lab=#net23}
N 6250 -4160 6260 -4150 {
lab=#net23}
N 6040 -4130 6050 -4140 {
lab=#net24}
N 6050 -4140 6250 -4140 {
lab=#net24}
N 6250 -4140 6260 -4130 {
lab=#net24}
N 6100 -4290 6100 -4270 {
lab=vcm}
N 6140 -4290 6140 -4270 {
lab=ctop}
N 6020 -4190 6040 -4190 {
lab=row_n[11]}
N 6020 -4170 6040 -4170 {
lab=rowon_n[11]}
N 6020 -4150 6040 -4150 {
lab=#net23}
N 6020 -4130 6040 -4130 {
lab=#net24}
N 6260 -4130 6280 -4130 {
lab=#net24}
N 6260 -4150 6280 -4150 {
lab=#net23}
N 6260 -4170 6280 -4170 {
lab=rowon_n[11]}
N 6260 -4190 6280 -4190 {
lab=row_n[11]}
N 6080 -4050 6080 -4040 {
lab=VSS}
N 6080 -4280 6080 -4270 {
lab=VDD}
N 6420 -4050 6430 -4060 {
lab=col_n[22]}
N 6430 -4260 6430 -4060 {
lab=col_n[22]}
N 6420 -4270 6430 -4260 {
lab=col_n[22]}
N 6420 -4050 6420 -4030 {
lab=col_n[22]}
N 6420 -4290 6420 -4270 {
lab=col_n[22]}
N 6300 -4190 6310 -4200 {
lab=row_n[11]}
N 6310 -4200 6510 -4200 {
lab=row_n[11]}
N 6510 -4200 6520 -4190 {
lab=row_n[11]}
N 6300 -4170 6310 -4180 {
lab=rowon_n[11]}
N 6310 -4180 6510 -4180 {
lab=rowon_n[11]}
N 6510 -4180 6520 -4170 {
lab=rowon_n[11]}
N 6300 -4150 6310 -4160 {
lab=#net23}
N 6310 -4160 6510 -4160 {
lab=#net23}
N 6510 -4160 6520 -4150 {
lab=#net23}
N 6300 -4130 6310 -4140 {
lab=#net24}
N 6310 -4140 6510 -4140 {
lab=#net24}
N 6510 -4140 6520 -4130 {
lab=#net24}
N 6360 -4290 6360 -4270 {
lab=vcm}
N 6400 -4290 6400 -4270 {
lab=ctop}
N 6280 -4190 6300 -4190 {
lab=row_n[11]}
N 6280 -4170 6300 -4170 {
lab=rowon_n[11]}
N 6280 -4150 6300 -4150 {
lab=#net23}
N 6280 -4130 6300 -4130 {
lab=#net24}
N 6520 -4130 6540 -4130 {
lab=#net24}
N 6520 -4150 6540 -4150 {
lab=#net23}
N 6520 -4170 6540 -4170 {
lab=rowon_n[11]}
N 6520 -4190 6540 -4190 {
lab=row_n[11]}
N 6340 -4050 6340 -4040 {
lab=VSS}
N 6340 -4280 6340 -4270 {
lab=VDD}
N 6680 -4050 6690 -4060 {
lab=col_n[23]}
N 6690 -4260 6690 -4060 {
lab=col_n[23]}
N 6680 -4270 6690 -4260 {
lab=col_n[23]}
N 6680 -4050 6680 -4030 {
lab=col_n[23]}
N 6680 -4290 6680 -4270 {
lab=col_n[23]}
N 6560 -4190 6570 -4200 {
lab=row_n[11]}
N 6570 -4200 6770 -4200 {
lab=row_n[11]}
N 6770 -4200 6780 -4190 {
lab=row_n[11]}
N 6560 -4170 6570 -4180 {
lab=rowon_n[11]}
N 6570 -4180 6770 -4180 {
lab=rowon_n[11]}
N 6770 -4180 6780 -4170 {
lab=rowon_n[11]}
N 6560 -4150 6570 -4160 {
lab=#net23}
N 6570 -4160 6770 -4160 {
lab=#net23}
N 6770 -4160 6780 -4150 {
lab=#net23}
N 6560 -4130 6570 -4140 {
lab=#net24}
N 6570 -4140 6770 -4140 {
lab=#net24}
N 6770 -4140 6780 -4130 {
lab=#net24}
N 6620 -4290 6620 -4270 {
lab=vcm}
N 6660 -4290 6660 -4270 {
lab=ctop}
N 6540 -4190 6560 -4190 {
lab=row_n[11]}
N 6540 -4170 6560 -4170 {
lab=rowon_n[11]}
N 6540 -4150 6560 -4150 {
lab=#net23}
N 6540 -4130 6560 -4130 {
lab=#net24}
N 6780 -4130 6800 -4130 {
lab=#net24}
N 6780 -4150 6800 -4150 {
lab=#net23}
N 6780 -4170 6800 -4170 {
lab=rowon_n[11]}
N 6780 -4190 6800 -4190 {
lab=row_n[11]}
N 6600 -4050 6600 -4040 {
lab=VSS}
N 6600 -4280 6600 -4270 {
lab=VDD}
N 6940 -4050 6950 -4060 {
lab=col_n[24]}
N 6950 -4260 6950 -4060 {
lab=col_n[24]}
N 6940 -4270 6950 -4260 {
lab=col_n[24]}
N 6940 -4050 6940 -4030 {
lab=col_n[24]}
N 6940 -4290 6940 -4270 {
lab=col_n[24]}
N 6820 -4190 6830 -4200 {
lab=row_n[11]}
N 6830 -4200 7030 -4200 {
lab=row_n[11]}
N 7030 -4200 7040 -4190 {
lab=row_n[11]}
N 6820 -4170 6830 -4180 {
lab=rowon_n[11]}
N 6830 -4180 7030 -4180 {
lab=rowon_n[11]}
N 7030 -4180 7040 -4170 {
lab=rowon_n[11]}
N 6820 -4150 6830 -4160 {
lab=#net23}
N 6830 -4160 7030 -4160 {
lab=#net23}
N 7030 -4160 7040 -4150 {
lab=#net23}
N 6820 -4130 6830 -4140 {
lab=#net24}
N 6830 -4140 7030 -4140 {
lab=#net24}
N 7030 -4140 7040 -4130 {
lab=#net24}
N 6880 -4290 6880 -4270 {
lab=vcm}
N 6920 -4290 6920 -4270 {
lab=ctop}
N 6800 -4190 6820 -4190 {
lab=row_n[11]}
N 6800 -4170 6820 -4170 {
lab=rowon_n[11]}
N 6800 -4150 6820 -4150 {
lab=#net23}
N 6800 -4130 6820 -4130 {
lab=#net24}
N 7040 -4130 7060 -4130 {
lab=#net24}
N 7040 -4150 7060 -4150 {
lab=#net23}
N 7040 -4170 7060 -4170 {
lab=rowon_n[11]}
N 7040 -4190 7060 -4190 {
lab=row_n[11]}
N 6860 -4050 6860 -4040 {
lab=VSS}
N 6860 -4280 6860 -4270 {
lab=VDD}
N 7200 -4050 7210 -4060 {
lab=col_n[25]}
N 7210 -4260 7210 -4060 {
lab=col_n[25]}
N 7200 -4270 7210 -4260 {
lab=col_n[25]}
N 7200 -4050 7200 -4030 {
lab=col_n[25]}
N 7200 -4290 7200 -4270 {
lab=col_n[25]}
N 7080 -4190 7090 -4200 {
lab=row_n[11]}
N 7090 -4200 7290 -4200 {
lab=row_n[11]}
N 7290 -4200 7300 -4190 {
lab=row_n[11]}
N 7080 -4170 7090 -4180 {
lab=rowon_n[11]}
N 7090 -4180 7290 -4180 {
lab=rowon_n[11]}
N 7290 -4180 7300 -4170 {
lab=rowon_n[11]}
N 7080 -4150 7090 -4160 {
lab=#net23}
N 7090 -4160 7290 -4160 {
lab=#net23}
N 7290 -4160 7300 -4150 {
lab=#net23}
N 7080 -4130 7090 -4140 {
lab=#net24}
N 7090 -4140 7290 -4140 {
lab=#net24}
N 7290 -4140 7300 -4130 {
lab=#net24}
N 7140 -4290 7140 -4270 {
lab=vcm}
N 7180 -4290 7180 -4270 {
lab=ctop}
N 7060 -4190 7080 -4190 {
lab=row_n[11]}
N 7060 -4170 7080 -4170 {
lab=rowon_n[11]}
N 7060 -4150 7080 -4150 {
lab=#net23}
N 7060 -4130 7080 -4130 {
lab=#net24}
N 7300 -4130 7320 -4130 {
lab=#net24}
N 7300 -4150 7320 -4150 {
lab=#net23}
N 7300 -4170 7320 -4170 {
lab=rowon_n[11]}
N 7300 -4190 7320 -4190 {
lab=row_n[11]}
N 7120 -4050 7120 -4040 {
lab=VSS}
N 7120 -4280 7120 -4270 {
lab=VDD}
N 7460 -4050 7470 -4060 {
lab=col_n[26]}
N 7470 -4260 7470 -4060 {
lab=col_n[26]}
N 7460 -4270 7470 -4260 {
lab=col_n[26]}
N 7460 -4050 7460 -4030 {
lab=col_n[26]}
N 7460 -4290 7460 -4270 {
lab=col_n[26]}
N 7340 -4190 7350 -4200 {
lab=row_n[11]}
N 7350 -4200 7550 -4200 {
lab=row_n[11]}
N 7550 -4200 7560 -4190 {
lab=row_n[11]}
N 7340 -4170 7350 -4180 {
lab=rowon_n[11]}
N 7350 -4180 7550 -4180 {
lab=rowon_n[11]}
N 7550 -4180 7560 -4170 {
lab=rowon_n[11]}
N 7340 -4150 7350 -4160 {
lab=#net23}
N 7350 -4160 7550 -4160 {
lab=#net23}
N 7550 -4160 7560 -4150 {
lab=#net23}
N 7340 -4130 7350 -4140 {
lab=#net24}
N 7350 -4140 7550 -4140 {
lab=#net24}
N 7550 -4140 7560 -4130 {
lab=#net24}
N 7400 -4290 7400 -4270 {
lab=vcm}
N 7440 -4290 7440 -4270 {
lab=ctop}
N 7320 -4190 7340 -4190 {
lab=row_n[11]}
N 7320 -4170 7340 -4170 {
lab=rowon_n[11]}
N 7320 -4150 7340 -4150 {
lab=#net23}
N 7320 -4130 7340 -4130 {
lab=#net24}
N 7560 -4130 7580 -4130 {
lab=#net24}
N 7560 -4150 7580 -4150 {
lab=#net23}
N 7560 -4170 7580 -4170 {
lab=rowon_n[11]}
N 7560 -4190 7580 -4190 {
lab=row_n[11]}
N 7380 -4050 7380 -4040 {
lab=VSS}
N 7380 -4280 7380 -4270 {
lab=VDD}
N 7720 -4050 7730 -4060 {
lab=col_n[27]}
N 7730 -4260 7730 -4060 {
lab=col_n[27]}
N 7720 -4270 7730 -4260 {
lab=col_n[27]}
N 7720 -4050 7720 -4030 {
lab=col_n[27]}
N 7720 -4290 7720 -4270 {
lab=col_n[27]}
N 7600 -4190 7610 -4200 {
lab=row_n[11]}
N 7610 -4200 7810 -4200 {
lab=row_n[11]}
N 7810 -4200 7820 -4190 {
lab=row_n[11]}
N 7600 -4170 7610 -4180 {
lab=rowon_n[11]}
N 7610 -4180 7810 -4180 {
lab=rowon_n[11]}
N 7810 -4180 7820 -4170 {
lab=rowon_n[11]}
N 7600 -4150 7610 -4160 {
lab=#net23}
N 7610 -4160 7810 -4160 {
lab=#net23}
N 7810 -4160 7820 -4150 {
lab=#net23}
N 7600 -4130 7610 -4140 {
lab=#net24}
N 7610 -4140 7810 -4140 {
lab=#net24}
N 7810 -4140 7820 -4130 {
lab=#net24}
N 7660 -4290 7660 -4270 {
lab=vcm}
N 7700 -4290 7700 -4270 {
lab=ctop}
N 7580 -4190 7600 -4190 {
lab=row_n[11]}
N 7580 -4170 7600 -4170 {
lab=rowon_n[11]}
N 7580 -4150 7600 -4150 {
lab=#net23}
N 7580 -4130 7600 -4130 {
lab=#net24}
N 7820 -4130 7840 -4130 {
lab=#net24}
N 7820 -4150 7840 -4150 {
lab=#net23}
N 7820 -4170 7840 -4170 {
lab=rowon_n[11]}
N 7820 -4190 7840 -4190 {
lab=row_n[11]}
N 7640 -4050 7640 -4040 {
lab=VSS}
N 7640 -4280 7640 -4270 {
lab=VDD}
N 7980 -4050 7990 -4060 {
lab=col_n[28]}
N 7990 -4260 7990 -4060 {
lab=col_n[28]}
N 7980 -4270 7990 -4260 {
lab=col_n[28]}
N 7980 -4050 7980 -4030 {
lab=col_n[28]}
N 7980 -4290 7980 -4270 {
lab=col_n[28]}
N 7860 -4190 7870 -4200 {
lab=row_n[11]}
N 7870 -4200 8070 -4200 {
lab=row_n[11]}
N 8070 -4200 8080 -4190 {
lab=row_n[11]}
N 7860 -4170 7870 -4180 {
lab=rowon_n[11]}
N 7870 -4180 8070 -4180 {
lab=rowon_n[11]}
N 8070 -4180 8080 -4170 {
lab=rowon_n[11]}
N 7860 -4150 7870 -4160 {
lab=#net23}
N 7870 -4160 8070 -4160 {
lab=#net23}
N 8070 -4160 8080 -4150 {
lab=#net23}
N 7860 -4130 7870 -4140 {
lab=#net24}
N 7870 -4140 8070 -4140 {
lab=#net24}
N 8070 -4140 8080 -4130 {
lab=#net24}
N 7920 -4290 7920 -4270 {
lab=vcm}
N 7960 -4290 7960 -4270 {
lab=ctop}
N 7840 -4190 7860 -4190 {
lab=row_n[11]}
N 7840 -4170 7860 -4170 {
lab=rowon_n[11]}
N 7840 -4150 7860 -4150 {
lab=#net23}
N 7840 -4130 7860 -4130 {
lab=#net24}
N 8080 -4130 8100 -4130 {
lab=#net24}
N 8080 -4150 8100 -4150 {
lab=#net23}
N 8080 -4170 8100 -4170 {
lab=rowon_n[11]}
N 8080 -4190 8100 -4190 {
lab=row_n[11]}
N 7900 -4050 7900 -4040 {
lab=VSS}
N 7900 -4280 7900 -4270 {
lab=VDD}
N 8240 -4050 8250 -4060 {
lab=col_n[29]}
N 8250 -4260 8250 -4060 {
lab=col_n[29]}
N 8240 -4270 8250 -4260 {
lab=col_n[29]}
N 8240 -4050 8240 -4030 {
lab=col_n[29]}
N 8240 -4290 8240 -4270 {
lab=col_n[29]}
N 8120 -4190 8130 -4200 {
lab=row_n[11]}
N 8130 -4200 8330 -4200 {
lab=row_n[11]}
N 8330 -4200 8340 -4190 {
lab=row_n[11]}
N 8120 -4170 8130 -4180 {
lab=rowon_n[11]}
N 8130 -4180 8330 -4180 {
lab=rowon_n[11]}
N 8330 -4180 8340 -4170 {
lab=rowon_n[11]}
N 8120 -4150 8130 -4160 {
lab=#net23}
N 8130 -4160 8330 -4160 {
lab=#net23}
N 8330 -4160 8340 -4150 {
lab=#net23}
N 8120 -4130 8130 -4140 {
lab=#net24}
N 8130 -4140 8330 -4140 {
lab=#net24}
N 8330 -4140 8340 -4130 {
lab=#net24}
N 8180 -4290 8180 -4270 {
lab=vcm}
N 8220 -4290 8220 -4270 {
lab=ctop}
N 8100 -4190 8120 -4190 {
lab=row_n[11]}
N 8100 -4170 8120 -4170 {
lab=rowon_n[11]}
N 8100 -4150 8120 -4150 {
lab=#net23}
N 8100 -4130 8120 -4130 {
lab=#net24}
N 8340 -4130 8360 -4130 {
lab=#net24}
N 8340 -4150 8360 -4150 {
lab=#net23}
N 8340 -4170 8360 -4170 {
lab=rowon_n[11]}
N 8340 -4190 8360 -4190 {
lab=row_n[11]}
N 8160 -4050 8160 -4040 {
lab=VSS}
N 8160 -4280 8160 -4270 {
lab=VDD}
N 8500 -4050 8510 -4060 {
lab=col_n[30]}
N 8510 -4260 8510 -4060 {
lab=col_n[30]}
N 8500 -4270 8510 -4260 {
lab=col_n[30]}
N 8500 -4050 8500 -4030 {
lab=col_n[30]}
N 8500 -4290 8500 -4270 {
lab=col_n[30]}
N 8380 -4190 8390 -4200 {
lab=row_n[11]}
N 8390 -4200 8590 -4200 {
lab=row_n[11]}
N 8590 -4200 8600 -4190 {
lab=row_n[11]}
N 8380 -4170 8390 -4180 {
lab=rowon_n[11]}
N 8390 -4180 8590 -4180 {
lab=rowon_n[11]}
N 8590 -4180 8600 -4170 {
lab=rowon_n[11]}
N 8380 -4150 8390 -4160 {
lab=#net23}
N 8390 -4160 8590 -4160 {
lab=#net23}
N 8590 -4160 8600 -4150 {
lab=#net23}
N 8380 -4130 8390 -4140 {
lab=#net24}
N 8390 -4140 8590 -4140 {
lab=#net24}
N 8590 -4140 8600 -4130 {
lab=#net24}
N 8440 -4290 8440 -4270 {
lab=vcm}
N 8480 -4290 8480 -4270 {
lab=ctop}
N 8360 -4190 8380 -4190 {
lab=row_n[11]}
N 8360 -4170 8380 -4170 {
lab=rowon_n[11]}
N 8360 -4150 8380 -4150 {
lab=#net23}
N 8360 -4130 8380 -4130 {
lab=#net24}
N 8600 -4130 8620 -4130 {
lab=#net24}
N 8600 -4150 8620 -4150 {
lab=#net23}
N 8600 -4170 8620 -4170 {
lab=rowon_n[11]}
N 8600 -4190 8620 -4190 {
lab=row_n[11]}
N 8420 -4050 8420 -4040 {
lab=VSS}
N 8420 -4280 8420 -4270 {
lab=VDD}
N 8760 -4050 8770 -4060 {
lab=col_n[31]}
N 8770 -4260 8770 -4060 {
lab=col_n[31]}
N 8760 -4270 8770 -4260 {
lab=col_n[31]}
N 8760 -4050 8760 -4030 {
lab=col_n[31]}
N 8760 -4290 8760 -4270 {
lab=col_n[31]}
N 8640 -4190 8650 -4200 {
lab=row_n[11]}
N 8650 -4200 8850 -4200 {
lab=row_n[11]}
N 8850 -4200 8860 -4190 {
lab=row_n[11]}
N 8640 -4170 8650 -4180 {
lab=rowon_n[11]}
N 8650 -4180 8850 -4180 {
lab=rowon_n[11]}
N 8850 -4180 8860 -4170 {
lab=rowon_n[11]}
N 8640 -4150 8650 -4160 {
lab=#net23}
N 8650 -4160 8850 -4160 {
lab=#net23}
N 8850 -4160 8860 -4150 {
lab=#net23}
N 8640 -4130 8650 -4140 {
lab=#net24}
N 8650 -4140 8850 -4140 {
lab=#net24}
N 8850 -4140 8860 -4130 {
lab=#net24}
N 8700 -4290 8700 -4270 {
lab=vcm}
N 8740 -4290 8740 -4270 {
lab=ctop}
N 8620 -4190 8640 -4190 {
lab=row_n[11]}
N 8620 -4170 8640 -4170 {
lab=rowon_n[11]}
N 8620 -4150 8640 -4150 {
lab=#net23}
N 8620 -4130 8640 -4130 {
lab=#net24}
N 8860 -4130 8880 -4130 {
lab=#net24}
N 8860 -4150 8880 -4150 {
lab=#net23}
N 8860 -4170 8880 -4170 {
lab=rowon_n[11]}
N 8860 -4190 8880 -4190 {
lab=row_n[11]}
N 8680 -4050 8680 -4040 {
lab=VSS}
N 8680 -4280 8680 -4270 {
lab=VDD}
N 700 -4310 710 -4320 {
lab=col_n[0]}
N 710 -4520 710 -4320 {
lab=col_n[0]}
N 700 -4530 710 -4520 {
lab=col_n[0]}
N 700 -4310 700 -4290 {
lab=col_n[0]}
N 700 -4550 700 -4530 {
lab=col_n[0]}
N 580 -4450 590 -4460 {
lab=row_n[12]}
N 590 -4460 790 -4460 {
lab=row_n[12]}
N 790 -4460 800 -4450 {
lab=row_n[12]}
N 580 -4430 590 -4440 {
lab=rowon_n[12]}
N 590 -4440 790 -4440 {
lab=rowon_n[12]}
N 790 -4440 800 -4430 {
lab=rowon_n[12]}
N 580 -4410 590 -4420 {
lab=#net25}
N 590 -4420 790 -4420 {
lab=#net25}
N 790 -4420 800 -4410 {
lab=#net25}
N 580 -4390 590 -4400 {
lab=#net26}
N 590 -4400 790 -4400 {
lab=#net26}
N 790 -4400 800 -4390 {
lab=#net26}
N 640 -4550 640 -4530 {
lab=vcm}
N 680 -4550 680 -4530 {
lab=ctop}
N 560 -4450 580 -4450 {
lab=row_n[12]}
N 560 -4430 580 -4430 {
lab=rowon_n[12]}
N 560 -4410 580 -4410 {
lab=#net25}
N 560 -4390 580 -4390 {
lab=#net26}
N 800 -4390 820 -4390 {
lab=#net26}
N 800 -4410 820 -4410 {
lab=#net25}
N 800 -4430 820 -4430 {
lab=rowon_n[12]}
N 800 -4450 820 -4450 {
lab=row_n[12]}
N 620 -4310 620 -4300 {
lab=VSS}
N 620 -4540 620 -4530 {
lab=VDD}
N 960 -4310 970 -4320 {
lab=col_n[1]}
N 970 -4520 970 -4320 {
lab=col_n[1]}
N 960 -4530 970 -4520 {
lab=col_n[1]}
N 960 -4310 960 -4290 {
lab=col_n[1]}
N 960 -4550 960 -4530 {
lab=col_n[1]}
N 840 -4450 850 -4460 {
lab=row_n[12]}
N 850 -4460 1050 -4460 {
lab=row_n[12]}
N 1050 -4460 1060 -4450 {
lab=row_n[12]}
N 840 -4430 850 -4440 {
lab=rowon_n[12]}
N 850 -4440 1050 -4440 {
lab=rowon_n[12]}
N 1050 -4440 1060 -4430 {
lab=rowon_n[12]}
N 840 -4410 850 -4420 {
lab=#net25}
N 850 -4420 1050 -4420 {
lab=#net25}
N 1050 -4420 1060 -4410 {
lab=#net25}
N 840 -4390 850 -4400 {
lab=#net26}
N 850 -4400 1050 -4400 {
lab=#net26}
N 1050 -4400 1060 -4390 {
lab=#net26}
N 900 -4550 900 -4530 {
lab=vcm}
N 940 -4550 940 -4530 {
lab=ctop}
N 820 -4450 840 -4450 {
lab=row_n[12]}
N 820 -4430 840 -4430 {
lab=rowon_n[12]}
N 820 -4410 840 -4410 {
lab=#net25}
N 820 -4390 840 -4390 {
lab=#net26}
N 1060 -4390 1080 -4390 {
lab=#net26}
N 1060 -4410 1080 -4410 {
lab=#net25}
N 1060 -4430 1080 -4430 {
lab=rowon_n[12]}
N 1060 -4450 1080 -4450 {
lab=row_n[12]}
N 880 -4310 880 -4300 {
lab=VSS}
N 880 -4540 880 -4530 {
lab=VDD}
N 1220 -4310 1230 -4320 {
lab=col_n[2]}
N 1230 -4520 1230 -4320 {
lab=col_n[2]}
N 1220 -4530 1230 -4520 {
lab=col_n[2]}
N 1220 -4310 1220 -4290 {
lab=col_n[2]}
N 1220 -4550 1220 -4530 {
lab=col_n[2]}
N 1100 -4450 1110 -4460 {
lab=row_n[12]}
N 1110 -4460 1310 -4460 {
lab=row_n[12]}
N 1310 -4460 1320 -4450 {
lab=row_n[12]}
N 1100 -4430 1110 -4440 {
lab=rowon_n[12]}
N 1110 -4440 1310 -4440 {
lab=rowon_n[12]}
N 1310 -4440 1320 -4430 {
lab=rowon_n[12]}
N 1100 -4410 1110 -4420 {
lab=#net25}
N 1110 -4420 1310 -4420 {
lab=#net25}
N 1310 -4420 1320 -4410 {
lab=#net25}
N 1100 -4390 1110 -4400 {
lab=#net26}
N 1110 -4400 1310 -4400 {
lab=#net26}
N 1310 -4400 1320 -4390 {
lab=#net26}
N 1160 -4550 1160 -4530 {
lab=vcm}
N 1200 -4550 1200 -4530 {
lab=ctop}
N 1080 -4450 1100 -4450 {
lab=row_n[12]}
N 1080 -4430 1100 -4430 {
lab=rowon_n[12]}
N 1080 -4410 1100 -4410 {
lab=#net25}
N 1080 -4390 1100 -4390 {
lab=#net26}
N 1320 -4390 1340 -4390 {
lab=#net26}
N 1320 -4410 1340 -4410 {
lab=#net25}
N 1320 -4430 1340 -4430 {
lab=rowon_n[12]}
N 1320 -4450 1340 -4450 {
lab=row_n[12]}
N 1140 -4310 1140 -4300 {
lab=VSS}
N 1140 -4540 1140 -4530 {
lab=VDD}
N 1480 -4310 1490 -4320 {
lab=col_n[3]}
N 1490 -4520 1490 -4320 {
lab=col_n[3]}
N 1480 -4530 1490 -4520 {
lab=col_n[3]}
N 1480 -4310 1480 -4290 {
lab=col_n[3]}
N 1480 -4550 1480 -4530 {
lab=col_n[3]}
N 1360 -4450 1370 -4460 {
lab=row_n[12]}
N 1370 -4460 1570 -4460 {
lab=row_n[12]}
N 1570 -4460 1580 -4450 {
lab=row_n[12]}
N 1360 -4430 1370 -4440 {
lab=rowon_n[12]}
N 1370 -4440 1570 -4440 {
lab=rowon_n[12]}
N 1570 -4440 1580 -4430 {
lab=rowon_n[12]}
N 1360 -4410 1370 -4420 {
lab=#net25}
N 1370 -4420 1570 -4420 {
lab=#net25}
N 1570 -4420 1580 -4410 {
lab=#net25}
N 1360 -4390 1370 -4400 {
lab=#net26}
N 1370 -4400 1570 -4400 {
lab=#net26}
N 1570 -4400 1580 -4390 {
lab=#net26}
N 1420 -4550 1420 -4530 {
lab=vcm}
N 1460 -4550 1460 -4530 {
lab=ctop}
N 1340 -4450 1360 -4450 {
lab=row_n[12]}
N 1340 -4430 1360 -4430 {
lab=rowon_n[12]}
N 1340 -4410 1360 -4410 {
lab=#net25}
N 1340 -4390 1360 -4390 {
lab=#net26}
N 1580 -4390 1600 -4390 {
lab=#net26}
N 1580 -4410 1600 -4410 {
lab=#net25}
N 1580 -4430 1600 -4430 {
lab=rowon_n[12]}
N 1580 -4450 1600 -4450 {
lab=row_n[12]}
N 1400 -4310 1400 -4300 {
lab=VSS}
N 1400 -4540 1400 -4530 {
lab=VDD}
N 1740 -4310 1750 -4320 {
lab=col_n[4]}
N 1750 -4520 1750 -4320 {
lab=col_n[4]}
N 1740 -4530 1750 -4520 {
lab=col_n[4]}
N 1740 -4310 1740 -4290 {
lab=col_n[4]}
N 1740 -4550 1740 -4530 {
lab=col_n[4]}
N 1620 -4450 1630 -4460 {
lab=row_n[12]}
N 1630 -4460 1830 -4460 {
lab=row_n[12]}
N 1830 -4460 1840 -4450 {
lab=row_n[12]}
N 1620 -4430 1630 -4440 {
lab=rowon_n[12]}
N 1630 -4440 1830 -4440 {
lab=rowon_n[12]}
N 1830 -4440 1840 -4430 {
lab=rowon_n[12]}
N 1620 -4410 1630 -4420 {
lab=#net25}
N 1630 -4420 1830 -4420 {
lab=#net25}
N 1830 -4420 1840 -4410 {
lab=#net25}
N 1620 -4390 1630 -4400 {
lab=#net26}
N 1630 -4400 1830 -4400 {
lab=#net26}
N 1830 -4400 1840 -4390 {
lab=#net26}
N 1680 -4550 1680 -4530 {
lab=vcm}
N 1720 -4550 1720 -4530 {
lab=ctop}
N 1600 -4450 1620 -4450 {
lab=row_n[12]}
N 1600 -4430 1620 -4430 {
lab=rowon_n[12]}
N 1600 -4410 1620 -4410 {
lab=#net25}
N 1600 -4390 1620 -4390 {
lab=#net26}
N 1840 -4390 1860 -4390 {
lab=#net26}
N 1840 -4410 1860 -4410 {
lab=#net25}
N 1840 -4430 1860 -4430 {
lab=rowon_n[12]}
N 1840 -4450 1860 -4450 {
lab=row_n[12]}
N 1660 -4310 1660 -4300 {
lab=VSS}
N 1660 -4540 1660 -4530 {
lab=VDD}
N 2000 -4310 2010 -4320 {
lab=col_n[5]}
N 2010 -4520 2010 -4320 {
lab=col_n[5]}
N 2000 -4530 2010 -4520 {
lab=col_n[5]}
N 2000 -4310 2000 -4290 {
lab=col_n[5]}
N 2000 -4550 2000 -4530 {
lab=col_n[5]}
N 1880 -4450 1890 -4460 {
lab=row_n[12]}
N 1890 -4460 2090 -4460 {
lab=row_n[12]}
N 2090 -4460 2100 -4450 {
lab=row_n[12]}
N 1880 -4430 1890 -4440 {
lab=rowon_n[12]}
N 1890 -4440 2090 -4440 {
lab=rowon_n[12]}
N 2090 -4440 2100 -4430 {
lab=rowon_n[12]}
N 1880 -4410 1890 -4420 {
lab=#net25}
N 1890 -4420 2090 -4420 {
lab=#net25}
N 2090 -4420 2100 -4410 {
lab=#net25}
N 1880 -4390 1890 -4400 {
lab=#net26}
N 1890 -4400 2090 -4400 {
lab=#net26}
N 2090 -4400 2100 -4390 {
lab=#net26}
N 1940 -4550 1940 -4530 {
lab=vcm}
N 1980 -4550 1980 -4530 {
lab=ctop}
N 1860 -4450 1880 -4450 {
lab=row_n[12]}
N 1860 -4430 1880 -4430 {
lab=rowon_n[12]}
N 1860 -4410 1880 -4410 {
lab=#net25}
N 1860 -4390 1880 -4390 {
lab=#net26}
N 2100 -4390 2120 -4390 {
lab=#net26}
N 2100 -4410 2120 -4410 {
lab=#net25}
N 2100 -4430 2120 -4430 {
lab=rowon_n[12]}
N 2100 -4450 2120 -4450 {
lab=row_n[12]}
N 1920 -4310 1920 -4300 {
lab=VSS}
N 1920 -4540 1920 -4530 {
lab=VDD}
N 2260 -4310 2270 -4320 {
lab=col_n[6]}
N 2270 -4520 2270 -4320 {
lab=col_n[6]}
N 2260 -4530 2270 -4520 {
lab=col_n[6]}
N 2260 -4310 2260 -4290 {
lab=col_n[6]}
N 2260 -4550 2260 -4530 {
lab=col_n[6]}
N 2140 -4450 2150 -4460 {
lab=row_n[12]}
N 2150 -4460 2350 -4460 {
lab=row_n[12]}
N 2350 -4460 2360 -4450 {
lab=row_n[12]}
N 2140 -4430 2150 -4440 {
lab=rowon_n[12]}
N 2150 -4440 2350 -4440 {
lab=rowon_n[12]}
N 2350 -4440 2360 -4430 {
lab=rowon_n[12]}
N 2140 -4410 2150 -4420 {
lab=#net25}
N 2150 -4420 2350 -4420 {
lab=#net25}
N 2350 -4420 2360 -4410 {
lab=#net25}
N 2140 -4390 2150 -4400 {
lab=#net26}
N 2150 -4400 2350 -4400 {
lab=#net26}
N 2350 -4400 2360 -4390 {
lab=#net26}
N 2200 -4550 2200 -4530 {
lab=vcm}
N 2240 -4550 2240 -4530 {
lab=ctop}
N 2120 -4450 2140 -4450 {
lab=row_n[12]}
N 2120 -4430 2140 -4430 {
lab=rowon_n[12]}
N 2120 -4410 2140 -4410 {
lab=#net25}
N 2120 -4390 2140 -4390 {
lab=#net26}
N 2360 -4390 2380 -4390 {
lab=#net26}
N 2360 -4410 2380 -4410 {
lab=#net25}
N 2360 -4430 2380 -4430 {
lab=rowon_n[12]}
N 2360 -4450 2380 -4450 {
lab=row_n[12]}
N 2180 -4310 2180 -4300 {
lab=VSS}
N 2180 -4540 2180 -4530 {
lab=VDD}
N 2520 -4310 2530 -4320 {
lab=col_n[7]}
N 2530 -4520 2530 -4320 {
lab=col_n[7]}
N 2520 -4530 2530 -4520 {
lab=col_n[7]}
N 2520 -4310 2520 -4290 {
lab=col_n[7]}
N 2520 -4550 2520 -4530 {
lab=col_n[7]}
N 2400 -4450 2410 -4460 {
lab=row_n[12]}
N 2410 -4460 2610 -4460 {
lab=row_n[12]}
N 2610 -4460 2620 -4450 {
lab=row_n[12]}
N 2400 -4430 2410 -4440 {
lab=rowon_n[12]}
N 2410 -4440 2610 -4440 {
lab=rowon_n[12]}
N 2610 -4440 2620 -4430 {
lab=rowon_n[12]}
N 2400 -4410 2410 -4420 {
lab=#net25}
N 2410 -4420 2610 -4420 {
lab=#net25}
N 2610 -4420 2620 -4410 {
lab=#net25}
N 2400 -4390 2410 -4400 {
lab=#net26}
N 2410 -4400 2610 -4400 {
lab=#net26}
N 2610 -4400 2620 -4390 {
lab=#net26}
N 2460 -4550 2460 -4530 {
lab=vcm}
N 2500 -4550 2500 -4530 {
lab=ctop}
N 2380 -4450 2400 -4450 {
lab=row_n[12]}
N 2380 -4430 2400 -4430 {
lab=rowon_n[12]}
N 2380 -4410 2400 -4410 {
lab=#net25}
N 2380 -4390 2400 -4390 {
lab=#net26}
N 2620 -4390 2640 -4390 {
lab=#net26}
N 2620 -4410 2640 -4410 {
lab=#net25}
N 2620 -4430 2640 -4430 {
lab=rowon_n[12]}
N 2620 -4450 2640 -4450 {
lab=row_n[12]}
N 2440 -4310 2440 -4300 {
lab=VSS}
N 2440 -4540 2440 -4530 {
lab=VDD}
N 2780 -4310 2790 -4320 {
lab=col_n[8]}
N 2790 -4520 2790 -4320 {
lab=col_n[8]}
N 2780 -4530 2790 -4520 {
lab=col_n[8]}
N 2780 -4310 2780 -4290 {
lab=col_n[8]}
N 2780 -4550 2780 -4530 {
lab=col_n[8]}
N 2660 -4450 2670 -4460 {
lab=row_n[12]}
N 2670 -4460 2870 -4460 {
lab=row_n[12]}
N 2870 -4460 2880 -4450 {
lab=row_n[12]}
N 2660 -4430 2670 -4440 {
lab=rowon_n[12]}
N 2670 -4440 2870 -4440 {
lab=rowon_n[12]}
N 2870 -4440 2880 -4430 {
lab=rowon_n[12]}
N 2660 -4410 2670 -4420 {
lab=#net25}
N 2670 -4420 2870 -4420 {
lab=#net25}
N 2870 -4420 2880 -4410 {
lab=#net25}
N 2660 -4390 2670 -4400 {
lab=#net26}
N 2670 -4400 2870 -4400 {
lab=#net26}
N 2870 -4400 2880 -4390 {
lab=#net26}
N 2720 -4550 2720 -4530 {
lab=vcm}
N 2760 -4550 2760 -4530 {
lab=ctop}
N 2640 -4450 2660 -4450 {
lab=row_n[12]}
N 2640 -4430 2660 -4430 {
lab=rowon_n[12]}
N 2640 -4410 2660 -4410 {
lab=#net25}
N 2640 -4390 2660 -4390 {
lab=#net26}
N 2880 -4390 2900 -4390 {
lab=#net26}
N 2880 -4410 2900 -4410 {
lab=#net25}
N 2880 -4430 2900 -4430 {
lab=rowon_n[12]}
N 2880 -4450 2900 -4450 {
lab=row_n[12]}
N 2700 -4310 2700 -4300 {
lab=VSS}
N 2700 -4540 2700 -4530 {
lab=VDD}
N 3040 -4310 3050 -4320 {
lab=col_n[9]}
N 3050 -4520 3050 -4320 {
lab=col_n[9]}
N 3040 -4530 3050 -4520 {
lab=col_n[9]}
N 3040 -4310 3040 -4290 {
lab=col_n[9]}
N 3040 -4550 3040 -4530 {
lab=col_n[9]}
N 2920 -4450 2930 -4460 {
lab=row_n[12]}
N 2930 -4460 3130 -4460 {
lab=row_n[12]}
N 3130 -4460 3140 -4450 {
lab=row_n[12]}
N 2920 -4430 2930 -4440 {
lab=rowon_n[12]}
N 2930 -4440 3130 -4440 {
lab=rowon_n[12]}
N 3130 -4440 3140 -4430 {
lab=rowon_n[12]}
N 2920 -4410 2930 -4420 {
lab=#net25}
N 2930 -4420 3130 -4420 {
lab=#net25}
N 3130 -4420 3140 -4410 {
lab=#net25}
N 2920 -4390 2930 -4400 {
lab=#net26}
N 2930 -4400 3130 -4400 {
lab=#net26}
N 3130 -4400 3140 -4390 {
lab=#net26}
N 2980 -4550 2980 -4530 {
lab=vcm}
N 3020 -4550 3020 -4530 {
lab=ctop}
N 2900 -4450 2920 -4450 {
lab=row_n[12]}
N 2900 -4430 2920 -4430 {
lab=rowon_n[12]}
N 2900 -4410 2920 -4410 {
lab=#net25}
N 2900 -4390 2920 -4390 {
lab=#net26}
N 3140 -4390 3160 -4390 {
lab=#net26}
N 3140 -4410 3160 -4410 {
lab=#net25}
N 3140 -4430 3160 -4430 {
lab=rowon_n[12]}
N 3140 -4450 3160 -4450 {
lab=row_n[12]}
N 2960 -4310 2960 -4300 {
lab=VSS}
N 2960 -4540 2960 -4530 {
lab=VDD}
N 3300 -4310 3310 -4320 {
lab=col_n[10]}
N 3310 -4520 3310 -4320 {
lab=col_n[10]}
N 3300 -4530 3310 -4520 {
lab=col_n[10]}
N 3300 -4310 3300 -4290 {
lab=col_n[10]}
N 3300 -4550 3300 -4530 {
lab=col_n[10]}
N 3180 -4450 3190 -4460 {
lab=row_n[12]}
N 3190 -4460 3390 -4460 {
lab=row_n[12]}
N 3390 -4460 3400 -4450 {
lab=row_n[12]}
N 3180 -4430 3190 -4440 {
lab=rowon_n[12]}
N 3190 -4440 3390 -4440 {
lab=rowon_n[12]}
N 3390 -4440 3400 -4430 {
lab=rowon_n[12]}
N 3180 -4410 3190 -4420 {
lab=#net25}
N 3190 -4420 3390 -4420 {
lab=#net25}
N 3390 -4420 3400 -4410 {
lab=#net25}
N 3180 -4390 3190 -4400 {
lab=#net26}
N 3190 -4400 3390 -4400 {
lab=#net26}
N 3390 -4400 3400 -4390 {
lab=#net26}
N 3240 -4550 3240 -4530 {
lab=vcm}
N 3280 -4550 3280 -4530 {
lab=ctop}
N 3160 -4450 3180 -4450 {
lab=row_n[12]}
N 3160 -4430 3180 -4430 {
lab=rowon_n[12]}
N 3160 -4410 3180 -4410 {
lab=#net25}
N 3160 -4390 3180 -4390 {
lab=#net26}
N 3400 -4390 3420 -4390 {
lab=#net26}
N 3400 -4410 3420 -4410 {
lab=#net25}
N 3400 -4430 3420 -4430 {
lab=rowon_n[12]}
N 3400 -4450 3420 -4450 {
lab=row_n[12]}
N 3220 -4310 3220 -4300 {
lab=VSS}
N 3220 -4540 3220 -4530 {
lab=VDD}
N 3560 -4310 3570 -4320 {
lab=col_n[11]}
N 3570 -4520 3570 -4320 {
lab=col_n[11]}
N 3560 -4530 3570 -4520 {
lab=col_n[11]}
N 3560 -4310 3560 -4290 {
lab=col_n[11]}
N 3560 -4550 3560 -4530 {
lab=col_n[11]}
N 3440 -4450 3450 -4460 {
lab=row_n[12]}
N 3450 -4460 3650 -4460 {
lab=row_n[12]}
N 3650 -4460 3660 -4450 {
lab=row_n[12]}
N 3440 -4430 3450 -4440 {
lab=rowon_n[12]}
N 3450 -4440 3650 -4440 {
lab=rowon_n[12]}
N 3650 -4440 3660 -4430 {
lab=rowon_n[12]}
N 3440 -4410 3450 -4420 {
lab=#net25}
N 3450 -4420 3650 -4420 {
lab=#net25}
N 3650 -4420 3660 -4410 {
lab=#net25}
N 3440 -4390 3450 -4400 {
lab=#net26}
N 3450 -4400 3650 -4400 {
lab=#net26}
N 3650 -4400 3660 -4390 {
lab=#net26}
N 3500 -4550 3500 -4530 {
lab=vcm}
N 3540 -4550 3540 -4530 {
lab=ctop}
N 3420 -4450 3440 -4450 {
lab=row_n[12]}
N 3420 -4430 3440 -4430 {
lab=rowon_n[12]}
N 3420 -4410 3440 -4410 {
lab=#net25}
N 3420 -4390 3440 -4390 {
lab=#net26}
N 3660 -4390 3680 -4390 {
lab=#net26}
N 3660 -4410 3680 -4410 {
lab=#net25}
N 3660 -4430 3680 -4430 {
lab=rowon_n[12]}
N 3660 -4450 3680 -4450 {
lab=row_n[12]}
N 3480 -4310 3480 -4300 {
lab=VSS}
N 3480 -4540 3480 -4530 {
lab=VDD}
N 3820 -4310 3830 -4320 {
lab=col_n[12]}
N 3830 -4520 3830 -4320 {
lab=col_n[12]}
N 3820 -4530 3830 -4520 {
lab=col_n[12]}
N 3820 -4310 3820 -4290 {
lab=col_n[12]}
N 3820 -4550 3820 -4530 {
lab=col_n[12]}
N 3700 -4450 3710 -4460 {
lab=row_n[12]}
N 3710 -4460 3910 -4460 {
lab=row_n[12]}
N 3910 -4460 3920 -4450 {
lab=row_n[12]}
N 3700 -4430 3710 -4440 {
lab=rowon_n[12]}
N 3710 -4440 3910 -4440 {
lab=rowon_n[12]}
N 3910 -4440 3920 -4430 {
lab=rowon_n[12]}
N 3700 -4410 3710 -4420 {
lab=#net25}
N 3710 -4420 3910 -4420 {
lab=#net25}
N 3910 -4420 3920 -4410 {
lab=#net25}
N 3700 -4390 3710 -4400 {
lab=#net26}
N 3710 -4400 3910 -4400 {
lab=#net26}
N 3910 -4400 3920 -4390 {
lab=#net26}
N 3760 -4550 3760 -4530 {
lab=vcm}
N 3800 -4550 3800 -4530 {
lab=ctop}
N 3680 -4450 3700 -4450 {
lab=row_n[12]}
N 3680 -4430 3700 -4430 {
lab=rowon_n[12]}
N 3680 -4410 3700 -4410 {
lab=#net25}
N 3680 -4390 3700 -4390 {
lab=#net26}
N 3920 -4390 3940 -4390 {
lab=#net26}
N 3920 -4410 3940 -4410 {
lab=#net25}
N 3920 -4430 3940 -4430 {
lab=rowon_n[12]}
N 3920 -4450 3940 -4450 {
lab=row_n[12]}
N 3740 -4310 3740 -4300 {
lab=VSS}
N 3740 -4540 3740 -4530 {
lab=VDD}
N 4080 -4310 4090 -4320 {
lab=col_n[13]}
N 4090 -4520 4090 -4320 {
lab=col_n[13]}
N 4080 -4530 4090 -4520 {
lab=col_n[13]}
N 4080 -4310 4080 -4290 {
lab=col_n[13]}
N 4080 -4550 4080 -4530 {
lab=col_n[13]}
N 3960 -4450 3970 -4460 {
lab=row_n[12]}
N 3970 -4460 4170 -4460 {
lab=row_n[12]}
N 4170 -4460 4180 -4450 {
lab=row_n[12]}
N 3960 -4430 3970 -4440 {
lab=rowon_n[12]}
N 3970 -4440 4170 -4440 {
lab=rowon_n[12]}
N 4170 -4440 4180 -4430 {
lab=rowon_n[12]}
N 3960 -4410 3970 -4420 {
lab=#net25}
N 3970 -4420 4170 -4420 {
lab=#net25}
N 4170 -4420 4180 -4410 {
lab=#net25}
N 3960 -4390 3970 -4400 {
lab=#net26}
N 3970 -4400 4170 -4400 {
lab=#net26}
N 4170 -4400 4180 -4390 {
lab=#net26}
N 4020 -4550 4020 -4530 {
lab=vcm}
N 4060 -4550 4060 -4530 {
lab=ctop}
N 3940 -4450 3960 -4450 {
lab=row_n[12]}
N 3940 -4430 3960 -4430 {
lab=rowon_n[12]}
N 3940 -4410 3960 -4410 {
lab=#net25}
N 3940 -4390 3960 -4390 {
lab=#net26}
N 4180 -4390 4200 -4390 {
lab=#net26}
N 4180 -4410 4200 -4410 {
lab=#net25}
N 4180 -4430 4200 -4430 {
lab=rowon_n[12]}
N 4180 -4450 4200 -4450 {
lab=row_n[12]}
N 4000 -4310 4000 -4300 {
lab=VSS}
N 4000 -4540 4000 -4530 {
lab=VDD}
N 4340 -4310 4350 -4320 {
lab=col_n[14]}
N 4350 -4520 4350 -4320 {
lab=col_n[14]}
N 4340 -4530 4350 -4520 {
lab=col_n[14]}
N 4340 -4310 4340 -4290 {
lab=col_n[14]}
N 4340 -4550 4340 -4530 {
lab=col_n[14]}
N 4220 -4450 4230 -4460 {
lab=row_n[12]}
N 4230 -4460 4430 -4460 {
lab=row_n[12]}
N 4430 -4460 4440 -4450 {
lab=row_n[12]}
N 4220 -4430 4230 -4440 {
lab=rowon_n[12]}
N 4230 -4440 4430 -4440 {
lab=rowon_n[12]}
N 4430 -4440 4440 -4430 {
lab=rowon_n[12]}
N 4220 -4410 4230 -4420 {
lab=#net25}
N 4230 -4420 4430 -4420 {
lab=#net25}
N 4430 -4420 4440 -4410 {
lab=#net25}
N 4220 -4390 4230 -4400 {
lab=#net26}
N 4230 -4400 4430 -4400 {
lab=#net26}
N 4430 -4400 4440 -4390 {
lab=#net26}
N 4280 -4550 4280 -4530 {
lab=vcm}
N 4320 -4550 4320 -4530 {
lab=ctop}
N 4200 -4450 4220 -4450 {
lab=row_n[12]}
N 4200 -4430 4220 -4430 {
lab=rowon_n[12]}
N 4200 -4410 4220 -4410 {
lab=#net25}
N 4200 -4390 4220 -4390 {
lab=#net26}
N 4440 -4390 4460 -4390 {
lab=#net26}
N 4440 -4410 4460 -4410 {
lab=#net25}
N 4440 -4430 4460 -4430 {
lab=rowon_n[12]}
N 4440 -4450 4460 -4450 {
lab=row_n[12]}
N 4260 -4310 4260 -4300 {
lab=VSS}
N 4260 -4540 4260 -4530 {
lab=VDD}
N 4600 -4310 4610 -4320 {
lab=col_n[15]}
N 4610 -4520 4610 -4320 {
lab=col_n[15]}
N 4600 -4530 4610 -4520 {
lab=col_n[15]}
N 4600 -4310 4600 -4290 {
lab=col_n[15]}
N 4600 -4550 4600 -4530 {
lab=col_n[15]}
N 4480 -4450 4490 -4460 {
lab=row_n[12]}
N 4490 -4460 4690 -4460 {
lab=row_n[12]}
N 4690 -4460 4700 -4450 {
lab=row_n[12]}
N 4480 -4430 4490 -4440 {
lab=rowon_n[12]}
N 4490 -4440 4690 -4440 {
lab=rowon_n[12]}
N 4690 -4440 4700 -4430 {
lab=rowon_n[12]}
N 4480 -4410 4490 -4420 {
lab=#net25}
N 4490 -4420 4690 -4420 {
lab=#net25}
N 4690 -4420 4700 -4410 {
lab=#net25}
N 4480 -4390 4490 -4400 {
lab=#net26}
N 4490 -4400 4690 -4400 {
lab=#net26}
N 4690 -4400 4700 -4390 {
lab=#net26}
N 4540 -4550 4540 -4530 {
lab=vcm}
N 4580 -4550 4580 -4530 {
lab=ctop}
N 4460 -4450 4480 -4450 {
lab=row_n[12]}
N 4460 -4430 4480 -4430 {
lab=rowon_n[12]}
N 4460 -4410 4480 -4410 {
lab=#net25}
N 4460 -4390 4480 -4390 {
lab=#net26}
N 4700 -4390 4720 -4390 {
lab=#net26}
N 4700 -4410 4720 -4410 {
lab=#net25}
N 4700 -4430 4720 -4430 {
lab=rowon_n[12]}
N 4700 -4450 4720 -4450 {
lab=row_n[12]}
N 4520 -4310 4520 -4300 {
lab=VSS}
N 4520 -4540 4520 -4530 {
lab=VDD}
N 4860 -4310 4870 -4320 {
lab=col_n[16]}
N 4870 -4520 4870 -4320 {
lab=col_n[16]}
N 4860 -4530 4870 -4520 {
lab=col_n[16]}
N 4860 -4310 4860 -4290 {
lab=col_n[16]}
N 4860 -4550 4860 -4530 {
lab=col_n[16]}
N 4740 -4450 4750 -4460 {
lab=row_n[12]}
N 4750 -4460 4950 -4460 {
lab=row_n[12]}
N 4950 -4460 4960 -4450 {
lab=row_n[12]}
N 4740 -4430 4750 -4440 {
lab=rowon_n[12]}
N 4750 -4440 4950 -4440 {
lab=rowon_n[12]}
N 4950 -4440 4960 -4430 {
lab=rowon_n[12]}
N 4740 -4410 4750 -4420 {
lab=#net25}
N 4750 -4420 4950 -4420 {
lab=#net25}
N 4950 -4420 4960 -4410 {
lab=#net25}
N 4740 -4390 4750 -4400 {
lab=#net26}
N 4750 -4400 4950 -4400 {
lab=#net26}
N 4950 -4400 4960 -4390 {
lab=#net26}
N 4800 -4550 4800 -4530 {
lab=vcm}
N 4840 -4550 4840 -4530 {
lab=ctop}
N 4720 -4450 4740 -4450 {
lab=row_n[12]}
N 4720 -4430 4740 -4430 {
lab=rowon_n[12]}
N 4720 -4410 4740 -4410 {
lab=#net25}
N 4720 -4390 4740 -4390 {
lab=#net26}
N 4960 -4390 4980 -4390 {
lab=#net26}
N 4960 -4410 4980 -4410 {
lab=#net25}
N 4960 -4430 4980 -4430 {
lab=rowon_n[12]}
N 4960 -4450 4980 -4450 {
lab=row_n[12]}
N 4780 -4310 4780 -4300 {
lab=VSS}
N 4780 -4540 4780 -4530 {
lab=VDD}
N 5120 -4310 5130 -4320 {
lab=col_n[17]}
N 5130 -4520 5130 -4320 {
lab=col_n[17]}
N 5120 -4530 5130 -4520 {
lab=col_n[17]}
N 5120 -4310 5120 -4290 {
lab=col_n[17]}
N 5120 -4550 5120 -4530 {
lab=col_n[17]}
N 5000 -4450 5010 -4460 {
lab=row_n[12]}
N 5010 -4460 5210 -4460 {
lab=row_n[12]}
N 5210 -4460 5220 -4450 {
lab=row_n[12]}
N 5000 -4430 5010 -4440 {
lab=rowon_n[12]}
N 5010 -4440 5210 -4440 {
lab=rowon_n[12]}
N 5210 -4440 5220 -4430 {
lab=rowon_n[12]}
N 5000 -4410 5010 -4420 {
lab=#net25}
N 5010 -4420 5210 -4420 {
lab=#net25}
N 5210 -4420 5220 -4410 {
lab=#net25}
N 5000 -4390 5010 -4400 {
lab=#net26}
N 5010 -4400 5210 -4400 {
lab=#net26}
N 5210 -4400 5220 -4390 {
lab=#net26}
N 5060 -4550 5060 -4530 {
lab=vcm}
N 5100 -4550 5100 -4530 {
lab=ctop}
N 4980 -4450 5000 -4450 {
lab=row_n[12]}
N 4980 -4430 5000 -4430 {
lab=rowon_n[12]}
N 4980 -4410 5000 -4410 {
lab=#net25}
N 4980 -4390 5000 -4390 {
lab=#net26}
N 5220 -4390 5240 -4390 {
lab=#net26}
N 5220 -4410 5240 -4410 {
lab=#net25}
N 5220 -4430 5240 -4430 {
lab=rowon_n[12]}
N 5220 -4450 5240 -4450 {
lab=row_n[12]}
N 5040 -4310 5040 -4300 {
lab=VSS}
N 5040 -4540 5040 -4530 {
lab=VDD}
N 5380 -4310 5390 -4320 {
lab=col_n[18]}
N 5390 -4520 5390 -4320 {
lab=col_n[18]}
N 5380 -4530 5390 -4520 {
lab=col_n[18]}
N 5380 -4310 5380 -4290 {
lab=col_n[18]}
N 5380 -4550 5380 -4530 {
lab=col_n[18]}
N 5260 -4450 5270 -4460 {
lab=row_n[12]}
N 5270 -4460 5470 -4460 {
lab=row_n[12]}
N 5470 -4460 5480 -4450 {
lab=row_n[12]}
N 5260 -4430 5270 -4440 {
lab=rowon_n[12]}
N 5270 -4440 5470 -4440 {
lab=rowon_n[12]}
N 5470 -4440 5480 -4430 {
lab=rowon_n[12]}
N 5260 -4410 5270 -4420 {
lab=#net25}
N 5270 -4420 5470 -4420 {
lab=#net25}
N 5470 -4420 5480 -4410 {
lab=#net25}
N 5260 -4390 5270 -4400 {
lab=#net26}
N 5270 -4400 5470 -4400 {
lab=#net26}
N 5470 -4400 5480 -4390 {
lab=#net26}
N 5320 -4550 5320 -4530 {
lab=vcm}
N 5360 -4550 5360 -4530 {
lab=ctop}
N 5240 -4450 5260 -4450 {
lab=row_n[12]}
N 5240 -4430 5260 -4430 {
lab=rowon_n[12]}
N 5240 -4410 5260 -4410 {
lab=#net25}
N 5240 -4390 5260 -4390 {
lab=#net26}
N 5480 -4390 5500 -4390 {
lab=#net26}
N 5480 -4410 5500 -4410 {
lab=#net25}
N 5480 -4430 5500 -4430 {
lab=rowon_n[12]}
N 5480 -4450 5500 -4450 {
lab=row_n[12]}
N 5300 -4310 5300 -4300 {
lab=VSS}
N 5300 -4540 5300 -4530 {
lab=VDD}
N 5640 -4310 5650 -4320 {
lab=col_n[19]}
N 5650 -4520 5650 -4320 {
lab=col_n[19]}
N 5640 -4530 5650 -4520 {
lab=col_n[19]}
N 5640 -4310 5640 -4290 {
lab=col_n[19]}
N 5640 -4550 5640 -4530 {
lab=col_n[19]}
N 5520 -4450 5530 -4460 {
lab=row_n[12]}
N 5530 -4460 5730 -4460 {
lab=row_n[12]}
N 5730 -4460 5740 -4450 {
lab=row_n[12]}
N 5520 -4430 5530 -4440 {
lab=rowon_n[12]}
N 5530 -4440 5730 -4440 {
lab=rowon_n[12]}
N 5730 -4440 5740 -4430 {
lab=rowon_n[12]}
N 5520 -4410 5530 -4420 {
lab=#net25}
N 5530 -4420 5730 -4420 {
lab=#net25}
N 5730 -4420 5740 -4410 {
lab=#net25}
N 5520 -4390 5530 -4400 {
lab=#net26}
N 5530 -4400 5730 -4400 {
lab=#net26}
N 5730 -4400 5740 -4390 {
lab=#net26}
N 5580 -4550 5580 -4530 {
lab=vcm}
N 5620 -4550 5620 -4530 {
lab=ctop}
N 5500 -4450 5520 -4450 {
lab=row_n[12]}
N 5500 -4430 5520 -4430 {
lab=rowon_n[12]}
N 5500 -4410 5520 -4410 {
lab=#net25}
N 5500 -4390 5520 -4390 {
lab=#net26}
N 5740 -4390 5760 -4390 {
lab=#net26}
N 5740 -4410 5760 -4410 {
lab=#net25}
N 5740 -4430 5760 -4430 {
lab=rowon_n[12]}
N 5740 -4450 5760 -4450 {
lab=row_n[12]}
N 5560 -4310 5560 -4300 {
lab=VSS}
N 5560 -4540 5560 -4530 {
lab=VDD}
N 5900 -4310 5910 -4320 {
lab=col_n[20]}
N 5910 -4520 5910 -4320 {
lab=col_n[20]}
N 5900 -4530 5910 -4520 {
lab=col_n[20]}
N 5900 -4310 5900 -4290 {
lab=col_n[20]}
N 5900 -4550 5900 -4530 {
lab=col_n[20]}
N 5780 -4450 5790 -4460 {
lab=row_n[12]}
N 5790 -4460 5990 -4460 {
lab=row_n[12]}
N 5990 -4460 6000 -4450 {
lab=row_n[12]}
N 5780 -4430 5790 -4440 {
lab=rowon_n[12]}
N 5790 -4440 5990 -4440 {
lab=rowon_n[12]}
N 5990 -4440 6000 -4430 {
lab=rowon_n[12]}
N 5780 -4410 5790 -4420 {
lab=#net25}
N 5790 -4420 5990 -4420 {
lab=#net25}
N 5990 -4420 6000 -4410 {
lab=#net25}
N 5780 -4390 5790 -4400 {
lab=#net26}
N 5790 -4400 5990 -4400 {
lab=#net26}
N 5990 -4400 6000 -4390 {
lab=#net26}
N 5840 -4550 5840 -4530 {
lab=vcm}
N 5880 -4550 5880 -4530 {
lab=ctop}
N 5760 -4450 5780 -4450 {
lab=row_n[12]}
N 5760 -4430 5780 -4430 {
lab=rowon_n[12]}
N 5760 -4410 5780 -4410 {
lab=#net25}
N 5760 -4390 5780 -4390 {
lab=#net26}
N 6000 -4390 6020 -4390 {
lab=#net26}
N 6000 -4410 6020 -4410 {
lab=#net25}
N 6000 -4430 6020 -4430 {
lab=rowon_n[12]}
N 6000 -4450 6020 -4450 {
lab=row_n[12]}
N 5820 -4310 5820 -4300 {
lab=VSS}
N 5820 -4540 5820 -4530 {
lab=VDD}
N 6160 -4310 6170 -4320 {
lab=col_n[21]}
N 6170 -4520 6170 -4320 {
lab=col_n[21]}
N 6160 -4530 6170 -4520 {
lab=col_n[21]}
N 6160 -4310 6160 -4290 {
lab=col_n[21]}
N 6160 -4550 6160 -4530 {
lab=col_n[21]}
N 6040 -4450 6050 -4460 {
lab=row_n[12]}
N 6050 -4460 6250 -4460 {
lab=row_n[12]}
N 6250 -4460 6260 -4450 {
lab=row_n[12]}
N 6040 -4430 6050 -4440 {
lab=rowon_n[12]}
N 6050 -4440 6250 -4440 {
lab=rowon_n[12]}
N 6250 -4440 6260 -4430 {
lab=rowon_n[12]}
N 6040 -4410 6050 -4420 {
lab=#net25}
N 6050 -4420 6250 -4420 {
lab=#net25}
N 6250 -4420 6260 -4410 {
lab=#net25}
N 6040 -4390 6050 -4400 {
lab=#net26}
N 6050 -4400 6250 -4400 {
lab=#net26}
N 6250 -4400 6260 -4390 {
lab=#net26}
N 6100 -4550 6100 -4530 {
lab=vcm}
N 6140 -4550 6140 -4530 {
lab=ctop}
N 6020 -4450 6040 -4450 {
lab=row_n[12]}
N 6020 -4430 6040 -4430 {
lab=rowon_n[12]}
N 6020 -4410 6040 -4410 {
lab=#net25}
N 6020 -4390 6040 -4390 {
lab=#net26}
N 6260 -4390 6280 -4390 {
lab=#net26}
N 6260 -4410 6280 -4410 {
lab=#net25}
N 6260 -4430 6280 -4430 {
lab=rowon_n[12]}
N 6260 -4450 6280 -4450 {
lab=row_n[12]}
N 6080 -4310 6080 -4300 {
lab=VSS}
N 6080 -4540 6080 -4530 {
lab=VDD}
N 6420 -4310 6430 -4320 {
lab=col_n[22]}
N 6430 -4520 6430 -4320 {
lab=col_n[22]}
N 6420 -4530 6430 -4520 {
lab=col_n[22]}
N 6420 -4310 6420 -4290 {
lab=col_n[22]}
N 6420 -4550 6420 -4530 {
lab=col_n[22]}
N 6300 -4450 6310 -4460 {
lab=row_n[12]}
N 6310 -4460 6510 -4460 {
lab=row_n[12]}
N 6510 -4460 6520 -4450 {
lab=row_n[12]}
N 6300 -4430 6310 -4440 {
lab=rowon_n[12]}
N 6310 -4440 6510 -4440 {
lab=rowon_n[12]}
N 6510 -4440 6520 -4430 {
lab=rowon_n[12]}
N 6300 -4410 6310 -4420 {
lab=#net25}
N 6310 -4420 6510 -4420 {
lab=#net25}
N 6510 -4420 6520 -4410 {
lab=#net25}
N 6300 -4390 6310 -4400 {
lab=#net26}
N 6310 -4400 6510 -4400 {
lab=#net26}
N 6510 -4400 6520 -4390 {
lab=#net26}
N 6360 -4550 6360 -4530 {
lab=vcm}
N 6400 -4550 6400 -4530 {
lab=ctop}
N 6280 -4450 6300 -4450 {
lab=row_n[12]}
N 6280 -4430 6300 -4430 {
lab=rowon_n[12]}
N 6280 -4410 6300 -4410 {
lab=#net25}
N 6280 -4390 6300 -4390 {
lab=#net26}
N 6520 -4390 6540 -4390 {
lab=#net26}
N 6520 -4410 6540 -4410 {
lab=#net25}
N 6520 -4430 6540 -4430 {
lab=rowon_n[12]}
N 6520 -4450 6540 -4450 {
lab=row_n[12]}
N 6340 -4310 6340 -4300 {
lab=VSS}
N 6340 -4540 6340 -4530 {
lab=VDD}
N 6680 -4310 6690 -4320 {
lab=col_n[23]}
N 6690 -4520 6690 -4320 {
lab=col_n[23]}
N 6680 -4530 6690 -4520 {
lab=col_n[23]}
N 6680 -4310 6680 -4290 {
lab=col_n[23]}
N 6680 -4550 6680 -4530 {
lab=col_n[23]}
N 6560 -4450 6570 -4460 {
lab=row_n[12]}
N 6570 -4460 6770 -4460 {
lab=row_n[12]}
N 6770 -4460 6780 -4450 {
lab=row_n[12]}
N 6560 -4430 6570 -4440 {
lab=rowon_n[12]}
N 6570 -4440 6770 -4440 {
lab=rowon_n[12]}
N 6770 -4440 6780 -4430 {
lab=rowon_n[12]}
N 6560 -4410 6570 -4420 {
lab=#net25}
N 6570 -4420 6770 -4420 {
lab=#net25}
N 6770 -4420 6780 -4410 {
lab=#net25}
N 6560 -4390 6570 -4400 {
lab=#net26}
N 6570 -4400 6770 -4400 {
lab=#net26}
N 6770 -4400 6780 -4390 {
lab=#net26}
N 6620 -4550 6620 -4530 {
lab=vcm}
N 6660 -4550 6660 -4530 {
lab=ctop}
N 6540 -4450 6560 -4450 {
lab=row_n[12]}
N 6540 -4430 6560 -4430 {
lab=rowon_n[12]}
N 6540 -4410 6560 -4410 {
lab=#net25}
N 6540 -4390 6560 -4390 {
lab=#net26}
N 6780 -4390 6800 -4390 {
lab=#net26}
N 6780 -4410 6800 -4410 {
lab=#net25}
N 6780 -4430 6800 -4430 {
lab=rowon_n[12]}
N 6780 -4450 6800 -4450 {
lab=row_n[12]}
N 6600 -4310 6600 -4300 {
lab=VSS}
N 6600 -4540 6600 -4530 {
lab=VDD}
N 6940 -4310 6950 -4320 {
lab=col_n[24]}
N 6950 -4520 6950 -4320 {
lab=col_n[24]}
N 6940 -4530 6950 -4520 {
lab=col_n[24]}
N 6940 -4310 6940 -4290 {
lab=col_n[24]}
N 6940 -4550 6940 -4530 {
lab=col_n[24]}
N 6820 -4450 6830 -4460 {
lab=row_n[12]}
N 6830 -4460 7030 -4460 {
lab=row_n[12]}
N 7030 -4460 7040 -4450 {
lab=row_n[12]}
N 6820 -4430 6830 -4440 {
lab=rowon_n[12]}
N 6830 -4440 7030 -4440 {
lab=rowon_n[12]}
N 7030 -4440 7040 -4430 {
lab=rowon_n[12]}
N 6820 -4410 6830 -4420 {
lab=#net25}
N 6830 -4420 7030 -4420 {
lab=#net25}
N 7030 -4420 7040 -4410 {
lab=#net25}
N 6820 -4390 6830 -4400 {
lab=#net26}
N 6830 -4400 7030 -4400 {
lab=#net26}
N 7030 -4400 7040 -4390 {
lab=#net26}
N 6880 -4550 6880 -4530 {
lab=vcm}
N 6920 -4550 6920 -4530 {
lab=ctop}
N 6800 -4450 6820 -4450 {
lab=row_n[12]}
N 6800 -4430 6820 -4430 {
lab=rowon_n[12]}
N 6800 -4410 6820 -4410 {
lab=#net25}
N 6800 -4390 6820 -4390 {
lab=#net26}
N 7040 -4390 7060 -4390 {
lab=#net26}
N 7040 -4410 7060 -4410 {
lab=#net25}
N 7040 -4430 7060 -4430 {
lab=rowon_n[12]}
N 7040 -4450 7060 -4450 {
lab=row_n[12]}
N 6860 -4310 6860 -4300 {
lab=VSS}
N 6860 -4540 6860 -4530 {
lab=VDD}
N 7200 -4310 7210 -4320 {
lab=col_n[25]}
N 7210 -4520 7210 -4320 {
lab=col_n[25]}
N 7200 -4530 7210 -4520 {
lab=col_n[25]}
N 7200 -4310 7200 -4290 {
lab=col_n[25]}
N 7200 -4550 7200 -4530 {
lab=col_n[25]}
N 7080 -4450 7090 -4460 {
lab=row_n[12]}
N 7090 -4460 7290 -4460 {
lab=row_n[12]}
N 7290 -4460 7300 -4450 {
lab=row_n[12]}
N 7080 -4430 7090 -4440 {
lab=rowon_n[12]}
N 7090 -4440 7290 -4440 {
lab=rowon_n[12]}
N 7290 -4440 7300 -4430 {
lab=rowon_n[12]}
N 7080 -4410 7090 -4420 {
lab=#net25}
N 7090 -4420 7290 -4420 {
lab=#net25}
N 7290 -4420 7300 -4410 {
lab=#net25}
N 7080 -4390 7090 -4400 {
lab=#net26}
N 7090 -4400 7290 -4400 {
lab=#net26}
N 7290 -4400 7300 -4390 {
lab=#net26}
N 7140 -4550 7140 -4530 {
lab=vcm}
N 7180 -4550 7180 -4530 {
lab=ctop}
N 7060 -4450 7080 -4450 {
lab=row_n[12]}
N 7060 -4430 7080 -4430 {
lab=rowon_n[12]}
N 7060 -4410 7080 -4410 {
lab=#net25}
N 7060 -4390 7080 -4390 {
lab=#net26}
N 7300 -4390 7320 -4390 {
lab=#net26}
N 7300 -4410 7320 -4410 {
lab=#net25}
N 7300 -4430 7320 -4430 {
lab=rowon_n[12]}
N 7300 -4450 7320 -4450 {
lab=row_n[12]}
N 7120 -4310 7120 -4300 {
lab=VSS}
N 7120 -4540 7120 -4530 {
lab=VDD}
N 7460 -4310 7470 -4320 {
lab=col_n[26]}
N 7470 -4520 7470 -4320 {
lab=col_n[26]}
N 7460 -4530 7470 -4520 {
lab=col_n[26]}
N 7460 -4310 7460 -4290 {
lab=col_n[26]}
N 7460 -4550 7460 -4530 {
lab=col_n[26]}
N 7340 -4450 7350 -4460 {
lab=row_n[12]}
N 7350 -4460 7550 -4460 {
lab=row_n[12]}
N 7550 -4460 7560 -4450 {
lab=row_n[12]}
N 7340 -4430 7350 -4440 {
lab=rowon_n[12]}
N 7350 -4440 7550 -4440 {
lab=rowon_n[12]}
N 7550 -4440 7560 -4430 {
lab=rowon_n[12]}
N 7340 -4410 7350 -4420 {
lab=#net25}
N 7350 -4420 7550 -4420 {
lab=#net25}
N 7550 -4420 7560 -4410 {
lab=#net25}
N 7340 -4390 7350 -4400 {
lab=#net26}
N 7350 -4400 7550 -4400 {
lab=#net26}
N 7550 -4400 7560 -4390 {
lab=#net26}
N 7400 -4550 7400 -4530 {
lab=vcm}
N 7440 -4550 7440 -4530 {
lab=ctop}
N 7320 -4450 7340 -4450 {
lab=row_n[12]}
N 7320 -4430 7340 -4430 {
lab=rowon_n[12]}
N 7320 -4410 7340 -4410 {
lab=#net25}
N 7320 -4390 7340 -4390 {
lab=#net26}
N 7560 -4390 7580 -4390 {
lab=#net26}
N 7560 -4410 7580 -4410 {
lab=#net25}
N 7560 -4430 7580 -4430 {
lab=rowon_n[12]}
N 7560 -4450 7580 -4450 {
lab=row_n[12]}
N 7380 -4310 7380 -4300 {
lab=VSS}
N 7380 -4540 7380 -4530 {
lab=VDD}
N 7720 -4310 7730 -4320 {
lab=col_n[27]}
N 7730 -4520 7730 -4320 {
lab=col_n[27]}
N 7720 -4530 7730 -4520 {
lab=col_n[27]}
N 7720 -4310 7720 -4290 {
lab=col_n[27]}
N 7720 -4550 7720 -4530 {
lab=col_n[27]}
N 7600 -4450 7610 -4460 {
lab=row_n[12]}
N 7610 -4460 7810 -4460 {
lab=row_n[12]}
N 7810 -4460 7820 -4450 {
lab=row_n[12]}
N 7600 -4430 7610 -4440 {
lab=rowon_n[12]}
N 7610 -4440 7810 -4440 {
lab=rowon_n[12]}
N 7810 -4440 7820 -4430 {
lab=rowon_n[12]}
N 7600 -4410 7610 -4420 {
lab=#net25}
N 7610 -4420 7810 -4420 {
lab=#net25}
N 7810 -4420 7820 -4410 {
lab=#net25}
N 7600 -4390 7610 -4400 {
lab=#net26}
N 7610 -4400 7810 -4400 {
lab=#net26}
N 7810 -4400 7820 -4390 {
lab=#net26}
N 7660 -4550 7660 -4530 {
lab=vcm}
N 7700 -4550 7700 -4530 {
lab=ctop}
N 7580 -4450 7600 -4450 {
lab=row_n[12]}
N 7580 -4430 7600 -4430 {
lab=rowon_n[12]}
N 7580 -4410 7600 -4410 {
lab=#net25}
N 7580 -4390 7600 -4390 {
lab=#net26}
N 7820 -4390 7840 -4390 {
lab=#net26}
N 7820 -4410 7840 -4410 {
lab=#net25}
N 7820 -4430 7840 -4430 {
lab=rowon_n[12]}
N 7820 -4450 7840 -4450 {
lab=row_n[12]}
N 7640 -4310 7640 -4300 {
lab=VSS}
N 7640 -4540 7640 -4530 {
lab=VDD}
N 7980 -4310 7990 -4320 {
lab=col_n[28]}
N 7990 -4520 7990 -4320 {
lab=col_n[28]}
N 7980 -4530 7990 -4520 {
lab=col_n[28]}
N 7980 -4310 7980 -4290 {
lab=col_n[28]}
N 7980 -4550 7980 -4530 {
lab=col_n[28]}
N 7860 -4450 7870 -4460 {
lab=row_n[12]}
N 7870 -4460 8070 -4460 {
lab=row_n[12]}
N 8070 -4460 8080 -4450 {
lab=row_n[12]}
N 7860 -4430 7870 -4440 {
lab=rowon_n[12]}
N 7870 -4440 8070 -4440 {
lab=rowon_n[12]}
N 8070 -4440 8080 -4430 {
lab=rowon_n[12]}
N 7860 -4410 7870 -4420 {
lab=#net25}
N 7870 -4420 8070 -4420 {
lab=#net25}
N 8070 -4420 8080 -4410 {
lab=#net25}
N 7860 -4390 7870 -4400 {
lab=#net26}
N 7870 -4400 8070 -4400 {
lab=#net26}
N 8070 -4400 8080 -4390 {
lab=#net26}
N 7920 -4550 7920 -4530 {
lab=vcm}
N 7960 -4550 7960 -4530 {
lab=ctop}
N 7840 -4450 7860 -4450 {
lab=row_n[12]}
N 7840 -4430 7860 -4430 {
lab=rowon_n[12]}
N 7840 -4410 7860 -4410 {
lab=#net25}
N 7840 -4390 7860 -4390 {
lab=#net26}
N 8080 -4390 8100 -4390 {
lab=#net26}
N 8080 -4410 8100 -4410 {
lab=#net25}
N 8080 -4430 8100 -4430 {
lab=rowon_n[12]}
N 8080 -4450 8100 -4450 {
lab=row_n[12]}
N 7900 -4310 7900 -4300 {
lab=VSS}
N 7900 -4540 7900 -4530 {
lab=VDD}
N 8240 -4310 8250 -4320 {
lab=col_n[29]}
N 8250 -4520 8250 -4320 {
lab=col_n[29]}
N 8240 -4530 8250 -4520 {
lab=col_n[29]}
N 8240 -4310 8240 -4290 {
lab=col_n[29]}
N 8240 -4550 8240 -4530 {
lab=col_n[29]}
N 8120 -4450 8130 -4460 {
lab=row_n[12]}
N 8130 -4460 8330 -4460 {
lab=row_n[12]}
N 8330 -4460 8340 -4450 {
lab=row_n[12]}
N 8120 -4430 8130 -4440 {
lab=rowon_n[12]}
N 8130 -4440 8330 -4440 {
lab=rowon_n[12]}
N 8330 -4440 8340 -4430 {
lab=rowon_n[12]}
N 8120 -4410 8130 -4420 {
lab=#net25}
N 8130 -4420 8330 -4420 {
lab=#net25}
N 8330 -4420 8340 -4410 {
lab=#net25}
N 8120 -4390 8130 -4400 {
lab=#net26}
N 8130 -4400 8330 -4400 {
lab=#net26}
N 8330 -4400 8340 -4390 {
lab=#net26}
N 8180 -4550 8180 -4530 {
lab=vcm}
N 8220 -4550 8220 -4530 {
lab=ctop}
N 8100 -4450 8120 -4450 {
lab=row_n[12]}
N 8100 -4430 8120 -4430 {
lab=rowon_n[12]}
N 8100 -4410 8120 -4410 {
lab=#net25}
N 8100 -4390 8120 -4390 {
lab=#net26}
N 8340 -4390 8360 -4390 {
lab=#net26}
N 8340 -4410 8360 -4410 {
lab=#net25}
N 8340 -4430 8360 -4430 {
lab=rowon_n[12]}
N 8340 -4450 8360 -4450 {
lab=row_n[12]}
N 8160 -4310 8160 -4300 {
lab=VSS}
N 8160 -4540 8160 -4530 {
lab=VDD}
N 8500 -4310 8510 -4320 {
lab=col_n[30]}
N 8510 -4520 8510 -4320 {
lab=col_n[30]}
N 8500 -4530 8510 -4520 {
lab=col_n[30]}
N 8500 -4310 8500 -4290 {
lab=col_n[30]}
N 8500 -4550 8500 -4530 {
lab=col_n[30]}
N 8380 -4450 8390 -4460 {
lab=row_n[12]}
N 8390 -4460 8590 -4460 {
lab=row_n[12]}
N 8590 -4460 8600 -4450 {
lab=row_n[12]}
N 8380 -4430 8390 -4440 {
lab=rowon_n[12]}
N 8390 -4440 8590 -4440 {
lab=rowon_n[12]}
N 8590 -4440 8600 -4430 {
lab=rowon_n[12]}
N 8380 -4410 8390 -4420 {
lab=#net25}
N 8390 -4420 8590 -4420 {
lab=#net25}
N 8590 -4420 8600 -4410 {
lab=#net25}
N 8380 -4390 8390 -4400 {
lab=#net26}
N 8390 -4400 8590 -4400 {
lab=#net26}
N 8590 -4400 8600 -4390 {
lab=#net26}
N 8440 -4550 8440 -4530 {
lab=vcm}
N 8480 -4550 8480 -4530 {
lab=ctop}
N 8360 -4450 8380 -4450 {
lab=row_n[12]}
N 8360 -4430 8380 -4430 {
lab=rowon_n[12]}
N 8360 -4410 8380 -4410 {
lab=#net25}
N 8360 -4390 8380 -4390 {
lab=#net26}
N 8600 -4390 8620 -4390 {
lab=#net26}
N 8600 -4410 8620 -4410 {
lab=#net25}
N 8600 -4430 8620 -4430 {
lab=rowon_n[12]}
N 8600 -4450 8620 -4450 {
lab=row_n[12]}
N 8420 -4310 8420 -4300 {
lab=VSS}
N 8420 -4540 8420 -4530 {
lab=VDD}
N 8760 -4310 8770 -4320 {
lab=col_n[31]}
N 8770 -4520 8770 -4320 {
lab=col_n[31]}
N 8760 -4530 8770 -4520 {
lab=col_n[31]}
N 8760 -4310 8760 -4290 {
lab=col_n[31]}
N 8760 -4550 8760 -4530 {
lab=col_n[31]}
N 8640 -4450 8650 -4460 {
lab=row_n[12]}
N 8650 -4460 8850 -4460 {
lab=row_n[12]}
N 8850 -4460 8860 -4450 {
lab=row_n[12]}
N 8640 -4430 8650 -4440 {
lab=rowon_n[12]}
N 8650 -4440 8850 -4440 {
lab=rowon_n[12]}
N 8850 -4440 8860 -4430 {
lab=rowon_n[12]}
N 8640 -4410 8650 -4420 {
lab=#net25}
N 8650 -4420 8850 -4420 {
lab=#net25}
N 8850 -4420 8860 -4410 {
lab=#net25}
N 8640 -4390 8650 -4400 {
lab=#net26}
N 8650 -4400 8850 -4400 {
lab=#net26}
N 8850 -4400 8860 -4390 {
lab=#net26}
N 8700 -4550 8700 -4530 {
lab=vcm}
N 8740 -4550 8740 -4530 {
lab=ctop}
N 8620 -4450 8640 -4450 {
lab=row_n[12]}
N 8620 -4430 8640 -4430 {
lab=rowon_n[12]}
N 8620 -4410 8640 -4410 {
lab=#net25}
N 8620 -4390 8640 -4390 {
lab=#net26}
N 8860 -4390 8880 -4390 {
lab=#net26}
N 8860 -4410 8880 -4410 {
lab=#net25}
N 8860 -4430 8880 -4430 {
lab=rowon_n[12]}
N 8860 -4450 8880 -4450 {
lab=row_n[12]}
N 8680 -4310 8680 -4300 {
lab=VSS}
N 8680 -4540 8680 -4530 {
lab=VDD}
N 700 -4570 710 -4580 {
lab=col_n[0]}
N 710 -4780 710 -4580 {
lab=col_n[0]}
N 700 -4790 710 -4780 {
lab=col_n[0]}
N 700 -4570 700 -4550 {
lab=col_n[0]}
N 700 -4810 700 -4790 {
lab=col_n[0]}
N 580 -4710 590 -4720 {
lab=row_n[13]}
N 590 -4720 790 -4720 {
lab=row_n[13]}
N 790 -4720 800 -4710 {
lab=row_n[13]}
N 580 -4690 590 -4700 {
lab=rowon_n[13]}
N 590 -4700 790 -4700 {
lab=rowon_n[13]}
N 790 -4700 800 -4690 {
lab=rowon_n[13]}
N 580 -4670 590 -4680 {
lab=#net27}
N 590 -4680 790 -4680 {
lab=#net27}
N 790 -4680 800 -4670 {
lab=#net27}
N 580 -4650 590 -4660 {
lab=#net28}
N 590 -4660 790 -4660 {
lab=#net28}
N 790 -4660 800 -4650 {
lab=#net28}
N 640 -4810 640 -4790 {
lab=vcm}
N 680 -4810 680 -4790 {
lab=ctop}
N 560 -4710 580 -4710 {
lab=row_n[13]}
N 560 -4690 580 -4690 {
lab=rowon_n[13]}
N 560 -4670 580 -4670 {
lab=#net27}
N 560 -4650 580 -4650 {
lab=#net28}
N 800 -4650 820 -4650 {
lab=#net28}
N 800 -4670 820 -4670 {
lab=#net27}
N 800 -4690 820 -4690 {
lab=rowon_n[13]}
N 800 -4710 820 -4710 {
lab=row_n[13]}
N 620 -4570 620 -4560 {
lab=VSS}
N 620 -4800 620 -4790 {
lab=VDD}
N 960 -4570 970 -4580 {
lab=col_n[1]}
N 970 -4780 970 -4580 {
lab=col_n[1]}
N 960 -4790 970 -4780 {
lab=col_n[1]}
N 960 -4570 960 -4550 {
lab=col_n[1]}
N 960 -4810 960 -4790 {
lab=col_n[1]}
N 840 -4710 850 -4720 {
lab=row_n[13]}
N 850 -4720 1050 -4720 {
lab=row_n[13]}
N 1050 -4720 1060 -4710 {
lab=row_n[13]}
N 840 -4690 850 -4700 {
lab=rowon_n[13]}
N 850 -4700 1050 -4700 {
lab=rowon_n[13]}
N 1050 -4700 1060 -4690 {
lab=rowon_n[13]}
N 840 -4670 850 -4680 {
lab=#net27}
N 850 -4680 1050 -4680 {
lab=#net27}
N 1050 -4680 1060 -4670 {
lab=#net27}
N 840 -4650 850 -4660 {
lab=#net28}
N 850 -4660 1050 -4660 {
lab=#net28}
N 1050 -4660 1060 -4650 {
lab=#net28}
N 900 -4810 900 -4790 {
lab=vcm}
N 940 -4810 940 -4790 {
lab=ctop}
N 820 -4710 840 -4710 {
lab=row_n[13]}
N 820 -4690 840 -4690 {
lab=rowon_n[13]}
N 820 -4670 840 -4670 {
lab=#net27}
N 820 -4650 840 -4650 {
lab=#net28}
N 1060 -4650 1080 -4650 {
lab=#net28}
N 1060 -4670 1080 -4670 {
lab=#net27}
N 1060 -4690 1080 -4690 {
lab=rowon_n[13]}
N 1060 -4710 1080 -4710 {
lab=row_n[13]}
N 880 -4570 880 -4560 {
lab=VSS}
N 880 -4800 880 -4790 {
lab=VDD}
N 1220 -4570 1230 -4580 {
lab=col_n[2]}
N 1230 -4780 1230 -4580 {
lab=col_n[2]}
N 1220 -4790 1230 -4780 {
lab=col_n[2]}
N 1220 -4570 1220 -4550 {
lab=col_n[2]}
N 1220 -4810 1220 -4790 {
lab=col_n[2]}
N 1100 -4710 1110 -4720 {
lab=row_n[13]}
N 1110 -4720 1310 -4720 {
lab=row_n[13]}
N 1310 -4720 1320 -4710 {
lab=row_n[13]}
N 1100 -4690 1110 -4700 {
lab=rowon_n[13]}
N 1110 -4700 1310 -4700 {
lab=rowon_n[13]}
N 1310 -4700 1320 -4690 {
lab=rowon_n[13]}
N 1100 -4670 1110 -4680 {
lab=#net27}
N 1110 -4680 1310 -4680 {
lab=#net27}
N 1310 -4680 1320 -4670 {
lab=#net27}
N 1100 -4650 1110 -4660 {
lab=#net28}
N 1110 -4660 1310 -4660 {
lab=#net28}
N 1310 -4660 1320 -4650 {
lab=#net28}
N 1160 -4810 1160 -4790 {
lab=vcm}
N 1200 -4810 1200 -4790 {
lab=ctop}
N 1080 -4710 1100 -4710 {
lab=row_n[13]}
N 1080 -4690 1100 -4690 {
lab=rowon_n[13]}
N 1080 -4670 1100 -4670 {
lab=#net27}
N 1080 -4650 1100 -4650 {
lab=#net28}
N 1320 -4650 1340 -4650 {
lab=#net28}
N 1320 -4670 1340 -4670 {
lab=#net27}
N 1320 -4690 1340 -4690 {
lab=rowon_n[13]}
N 1320 -4710 1340 -4710 {
lab=row_n[13]}
N 1140 -4570 1140 -4560 {
lab=VSS}
N 1140 -4800 1140 -4790 {
lab=VDD}
N 1480 -4570 1490 -4580 {
lab=col_n[3]}
N 1490 -4780 1490 -4580 {
lab=col_n[3]}
N 1480 -4790 1490 -4780 {
lab=col_n[3]}
N 1480 -4570 1480 -4550 {
lab=col_n[3]}
N 1480 -4810 1480 -4790 {
lab=col_n[3]}
N 1360 -4710 1370 -4720 {
lab=row_n[13]}
N 1370 -4720 1570 -4720 {
lab=row_n[13]}
N 1570 -4720 1580 -4710 {
lab=row_n[13]}
N 1360 -4690 1370 -4700 {
lab=rowon_n[13]}
N 1370 -4700 1570 -4700 {
lab=rowon_n[13]}
N 1570 -4700 1580 -4690 {
lab=rowon_n[13]}
N 1360 -4670 1370 -4680 {
lab=#net27}
N 1370 -4680 1570 -4680 {
lab=#net27}
N 1570 -4680 1580 -4670 {
lab=#net27}
N 1360 -4650 1370 -4660 {
lab=#net28}
N 1370 -4660 1570 -4660 {
lab=#net28}
N 1570 -4660 1580 -4650 {
lab=#net28}
N 1420 -4810 1420 -4790 {
lab=vcm}
N 1460 -4810 1460 -4790 {
lab=ctop}
N 1340 -4710 1360 -4710 {
lab=row_n[13]}
N 1340 -4690 1360 -4690 {
lab=rowon_n[13]}
N 1340 -4670 1360 -4670 {
lab=#net27}
N 1340 -4650 1360 -4650 {
lab=#net28}
N 1580 -4650 1600 -4650 {
lab=#net28}
N 1580 -4670 1600 -4670 {
lab=#net27}
N 1580 -4690 1600 -4690 {
lab=rowon_n[13]}
N 1580 -4710 1600 -4710 {
lab=row_n[13]}
N 1400 -4570 1400 -4560 {
lab=VSS}
N 1400 -4800 1400 -4790 {
lab=VDD}
N 1740 -4570 1750 -4580 {
lab=col_n[4]}
N 1750 -4780 1750 -4580 {
lab=col_n[4]}
N 1740 -4790 1750 -4780 {
lab=col_n[4]}
N 1740 -4570 1740 -4550 {
lab=col_n[4]}
N 1740 -4810 1740 -4790 {
lab=col_n[4]}
N 1620 -4710 1630 -4720 {
lab=row_n[13]}
N 1630 -4720 1830 -4720 {
lab=row_n[13]}
N 1830 -4720 1840 -4710 {
lab=row_n[13]}
N 1620 -4690 1630 -4700 {
lab=rowon_n[13]}
N 1630 -4700 1830 -4700 {
lab=rowon_n[13]}
N 1830 -4700 1840 -4690 {
lab=rowon_n[13]}
N 1620 -4670 1630 -4680 {
lab=#net27}
N 1630 -4680 1830 -4680 {
lab=#net27}
N 1830 -4680 1840 -4670 {
lab=#net27}
N 1620 -4650 1630 -4660 {
lab=#net28}
N 1630 -4660 1830 -4660 {
lab=#net28}
N 1830 -4660 1840 -4650 {
lab=#net28}
N 1680 -4810 1680 -4790 {
lab=vcm}
N 1720 -4810 1720 -4790 {
lab=ctop}
N 1600 -4710 1620 -4710 {
lab=row_n[13]}
N 1600 -4690 1620 -4690 {
lab=rowon_n[13]}
N 1600 -4670 1620 -4670 {
lab=#net27}
N 1600 -4650 1620 -4650 {
lab=#net28}
N 1840 -4650 1860 -4650 {
lab=#net28}
N 1840 -4670 1860 -4670 {
lab=#net27}
N 1840 -4690 1860 -4690 {
lab=rowon_n[13]}
N 1840 -4710 1860 -4710 {
lab=row_n[13]}
N 1660 -4570 1660 -4560 {
lab=VSS}
N 1660 -4800 1660 -4790 {
lab=VDD}
N 2000 -4570 2010 -4580 {
lab=col_n[5]}
N 2010 -4780 2010 -4580 {
lab=col_n[5]}
N 2000 -4790 2010 -4780 {
lab=col_n[5]}
N 2000 -4570 2000 -4550 {
lab=col_n[5]}
N 2000 -4810 2000 -4790 {
lab=col_n[5]}
N 1880 -4710 1890 -4720 {
lab=row_n[13]}
N 1890 -4720 2090 -4720 {
lab=row_n[13]}
N 2090 -4720 2100 -4710 {
lab=row_n[13]}
N 1880 -4690 1890 -4700 {
lab=rowon_n[13]}
N 1890 -4700 2090 -4700 {
lab=rowon_n[13]}
N 2090 -4700 2100 -4690 {
lab=rowon_n[13]}
N 1880 -4670 1890 -4680 {
lab=#net27}
N 1890 -4680 2090 -4680 {
lab=#net27}
N 2090 -4680 2100 -4670 {
lab=#net27}
N 1880 -4650 1890 -4660 {
lab=#net28}
N 1890 -4660 2090 -4660 {
lab=#net28}
N 2090 -4660 2100 -4650 {
lab=#net28}
N 1940 -4810 1940 -4790 {
lab=vcm}
N 1980 -4810 1980 -4790 {
lab=ctop}
N 1860 -4710 1880 -4710 {
lab=row_n[13]}
N 1860 -4690 1880 -4690 {
lab=rowon_n[13]}
N 1860 -4670 1880 -4670 {
lab=#net27}
N 1860 -4650 1880 -4650 {
lab=#net28}
N 2100 -4650 2120 -4650 {
lab=#net28}
N 2100 -4670 2120 -4670 {
lab=#net27}
N 2100 -4690 2120 -4690 {
lab=rowon_n[13]}
N 2100 -4710 2120 -4710 {
lab=row_n[13]}
N 1920 -4570 1920 -4560 {
lab=VSS}
N 1920 -4800 1920 -4790 {
lab=VDD}
N 2260 -4570 2270 -4580 {
lab=col_n[6]}
N 2270 -4780 2270 -4580 {
lab=col_n[6]}
N 2260 -4790 2270 -4780 {
lab=col_n[6]}
N 2260 -4570 2260 -4550 {
lab=col_n[6]}
N 2260 -4810 2260 -4790 {
lab=col_n[6]}
N 2140 -4710 2150 -4720 {
lab=row_n[13]}
N 2150 -4720 2350 -4720 {
lab=row_n[13]}
N 2350 -4720 2360 -4710 {
lab=row_n[13]}
N 2140 -4690 2150 -4700 {
lab=rowon_n[13]}
N 2150 -4700 2350 -4700 {
lab=rowon_n[13]}
N 2350 -4700 2360 -4690 {
lab=rowon_n[13]}
N 2140 -4670 2150 -4680 {
lab=#net27}
N 2150 -4680 2350 -4680 {
lab=#net27}
N 2350 -4680 2360 -4670 {
lab=#net27}
N 2140 -4650 2150 -4660 {
lab=#net28}
N 2150 -4660 2350 -4660 {
lab=#net28}
N 2350 -4660 2360 -4650 {
lab=#net28}
N 2200 -4810 2200 -4790 {
lab=vcm}
N 2240 -4810 2240 -4790 {
lab=ctop}
N 2120 -4710 2140 -4710 {
lab=row_n[13]}
N 2120 -4690 2140 -4690 {
lab=rowon_n[13]}
N 2120 -4670 2140 -4670 {
lab=#net27}
N 2120 -4650 2140 -4650 {
lab=#net28}
N 2360 -4650 2380 -4650 {
lab=#net28}
N 2360 -4670 2380 -4670 {
lab=#net27}
N 2360 -4690 2380 -4690 {
lab=rowon_n[13]}
N 2360 -4710 2380 -4710 {
lab=row_n[13]}
N 2180 -4570 2180 -4560 {
lab=VSS}
N 2180 -4800 2180 -4790 {
lab=VDD}
N 2520 -4570 2530 -4580 {
lab=col_n[7]}
N 2530 -4780 2530 -4580 {
lab=col_n[7]}
N 2520 -4790 2530 -4780 {
lab=col_n[7]}
N 2520 -4570 2520 -4550 {
lab=col_n[7]}
N 2520 -4810 2520 -4790 {
lab=col_n[7]}
N 2400 -4710 2410 -4720 {
lab=row_n[13]}
N 2410 -4720 2610 -4720 {
lab=row_n[13]}
N 2610 -4720 2620 -4710 {
lab=row_n[13]}
N 2400 -4690 2410 -4700 {
lab=rowon_n[13]}
N 2410 -4700 2610 -4700 {
lab=rowon_n[13]}
N 2610 -4700 2620 -4690 {
lab=rowon_n[13]}
N 2400 -4670 2410 -4680 {
lab=#net27}
N 2410 -4680 2610 -4680 {
lab=#net27}
N 2610 -4680 2620 -4670 {
lab=#net27}
N 2400 -4650 2410 -4660 {
lab=#net28}
N 2410 -4660 2610 -4660 {
lab=#net28}
N 2610 -4660 2620 -4650 {
lab=#net28}
N 2460 -4810 2460 -4790 {
lab=vcm}
N 2500 -4810 2500 -4790 {
lab=ctop}
N 2380 -4710 2400 -4710 {
lab=row_n[13]}
N 2380 -4690 2400 -4690 {
lab=rowon_n[13]}
N 2380 -4670 2400 -4670 {
lab=#net27}
N 2380 -4650 2400 -4650 {
lab=#net28}
N 2620 -4650 2640 -4650 {
lab=#net28}
N 2620 -4670 2640 -4670 {
lab=#net27}
N 2620 -4690 2640 -4690 {
lab=rowon_n[13]}
N 2620 -4710 2640 -4710 {
lab=row_n[13]}
N 2440 -4570 2440 -4560 {
lab=VSS}
N 2440 -4800 2440 -4790 {
lab=VDD}
N 2780 -4570 2790 -4580 {
lab=col_n[8]}
N 2790 -4780 2790 -4580 {
lab=col_n[8]}
N 2780 -4790 2790 -4780 {
lab=col_n[8]}
N 2780 -4570 2780 -4550 {
lab=col_n[8]}
N 2780 -4810 2780 -4790 {
lab=col_n[8]}
N 2660 -4710 2670 -4720 {
lab=row_n[13]}
N 2670 -4720 2870 -4720 {
lab=row_n[13]}
N 2870 -4720 2880 -4710 {
lab=row_n[13]}
N 2660 -4690 2670 -4700 {
lab=rowon_n[13]}
N 2670 -4700 2870 -4700 {
lab=rowon_n[13]}
N 2870 -4700 2880 -4690 {
lab=rowon_n[13]}
N 2660 -4670 2670 -4680 {
lab=#net27}
N 2670 -4680 2870 -4680 {
lab=#net27}
N 2870 -4680 2880 -4670 {
lab=#net27}
N 2660 -4650 2670 -4660 {
lab=#net28}
N 2670 -4660 2870 -4660 {
lab=#net28}
N 2870 -4660 2880 -4650 {
lab=#net28}
N 2720 -4810 2720 -4790 {
lab=vcm}
N 2760 -4810 2760 -4790 {
lab=ctop}
N 2640 -4710 2660 -4710 {
lab=row_n[13]}
N 2640 -4690 2660 -4690 {
lab=rowon_n[13]}
N 2640 -4670 2660 -4670 {
lab=#net27}
N 2640 -4650 2660 -4650 {
lab=#net28}
N 2880 -4650 2900 -4650 {
lab=#net28}
N 2880 -4670 2900 -4670 {
lab=#net27}
N 2880 -4690 2900 -4690 {
lab=rowon_n[13]}
N 2880 -4710 2900 -4710 {
lab=row_n[13]}
N 2700 -4570 2700 -4560 {
lab=VSS}
N 2700 -4800 2700 -4790 {
lab=VDD}
N 3040 -4570 3050 -4580 {
lab=col_n[9]}
N 3050 -4780 3050 -4580 {
lab=col_n[9]}
N 3040 -4790 3050 -4780 {
lab=col_n[9]}
N 3040 -4570 3040 -4550 {
lab=col_n[9]}
N 3040 -4810 3040 -4790 {
lab=col_n[9]}
N 2920 -4710 2930 -4720 {
lab=row_n[13]}
N 2930 -4720 3130 -4720 {
lab=row_n[13]}
N 3130 -4720 3140 -4710 {
lab=row_n[13]}
N 2920 -4690 2930 -4700 {
lab=rowon_n[13]}
N 2930 -4700 3130 -4700 {
lab=rowon_n[13]}
N 3130 -4700 3140 -4690 {
lab=rowon_n[13]}
N 2920 -4670 2930 -4680 {
lab=#net27}
N 2930 -4680 3130 -4680 {
lab=#net27}
N 3130 -4680 3140 -4670 {
lab=#net27}
N 2920 -4650 2930 -4660 {
lab=#net28}
N 2930 -4660 3130 -4660 {
lab=#net28}
N 3130 -4660 3140 -4650 {
lab=#net28}
N 2980 -4810 2980 -4790 {
lab=vcm}
N 3020 -4810 3020 -4790 {
lab=ctop}
N 2900 -4710 2920 -4710 {
lab=row_n[13]}
N 2900 -4690 2920 -4690 {
lab=rowon_n[13]}
N 2900 -4670 2920 -4670 {
lab=#net27}
N 2900 -4650 2920 -4650 {
lab=#net28}
N 3140 -4650 3160 -4650 {
lab=#net28}
N 3140 -4670 3160 -4670 {
lab=#net27}
N 3140 -4690 3160 -4690 {
lab=rowon_n[13]}
N 3140 -4710 3160 -4710 {
lab=row_n[13]}
N 2960 -4570 2960 -4560 {
lab=VSS}
N 2960 -4800 2960 -4790 {
lab=VDD}
N 3300 -4570 3310 -4580 {
lab=col_n[10]}
N 3310 -4780 3310 -4580 {
lab=col_n[10]}
N 3300 -4790 3310 -4780 {
lab=col_n[10]}
N 3300 -4570 3300 -4550 {
lab=col_n[10]}
N 3300 -4810 3300 -4790 {
lab=col_n[10]}
N 3180 -4710 3190 -4720 {
lab=row_n[13]}
N 3190 -4720 3390 -4720 {
lab=row_n[13]}
N 3390 -4720 3400 -4710 {
lab=row_n[13]}
N 3180 -4690 3190 -4700 {
lab=rowon_n[13]}
N 3190 -4700 3390 -4700 {
lab=rowon_n[13]}
N 3390 -4700 3400 -4690 {
lab=rowon_n[13]}
N 3180 -4670 3190 -4680 {
lab=#net27}
N 3190 -4680 3390 -4680 {
lab=#net27}
N 3390 -4680 3400 -4670 {
lab=#net27}
N 3180 -4650 3190 -4660 {
lab=#net28}
N 3190 -4660 3390 -4660 {
lab=#net28}
N 3390 -4660 3400 -4650 {
lab=#net28}
N 3240 -4810 3240 -4790 {
lab=vcm}
N 3280 -4810 3280 -4790 {
lab=ctop}
N 3160 -4710 3180 -4710 {
lab=row_n[13]}
N 3160 -4690 3180 -4690 {
lab=rowon_n[13]}
N 3160 -4670 3180 -4670 {
lab=#net27}
N 3160 -4650 3180 -4650 {
lab=#net28}
N 3400 -4650 3420 -4650 {
lab=#net28}
N 3400 -4670 3420 -4670 {
lab=#net27}
N 3400 -4690 3420 -4690 {
lab=rowon_n[13]}
N 3400 -4710 3420 -4710 {
lab=row_n[13]}
N 3220 -4570 3220 -4560 {
lab=VSS}
N 3220 -4800 3220 -4790 {
lab=VDD}
N 3560 -4570 3570 -4580 {
lab=col_n[11]}
N 3570 -4780 3570 -4580 {
lab=col_n[11]}
N 3560 -4790 3570 -4780 {
lab=col_n[11]}
N 3560 -4570 3560 -4550 {
lab=col_n[11]}
N 3560 -4810 3560 -4790 {
lab=col_n[11]}
N 3440 -4710 3450 -4720 {
lab=row_n[13]}
N 3450 -4720 3650 -4720 {
lab=row_n[13]}
N 3650 -4720 3660 -4710 {
lab=row_n[13]}
N 3440 -4690 3450 -4700 {
lab=rowon_n[13]}
N 3450 -4700 3650 -4700 {
lab=rowon_n[13]}
N 3650 -4700 3660 -4690 {
lab=rowon_n[13]}
N 3440 -4670 3450 -4680 {
lab=#net27}
N 3450 -4680 3650 -4680 {
lab=#net27}
N 3650 -4680 3660 -4670 {
lab=#net27}
N 3440 -4650 3450 -4660 {
lab=#net28}
N 3450 -4660 3650 -4660 {
lab=#net28}
N 3650 -4660 3660 -4650 {
lab=#net28}
N 3500 -4810 3500 -4790 {
lab=vcm}
N 3540 -4810 3540 -4790 {
lab=ctop}
N 3420 -4710 3440 -4710 {
lab=row_n[13]}
N 3420 -4690 3440 -4690 {
lab=rowon_n[13]}
N 3420 -4670 3440 -4670 {
lab=#net27}
N 3420 -4650 3440 -4650 {
lab=#net28}
N 3660 -4650 3680 -4650 {
lab=#net28}
N 3660 -4670 3680 -4670 {
lab=#net27}
N 3660 -4690 3680 -4690 {
lab=rowon_n[13]}
N 3660 -4710 3680 -4710 {
lab=row_n[13]}
N 3480 -4570 3480 -4560 {
lab=VSS}
N 3480 -4800 3480 -4790 {
lab=VDD}
N 3820 -4570 3830 -4580 {
lab=col_n[12]}
N 3830 -4780 3830 -4580 {
lab=col_n[12]}
N 3820 -4790 3830 -4780 {
lab=col_n[12]}
N 3820 -4570 3820 -4550 {
lab=col_n[12]}
N 3820 -4810 3820 -4790 {
lab=col_n[12]}
N 3700 -4710 3710 -4720 {
lab=row_n[13]}
N 3710 -4720 3910 -4720 {
lab=row_n[13]}
N 3910 -4720 3920 -4710 {
lab=row_n[13]}
N 3700 -4690 3710 -4700 {
lab=rowon_n[13]}
N 3710 -4700 3910 -4700 {
lab=rowon_n[13]}
N 3910 -4700 3920 -4690 {
lab=rowon_n[13]}
N 3700 -4670 3710 -4680 {
lab=#net27}
N 3710 -4680 3910 -4680 {
lab=#net27}
N 3910 -4680 3920 -4670 {
lab=#net27}
N 3700 -4650 3710 -4660 {
lab=#net28}
N 3710 -4660 3910 -4660 {
lab=#net28}
N 3910 -4660 3920 -4650 {
lab=#net28}
N 3760 -4810 3760 -4790 {
lab=vcm}
N 3800 -4810 3800 -4790 {
lab=ctop}
N 3680 -4710 3700 -4710 {
lab=row_n[13]}
N 3680 -4690 3700 -4690 {
lab=rowon_n[13]}
N 3680 -4670 3700 -4670 {
lab=#net27}
N 3680 -4650 3700 -4650 {
lab=#net28}
N 3920 -4650 3940 -4650 {
lab=#net28}
N 3920 -4670 3940 -4670 {
lab=#net27}
N 3920 -4690 3940 -4690 {
lab=rowon_n[13]}
N 3920 -4710 3940 -4710 {
lab=row_n[13]}
N 3740 -4570 3740 -4560 {
lab=VSS}
N 3740 -4800 3740 -4790 {
lab=VDD}
N 4080 -4570 4090 -4580 {
lab=col_n[13]}
N 4090 -4780 4090 -4580 {
lab=col_n[13]}
N 4080 -4790 4090 -4780 {
lab=col_n[13]}
N 4080 -4570 4080 -4550 {
lab=col_n[13]}
N 4080 -4810 4080 -4790 {
lab=col_n[13]}
N 3960 -4710 3970 -4720 {
lab=row_n[13]}
N 3970 -4720 4170 -4720 {
lab=row_n[13]}
N 4170 -4720 4180 -4710 {
lab=row_n[13]}
N 3960 -4690 3970 -4700 {
lab=rowon_n[13]}
N 3970 -4700 4170 -4700 {
lab=rowon_n[13]}
N 4170 -4700 4180 -4690 {
lab=rowon_n[13]}
N 3960 -4670 3970 -4680 {
lab=#net27}
N 3970 -4680 4170 -4680 {
lab=#net27}
N 4170 -4680 4180 -4670 {
lab=#net27}
N 3960 -4650 3970 -4660 {
lab=#net28}
N 3970 -4660 4170 -4660 {
lab=#net28}
N 4170 -4660 4180 -4650 {
lab=#net28}
N 4020 -4810 4020 -4790 {
lab=vcm}
N 4060 -4810 4060 -4790 {
lab=ctop}
N 3940 -4710 3960 -4710 {
lab=row_n[13]}
N 3940 -4690 3960 -4690 {
lab=rowon_n[13]}
N 3940 -4670 3960 -4670 {
lab=#net27}
N 3940 -4650 3960 -4650 {
lab=#net28}
N 4180 -4650 4200 -4650 {
lab=#net28}
N 4180 -4670 4200 -4670 {
lab=#net27}
N 4180 -4690 4200 -4690 {
lab=rowon_n[13]}
N 4180 -4710 4200 -4710 {
lab=row_n[13]}
N 4000 -4570 4000 -4560 {
lab=VSS}
N 4000 -4800 4000 -4790 {
lab=VDD}
N 4340 -4570 4350 -4580 {
lab=col_n[14]}
N 4350 -4780 4350 -4580 {
lab=col_n[14]}
N 4340 -4790 4350 -4780 {
lab=col_n[14]}
N 4340 -4570 4340 -4550 {
lab=col_n[14]}
N 4340 -4810 4340 -4790 {
lab=col_n[14]}
N 4220 -4710 4230 -4720 {
lab=row_n[13]}
N 4230 -4720 4430 -4720 {
lab=row_n[13]}
N 4430 -4720 4440 -4710 {
lab=row_n[13]}
N 4220 -4690 4230 -4700 {
lab=rowon_n[13]}
N 4230 -4700 4430 -4700 {
lab=rowon_n[13]}
N 4430 -4700 4440 -4690 {
lab=rowon_n[13]}
N 4220 -4670 4230 -4680 {
lab=#net27}
N 4230 -4680 4430 -4680 {
lab=#net27}
N 4430 -4680 4440 -4670 {
lab=#net27}
N 4220 -4650 4230 -4660 {
lab=#net28}
N 4230 -4660 4430 -4660 {
lab=#net28}
N 4430 -4660 4440 -4650 {
lab=#net28}
N 4280 -4810 4280 -4790 {
lab=vcm}
N 4320 -4810 4320 -4790 {
lab=ctop}
N 4200 -4710 4220 -4710 {
lab=row_n[13]}
N 4200 -4690 4220 -4690 {
lab=rowon_n[13]}
N 4200 -4670 4220 -4670 {
lab=#net27}
N 4200 -4650 4220 -4650 {
lab=#net28}
N 4440 -4650 4460 -4650 {
lab=#net28}
N 4440 -4670 4460 -4670 {
lab=#net27}
N 4440 -4690 4460 -4690 {
lab=rowon_n[13]}
N 4440 -4710 4460 -4710 {
lab=row_n[13]}
N 4260 -4570 4260 -4560 {
lab=VSS}
N 4260 -4800 4260 -4790 {
lab=VDD}
N 4600 -4570 4610 -4580 {
lab=col_n[15]}
N 4610 -4780 4610 -4580 {
lab=col_n[15]}
N 4600 -4790 4610 -4780 {
lab=col_n[15]}
N 4600 -4570 4600 -4550 {
lab=col_n[15]}
N 4600 -4810 4600 -4790 {
lab=col_n[15]}
N 4480 -4710 4490 -4720 {
lab=row_n[13]}
N 4490 -4720 4690 -4720 {
lab=row_n[13]}
N 4690 -4720 4700 -4710 {
lab=row_n[13]}
N 4480 -4690 4490 -4700 {
lab=rowon_n[13]}
N 4490 -4700 4690 -4700 {
lab=rowon_n[13]}
N 4690 -4700 4700 -4690 {
lab=rowon_n[13]}
N 4480 -4670 4490 -4680 {
lab=#net27}
N 4490 -4680 4690 -4680 {
lab=#net27}
N 4690 -4680 4700 -4670 {
lab=#net27}
N 4480 -4650 4490 -4660 {
lab=#net28}
N 4490 -4660 4690 -4660 {
lab=#net28}
N 4690 -4660 4700 -4650 {
lab=#net28}
N 4540 -4810 4540 -4790 {
lab=vcm}
N 4580 -4810 4580 -4790 {
lab=ctop}
N 4460 -4710 4480 -4710 {
lab=row_n[13]}
N 4460 -4690 4480 -4690 {
lab=rowon_n[13]}
N 4460 -4670 4480 -4670 {
lab=#net27}
N 4460 -4650 4480 -4650 {
lab=#net28}
N 4700 -4650 4720 -4650 {
lab=#net28}
N 4700 -4670 4720 -4670 {
lab=#net27}
N 4700 -4690 4720 -4690 {
lab=rowon_n[13]}
N 4700 -4710 4720 -4710 {
lab=row_n[13]}
N 4520 -4570 4520 -4560 {
lab=VSS}
N 4520 -4800 4520 -4790 {
lab=VDD}
N 4860 -4570 4870 -4580 {
lab=col_n[16]}
N 4870 -4780 4870 -4580 {
lab=col_n[16]}
N 4860 -4790 4870 -4780 {
lab=col_n[16]}
N 4860 -4570 4860 -4550 {
lab=col_n[16]}
N 4860 -4810 4860 -4790 {
lab=col_n[16]}
N 4740 -4710 4750 -4720 {
lab=row_n[13]}
N 4750 -4720 4950 -4720 {
lab=row_n[13]}
N 4950 -4720 4960 -4710 {
lab=row_n[13]}
N 4740 -4690 4750 -4700 {
lab=rowon_n[13]}
N 4750 -4700 4950 -4700 {
lab=rowon_n[13]}
N 4950 -4700 4960 -4690 {
lab=rowon_n[13]}
N 4740 -4670 4750 -4680 {
lab=#net27}
N 4750 -4680 4950 -4680 {
lab=#net27}
N 4950 -4680 4960 -4670 {
lab=#net27}
N 4740 -4650 4750 -4660 {
lab=#net28}
N 4750 -4660 4950 -4660 {
lab=#net28}
N 4950 -4660 4960 -4650 {
lab=#net28}
N 4800 -4810 4800 -4790 {
lab=vcm}
N 4840 -4810 4840 -4790 {
lab=ctop}
N 4720 -4710 4740 -4710 {
lab=row_n[13]}
N 4720 -4690 4740 -4690 {
lab=rowon_n[13]}
N 4720 -4670 4740 -4670 {
lab=#net27}
N 4720 -4650 4740 -4650 {
lab=#net28}
N 4960 -4650 4980 -4650 {
lab=#net28}
N 4960 -4670 4980 -4670 {
lab=#net27}
N 4960 -4690 4980 -4690 {
lab=rowon_n[13]}
N 4960 -4710 4980 -4710 {
lab=row_n[13]}
N 4780 -4570 4780 -4560 {
lab=VSS}
N 4780 -4800 4780 -4790 {
lab=VDD}
N 5120 -4570 5130 -4580 {
lab=col_n[17]}
N 5130 -4780 5130 -4580 {
lab=col_n[17]}
N 5120 -4790 5130 -4780 {
lab=col_n[17]}
N 5120 -4570 5120 -4550 {
lab=col_n[17]}
N 5120 -4810 5120 -4790 {
lab=col_n[17]}
N 5000 -4710 5010 -4720 {
lab=row_n[13]}
N 5010 -4720 5210 -4720 {
lab=row_n[13]}
N 5210 -4720 5220 -4710 {
lab=row_n[13]}
N 5000 -4690 5010 -4700 {
lab=rowon_n[13]}
N 5010 -4700 5210 -4700 {
lab=rowon_n[13]}
N 5210 -4700 5220 -4690 {
lab=rowon_n[13]}
N 5000 -4670 5010 -4680 {
lab=#net27}
N 5010 -4680 5210 -4680 {
lab=#net27}
N 5210 -4680 5220 -4670 {
lab=#net27}
N 5000 -4650 5010 -4660 {
lab=#net28}
N 5010 -4660 5210 -4660 {
lab=#net28}
N 5210 -4660 5220 -4650 {
lab=#net28}
N 5060 -4810 5060 -4790 {
lab=vcm}
N 5100 -4810 5100 -4790 {
lab=ctop}
N 4980 -4710 5000 -4710 {
lab=row_n[13]}
N 4980 -4690 5000 -4690 {
lab=rowon_n[13]}
N 4980 -4670 5000 -4670 {
lab=#net27}
N 4980 -4650 5000 -4650 {
lab=#net28}
N 5220 -4650 5240 -4650 {
lab=#net28}
N 5220 -4670 5240 -4670 {
lab=#net27}
N 5220 -4690 5240 -4690 {
lab=rowon_n[13]}
N 5220 -4710 5240 -4710 {
lab=row_n[13]}
N 5040 -4570 5040 -4560 {
lab=VSS}
N 5040 -4800 5040 -4790 {
lab=VDD}
N 5380 -4570 5390 -4580 {
lab=col_n[18]}
N 5390 -4780 5390 -4580 {
lab=col_n[18]}
N 5380 -4790 5390 -4780 {
lab=col_n[18]}
N 5380 -4570 5380 -4550 {
lab=col_n[18]}
N 5380 -4810 5380 -4790 {
lab=col_n[18]}
N 5260 -4710 5270 -4720 {
lab=row_n[13]}
N 5270 -4720 5470 -4720 {
lab=row_n[13]}
N 5470 -4720 5480 -4710 {
lab=row_n[13]}
N 5260 -4690 5270 -4700 {
lab=rowon_n[13]}
N 5270 -4700 5470 -4700 {
lab=rowon_n[13]}
N 5470 -4700 5480 -4690 {
lab=rowon_n[13]}
N 5260 -4670 5270 -4680 {
lab=#net27}
N 5270 -4680 5470 -4680 {
lab=#net27}
N 5470 -4680 5480 -4670 {
lab=#net27}
N 5260 -4650 5270 -4660 {
lab=#net28}
N 5270 -4660 5470 -4660 {
lab=#net28}
N 5470 -4660 5480 -4650 {
lab=#net28}
N 5320 -4810 5320 -4790 {
lab=vcm}
N 5360 -4810 5360 -4790 {
lab=ctop}
N 5240 -4710 5260 -4710 {
lab=row_n[13]}
N 5240 -4690 5260 -4690 {
lab=rowon_n[13]}
N 5240 -4670 5260 -4670 {
lab=#net27}
N 5240 -4650 5260 -4650 {
lab=#net28}
N 5480 -4650 5500 -4650 {
lab=#net28}
N 5480 -4670 5500 -4670 {
lab=#net27}
N 5480 -4690 5500 -4690 {
lab=rowon_n[13]}
N 5480 -4710 5500 -4710 {
lab=row_n[13]}
N 5300 -4570 5300 -4560 {
lab=VSS}
N 5300 -4800 5300 -4790 {
lab=VDD}
N 5640 -4570 5650 -4580 {
lab=col_n[19]}
N 5650 -4780 5650 -4580 {
lab=col_n[19]}
N 5640 -4790 5650 -4780 {
lab=col_n[19]}
N 5640 -4570 5640 -4550 {
lab=col_n[19]}
N 5640 -4810 5640 -4790 {
lab=col_n[19]}
N 5520 -4710 5530 -4720 {
lab=row_n[13]}
N 5530 -4720 5730 -4720 {
lab=row_n[13]}
N 5730 -4720 5740 -4710 {
lab=row_n[13]}
N 5520 -4690 5530 -4700 {
lab=rowon_n[13]}
N 5530 -4700 5730 -4700 {
lab=rowon_n[13]}
N 5730 -4700 5740 -4690 {
lab=rowon_n[13]}
N 5520 -4670 5530 -4680 {
lab=#net27}
N 5530 -4680 5730 -4680 {
lab=#net27}
N 5730 -4680 5740 -4670 {
lab=#net27}
N 5520 -4650 5530 -4660 {
lab=#net28}
N 5530 -4660 5730 -4660 {
lab=#net28}
N 5730 -4660 5740 -4650 {
lab=#net28}
N 5580 -4810 5580 -4790 {
lab=vcm}
N 5620 -4810 5620 -4790 {
lab=ctop}
N 5500 -4710 5520 -4710 {
lab=row_n[13]}
N 5500 -4690 5520 -4690 {
lab=rowon_n[13]}
N 5500 -4670 5520 -4670 {
lab=#net27}
N 5500 -4650 5520 -4650 {
lab=#net28}
N 5740 -4650 5760 -4650 {
lab=#net28}
N 5740 -4670 5760 -4670 {
lab=#net27}
N 5740 -4690 5760 -4690 {
lab=rowon_n[13]}
N 5740 -4710 5760 -4710 {
lab=row_n[13]}
N 5560 -4570 5560 -4560 {
lab=VSS}
N 5560 -4800 5560 -4790 {
lab=VDD}
N 5900 -4570 5910 -4580 {
lab=col_n[20]}
N 5910 -4780 5910 -4580 {
lab=col_n[20]}
N 5900 -4790 5910 -4780 {
lab=col_n[20]}
N 5900 -4570 5900 -4550 {
lab=col_n[20]}
N 5900 -4810 5900 -4790 {
lab=col_n[20]}
N 5780 -4710 5790 -4720 {
lab=row_n[13]}
N 5790 -4720 5990 -4720 {
lab=row_n[13]}
N 5990 -4720 6000 -4710 {
lab=row_n[13]}
N 5780 -4690 5790 -4700 {
lab=rowon_n[13]}
N 5790 -4700 5990 -4700 {
lab=rowon_n[13]}
N 5990 -4700 6000 -4690 {
lab=rowon_n[13]}
N 5780 -4670 5790 -4680 {
lab=#net27}
N 5790 -4680 5990 -4680 {
lab=#net27}
N 5990 -4680 6000 -4670 {
lab=#net27}
N 5780 -4650 5790 -4660 {
lab=#net28}
N 5790 -4660 5990 -4660 {
lab=#net28}
N 5990 -4660 6000 -4650 {
lab=#net28}
N 5840 -4810 5840 -4790 {
lab=vcm}
N 5880 -4810 5880 -4790 {
lab=ctop}
N 5760 -4710 5780 -4710 {
lab=row_n[13]}
N 5760 -4690 5780 -4690 {
lab=rowon_n[13]}
N 5760 -4670 5780 -4670 {
lab=#net27}
N 5760 -4650 5780 -4650 {
lab=#net28}
N 6000 -4650 6020 -4650 {
lab=#net28}
N 6000 -4670 6020 -4670 {
lab=#net27}
N 6000 -4690 6020 -4690 {
lab=rowon_n[13]}
N 6000 -4710 6020 -4710 {
lab=row_n[13]}
N 5820 -4570 5820 -4560 {
lab=VSS}
N 5820 -4800 5820 -4790 {
lab=VDD}
N 6160 -4570 6170 -4580 {
lab=col_n[21]}
N 6170 -4780 6170 -4580 {
lab=col_n[21]}
N 6160 -4790 6170 -4780 {
lab=col_n[21]}
N 6160 -4570 6160 -4550 {
lab=col_n[21]}
N 6160 -4810 6160 -4790 {
lab=col_n[21]}
N 6040 -4710 6050 -4720 {
lab=row_n[13]}
N 6050 -4720 6250 -4720 {
lab=row_n[13]}
N 6250 -4720 6260 -4710 {
lab=row_n[13]}
N 6040 -4690 6050 -4700 {
lab=rowon_n[13]}
N 6050 -4700 6250 -4700 {
lab=rowon_n[13]}
N 6250 -4700 6260 -4690 {
lab=rowon_n[13]}
N 6040 -4670 6050 -4680 {
lab=#net27}
N 6050 -4680 6250 -4680 {
lab=#net27}
N 6250 -4680 6260 -4670 {
lab=#net27}
N 6040 -4650 6050 -4660 {
lab=#net28}
N 6050 -4660 6250 -4660 {
lab=#net28}
N 6250 -4660 6260 -4650 {
lab=#net28}
N 6100 -4810 6100 -4790 {
lab=vcm}
N 6140 -4810 6140 -4790 {
lab=ctop}
N 6020 -4710 6040 -4710 {
lab=row_n[13]}
N 6020 -4690 6040 -4690 {
lab=rowon_n[13]}
N 6020 -4670 6040 -4670 {
lab=#net27}
N 6020 -4650 6040 -4650 {
lab=#net28}
N 6260 -4650 6280 -4650 {
lab=#net28}
N 6260 -4670 6280 -4670 {
lab=#net27}
N 6260 -4690 6280 -4690 {
lab=rowon_n[13]}
N 6260 -4710 6280 -4710 {
lab=row_n[13]}
N 6080 -4570 6080 -4560 {
lab=VSS}
N 6080 -4800 6080 -4790 {
lab=VDD}
N 6420 -4570 6430 -4580 {
lab=col_n[22]}
N 6430 -4780 6430 -4580 {
lab=col_n[22]}
N 6420 -4790 6430 -4780 {
lab=col_n[22]}
N 6420 -4570 6420 -4550 {
lab=col_n[22]}
N 6420 -4810 6420 -4790 {
lab=col_n[22]}
N 6300 -4710 6310 -4720 {
lab=row_n[13]}
N 6310 -4720 6510 -4720 {
lab=row_n[13]}
N 6510 -4720 6520 -4710 {
lab=row_n[13]}
N 6300 -4690 6310 -4700 {
lab=rowon_n[13]}
N 6310 -4700 6510 -4700 {
lab=rowon_n[13]}
N 6510 -4700 6520 -4690 {
lab=rowon_n[13]}
N 6300 -4670 6310 -4680 {
lab=#net27}
N 6310 -4680 6510 -4680 {
lab=#net27}
N 6510 -4680 6520 -4670 {
lab=#net27}
N 6300 -4650 6310 -4660 {
lab=#net28}
N 6310 -4660 6510 -4660 {
lab=#net28}
N 6510 -4660 6520 -4650 {
lab=#net28}
N 6360 -4810 6360 -4790 {
lab=vcm}
N 6400 -4810 6400 -4790 {
lab=ctop}
N 6280 -4710 6300 -4710 {
lab=row_n[13]}
N 6280 -4690 6300 -4690 {
lab=rowon_n[13]}
N 6280 -4670 6300 -4670 {
lab=#net27}
N 6280 -4650 6300 -4650 {
lab=#net28}
N 6520 -4650 6540 -4650 {
lab=#net28}
N 6520 -4670 6540 -4670 {
lab=#net27}
N 6520 -4690 6540 -4690 {
lab=rowon_n[13]}
N 6520 -4710 6540 -4710 {
lab=row_n[13]}
N 6340 -4570 6340 -4560 {
lab=VSS}
N 6340 -4800 6340 -4790 {
lab=VDD}
N 6680 -4570 6690 -4580 {
lab=col_n[23]}
N 6690 -4780 6690 -4580 {
lab=col_n[23]}
N 6680 -4790 6690 -4780 {
lab=col_n[23]}
N 6680 -4570 6680 -4550 {
lab=col_n[23]}
N 6680 -4810 6680 -4790 {
lab=col_n[23]}
N 6560 -4710 6570 -4720 {
lab=row_n[13]}
N 6570 -4720 6770 -4720 {
lab=row_n[13]}
N 6770 -4720 6780 -4710 {
lab=row_n[13]}
N 6560 -4690 6570 -4700 {
lab=rowon_n[13]}
N 6570 -4700 6770 -4700 {
lab=rowon_n[13]}
N 6770 -4700 6780 -4690 {
lab=rowon_n[13]}
N 6560 -4670 6570 -4680 {
lab=#net27}
N 6570 -4680 6770 -4680 {
lab=#net27}
N 6770 -4680 6780 -4670 {
lab=#net27}
N 6560 -4650 6570 -4660 {
lab=#net28}
N 6570 -4660 6770 -4660 {
lab=#net28}
N 6770 -4660 6780 -4650 {
lab=#net28}
N 6620 -4810 6620 -4790 {
lab=vcm}
N 6660 -4810 6660 -4790 {
lab=ctop}
N 6540 -4710 6560 -4710 {
lab=row_n[13]}
N 6540 -4690 6560 -4690 {
lab=rowon_n[13]}
N 6540 -4670 6560 -4670 {
lab=#net27}
N 6540 -4650 6560 -4650 {
lab=#net28}
N 6780 -4650 6800 -4650 {
lab=#net28}
N 6780 -4670 6800 -4670 {
lab=#net27}
N 6780 -4690 6800 -4690 {
lab=rowon_n[13]}
N 6780 -4710 6800 -4710 {
lab=row_n[13]}
N 6600 -4570 6600 -4560 {
lab=VSS}
N 6600 -4800 6600 -4790 {
lab=VDD}
N 6940 -4570 6950 -4580 {
lab=col_n[24]}
N 6950 -4780 6950 -4580 {
lab=col_n[24]}
N 6940 -4790 6950 -4780 {
lab=col_n[24]}
N 6940 -4570 6940 -4550 {
lab=col_n[24]}
N 6940 -4810 6940 -4790 {
lab=col_n[24]}
N 6820 -4710 6830 -4720 {
lab=row_n[13]}
N 6830 -4720 7030 -4720 {
lab=row_n[13]}
N 7030 -4720 7040 -4710 {
lab=row_n[13]}
N 6820 -4690 6830 -4700 {
lab=rowon_n[13]}
N 6830 -4700 7030 -4700 {
lab=rowon_n[13]}
N 7030 -4700 7040 -4690 {
lab=rowon_n[13]}
N 6820 -4670 6830 -4680 {
lab=#net27}
N 6830 -4680 7030 -4680 {
lab=#net27}
N 7030 -4680 7040 -4670 {
lab=#net27}
N 6820 -4650 6830 -4660 {
lab=#net28}
N 6830 -4660 7030 -4660 {
lab=#net28}
N 7030 -4660 7040 -4650 {
lab=#net28}
N 6880 -4810 6880 -4790 {
lab=vcm}
N 6920 -4810 6920 -4790 {
lab=ctop}
N 6800 -4710 6820 -4710 {
lab=row_n[13]}
N 6800 -4690 6820 -4690 {
lab=rowon_n[13]}
N 6800 -4670 6820 -4670 {
lab=#net27}
N 6800 -4650 6820 -4650 {
lab=#net28}
N 7040 -4650 7060 -4650 {
lab=#net28}
N 7040 -4670 7060 -4670 {
lab=#net27}
N 7040 -4690 7060 -4690 {
lab=rowon_n[13]}
N 7040 -4710 7060 -4710 {
lab=row_n[13]}
N 6860 -4570 6860 -4560 {
lab=VSS}
N 6860 -4800 6860 -4790 {
lab=VDD}
N 7200 -4570 7210 -4580 {
lab=col_n[25]}
N 7210 -4780 7210 -4580 {
lab=col_n[25]}
N 7200 -4790 7210 -4780 {
lab=col_n[25]}
N 7200 -4570 7200 -4550 {
lab=col_n[25]}
N 7200 -4810 7200 -4790 {
lab=col_n[25]}
N 7080 -4710 7090 -4720 {
lab=row_n[13]}
N 7090 -4720 7290 -4720 {
lab=row_n[13]}
N 7290 -4720 7300 -4710 {
lab=row_n[13]}
N 7080 -4690 7090 -4700 {
lab=rowon_n[13]}
N 7090 -4700 7290 -4700 {
lab=rowon_n[13]}
N 7290 -4700 7300 -4690 {
lab=rowon_n[13]}
N 7080 -4670 7090 -4680 {
lab=#net27}
N 7090 -4680 7290 -4680 {
lab=#net27}
N 7290 -4680 7300 -4670 {
lab=#net27}
N 7080 -4650 7090 -4660 {
lab=#net28}
N 7090 -4660 7290 -4660 {
lab=#net28}
N 7290 -4660 7300 -4650 {
lab=#net28}
N 7140 -4810 7140 -4790 {
lab=vcm}
N 7180 -4810 7180 -4790 {
lab=ctop}
N 7060 -4710 7080 -4710 {
lab=row_n[13]}
N 7060 -4690 7080 -4690 {
lab=rowon_n[13]}
N 7060 -4670 7080 -4670 {
lab=#net27}
N 7060 -4650 7080 -4650 {
lab=#net28}
N 7300 -4650 7320 -4650 {
lab=#net28}
N 7300 -4670 7320 -4670 {
lab=#net27}
N 7300 -4690 7320 -4690 {
lab=rowon_n[13]}
N 7300 -4710 7320 -4710 {
lab=row_n[13]}
N 7120 -4570 7120 -4560 {
lab=VSS}
N 7120 -4800 7120 -4790 {
lab=VDD}
N 7460 -4570 7470 -4580 {
lab=col_n[26]}
N 7470 -4780 7470 -4580 {
lab=col_n[26]}
N 7460 -4790 7470 -4780 {
lab=col_n[26]}
N 7460 -4570 7460 -4550 {
lab=col_n[26]}
N 7460 -4810 7460 -4790 {
lab=col_n[26]}
N 7340 -4710 7350 -4720 {
lab=row_n[13]}
N 7350 -4720 7550 -4720 {
lab=row_n[13]}
N 7550 -4720 7560 -4710 {
lab=row_n[13]}
N 7340 -4690 7350 -4700 {
lab=rowon_n[13]}
N 7350 -4700 7550 -4700 {
lab=rowon_n[13]}
N 7550 -4700 7560 -4690 {
lab=rowon_n[13]}
N 7340 -4670 7350 -4680 {
lab=#net27}
N 7350 -4680 7550 -4680 {
lab=#net27}
N 7550 -4680 7560 -4670 {
lab=#net27}
N 7340 -4650 7350 -4660 {
lab=#net28}
N 7350 -4660 7550 -4660 {
lab=#net28}
N 7550 -4660 7560 -4650 {
lab=#net28}
N 7400 -4810 7400 -4790 {
lab=vcm}
N 7440 -4810 7440 -4790 {
lab=ctop}
N 7320 -4710 7340 -4710 {
lab=row_n[13]}
N 7320 -4690 7340 -4690 {
lab=rowon_n[13]}
N 7320 -4670 7340 -4670 {
lab=#net27}
N 7320 -4650 7340 -4650 {
lab=#net28}
N 7560 -4650 7580 -4650 {
lab=#net28}
N 7560 -4670 7580 -4670 {
lab=#net27}
N 7560 -4690 7580 -4690 {
lab=rowon_n[13]}
N 7560 -4710 7580 -4710 {
lab=row_n[13]}
N 7380 -4570 7380 -4560 {
lab=VSS}
N 7380 -4800 7380 -4790 {
lab=VDD}
N 7720 -4570 7730 -4580 {
lab=col_n[27]}
N 7730 -4780 7730 -4580 {
lab=col_n[27]}
N 7720 -4790 7730 -4780 {
lab=col_n[27]}
N 7720 -4570 7720 -4550 {
lab=col_n[27]}
N 7720 -4810 7720 -4790 {
lab=col_n[27]}
N 7600 -4710 7610 -4720 {
lab=row_n[13]}
N 7610 -4720 7810 -4720 {
lab=row_n[13]}
N 7810 -4720 7820 -4710 {
lab=row_n[13]}
N 7600 -4690 7610 -4700 {
lab=rowon_n[13]}
N 7610 -4700 7810 -4700 {
lab=rowon_n[13]}
N 7810 -4700 7820 -4690 {
lab=rowon_n[13]}
N 7600 -4670 7610 -4680 {
lab=#net27}
N 7610 -4680 7810 -4680 {
lab=#net27}
N 7810 -4680 7820 -4670 {
lab=#net27}
N 7600 -4650 7610 -4660 {
lab=#net28}
N 7610 -4660 7810 -4660 {
lab=#net28}
N 7810 -4660 7820 -4650 {
lab=#net28}
N 7660 -4810 7660 -4790 {
lab=vcm}
N 7700 -4810 7700 -4790 {
lab=ctop}
N 7580 -4710 7600 -4710 {
lab=row_n[13]}
N 7580 -4690 7600 -4690 {
lab=rowon_n[13]}
N 7580 -4670 7600 -4670 {
lab=#net27}
N 7580 -4650 7600 -4650 {
lab=#net28}
N 7820 -4650 7840 -4650 {
lab=#net28}
N 7820 -4670 7840 -4670 {
lab=#net27}
N 7820 -4690 7840 -4690 {
lab=rowon_n[13]}
N 7820 -4710 7840 -4710 {
lab=row_n[13]}
N 7640 -4570 7640 -4560 {
lab=VSS}
N 7640 -4800 7640 -4790 {
lab=VDD}
N 7980 -4570 7990 -4580 {
lab=col_n[28]}
N 7990 -4780 7990 -4580 {
lab=col_n[28]}
N 7980 -4790 7990 -4780 {
lab=col_n[28]}
N 7980 -4570 7980 -4550 {
lab=col_n[28]}
N 7980 -4810 7980 -4790 {
lab=col_n[28]}
N 7860 -4710 7870 -4720 {
lab=row_n[13]}
N 7870 -4720 8070 -4720 {
lab=row_n[13]}
N 8070 -4720 8080 -4710 {
lab=row_n[13]}
N 7860 -4690 7870 -4700 {
lab=rowon_n[13]}
N 7870 -4700 8070 -4700 {
lab=rowon_n[13]}
N 8070 -4700 8080 -4690 {
lab=rowon_n[13]}
N 7860 -4670 7870 -4680 {
lab=#net27}
N 7870 -4680 8070 -4680 {
lab=#net27}
N 8070 -4680 8080 -4670 {
lab=#net27}
N 7860 -4650 7870 -4660 {
lab=#net28}
N 7870 -4660 8070 -4660 {
lab=#net28}
N 8070 -4660 8080 -4650 {
lab=#net28}
N 7920 -4810 7920 -4790 {
lab=vcm}
N 7960 -4810 7960 -4790 {
lab=ctop}
N 7840 -4710 7860 -4710 {
lab=row_n[13]}
N 7840 -4690 7860 -4690 {
lab=rowon_n[13]}
N 7840 -4670 7860 -4670 {
lab=#net27}
N 7840 -4650 7860 -4650 {
lab=#net28}
N 8080 -4650 8100 -4650 {
lab=#net28}
N 8080 -4670 8100 -4670 {
lab=#net27}
N 8080 -4690 8100 -4690 {
lab=rowon_n[13]}
N 8080 -4710 8100 -4710 {
lab=row_n[13]}
N 7900 -4570 7900 -4560 {
lab=VSS}
N 7900 -4800 7900 -4790 {
lab=VDD}
N 8240 -4570 8250 -4580 {
lab=col_n[29]}
N 8250 -4780 8250 -4580 {
lab=col_n[29]}
N 8240 -4790 8250 -4780 {
lab=col_n[29]}
N 8240 -4570 8240 -4550 {
lab=col_n[29]}
N 8240 -4810 8240 -4790 {
lab=col_n[29]}
N 8120 -4710 8130 -4720 {
lab=row_n[13]}
N 8130 -4720 8330 -4720 {
lab=row_n[13]}
N 8330 -4720 8340 -4710 {
lab=row_n[13]}
N 8120 -4690 8130 -4700 {
lab=rowon_n[13]}
N 8130 -4700 8330 -4700 {
lab=rowon_n[13]}
N 8330 -4700 8340 -4690 {
lab=rowon_n[13]}
N 8120 -4670 8130 -4680 {
lab=#net27}
N 8130 -4680 8330 -4680 {
lab=#net27}
N 8330 -4680 8340 -4670 {
lab=#net27}
N 8120 -4650 8130 -4660 {
lab=#net28}
N 8130 -4660 8330 -4660 {
lab=#net28}
N 8330 -4660 8340 -4650 {
lab=#net28}
N 8180 -4810 8180 -4790 {
lab=vcm}
N 8220 -4810 8220 -4790 {
lab=ctop}
N 8100 -4710 8120 -4710 {
lab=row_n[13]}
N 8100 -4690 8120 -4690 {
lab=rowon_n[13]}
N 8100 -4670 8120 -4670 {
lab=#net27}
N 8100 -4650 8120 -4650 {
lab=#net28}
N 8340 -4650 8360 -4650 {
lab=#net28}
N 8340 -4670 8360 -4670 {
lab=#net27}
N 8340 -4690 8360 -4690 {
lab=rowon_n[13]}
N 8340 -4710 8360 -4710 {
lab=row_n[13]}
N 8160 -4570 8160 -4560 {
lab=VSS}
N 8160 -4800 8160 -4790 {
lab=VDD}
N 8500 -4570 8510 -4580 {
lab=col_n[30]}
N 8510 -4780 8510 -4580 {
lab=col_n[30]}
N 8500 -4790 8510 -4780 {
lab=col_n[30]}
N 8500 -4570 8500 -4550 {
lab=col_n[30]}
N 8500 -4810 8500 -4790 {
lab=col_n[30]}
N 8380 -4710 8390 -4720 {
lab=row_n[13]}
N 8390 -4720 8590 -4720 {
lab=row_n[13]}
N 8590 -4720 8600 -4710 {
lab=row_n[13]}
N 8380 -4690 8390 -4700 {
lab=rowon_n[13]}
N 8390 -4700 8590 -4700 {
lab=rowon_n[13]}
N 8590 -4700 8600 -4690 {
lab=rowon_n[13]}
N 8380 -4670 8390 -4680 {
lab=#net27}
N 8390 -4680 8590 -4680 {
lab=#net27}
N 8590 -4680 8600 -4670 {
lab=#net27}
N 8380 -4650 8390 -4660 {
lab=#net28}
N 8390 -4660 8590 -4660 {
lab=#net28}
N 8590 -4660 8600 -4650 {
lab=#net28}
N 8440 -4810 8440 -4790 {
lab=vcm}
N 8480 -4810 8480 -4790 {
lab=ctop}
N 8360 -4710 8380 -4710 {
lab=row_n[13]}
N 8360 -4690 8380 -4690 {
lab=rowon_n[13]}
N 8360 -4670 8380 -4670 {
lab=#net27}
N 8360 -4650 8380 -4650 {
lab=#net28}
N 8600 -4650 8620 -4650 {
lab=#net28}
N 8600 -4670 8620 -4670 {
lab=#net27}
N 8600 -4690 8620 -4690 {
lab=rowon_n[13]}
N 8600 -4710 8620 -4710 {
lab=row_n[13]}
N 8420 -4570 8420 -4560 {
lab=VSS}
N 8420 -4800 8420 -4790 {
lab=VDD}
N 8760 -4570 8770 -4580 {
lab=col_n[31]}
N 8770 -4780 8770 -4580 {
lab=col_n[31]}
N 8760 -4790 8770 -4780 {
lab=col_n[31]}
N 8760 -4570 8760 -4550 {
lab=col_n[31]}
N 8760 -4810 8760 -4790 {
lab=col_n[31]}
N 8640 -4710 8650 -4720 {
lab=row_n[13]}
N 8650 -4720 8850 -4720 {
lab=row_n[13]}
N 8850 -4720 8860 -4710 {
lab=row_n[13]}
N 8640 -4690 8650 -4700 {
lab=rowon_n[13]}
N 8650 -4700 8850 -4700 {
lab=rowon_n[13]}
N 8850 -4700 8860 -4690 {
lab=rowon_n[13]}
N 8640 -4670 8650 -4680 {
lab=#net27}
N 8650 -4680 8850 -4680 {
lab=#net27}
N 8850 -4680 8860 -4670 {
lab=#net27}
N 8640 -4650 8650 -4660 {
lab=#net28}
N 8650 -4660 8850 -4660 {
lab=#net28}
N 8850 -4660 8860 -4650 {
lab=#net28}
N 8700 -4810 8700 -4790 {
lab=vcm}
N 8740 -4810 8740 -4790 {
lab=ctop}
N 8620 -4710 8640 -4710 {
lab=row_n[13]}
N 8620 -4690 8640 -4690 {
lab=rowon_n[13]}
N 8620 -4670 8640 -4670 {
lab=#net27}
N 8620 -4650 8640 -4650 {
lab=#net28}
N 8860 -4650 8880 -4650 {
lab=#net28}
N 8860 -4670 8880 -4670 {
lab=#net27}
N 8860 -4690 8880 -4690 {
lab=rowon_n[13]}
N 8860 -4710 8880 -4710 {
lab=row_n[13]}
N 8680 -4570 8680 -4560 {
lab=VSS}
N 8680 -4800 8680 -4790 {
lab=VDD}
N 700 -4830 710 -4840 {
lab=col_n[0]}
N 710 -5040 710 -4840 {
lab=col_n[0]}
N 700 -5050 710 -5040 {
lab=col_n[0]}
N 700 -4830 700 -4810 {
lab=col_n[0]}
N 700 -5070 700 -5050 {
lab=col_n[0]}
N 580 -4970 590 -4980 {
lab=row_n[14]}
N 590 -4980 790 -4980 {
lab=row_n[14]}
N 790 -4980 800 -4970 {
lab=row_n[14]}
N 580 -4950 590 -4960 {
lab=rowon_n[14]}
N 590 -4960 790 -4960 {
lab=rowon_n[14]}
N 790 -4960 800 -4950 {
lab=rowon_n[14]}
N 580 -4930 590 -4940 {
lab=#net29}
N 590 -4940 790 -4940 {
lab=#net29}
N 790 -4940 800 -4930 {
lab=#net29}
N 580 -4910 590 -4920 {
lab=#net30}
N 590 -4920 790 -4920 {
lab=#net30}
N 790 -4920 800 -4910 {
lab=#net30}
N 640 -5070 640 -5050 {
lab=vcm}
N 680 -5070 680 -5050 {
lab=ctop}
N 560 -4970 580 -4970 {
lab=row_n[14]}
N 560 -4950 580 -4950 {
lab=rowon_n[14]}
N 560 -4930 580 -4930 {
lab=#net29}
N 560 -4910 580 -4910 {
lab=#net30}
N 800 -4910 820 -4910 {
lab=#net30}
N 800 -4930 820 -4930 {
lab=#net29}
N 800 -4950 820 -4950 {
lab=rowon_n[14]}
N 800 -4970 820 -4970 {
lab=row_n[14]}
N 620 -4830 620 -4820 {
lab=VSS}
N 620 -5060 620 -5050 {
lab=VDD}
N 960 -4830 970 -4840 {
lab=col_n[1]}
N 970 -5040 970 -4840 {
lab=col_n[1]}
N 960 -5050 970 -5040 {
lab=col_n[1]}
N 960 -4830 960 -4810 {
lab=col_n[1]}
N 960 -5070 960 -5050 {
lab=col_n[1]}
N 840 -4970 850 -4980 {
lab=row_n[14]}
N 850 -4980 1050 -4980 {
lab=row_n[14]}
N 1050 -4980 1060 -4970 {
lab=row_n[14]}
N 840 -4950 850 -4960 {
lab=rowon_n[14]}
N 850 -4960 1050 -4960 {
lab=rowon_n[14]}
N 1050 -4960 1060 -4950 {
lab=rowon_n[14]}
N 840 -4930 850 -4940 {
lab=#net29}
N 850 -4940 1050 -4940 {
lab=#net29}
N 1050 -4940 1060 -4930 {
lab=#net29}
N 840 -4910 850 -4920 {
lab=#net30}
N 850 -4920 1050 -4920 {
lab=#net30}
N 1050 -4920 1060 -4910 {
lab=#net30}
N 900 -5070 900 -5050 {
lab=vcm}
N 940 -5070 940 -5050 {
lab=ctop}
N 820 -4970 840 -4970 {
lab=row_n[14]}
N 820 -4950 840 -4950 {
lab=rowon_n[14]}
N 820 -4930 840 -4930 {
lab=#net29}
N 820 -4910 840 -4910 {
lab=#net30}
N 1060 -4910 1080 -4910 {
lab=#net30}
N 1060 -4930 1080 -4930 {
lab=#net29}
N 1060 -4950 1080 -4950 {
lab=rowon_n[14]}
N 1060 -4970 1080 -4970 {
lab=row_n[14]}
N 880 -4830 880 -4820 {
lab=VSS}
N 880 -5060 880 -5050 {
lab=VDD}
N 1220 -4830 1230 -4840 {
lab=col_n[2]}
N 1230 -5040 1230 -4840 {
lab=col_n[2]}
N 1220 -5050 1230 -5040 {
lab=col_n[2]}
N 1220 -4830 1220 -4810 {
lab=col_n[2]}
N 1220 -5070 1220 -5050 {
lab=col_n[2]}
N 1100 -4970 1110 -4980 {
lab=row_n[14]}
N 1110 -4980 1310 -4980 {
lab=row_n[14]}
N 1310 -4980 1320 -4970 {
lab=row_n[14]}
N 1100 -4950 1110 -4960 {
lab=rowon_n[14]}
N 1110 -4960 1310 -4960 {
lab=rowon_n[14]}
N 1310 -4960 1320 -4950 {
lab=rowon_n[14]}
N 1100 -4930 1110 -4940 {
lab=#net29}
N 1110 -4940 1310 -4940 {
lab=#net29}
N 1310 -4940 1320 -4930 {
lab=#net29}
N 1100 -4910 1110 -4920 {
lab=#net30}
N 1110 -4920 1310 -4920 {
lab=#net30}
N 1310 -4920 1320 -4910 {
lab=#net30}
N 1160 -5070 1160 -5050 {
lab=vcm}
N 1200 -5070 1200 -5050 {
lab=ctop}
N 1080 -4970 1100 -4970 {
lab=row_n[14]}
N 1080 -4950 1100 -4950 {
lab=rowon_n[14]}
N 1080 -4930 1100 -4930 {
lab=#net29}
N 1080 -4910 1100 -4910 {
lab=#net30}
N 1320 -4910 1340 -4910 {
lab=#net30}
N 1320 -4930 1340 -4930 {
lab=#net29}
N 1320 -4950 1340 -4950 {
lab=rowon_n[14]}
N 1320 -4970 1340 -4970 {
lab=row_n[14]}
N 1140 -4830 1140 -4820 {
lab=VSS}
N 1140 -5060 1140 -5050 {
lab=VDD}
N 1480 -4830 1490 -4840 {
lab=col_n[3]}
N 1490 -5040 1490 -4840 {
lab=col_n[3]}
N 1480 -5050 1490 -5040 {
lab=col_n[3]}
N 1480 -4830 1480 -4810 {
lab=col_n[3]}
N 1480 -5070 1480 -5050 {
lab=col_n[3]}
N 1360 -4970 1370 -4980 {
lab=row_n[14]}
N 1370 -4980 1570 -4980 {
lab=row_n[14]}
N 1570 -4980 1580 -4970 {
lab=row_n[14]}
N 1360 -4950 1370 -4960 {
lab=rowon_n[14]}
N 1370 -4960 1570 -4960 {
lab=rowon_n[14]}
N 1570 -4960 1580 -4950 {
lab=rowon_n[14]}
N 1360 -4930 1370 -4940 {
lab=#net29}
N 1370 -4940 1570 -4940 {
lab=#net29}
N 1570 -4940 1580 -4930 {
lab=#net29}
N 1360 -4910 1370 -4920 {
lab=#net30}
N 1370 -4920 1570 -4920 {
lab=#net30}
N 1570 -4920 1580 -4910 {
lab=#net30}
N 1420 -5070 1420 -5050 {
lab=vcm}
N 1460 -5070 1460 -5050 {
lab=ctop}
N 1340 -4970 1360 -4970 {
lab=row_n[14]}
N 1340 -4950 1360 -4950 {
lab=rowon_n[14]}
N 1340 -4930 1360 -4930 {
lab=#net29}
N 1340 -4910 1360 -4910 {
lab=#net30}
N 1580 -4910 1600 -4910 {
lab=#net30}
N 1580 -4930 1600 -4930 {
lab=#net29}
N 1580 -4950 1600 -4950 {
lab=rowon_n[14]}
N 1580 -4970 1600 -4970 {
lab=row_n[14]}
N 1400 -4830 1400 -4820 {
lab=VSS}
N 1400 -5060 1400 -5050 {
lab=VDD}
N 1740 -4830 1750 -4840 {
lab=col_n[4]}
N 1750 -5040 1750 -4840 {
lab=col_n[4]}
N 1740 -5050 1750 -5040 {
lab=col_n[4]}
N 1740 -4830 1740 -4810 {
lab=col_n[4]}
N 1740 -5070 1740 -5050 {
lab=col_n[4]}
N 1620 -4970 1630 -4980 {
lab=row_n[14]}
N 1630 -4980 1830 -4980 {
lab=row_n[14]}
N 1830 -4980 1840 -4970 {
lab=row_n[14]}
N 1620 -4950 1630 -4960 {
lab=rowon_n[14]}
N 1630 -4960 1830 -4960 {
lab=rowon_n[14]}
N 1830 -4960 1840 -4950 {
lab=rowon_n[14]}
N 1620 -4930 1630 -4940 {
lab=#net29}
N 1630 -4940 1830 -4940 {
lab=#net29}
N 1830 -4940 1840 -4930 {
lab=#net29}
N 1620 -4910 1630 -4920 {
lab=#net30}
N 1630 -4920 1830 -4920 {
lab=#net30}
N 1830 -4920 1840 -4910 {
lab=#net30}
N 1680 -5070 1680 -5050 {
lab=vcm}
N 1720 -5070 1720 -5050 {
lab=ctop}
N 1600 -4970 1620 -4970 {
lab=row_n[14]}
N 1600 -4950 1620 -4950 {
lab=rowon_n[14]}
N 1600 -4930 1620 -4930 {
lab=#net29}
N 1600 -4910 1620 -4910 {
lab=#net30}
N 1840 -4910 1860 -4910 {
lab=#net30}
N 1840 -4930 1860 -4930 {
lab=#net29}
N 1840 -4950 1860 -4950 {
lab=rowon_n[14]}
N 1840 -4970 1860 -4970 {
lab=row_n[14]}
N 1660 -4830 1660 -4820 {
lab=VSS}
N 1660 -5060 1660 -5050 {
lab=VDD}
N 2000 -4830 2010 -4840 {
lab=col_n[5]}
N 2010 -5040 2010 -4840 {
lab=col_n[5]}
N 2000 -5050 2010 -5040 {
lab=col_n[5]}
N 2000 -4830 2000 -4810 {
lab=col_n[5]}
N 2000 -5070 2000 -5050 {
lab=col_n[5]}
N 1880 -4970 1890 -4980 {
lab=row_n[14]}
N 1890 -4980 2090 -4980 {
lab=row_n[14]}
N 2090 -4980 2100 -4970 {
lab=row_n[14]}
N 1880 -4950 1890 -4960 {
lab=rowon_n[14]}
N 1890 -4960 2090 -4960 {
lab=rowon_n[14]}
N 2090 -4960 2100 -4950 {
lab=rowon_n[14]}
N 1880 -4930 1890 -4940 {
lab=#net29}
N 1890 -4940 2090 -4940 {
lab=#net29}
N 2090 -4940 2100 -4930 {
lab=#net29}
N 1880 -4910 1890 -4920 {
lab=#net30}
N 1890 -4920 2090 -4920 {
lab=#net30}
N 2090 -4920 2100 -4910 {
lab=#net30}
N 1940 -5070 1940 -5050 {
lab=vcm}
N 1980 -5070 1980 -5050 {
lab=ctop}
N 1860 -4970 1880 -4970 {
lab=row_n[14]}
N 1860 -4950 1880 -4950 {
lab=rowon_n[14]}
N 1860 -4930 1880 -4930 {
lab=#net29}
N 1860 -4910 1880 -4910 {
lab=#net30}
N 2100 -4910 2120 -4910 {
lab=#net30}
N 2100 -4930 2120 -4930 {
lab=#net29}
N 2100 -4950 2120 -4950 {
lab=rowon_n[14]}
N 2100 -4970 2120 -4970 {
lab=row_n[14]}
N 1920 -4830 1920 -4820 {
lab=VSS}
N 1920 -5060 1920 -5050 {
lab=VDD}
N 2260 -4830 2270 -4840 {
lab=col_n[6]}
N 2270 -5040 2270 -4840 {
lab=col_n[6]}
N 2260 -5050 2270 -5040 {
lab=col_n[6]}
N 2260 -4830 2260 -4810 {
lab=col_n[6]}
N 2260 -5070 2260 -5050 {
lab=col_n[6]}
N 2140 -4970 2150 -4980 {
lab=row_n[14]}
N 2150 -4980 2350 -4980 {
lab=row_n[14]}
N 2350 -4980 2360 -4970 {
lab=row_n[14]}
N 2140 -4950 2150 -4960 {
lab=rowon_n[14]}
N 2150 -4960 2350 -4960 {
lab=rowon_n[14]}
N 2350 -4960 2360 -4950 {
lab=rowon_n[14]}
N 2140 -4930 2150 -4940 {
lab=#net29}
N 2150 -4940 2350 -4940 {
lab=#net29}
N 2350 -4940 2360 -4930 {
lab=#net29}
N 2140 -4910 2150 -4920 {
lab=#net30}
N 2150 -4920 2350 -4920 {
lab=#net30}
N 2350 -4920 2360 -4910 {
lab=#net30}
N 2200 -5070 2200 -5050 {
lab=vcm}
N 2240 -5070 2240 -5050 {
lab=ctop}
N 2120 -4970 2140 -4970 {
lab=row_n[14]}
N 2120 -4950 2140 -4950 {
lab=rowon_n[14]}
N 2120 -4930 2140 -4930 {
lab=#net29}
N 2120 -4910 2140 -4910 {
lab=#net30}
N 2360 -4910 2380 -4910 {
lab=#net30}
N 2360 -4930 2380 -4930 {
lab=#net29}
N 2360 -4950 2380 -4950 {
lab=rowon_n[14]}
N 2360 -4970 2380 -4970 {
lab=row_n[14]}
N 2180 -4830 2180 -4820 {
lab=VSS}
N 2180 -5060 2180 -5050 {
lab=VDD}
N 2520 -4830 2530 -4840 {
lab=col_n[7]}
N 2530 -5040 2530 -4840 {
lab=col_n[7]}
N 2520 -5050 2530 -5040 {
lab=col_n[7]}
N 2520 -4830 2520 -4810 {
lab=col_n[7]}
N 2520 -5070 2520 -5050 {
lab=col_n[7]}
N 2400 -4970 2410 -4980 {
lab=row_n[14]}
N 2410 -4980 2610 -4980 {
lab=row_n[14]}
N 2610 -4980 2620 -4970 {
lab=row_n[14]}
N 2400 -4950 2410 -4960 {
lab=rowon_n[14]}
N 2410 -4960 2610 -4960 {
lab=rowon_n[14]}
N 2610 -4960 2620 -4950 {
lab=rowon_n[14]}
N 2400 -4930 2410 -4940 {
lab=#net29}
N 2410 -4940 2610 -4940 {
lab=#net29}
N 2610 -4940 2620 -4930 {
lab=#net29}
N 2400 -4910 2410 -4920 {
lab=#net30}
N 2410 -4920 2610 -4920 {
lab=#net30}
N 2610 -4920 2620 -4910 {
lab=#net30}
N 2460 -5070 2460 -5050 {
lab=vcm}
N 2500 -5070 2500 -5050 {
lab=ctop}
N 2380 -4970 2400 -4970 {
lab=row_n[14]}
N 2380 -4950 2400 -4950 {
lab=rowon_n[14]}
N 2380 -4930 2400 -4930 {
lab=#net29}
N 2380 -4910 2400 -4910 {
lab=#net30}
N 2620 -4910 2640 -4910 {
lab=#net30}
N 2620 -4930 2640 -4930 {
lab=#net29}
N 2620 -4950 2640 -4950 {
lab=rowon_n[14]}
N 2620 -4970 2640 -4970 {
lab=row_n[14]}
N 2440 -4830 2440 -4820 {
lab=VSS}
N 2440 -5060 2440 -5050 {
lab=VDD}
N 2780 -4830 2790 -4840 {
lab=col_n[8]}
N 2790 -5040 2790 -4840 {
lab=col_n[8]}
N 2780 -5050 2790 -5040 {
lab=col_n[8]}
N 2780 -4830 2780 -4810 {
lab=col_n[8]}
N 2780 -5070 2780 -5050 {
lab=col_n[8]}
N 2660 -4970 2670 -4980 {
lab=row_n[14]}
N 2670 -4980 2870 -4980 {
lab=row_n[14]}
N 2870 -4980 2880 -4970 {
lab=row_n[14]}
N 2660 -4950 2670 -4960 {
lab=rowon_n[14]}
N 2670 -4960 2870 -4960 {
lab=rowon_n[14]}
N 2870 -4960 2880 -4950 {
lab=rowon_n[14]}
N 2660 -4930 2670 -4940 {
lab=#net29}
N 2670 -4940 2870 -4940 {
lab=#net29}
N 2870 -4940 2880 -4930 {
lab=#net29}
N 2660 -4910 2670 -4920 {
lab=#net30}
N 2670 -4920 2870 -4920 {
lab=#net30}
N 2870 -4920 2880 -4910 {
lab=#net30}
N 2720 -5070 2720 -5050 {
lab=vcm}
N 2760 -5070 2760 -5050 {
lab=ctop}
N 2640 -4970 2660 -4970 {
lab=row_n[14]}
N 2640 -4950 2660 -4950 {
lab=rowon_n[14]}
N 2640 -4930 2660 -4930 {
lab=#net29}
N 2640 -4910 2660 -4910 {
lab=#net30}
N 2880 -4910 2900 -4910 {
lab=#net30}
N 2880 -4930 2900 -4930 {
lab=#net29}
N 2880 -4950 2900 -4950 {
lab=rowon_n[14]}
N 2880 -4970 2900 -4970 {
lab=row_n[14]}
N 2700 -4830 2700 -4820 {
lab=VSS}
N 2700 -5060 2700 -5050 {
lab=VDD}
N 3040 -4830 3050 -4840 {
lab=col_n[9]}
N 3050 -5040 3050 -4840 {
lab=col_n[9]}
N 3040 -5050 3050 -5040 {
lab=col_n[9]}
N 3040 -4830 3040 -4810 {
lab=col_n[9]}
N 3040 -5070 3040 -5050 {
lab=col_n[9]}
N 2920 -4970 2930 -4980 {
lab=row_n[14]}
N 2930 -4980 3130 -4980 {
lab=row_n[14]}
N 3130 -4980 3140 -4970 {
lab=row_n[14]}
N 2920 -4950 2930 -4960 {
lab=rowon_n[14]}
N 2930 -4960 3130 -4960 {
lab=rowon_n[14]}
N 3130 -4960 3140 -4950 {
lab=rowon_n[14]}
N 2920 -4930 2930 -4940 {
lab=#net29}
N 2930 -4940 3130 -4940 {
lab=#net29}
N 3130 -4940 3140 -4930 {
lab=#net29}
N 2920 -4910 2930 -4920 {
lab=#net30}
N 2930 -4920 3130 -4920 {
lab=#net30}
N 3130 -4920 3140 -4910 {
lab=#net30}
N 2980 -5070 2980 -5050 {
lab=vcm}
N 3020 -5070 3020 -5050 {
lab=ctop}
N 2900 -4970 2920 -4970 {
lab=row_n[14]}
N 2900 -4950 2920 -4950 {
lab=rowon_n[14]}
N 2900 -4930 2920 -4930 {
lab=#net29}
N 2900 -4910 2920 -4910 {
lab=#net30}
N 3140 -4910 3160 -4910 {
lab=#net30}
N 3140 -4930 3160 -4930 {
lab=#net29}
N 3140 -4950 3160 -4950 {
lab=rowon_n[14]}
N 3140 -4970 3160 -4970 {
lab=row_n[14]}
N 2960 -4830 2960 -4820 {
lab=VSS}
N 2960 -5060 2960 -5050 {
lab=VDD}
N 3300 -4830 3310 -4840 {
lab=col_n[10]}
N 3310 -5040 3310 -4840 {
lab=col_n[10]}
N 3300 -5050 3310 -5040 {
lab=col_n[10]}
N 3300 -4830 3300 -4810 {
lab=col_n[10]}
N 3300 -5070 3300 -5050 {
lab=col_n[10]}
N 3180 -4970 3190 -4980 {
lab=row_n[14]}
N 3190 -4980 3390 -4980 {
lab=row_n[14]}
N 3390 -4980 3400 -4970 {
lab=row_n[14]}
N 3180 -4950 3190 -4960 {
lab=rowon_n[14]}
N 3190 -4960 3390 -4960 {
lab=rowon_n[14]}
N 3390 -4960 3400 -4950 {
lab=rowon_n[14]}
N 3180 -4930 3190 -4940 {
lab=#net29}
N 3190 -4940 3390 -4940 {
lab=#net29}
N 3390 -4940 3400 -4930 {
lab=#net29}
N 3180 -4910 3190 -4920 {
lab=#net30}
N 3190 -4920 3390 -4920 {
lab=#net30}
N 3390 -4920 3400 -4910 {
lab=#net30}
N 3240 -5070 3240 -5050 {
lab=vcm}
N 3280 -5070 3280 -5050 {
lab=ctop}
N 3160 -4970 3180 -4970 {
lab=row_n[14]}
N 3160 -4950 3180 -4950 {
lab=rowon_n[14]}
N 3160 -4930 3180 -4930 {
lab=#net29}
N 3160 -4910 3180 -4910 {
lab=#net30}
N 3400 -4910 3420 -4910 {
lab=#net30}
N 3400 -4930 3420 -4930 {
lab=#net29}
N 3400 -4950 3420 -4950 {
lab=rowon_n[14]}
N 3400 -4970 3420 -4970 {
lab=row_n[14]}
N 3220 -4830 3220 -4820 {
lab=VSS}
N 3220 -5060 3220 -5050 {
lab=VDD}
N 3560 -4830 3570 -4840 {
lab=col_n[11]}
N 3570 -5040 3570 -4840 {
lab=col_n[11]}
N 3560 -5050 3570 -5040 {
lab=col_n[11]}
N 3560 -4830 3560 -4810 {
lab=col_n[11]}
N 3560 -5070 3560 -5050 {
lab=col_n[11]}
N 3440 -4970 3450 -4980 {
lab=row_n[14]}
N 3450 -4980 3650 -4980 {
lab=row_n[14]}
N 3650 -4980 3660 -4970 {
lab=row_n[14]}
N 3440 -4950 3450 -4960 {
lab=rowon_n[14]}
N 3450 -4960 3650 -4960 {
lab=rowon_n[14]}
N 3650 -4960 3660 -4950 {
lab=rowon_n[14]}
N 3440 -4930 3450 -4940 {
lab=#net29}
N 3450 -4940 3650 -4940 {
lab=#net29}
N 3650 -4940 3660 -4930 {
lab=#net29}
N 3440 -4910 3450 -4920 {
lab=#net30}
N 3450 -4920 3650 -4920 {
lab=#net30}
N 3650 -4920 3660 -4910 {
lab=#net30}
N 3500 -5070 3500 -5050 {
lab=vcm}
N 3540 -5070 3540 -5050 {
lab=ctop}
N 3420 -4970 3440 -4970 {
lab=row_n[14]}
N 3420 -4950 3440 -4950 {
lab=rowon_n[14]}
N 3420 -4930 3440 -4930 {
lab=#net29}
N 3420 -4910 3440 -4910 {
lab=#net30}
N 3660 -4910 3680 -4910 {
lab=#net30}
N 3660 -4930 3680 -4930 {
lab=#net29}
N 3660 -4950 3680 -4950 {
lab=rowon_n[14]}
N 3660 -4970 3680 -4970 {
lab=row_n[14]}
N 3480 -4830 3480 -4820 {
lab=VSS}
N 3480 -5060 3480 -5050 {
lab=VDD}
N 3820 -4830 3830 -4840 {
lab=col_n[12]}
N 3830 -5040 3830 -4840 {
lab=col_n[12]}
N 3820 -5050 3830 -5040 {
lab=col_n[12]}
N 3820 -4830 3820 -4810 {
lab=col_n[12]}
N 3820 -5070 3820 -5050 {
lab=col_n[12]}
N 3700 -4970 3710 -4980 {
lab=row_n[14]}
N 3710 -4980 3910 -4980 {
lab=row_n[14]}
N 3910 -4980 3920 -4970 {
lab=row_n[14]}
N 3700 -4950 3710 -4960 {
lab=rowon_n[14]}
N 3710 -4960 3910 -4960 {
lab=rowon_n[14]}
N 3910 -4960 3920 -4950 {
lab=rowon_n[14]}
N 3700 -4930 3710 -4940 {
lab=#net29}
N 3710 -4940 3910 -4940 {
lab=#net29}
N 3910 -4940 3920 -4930 {
lab=#net29}
N 3700 -4910 3710 -4920 {
lab=#net30}
N 3710 -4920 3910 -4920 {
lab=#net30}
N 3910 -4920 3920 -4910 {
lab=#net30}
N 3760 -5070 3760 -5050 {
lab=vcm}
N 3800 -5070 3800 -5050 {
lab=ctop}
N 3680 -4970 3700 -4970 {
lab=row_n[14]}
N 3680 -4950 3700 -4950 {
lab=rowon_n[14]}
N 3680 -4930 3700 -4930 {
lab=#net29}
N 3680 -4910 3700 -4910 {
lab=#net30}
N 3920 -4910 3940 -4910 {
lab=#net30}
N 3920 -4930 3940 -4930 {
lab=#net29}
N 3920 -4950 3940 -4950 {
lab=rowon_n[14]}
N 3920 -4970 3940 -4970 {
lab=row_n[14]}
N 3740 -4830 3740 -4820 {
lab=VSS}
N 3740 -5060 3740 -5050 {
lab=VDD}
N 4080 -4830 4090 -4840 {
lab=col_n[13]}
N 4090 -5040 4090 -4840 {
lab=col_n[13]}
N 4080 -5050 4090 -5040 {
lab=col_n[13]}
N 4080 -4830 4080 -4810 {
lab=col_n[13]}
N 4080 -5070 4080 -5050 {
lab=col_n[13]}
N 3960 -4970 3970 -4980 {
lab=row_n[14]}
N 3970 -4980 4170 -4980 {
lab=row_n[14]}
N 4170 -4980 4180 -4970 {
lab=row_n[14]}
N 3960 -4950 3970 -4960 {
lab=rowon_n[14]}
N 3970 -4960 4170 -4960 {
lab=rowon_n[14]}
N 4170 -4960 4180 -4950 {
lab=rowon_n[14]}
N 3960 -4930 3970 -4940 {
lab=#net29}
N 3970 -4940 4170 -4940 {
lab=#net29}
N 4170 -4940 4180 -4930 {
lab=#net29}
N 3960 -4910 3970 -4920 {
lab=#net30}
N 3970 -4920 4170 -4920 {
lab=#net30}
N 4170 -4920 4180 -4910 {
lab=#net30}
N 4020 -5070 4020 -5050 {
lab=vcm}
N 4060 -5070 4060 -5050 {
lab=ctop}
N 3940 -4970 3960 -4970 {
lab=row_n[14]}
N 3940 -4950 3960 -4950 {
lab=rowon_n[14]}
N 3940 -4930 3960 -4930 {
lab=#net29}
N 3940 -4910 3960 -4910 {
lab=#net30}
N 4180 -4910 4200 -4910 {
lab=#net30}
N 4180 -4930 4200 -4930 {
lab=#net29}
N 4180 -4950 4200 -4950 {
lab=rowon_n[14]}
N 4180 -4970 4200 -4970 {
lab=row_n[14]}
N 4000 -4830 4000 -4820 {
lab=VSS}
N 4000 -5060 4000 -5050 {
lab=VDD}
N 4340 -4830 4350 -4840 {
lab=col_n[14]}
N 4350 -5040 4350 -4840 {
lab=col_n[14]}
N 4340 -5050 4350 -5040 {
lab=col_n[14]}
N 4340 -4830 4340 -4810 {
lab=col_n[14]}
N 4340 -5070 4340 -5050 {
lab=col_n[14]}
N 4220 -4970 4230 -4980 {
lab=row_n[14]}
N 4230 -4980 4430 -4980 {
lab=row_n[14]}
N 4430 -4980 4440 -4970 {
lab=row_n[14]}
N 4220 -4950 4230 -4960 {
lab=rowon_n[14]}
N 4230 -4960 4430 -4960 {
lab=rowon_n[14]}
N 4430 -4960 4440 -4950 {
lab=rowon_n[14]}
N 4220 -4930 4230 -4940 {
lab=#net29}
N 4230 -4940 4430 -4940 {
lab=#net29}
N 4430 -4940 4440 -4930 {
lab=#net29}
N 4220 -4910 4230 -4920 {
lab=#net30}
N 4230 -4920 4430 -4920 {
lab=#net30}
N 4430 -4920 4440 -4910 {
lab=#net30}
N 4280 -5070 4280 -5050 {
lab=vcm}
N 4320 -5070 4320 -5050 {
lab=ctop}
N 4200 -4970 4220 -4970 {
lab=row_n[14]}
N 4200 -4950 4220 -4950 {
lab=rowon_n[14]}
N 4200 -4930 4220 -4930 {
lab=#net29}
N 4200 -4910 4220 -4910 {
lab=#net30}
N 4440 -4910 4460 -4910 {
lab=#net30}
N 4440 -4930 4460 -4930 {
lab=#net29}
N 4440 -4950 4460 -4950 {
lab=rowon_n[14]}
N 4440 -4970 4460 -4970 {
lab=row_n[14]}
N 4260 -4830 4260 -4820 {
lab=VSS}
N 4260 -5060 4260 -5050 {
lab=VDD}
N 4600 -4830 4610 -4840 {
lab=col_n[15]}
N 4610 -5040 4610 -4840 {
lab=col_n[15]}
N 4600 -5050 4610 -5040 {
lab=col_n[15]}
N 4600 -4830 4600 -4810 {
lab=col_n[15]}
N 4600 -5070 4600 -5050 {
lab=col_n[15]}
N 4480 -4970 4490 -4980 {
lab=row_n[14]}
N 4490 -4980 4690 -4980 {
lab=row_n[14]}
N 4690 -4980 4700 -4970 {
lab=row_n[14]}
N 4480 -4950 4490 -4960 {
lab=rowon_n[14]}
N 4490 -4960 4690 -4960 {
lab=rowon_n[14]}
N 4690 -4960 4700 -4950 {
lab=rowon_n[14]}
N 4480 -4930 4490 -4940 {
lab=#net29}
N 4490 -4940 4690 -4940 {
lab=#net29}
N 4690 -4940 4700 -4930 {
lab=#net29}
N 4480 -4910 4490 -4920 {
lab=#net30}
N 4490 -4920 4690 -4920 {
lab=#net30}
N 4690 -4920 4700 -4910 {
lab=#net30}
N 4540 -5070 4540 -5050 {
lab=vcm}
N 4580 -5070 4580 -5050 {
lab=ctop}
N 4460 -4970 4480 -4970 {
lab=row_n[14]}
N 4460 -4950 4480 -4950 {
lab=rowon_n[14]}
N 4460 -4930 4480 -4930 {
lab=#net29}
N 4460 -4910 4480 -4910 {
lab=#net30}
N 4700 -4910 4720 -4910 {
lab=#net30}
N 4700 -4930 4720 -4930 {
lab=#net29}
N 4700 -4950 4720 -4950 {
lab=rowon_n[14]}
N 4700 -4970 4720 -4970 {
lab=row_n[14]}
N 4520 -4830 4520 -4820 {
lab=VSS}
N 4520 -5060 4520 -5050 {
lab=VDD}
N 4860 -4830 4870 -4840 {
lab=col_n[16]}
N 4870 -5040 4870 -4840 {
lab=col_n[16]}
N 4860 -5050 4870 -5040 {
lab=col_n[16]}
N 4860 -4830 4860 -4810 {
lab=col_n[16]}
N 4860 -5070 4860 -5050 {
lab=col_n[16]}
N 4740 -4970 4750 -4980 {
lab=row_n[14]}
N 4750 -4980 4950 -4980 {
lab=row_n[14]}
N 4950 -4980 4960 -4970 {
lab=row_n[14]}
N 4740 -4950 4750 -4960 {
lab=rowon_n[14]}
N 4750 -4960 4950 -4960 {
lab=rowon_n[14]}
N 4950 -4960 4960 -4950 {
lab=rowon_n[14]}
N 4740 -4930 4750 -4940 {
lab=#net29}
N 4750 -4940 4950 -4940 {
lab=#net29}
N 4950 -4940 4960 -4930 {
lab=#net29}
N 4740 -4910 4750 -4920 {
lab=#net30}
N 4750 -4920 4950 -4920 {
lab=#net30}
N 4950 -4920 4960 -4910 {
lab=#net30}
N 4800 -5070 4800 -5050 {
lab=vcm}
N 4840 -5070 4840 -5050 {
lab=ctop}
N 4720 -4970 4740 -4970 {
lab=row_n[14]}
N 4720 -4950 4740 -4950 {
lab=rowon_n[14]}
N 4720 -4930 4740 -4930 {
lab=#net29}
N 4720 -4910 4740 -4910 {
lab=#net30}
N 4960 -4910 4980 -4910 {
lab=#net30}
N 4960 -4930 4980 -4930 {
lab=#net29}
N 4960 -4950 4980 -4950 {
lab=rowon_n[14]}
N 4960 -4970 4980 -4970 {
lab=row_n[14]}
N 4780 -4830 4780 -4820 {
lab=VSS}
N 4780 -5060 4780 -5050 {
lab=VDD}
N 5120 -4830 5130 -4840 {
lab=col_n[17]}
N 5130 -5040 5130 -4840 {
lab=col_n[17]}
N 5120 -5050 5130 -5040 {
lab=col_n[17]}
N 5120 -4830 5120 -4810 {
lab=col_n[17]}
N 5120 -5070 5120 -5050 {
lab=col_n[17]}
N 5000 -4970 5010 -4980 {
lab=row_n[14]}
N 5010 -4980 5210 -4980 {
lab=row_n[14]}
N 5210 -4980 5220 -4970 {
lab=row_n[14]}
N 5000 -4950 5010 -4960 {
lab=rowon_n[14]}
N 5010 -4960 5210 -4960 {
lab=rowon_n[14]}
N 5210 -4960 5220 -4950 {
lab=rowon_n[14]}
N 5000 -4930 5010 -4940 {
lab=#net29}
N 5010 -4940 5210 -4940 {
lab=#net29}
N 5210 -4940 5220 -4930 {
lab=#net29}
N 5000 -4910 5010 -4920 {
lab=#net30}
N 5010 -4920 5210 -4920 {
lab=#net30}
N 5210 -4920 5220 -4910 {
lab=#net30}
N 5060 -5070 5060 -5050 {
lab=vcm}
N 5100 -5070 5100 -5050 {
lab=ctop}
N 4980 -4970 5000 -4970 {
lab=row_n[14]}
N 4980 -4950 5000 -4950 {
lab=rowon_n[14]}
N 4980 -4930 5000 -4930 {
lab=#net29}
N 4980 -4910 5000 -4910 {
lab=#net30}
N 5220 -4910 5240 -4910 {
lab=#net30}
N 5220 -4930 5240 -4930 {
lab=#net29}
N 5220 -4950 5240 -4950 {
lab=rowon_n[14]}
N 5220 -4970 5240 -4970 {
lab=row_n[14]}
N 5040 -4830 5040 -4820 {
lab=VSS}
N 5040 -5060 5040 -5050 {
lab=VDD}
N 5380 -4830 5390 -4840 {
lab=col_n[18]}
N 5390 -5040 5390 -4840 {
lab=col_n[18]}
N 5380 -5050 5390 -5040 {
lab=col_n[18]}
N 5380 -4830 5380 -4810 {
lab=col_n[18]}
N 5380 -5070 5380 -5050 {
lab=col_n[18]}
N 5260 -4970 5270 -4980 {
lab=row_n[14]}
N 5270 -4980 5470 -4980 {
lab=row_n[14]}
N 5470 -4980 5480 -4970 {
lab=row_n[14]}
N 5260 -4950 5270 -4960 {
lab=rowon_n[14]}
N 5270 -4960 5470 -4960 {
lab=rowon_n[14]}
N 5470 -4960 5480 -4950 {
lab=rowon_n[14]}
N 5260 -4930 5270 -4940 {
lab=#net29}
N 5270 -4940 5470 -4940 {
lab=#net29}
N 5470 -4940 5480 -4930 {
lab=#net29}
N 5260 -4910 5270 -4920 {
lab=#net30}
N 5270 -4920 5470 -4920 {
lab=#net30}
N 5470 -4920 5480 -4910 {
lab=#net30}
N 5320 -5070 5320 -5050 {
lab=vcm}
N 5360 -5070 5360 -5050 {
lab=ctop}
N 5240 -4970 5260 -4970 {
lab=row_n[14]}
N 5240 -4950 5260 -4950 {
lab=rowon_n[14]}
N 5240 -4930 5260 -4930 {
lab=#net29}
N 5240 -4910 5260 -4910 {
lab=#net30}
N 5480 -4910 5500 -4910 {
lab=#net30}
N 5480 -4930 5500 -4930 {
lab=#net29}
N 5480 -4950 5500 -4950 {
lab=rowon_n[14]}
N 5480 -4970 5500 -4970 {
lab=row_n[14]}
N 5300 -4830 5300 -4820 {
lab=VSS}
N 5300 -5060 5300 -5050 {
lab=VDD}
N 5640 -4830 5650 -4840 {
lab=col_n[19]}
N 5650 -5040 5650 -4840 {
lab=col_n[19]}
N 5640 -5050 5650 -5040 {
lab=col_n[19]}
N 5640 -4830 5640 -4810 {
lab=col_n[19]}
N 5640 -5070 5640 -5050 {
lab=col_n[19]}
N 5520 -4970 5530 -4980 {
lab=row_n[14]}
N 5530 -4980 5730 -4980 {
lab=row_n[14]}
N 5730 -4980 5740 -4970 {
lab=row_n[14]}
N 5520 -4950 5530 -4960 {
lab=rowon_n[14]}
N 5530 -4960 5730 -4960 {
lab=rowon_n[14]}
N 5730 -4960 5740 -4950 {
lab=rowon_n[14]}
N 5520 -4930 5530 -4940 {
lab=#net29}
N 5530 -4940 5730 -4940 {
lab=#net29}
N 5730 -4940 5740 -4930 {
lab=#net29}
N 5520 -4910 5530 -4920 {
lab=#net30}
N 5530 -4920 5730 -4920 {
lab=#net30}
N 5730 -4920 5740 -4910 {
lab=#net30}
N 5580 -5070 5580 -5050 {
lab=vcm}
N 5620 -5070 5620 -5050 {
lab=ctop}
N 5500 -4970 5520 -4970 {
lab=row_n[14]}
N 5500 -4950 5520 -4950 {
lab=rowon_n[14]}
N 5500 -4930 5520 -4930 {
lab=#net29}
N 5500 -4910 5520 -4910 {
lab=#net30}
N 5740 -4910 5760 -4910 {
lab=#net30}
N 5740 -4930 5760 -4930 {
lab=#net29}
N 5740 -4950 5760 -4950 {
lab=rowon_n[14]}
N 5740 -4970 5760 -4970 {
lab=row_n[14]}
N 5560 -4830 5560 -4820 {
lab=VSS}
N 5560 -5060 5560 -5050 {
lab=VDD}
N 5900 -4830 5910 -4840 {
lab=col_n[20]}
N 5910 -5040 5910 -4840 {
lab=col_n[20]}
N 5900 -5050 5910 -5040 {
lab=col_n[20]}
N 5900 -4830 5900 -4810 {
lab=col_n[20]}
N 5900 -5070 5900 -5050 {
lab=col_n[20]}
N 5780 -4970 5790 -4980 {
lab=row_n[14]}
N 5790 -4980 5990 -4980 {
lab=row_n[14]}
N 5990 -4980 6000 -4970 {
lab=row_n[14]}
N 5780 -4950 5790 -4960 {
lab=rowon_n[14]}
N 5790 -4960 5990 -4960 {
lab=rowon_n[14]}
N 5990 -4960 6000 -4950 {
lab=rowon_n[14]}
N 5780 -4930 5790 -4940 {
lab=#net29}
N 5790 -4940 5990 -4940 {
lab=#net29}
N 5990 -4940 6000 -4930 {
lab=#net29}
N 5780 -4910 5790 -4920 {
lab=#net30}
N 5790 -4920 5990 -4920 {
lab=#net30}
N 5990 -4920 6000 -4910 {
lab=#net30}
N 5840 -5070 5840 -5050 {
lab=vcm}
N 5880 -5070 5880 -5050 {
lab=ctop}
N 5760 -4970 5780 -4970 {
lab=row_n[14]}
N 5760 -4950 5780 -4950 {
lab=rowon_n[14]}
N 5760 -4930 5780 -4930 {
lab=#net29}
N 5760 -4910 5780 -4910 {
lab=#net30}
N 6000 -4910 6020 -4910 {
lab=#net30}
N 6000 -4930 6020 -4930 {
lab=#net29}
N 6000 -4950 6020 -4950 {
lab=rowon_n[14]}
N 6000 -4970 6020 -4970 {
lab=row_n[14]}
N 5820 -4830 5820 -4820 {
lab=VSS}
N 5820 -5060 5820 -5050 {
lab=VDD}
N 6160 -4830 6170 -4840 {
lab=col_n[21]}
N 6170 -5040 6170 -4840 {
lab=col_n[21]}
N 6160 -5050 6170 -5040 {
lab=col_n[21]}
N 6160 -4830 6160 -4810 {
lab=col_n[21]}
N 6160 -5070 6160 -5050 {
lab=col_n[21]}
N 6040 -4970 6050 -4980 {
lab=row_n[14]}
N 6050 -4980 6250 -4980 {
lab=row_n[14]}
N 6250 -4980 6260 -4970 {
lab=row_n[14]}
N 6040 -4950 6050 -4960 {
lab=rowon_n[14]}
N 6050 -4960 6250 -4960 {
lab=rowon_n[14]}
N 6250 -4960 6260 -4950 {
lab=rowon_n[14]}
N 6040 -4930 6050 -4940 {
lab=#net29}
N 6050 -4940 6250 -4940 {
lab=#net29}
N 6250 -4940 6260 -4930 {
lab=#net29}
N 6040 -4910 6050 -4920 {
lab=#net30}
N 6050 -4920 6250 -4920 {
lab=#net30}
N 6250 -4920 6260 -4910 {
lab=#net30}
N 6100 -5070 6100 -5050 {
lab=vcm}
N 6140 -5070 6140 -5050 {
lab=ctop}
N 6020 -4970 6040 -4970 {
lab=row_n[14]}
N 6020 -4950 6040 -4950 {
lab=rowon_n[14]}
N 6020 -4930 6040 -4930 {
lab=#net29}
N 6020 -4910 6040 -4910 {
lab=#net30}
N 6260 -4910 6280 -4910 {
lab=#net30}
N 6260 -4930 6280 -4930 {
lab=#net29}
N 6260 -4950 6280 -4950 {
lab=rowon_n[14]}
N 6260 -4970 6280 -4970 {
lab=row_n[14]}
N 6080 -4830 6080 -4820 {
lab=VSS}
N 6080 -5060 6080 -5050 {
lab=VDD}
N 6420 -4830 6430 -4840 {
lab=col_n[22]}
N 6430 -5040 6430 -4840 {
lab=col_n[22]}
N 6420 -5050 6430 -5040 {
lab=col_n[22]}
N 6420 -4830 6420 -4810 {
lab=col_n[22]}
N 6420 -5070 6420 -5050 {
lab=col_n[22]}
N 6300 -4970 6310 -4980 {
lab=row_n[14]}
N 6310 -4980 6510 -4980 {
lab=row_n[14]}
N 6510 -4980 6520 -4970 {
lab=row_n[14]}
N 6300 -4950 6310 -4960 {
lab=rowon_n[14]}
N 6310 -4960 6510 -4960 {
lab=rowon_n[14]}
N 6510 -4960 6520 -4950 {
lab=rowon_n[14]}
N 6300 -4930 6310 -4940 {
lab=#net29}
N 6310 -4940 6510 -4940 {
lab=#net29}
N 6510 -4940 6520 -4930 {
lab=#net29}
N 6300 -4910 6310 -4920 {
lab=#net30}
N 6310 -4920 6510 -4920 {
lab=#net30}
N 6510 -4920 6520 -4910 {
lab=#net30}
N 6360 -5070 6360 -5050 {
lab=vcm}
N 6400 -5070 6400 -5050 {
lab=ctop}
N 6280 -4970 6300 -4970 {
lab=row_n[14]}
N 6280 -4950 6300 -4950 {
lab=rowon_n[14]}
N 6280 -4930 6300 -4930 {
lab=#net29}
N 6280 -4910 6300 -4910 {
lab=#net30}
N 6520 -4910 6540 -4910 {
lab=#net30}
N 6520 -4930 6540 -4930 {
lab=#net29}
N 6520 -4950 6540 -4950 {
lab=rowon_n[14]}
N 6520 -4970 6540 -4970 {
lab=row_n[14]}
N 6340 -4830 6340 -4820 {
lab=VSS}
N 6340 -5060 6340 -5050 {
lab=VDD}
N 6680 -4830 6690 -4840 {
lab=col_n[23]}
N 6690 -5040 6690 -4840 {
lab=col_n[23]}
N 6680 -5050 6690 -5040 {
lab=col_n[23]}
N 6680 -4830 6680 -4810 {
lab=col_n[23]}
N 6680 -5070 6680 -5050 {
lab=col_n[23]}
N 6560 -4970 6570 -4980 {
lab=row_n[14]}
N 6570 -4980 6770 -4980 {
lab=row_n[14]}
N 6770 -4980 6780 -4970 {
lab=row_n[14]}
N 6560 -4950 6570 -4960 {
lab=rowon_n[14]}
N 6570 -4960 6770 -4960 {
lab=rowon_n[14]}
N 6770 -4960 6780 -4950 {
lab=rowon_n[14]}
N 6560 -4930 6570 -4940 {
lab=#net29}
N 6570 -4940 6770 -4940 {
lab=#net29}
N 6770 -4940 6780 -4930 {
lab=#net29}
N 6560 -4910 6570 -4920 {
lab=#net30}
N 6570 -4920 6770 -4920 {
lab=#net30}
N 6770 -4920 6780 -4910 {
lab=#net30}
N 6620 -5070 6620 -5050 {
lab=vcm}
N 6660 -5070 6660 -5050 {
lab=ctop}
N 6540 -4970 6560 -4970 {
lab=row_n[14]}
N 6540 -4950 6560 -4950 {
lab=rowon_n[14]}
N 6540 -4930 6560 -4930 {
lab=#net29}
N 6540 -4910 6560 -4910 {
lab=#net30}
N 6780 -4910 6800 -4910 {
lab=#net30}
N 6780 -4930 6800 -4930 {
lab=#net29}
N 6780 -4950 6800 -4950 {
lab=rowon_n[14]}
N 6780 -4970 6800 -4970 {
lab=row_n[14]}
N 6600 -4830 6600 -4820 {
lab=VSS}
N 6600 -5060 6600 -5050 {
lab=VDD}
N 6940 -4830 6950 -4840 {
lab=col_n[24]}
N 6950 -5040 6950 -4840 {
lab=col_n[24]}
N 6940 -5050 6950 -5040 {
lab=col_n[24]}
N 6940 -4830 6940 -4810 {
lab=col_n[24]}
N 6940 -5070 6940 -5050 {
lab=col_n[24]}
N 6820 -4970 6830 -4980 {
lab=row_n[14]}
N 6830 -4980 7030 -4980 {
lab=row_n[14]}
N 7030 -4980 7040 -4970 {
lab=row_n[14]}
N 6820 -4950 6830 -4960 {
lab=rowon_n[14]}
N 6830 -4960 7030 -4960 {
lab=rowon_n[14]}
N 7030 -4960 7040 -4950 {
lab=rowon_n[14]}
N 6820 -4930 6830 -4940 {
lab=#net29}
N 6830 -4940 7030 -4940 {
lab=#net29}
N 7030 -4940 7040 -4930 {
lab=#net29}
N 6820 -4910 6830 -4920 {
lab=#net30}
N 6830 -4920 7030 -4920 {
lab=#net30}
N 7030 -4920 7040 -4910 {
lab=#net30}
N 6880 -5070 6880 -5050 {
lab=vcm}
N 6920 -5070 6920 -5050 {
lab=ctop}
N 6800 -4970 6820 -4970 {
lab=row_n[14]}
N 6800 -4950 6820 -4950 {
lab=rowon_n[14]}
N 6800 -4930 6820 -4930 {
lab=#net29}
N 6800 -4910 6820 -4910 {
lab=#net30}
N 7040 -4910 7060 -4910 {
lab=#net30}
N 7040 -4930 7060 -4930 {
lab=#net29}
N 7040 -4950 7060 -4950 {
lab=rowon_n[14]}
N 7040 -4970 7060 -4970 {
lab=row_n[14]}
N 6860 -4830 6860 -4820 {
lab=VSS}
N 6860 -5060 6860 -5050 {
lab=VDD}
N 7200 -4830 7210 -4840 {
lab=col_n[25]}
N 7210 -5040 7210 -4840 {
lab=col_n[25]}
N 7200 -5050 7210 -5040 {
lab=col_n[25]}
N 7200 -4830 7200 -4810 {
lab=col_n[25]}
N 7200 -5070 7200 -5050 {
lab=col_n[25]}
N 7080 -4970 7090 -4980 {
lab=row_n[14]}
N 7090 -4980 7290 -4980 {
lab=row_n[14]}
N 7290 -4980 7300 -4970 {
lab=row_n[14]}
N 7080 -4950 7090 -4960 {
lab=rowon_n[14]}
N 7090 -4960 7290 -4960 {
lab=rowon_n[14]}
N 7290 -4960 7300 -4950 {
lab=rowon_n[14]}
N 7080 -4930 7090 -4940 {
lab=#net29}
N 7090 -4940 7290 -4940 {
lab=#net29}
N 7290 -4940 7300 -4930 {
lab=#net29}
N 7080 -4910 7090 -4920 {
lab=#net30}
N 7090 -4920 7290 -4920 {
lab=#net30}
N 7290 -4920 7300 -4910 {
lab=#net30}
N 7140 -5070 7140 -5050 {
lab=vcm}
N 7180 -5070 7180 -5050 {
lab=ctop}
N 7060 -4970 7080 -4970 {
lab=row_n[14]}
N 7060 -4950 7080 -4950 {
lab=rowon_n[14]}
N 7060 -4930 7080 -4930 {
lab=#net29}
N 7060 -4910 7080 -4910 {
lab=#net30}
N 7300 -4910 7320 -4910 {
lab=#net30}
N 7300 -4930 7320 -4930 {
lab=#net29}
N 7300 -4950 7320 -4950 {
lab=rowon_n[14]}
N 7300 -4970 7320 -4970 {
lab=row_n[14]}
N 7120 -4830 7120 -4820 {
lab=VSS}
N 7120 -5060 7120 -5050 {
lab=VDD}
N 7460 -4830 7470 -4840 {
lab=col_n[26]}
N 7470 -5040 7470 -4840 {
lab=col_n[26]}
N 7460 -5050 7470 -5040 {
lab=col_n[26]}
N 7460 -4830 7460 -4810 {
lab=col_n[26]}
N 7460 -5070 7460 -5050 {
lab=col_n[26]}
N 7340 -4970 7350 -4980 {
lab=row_n[14]}
N 7350 -4980 7550 -4980 {
lab=row_n[14]}
N 7550 -4980 7560 -4970 {
lab=row_n[14]}
N 7340 -4950 7350 -4960 {
lab=rowon_n[14]}
N 7350 -4960 7550 -4960 {
lab=rowon_n[14]}
N 7550 -4960 7560 -4950 {
lab=rowon_n[14]}
N 7340 -4930 7350 -4940 {
lab=#net29}
N 7350 -4940 7550 -4940 {
lab=#net29}
N 7550 -4940 7560 -4930 {
lab=#net29}
N 7340 -4910 7350 -4920 {
lab=#net30}
N 7350 -4920 7550 -4920 {
lab=#net30}
N 7550 -4920 7560 -4910 {
lab=#net30}
N 7400 -5070 7400 -5050 {
lab=vcm}
N 7440 -5070 7440 -5050 {
lab=ctop}
N 7320 -4970 7340 -4970 {
lab=row_n[14]}
N 7320 -4950 7340 -4950 {
lab=rowon_n[14]}
N 7320 -4930 7340 -4930 {
lab=#net29}
N 7320 -4910 7340 -4910 {
lab=#net30}
N 7560 -4910 7580 -4910 {
lab=#net30}
N 7560 -4930 7580 -4930 {
lab=#net29}
N 7560 -4950 7580 -4950 {
lab=rowon_n[14]}
N 7560 -4970 7580 -4970 {
lab=row_n[14]}
N 7380 -4830 7380 -4820 {
lab=VSS}
N 7380 -5060 7380 -5050 {
lab=VDD}
N 7720 -4830 7730 -4840 {
lab=col_n[27]}
N 7730 -5040 7730 -4840 {
lab=col_n[27]}
N 7720 -5050 7730 -5040 {
lab=col_n[27]}
N 7720 -4830 7720 -4810 {
lab=col_n[27]}
N 7720 -5070 7720 -5050 {
lab=col_n[27]}
N 7600 -4970 7610 -4980 {
lab=row_n[14]}
N 7610 -4980 7810 -4980 {
lab=row_n[14]}
N 7810 -4980 7820 -4970 {
lab=row_n[14]}
N 7600 -4950 7610 -4960 {
lab=rowon_n[14]}
N 7610 -4960 7810 -4960 {
lab=rowon_n[14]}
N 7810 -4960 7820 -4950 {
lab=rowon_n[14]}
N 7600 -4930 7610 -4940 {
lab=#net29}
N 7610 -4940 7810 -4940 {
lab=#net29}
N 7810 -4940 7820 -4930 {
lab=#net29}
N 7600 -4910 7610 -4920 {
lab=#net30}
N 7610 -4920 7810 -4920 {
lab=#net30}
N 7810 -4920 7820 -4910 {
lab=#net30}
N 7660 -5070 7660 -5050 {
lab=vcm}
N 7700 -5070 7700 -5050 {
lab=ctop}
N 7580 -4970 7600 -4970 {
lab=row_n[14]}
N 7580 -4950 7600 -4950 {
lab=rowon_n[14]}
N 7580 -4930 7600 -4930 {
lab=#net29}
N 7580 -4910 7600 -4910 {
lab=#net30}
N 7820 -4910 7840 -4910 {
lab=#net30}
N 7820 -4930 7840 -4930 {
lab=#net29}
N 7820 -4950 7840 -4950 {
lab=rowon_n[14]}
N 7820 -4970 7840 -4970 {
lab=row_n[14]}
N 7640 -4830 7640 -4820 {
lab=VSS}
N 7640 -5060 7640 -5050 {
lab=VDD}
N 7980 -4830 7990 -4840 {
lab=col_n[28]}
N 7990 -5040 7990 -4840 {
lab=col_n[28]}
N 7980 -5050 7990 -5040 {
lab=col_n[28]}
N 7980 -4830 7980 -4810 {
lab=col_n[28]}
N 7980 -5070 7980 -5050 {
lab=col_n[28]}
N 7860 -4970 7870 -4980 {
lab=row_n[14]}
N 7870 -4980 8070 -4980 {
lab=row_n[14]}
N 8070 -4980 8080 -4970 {
lab=row_n[14]}
N 7860 -4950 7870 -4960 {
lab=rowon_n[14]}
N 7870 -4960 8070 -4960 {
lab=rowon_n[14]}
N 8070 -4960 8080 -4950 {
lab=rowon_n[14]}
N 7860 -4930 7870 -4940 {
lab=#net29}
N 7870 -4940 8070 -4940 {
lab=#net29}
N 8070 -4940 8080 -4930 {
lab=#net29}
N 7860 -4910 7870 -4920 {
lab=#net30}
N 7870 -4920 8070 -4920 {
lab=#net30}
N 8070 -4920 8080 -4910 {
lab=#net30}
N 7920 -5070 7920 -5050 {
lab=vcm}
N 7960 -5070 7960 -5050 {
lab=ctop}
N 7840 -4970 7860 -4970 {
lab=row_n[14]}
N 7840 -4950 7860 -4950 {
lab=rowon_n[14]}
N 7840 -4930 7860 -4930 {
lab=#net29}
N 7840 -4910 7860 -4910 {
lab=#net30}
N 8080 -4910 8100 -4910 {
lab=#net30}
N 8080 -4930 8100 -4930 {
lab=#net29}
N 8080 -4950 8100 -4950 {
lab=rowon_n[14]}
N 8080 -4970 8100 -4970 {
lab=row_n[14]}
N 7900 -4830 7900 -4820 {
lab=VSS}
N 7900 -5060 7900 -5050 {
lab=VDD}
N 8240 -4830 8250 -4840 {
lab=col_n[29]}
N 8250 -5040 8250 -4840 {
lab=col_n[29]}
N 8240 -5050 8250 -5040 {
lab=col_n[29]}
N 8240 -4830 8240 -4810 {
lab=col_n[29]}
N 8240 -5070 8240 -5050 {
lab=col_n[29]}
N 8120 -4970 8130 -4980 {
lab=row_n[14]}
N 8130 -4980 8330 -4980 {
lab=row_n[14]}
N 8330 -4980 8340 -4970 {
lab=row_n[14]}
N 8120 -4950 8130 -4960 {
lab=rowon_n[14]}
N 8130 -4960 8330 -4960 {
lab=rowon_n[14]}
N 8330 -4960 8340 -4950 {
lab=rowon_n[14]}
N 8120 -4930 8130 -4940 {
lab=#net29}
N 8130 -4940 8330 -4940 {
lab=#net29}
N 8330 -4940 8340 -4930 {
lab=#net29}
N 8120 -4910 8130 -4920 {
lab=#net30}
N 8130 -4920 8330 -4920 {
lab=#net30}
N 8330 -4920 8340 -4910 {
lab=#net30}
N 8180 -5070 8180 -5050 {
lab=vcm}
N 8220 -5070 8220 -5050 {
lab=ctop}
N 8100 -4970 8120 -4970 {
lab=row_n[14]}
N 8100 -4950 8120 -4950 {
lab=rowon_n[14]}
N 8100 -4930 8120 -4930 {
lab=#net29}
N 8100 -4910 8120 -4910 {
lab=#net30}
N 8340 -4910 8360 -4910 {
lab=#net30}
N 8340 -4930 8360 -4930 {
lab=#net29}
N 8340 -4950 8360 -4950 {
lab=rowon_n[14]}
N 8340 -4970 8360 -4970 {
lab=row_n[14]}
N 8160 -4830 8160 -4820 {
lab=VSS}
N 8160 -5060 8160 -5050 {
lab=VDD}
N 8500 -4830 8510 -4840 {
lab=col_n[30]}
N 8510 -5040 8510 -4840 {
lab=col_n[30]}
N 8500 -5050 8510 -5040 {
lab=col_n[30]}
N 8500 -4830 8500 -4810 {
lab=col_n[30]}
N 8500 -5070 8500 -5050 {
lab=col_n[30]}
N 8380 -4970 8390 -4980 {
lab=row_n[14]}
N 8390 -4980 8590 -4980 {
lab=row_n[14]}
N 8590 -4980 8600 -4970 {
lab=row_n[14]}
N 8380 -4950 8390 -4960 {
lab=rowon_n[14]}
N 8390 -4960 8590 -4960 {
lab=rowon_n[14]}
N 8590 -4960 8600 -4950 {
lab=rowon_n[14]}
N 8380 -4930 8390 -4940 {
lab=#net29}
N 8390 -4940 8590 -4940 {
lab=#net29}
N 8590 -4940 8600 -4930 {
lab=#net29}
N 8380 -4910 8390 -4920 {
lab=#net30}
N 8390 -4920 8590 -4920 {
lab=#net30}
N 8590 -4920 8600 -4910 {
lab=#net30}
N 8440 -5070 8440 -5050 {
lab=vcm}
N 8480 -5070 8480 -5050 {
lab=ctop}
N 8360 -4970 8380 -4970 {
lab=row_n[14]}
N 8360 -4950 8380 -4950 {
lab=rowon_n[14]}
N 8360 -4930 8380 -4930 {
lab=#net29}
N 8360 -4910 8380 -4910 {
lab=#net30}
N 8600 -4910 8620 -4910 {
lab=#net30}
N 8600 -4930 8620 -4930 {
lab=#net29}
N 8600 -4950 8620 -4950 {
lab=rowon_n[14]}
N 8600 -4970 8620 -4970 {
lab=row_n[14]}
N 8420 -4830 8420 -4820 {
lab=VSS}
N 8420 -5060 8420 -5050 {
lab=VDD}
N 8760 -4830 8770 -4840 {
lab=col_n[31]}
N 8770 -5040 8770 -4840 {
lab=col_n[31]}
N 8760 -5050 8770 -5040 {
lab=col_n[31]}
N 8760 -4830 8760 -4810 {
lab=col_n[31]}
N 8760 -5070 8760 -5050 {
lab=col_n[31]}
N 8640 -4970 8650 -4980 {
lab=row_n[14]}
N 8650 -4980 8850 -4980 {
lab=row_n[14]}
N 8850 -4980 8860 -4970 {
lab=row_n[14]}
N 8640 -4950 8650 -4960 {
lab=rowon_n[14]}
N 8650 -4960 8850 -4960 {
lab=rowon_n[14]}
N 8850 -4960 8860 -4950 {
lab=rowon_n[14]}
N 8640 -4930 8650 -4940 {
lab=#net29}
N 8650 -4940 8850 -4940 {
lab=#net29}
N 8850 -4940 8860 -4930 {
lab=#net29}
N 8640 -4910 8650 -4920 {
lab=#net30}
N 8650 -4920 8850 -4920 {
lab=#net30}
N 8850 -4920 8860 -4910 {
lab=#net30}
N 8700 -5070 8700 -5050 {
lab=vcm}
N 8740 -5070 8740 -5050 {
lab=ctop}
N 8620 -4970 8640 -4970 {
lab=row_n[14]}
N 8620 -4950 8640 -4950 {
lab=rowon_n[14]}
N 8620 -4930 8640 -4930 {
lab=#net29}
N 8620 -4910 8640 -4910 {
lab=#net30}
N 8860 -4910 8880 -4910 {
lab=#net30}
N 8860 -4930 8880 -4930 {
lab=#net29}
N 8860 -4950 8880 -4950 {
lab=rowon_n[14]}
N 8860 -4970 8880 -4970 {
lab=row_n[14]}
N 8680 -4830 8680 -4820 {
lab=VSS}
N 8680 -5060 8680 -5050 {
lab=VDD}
N 700 -5090 710 -5100 {
lab=col_n[0]}
N 710 -5300 710 -5100 {
lab=col_n[0]}
N 700 -5310 710 -5300 {
lab=col_n[0]}
N 700 -5090 700 -5070 {
lab=col_n[0]}
N 700 -5330 700 -5310 {
lab=col_n[0]}
N 580 -5230 590 -5240 {
lab=row_n[15]}
N 590 -5240 790 -5240 {
lab=row_n[15]}
N 790 -5240 800 -5230 {
lab=row_n[15]}
N 580 -5210 590 -5220 {
lab=rowon_n[15]}
N 590 -5220 790 -5220 {
lab=rowon_n[15]}
N 790 -5220 800 -5210 {
lab=rowon_n[15]}
N 580 -5190 590 -5200 {
lab=#net31}
N 590 -5200 790 -5200 {
lab=#net31}
N 790 -5200 800 -5190 {
lab=#net31}
N 580 -5170 590 -5180 {
lab=#net32}
N 590 -5180 790 -5180 {
lab=#net32}
N 790 -5180 800 -5170 {
lab=#net32}
N 640 -5330 640 -5310 {
lab=vcm}
N 680 -5330 680 -5310 {
lab=ctop}
N 560 -5230 580 -5230 {
lab=row_n[15]}
N 560 -5210 580 -5210 {
lab=rowon_n[15]}
N 560 -5190 580 -5190 {
lab=#net31}
N 560 -5170 580 -5170 {
lab=#net32}
N 800 -5170 820 -5170 {
lab=#net32}
N 800 -5190 820 -5190 {
lab=#net31}
N 800 -5210 820 -5210 {
lab=rowon_n[15]}
N 800 -5230 820 -5230 {
lab=row_n[15]}
N 620 -5090 620 -5080 {
lab=VSS}
N 620 -5320 620 -5310 {
lab=VDD}
N 960 -5090 970 -5100 {
lab=col_n[1]}
N 970 -5300 970 -5100 {
lab=col_n[1]}
N 960 -5310 970 -5300 {
lab=col_n[1]}
N 960 -5090 960 -5070 {
lab=col_n[1]}
N 960 -5330 960 -5310 {
lab=col_n[1]}
N 840 -5230 850 -5240 {
lab=row_n[15]}
N 850 -5240 1050 -5240 {
lab=row_n[15]}
N 1050 -5240 1060 -5230 {
lab=row_n[15]}
N 840 -5210 850 -5220 {
lab=rowon_n[15]}
N 850 -5220 1050 -5220 {
lab=rowon_n[15]}
N 1050 -5220 1060 -5210 {
lab=rowon_n[15]}
N 840 -5190 850 -5200 {
lab=#net31}
N 850 -5200 1050 -5200 {
lab=#net31}
N 1050 -5200 1060 -5190 {
lab=#net31}
N 840 -5170 850 -5180 {
lab=#net32}
N 850 -5180 1050 -5180 {
lab=#net32}
N 1050 -5180 1060 -5170 {
lab=#net32}
N 900 -5330 900 -5310 {
lab=vcm}
N 940 -5330 940 -5310 {
lab=ctop}
N 820 -5230 840 -5230 {
lab=row_n[15]}
N 820 -5210 840 -5210 {
lab=rowon_n[15]}
N 820 -5190 840 -5190 {
lab=#net31}
N 820 -5170 840 -5170 {
lab=#net32}
N 1060 -5170 1080 -5170 {
lab=#net32}
N 1060 -5190 1080 -5190 {
lab=#net31}
N 1060 -5210 1080 -5210 {
lab=rowon_n[15]}
N 1060 -5230 1080 -5230 {
lab=row_n[15]}
N 880 -5090 880 -5080 {
lab=VSS}
N 880 -5320 880 -5310 {
lab=VDD}
N 1220 -5090 1230 -5100 {
lab=col_n[2]}
N 1230 -5300 1230 -5100 {
lab=col_n[2]}
N 1220 -5310 1230 -5300 {
lab=col_n[2]}
N 1220 -5090 1220 -5070 {
lab=col_n[2]}
N 1220 -5330 1220 -5310 {
lab=col_n[2]}
N 1100 -5230 1110 -5240 {
lab=row_n[15]}
N 1110 -5240 1310 -5240 {
lab=row_n[15]}
N 1310 -5240 1320 -5230 {
lab=row_n[15]}
N 1100 -5210 1110 -5220 {
lab=rowon_n[15]}
N 1110 -5220 1310 -5220 {
lab=rowon_n[15]}
N 1310 -5220 1320 -5210 {
lab=rowon_n[15]}
N 1100 -5190 1110 -5200 {
lab=#net31}
N 1110 -5200 1310 -5200 {
lab=#net31}
N 1310 -5200 1320 -5190 {
lab=#net31}
N 1100 -5170 1110 -5180 {
lab=#net32}
N 1110 -5180 1310 -5180 {
lab=#net32}
N 1310 -5180 1320 -5170 {
lab=#net32}
N 1160 -5330 1160 -5310 {
lab=vcm}
N 1200 -5330 1200 -5310 {
lab=ctop}
N 1080 -5230 1100 -5230 {
lab=row_n[15]}
N 1080 -5210 1100 -5210 {
lab=rowon_n[15]}
N 1080 -5190 1100 -5190 {
lab=#net31}
N 1080 -5170 1100 -5170 {
lab=#net32}
N 1320 -5170 1340 -5170 {
lab=#net32}
N 1320 -5190 1340 -5190 {
lab=#net31}
N 1320 -5210 1340 -5210 {
lab=rowon_n[15]}
N 1320 -5230 1340 -5230 {
lab=row_n[15]}
N 1140 -5090 1140 -5080 {
lab=VSS}
N 1140 -5320 1140 -5310 {
lab=VDD}
N 1480 -5090 1490 -5100 {
lab=col_n[3]}
N 1490 -5300 1490 -5100 {
lab=col_n[3]}
N 1480 -5310 1490 -5300 {
lab=col_n[3]}
N 1480 -5090 1480 -5070 {
lab=col_n[3]}
N 1480 -5330 1480 -5310 {
lab=col_n[3]}
N 1360 -5230 1370 -5240 {
lab=row_n[15]}
N 1370 -5240 1570 -5240 {
lab=row_n[15]}
N 1570 -5240 1580 -5230 {
lab=row_n[15]}
N 1360 -5210 1370 -5220 {
lab=rowon_n[15]}
N 1370 -5220 1570 -5220 {
lab=rowon_n[15]}
N 1570 -5220 1580 -5210 {
lab=rowon_n[15]}
N 1360 -5190 1370 -5200 {
lab=#net31}
N 1370 -5200 1570 -5200 {
lab=#net31}
N 1570 -5200 1580 -5190 {
lab=#net31}
N 1360 -5170 1370 -5180 {
lab=#net32}
N 1370 -5180 1570 -5180 {
lab=#net32}
N 1570 -5180 1580 -5170 {
lab=#net32}
N 1420 -5330 1420 -5310 {
lab=vcm}
N 1460 -5330 1460 -5310 {
lab=ctop}
N 1340 -5230 1360 -5230 {
lab=row_n[15]}
N 1340 -5210 1360 -5210 {
lab=rowon_n[15]}
N 1340 -5190 1360 -5190 {
lab=#net31}
N 1340 -5170 1360 -5170 {
lab=#net32}
N 1580 -5170 1600 -5170 {
lab=#net32}
N 1580 -5190 1600 -5190 {
lab=#net31}
N 1580 -5210 1600 -5210 {
lab=rowon_n[15]}
N 1580 -5230 1600 -5230 {
lab=row_n[15]}
N 1400 -5090 1400 -5080 {
lab=VSS}
N 1400 -5320 1400 -5310 {
lab=VDD}
N 1740 -5090 1750 -5100 {
lab=col_n[4]}
N 1750 -5300 1750 -5100 {
lab=col_n[4]}
N 1740 -5310 1750 -5300 {
lab=col_n[4]}
N 1740 -5090 1740 -5070 {
lab=col_n[4]}
N 1740 -5330 1740 -5310 {
lab=col_n[4]}
N 1620 -5230 1630 -5240 {
lab=row_n[15]}
N 1630 -5240 1830 -5240 {
lab=row_n[15]}
N 1830 -5240 1840 -5230 {
lab=row_n[15]}
N 1620 -5210 1630 -5220 {
lab=rowon_n[15]}
N 1630 -5220 1830 -5220 {
lab=rowon_n[15]}
N 1830 -5220 1840 -5210 {
lab=rowon_n[15]}
N 1620 -5190 1630 -5200 {
lab=#net31}
N 1630 -5200 1830 -5200 {
lab=#net31}
N 1830 -5200 1840 -5190 {
lab=#net31}
N 1620 -5170 1630 -5180 {
lab=#net32}
N 1630 -5180 1830 -5180 {
lab=#net32}
N 1830 -5180 1840 -5170 {
lab=#net32}
N 1680 -5330 1680 -5310 {
lab=vcm}
N 1720 -5330 1720 -5310 {
lab=ctop}
N 1600 -5230 1620 -5230 {
lab=row_n[15]}
N 1600 -5210 1620 -5210 {
lab=rowon_n[15]}
N 1600 -5190 1620 -5190 {
lab=#net31}
N 1600 -5170 1620 -5170 {
lab=#net32}
N 1840 -5170 1860 -5170 {
lab=#net32}
N 1840 -5190 1860 -5190 {
lab=#net31}
N 1840 -5210 1860 -5210 {
lab=rowon_n[15]}
N 1840 -5230 1860 -5230 {
lab=row_n[15]}
N 1660 -5090 1660 -5080 {
lab=VSS}
N 1660 -5320 1660 -5310 {
lab=VDD}
N 2000 -5090 2010 -5100 {
lab=col_n[5]}
N 2010 -5300 2010 -5100 {
lab=col_n[5]}
N 2000 -5310 2010 -5300 {
lab=col_n[5]}
N 2000 -5090 2000 -5070 {
lab=col_n[5]}
N 2000 -5330 2000 -5310 {
lab=col_n[5]}
N 1880 -5230 1890 -5240 {
lab=row_n[15]}
N 1890 -5240 2090 -5240 {
lab=row_n[15]}
N 2090 -5240 2100 -5230 {
lab=row_n[15]}
N 1880 -5210 1890 -5220 {
lab=rowon_n[15]}
N 1890 -5220 2090 -5220 {
lab=rowon_n[15]}
N 2090 -5220 2100 -5210 {
lab=rowon_n[15]}
N 1880 -5190 1890 -5200 {
lab=#net31}
N 1890 -5200 2090 -5200 {
lab=#net31}
N 2090 -5200 2100 -5190 {
lab=#net31}
N 1880 -5170 1890 -5180 {
lab=#net32}
N 1890 -5180 2090 -5180 {
lab=#net32}
N 2090 -5180 2100 -5170 {
lab=#net32}
N 1940 -5330 1940 -5310 {
lab=vcm}
N 1980 -5330 1980 -5310 {
lab=ctop}
N 1860 -5230 1880 -5230 {
lab=row_n[15]}
N 1860 -5210 1880 -5210 {
lab=rowon_n[15]}
N 1860 -5190 1880 -5190 {
lab=#net31}
N 1860 -5170 1880 -5170 {
lab=#net32}
N 2100 -5170 2120 -5170 {
lab=#net32}
N 2100 -5190 2120 -5190 {
lab=#net31}
N 2100 -5210 2120 -5210 {
lab=rowon_n[15]}
N 2100 -5230 2120 -5230 {
lab=row_n[15]}
N 1920 -5090 1920 -5080 {
lab=VSS}
N 1920 -5320 1920 -5310 {
lab=VDD}
N 2260 -5090 2270 -5100 {
lab=col_n[6]}
N 2270 -5300 2270 -5100 {
lab=col_n[6]}
N 2260 -5310 2270 -5300 {
lab=col_n[6]}
N 2260 -5090 2260 -5070 {
lab=col_n[6]}
N 2260 -5330 2260 -5310 {
lab=col_n[6]}
N 2140 -5230 2150 -5240 {
lab=row_n[15]}
N 2150 -5240 2350 -5240 {
lab=row_n[15]}
N 2350 -5240 2360 -5230 {
lab=row_n[15]}
N 2140 -5210 2150 -5220 {
lab=rowon_n[15]}
N 2150 -5220 2350 -5220 {
lab=rowon_n[15]}
N 2350 -5220 2360 -5210 {
lab=rowon_n[15]}
N 2140 -5190 2150 -5200 {
lab=#net31}
N 2150 -5200 2350 -5200 {
lab=#net31}
N 2350 -5200 2360 -5190 {
lab=#net31}
N 2140 -5170 2150 -5180 {
lab=#net32}
N 2150 -5180 2350 -5180 {
lab=#net32}
N 2350 -5180 2360 -5170 {
lab=#net32}
N 2200 -5330 2200 -5310 {
lab=vcm}
N 2240 -5330 2240 -5310 {
lab=ctop}
N 2120 -5230 2140 -5230 {
lab=row_n[15]}
N 2120 -5210 2140 -5210 {
lab=rowon_n[15]}
N 2120 -5190 2140 -5190 {
lab=#net31}
N 2120 -5170 2140 -5170 {
lab=#net32}
N 2360 -5170 2380 -5170 {
lab=#net32}
N 2360 -5190 2380 -5190 {
lab=#net31}
N 2360 -5210 2380 -5210 {
lab=rowon_n[15]}
N 2360 -5230 2380 -5230 {
lab=row_n[15]}
N 2180 -5090 2180 -5080 {
lab=VSS}
N 2180 -5320 2180 -5310 {
lab=VDD}
N 2520 -5090 2530 -5100 {
lab=col_n[7]}
N 2530 -5300 2530 -5100 {
lab=col_n[7]}
N 2520 -5310 2530 -5300 {
lab=col_n[7]}
N 2520 -5090 2520 -5070 {
lab=col_n[7]}
N 2520 -5330 2520 -5310 {
lab=col_n[7]}
N 2400 -5230 2410 -5240 {
lab=row_n[15]}
N 2410 -5240 2610 -5240 {
lab=row_n[15]}
N 2610 -5240 2620 -5230 {
lab=row_n[15]}
N 2400 -5210 2410 -5220 {
lab=rowon_n[15]}
N 2410 -5220 2610 -5220 {
lab=rowon_n[15]}
N 2610 -5220 2620 -5210 {
lab=rowon_n[15]}
N 2400 -5190 2410 -5200 {
lab=#net31}
N 2410 -5200 2610 -5200 {
lab=#net31}
N 2610 -5200 2620 -5190 {
lab=#net31}
N 2400 -5170 2410 -5180 {
lab=#net32}
N 2410 -5180 2610 -5180 {
lab=#net32}
N 2610 -5180 2620 -5170 {
lab=#net32}
N 2460 -5330 2460 -5310 {
lab=vcm}
N 2500 -5330 2500 -5310 {
lab=ctop}
N 2380 -5230 2400 -5230 {
lab=row_n[15]}
N 2380 -5210 2400 -5210 {
lab=rowon_n[15]}
N 2380 -5190 2400 -5190 {
lab=#net31}
N 2380 -5170 2400 -5170 {
lab=#net32}
N 2620 -5170 2640 -5170 {
lab=#net32}
N 2620 -5190 2640 -5190 {
lab=#net31}
N 2620 -5210 2640 -5210 {
lab=rowon_n[15]}
N 2620 -5230 2640 -5230 {
lab=row_n[15]}
N 2440 -5090 2440 -5080 {
lab=VSS}
N 2440 -5320 2440 -5310 {
lab=VDD}
N 2780 -5090 2790 -5100 {
lab=col_n[8]}
N 2790 -5300 2790 -5100 {
lab=col_n[8]}
N 2780 -5310 2790 -5300 {
lab=col_n[8]}
N 2780 -5090 2780 -5070 {
lab=col_n[8]}
N 2780 -5330 2780 -5310 {
lab=col_n[8]}
N 2660 -5230 2670 -5240 {
lab=row_n[15]}
N 2670 -5240 2870 -5240 {
lab=row_n[15]}
N 2870 -5240 2880 -5230 {
lab=row_n[15]}
N 2660 -5210 2670 -5220 {
lab=rowon_n[15]}
N 2670 -5220 2870 -5220 {
lab=rowon_n[15]}
N 2870 -5220 2880 -5210 {
lab=rowon_n[15]}
N 2660 -5190 2670 -5200 {
lab=#net31}
N 2670 -5200 2870 -5200 {
lab=#net31}
N 2870 -5200 2880 -5190 {
lab=#net31}
N 2660 -5170 2670 -5180 {
lab=#net32}
N 2670 -5180 2870 -5180 {
lab=#net32}
N 2870 -5180 2880 -5170 {
lab=#net32}
N 2720 -5330 2720 -5310 {
lab=vcm}
N 2760 -5330 2760 -5310 {
lab=ctop}
N 2640 -5230 2660 -5230 {
lab=row_n[15]}
N 2640 -5210 2660 -5210 {
lab=rowon_n[15]}
N 2640 -5190 2660 -5190 {
lab=#net31}
N 2640 -5170 2660 -5170 {
lab=#net32}
N 2880 -5170 2900 -5170 {
lab=#net32}
N 2880 -5190 2900 -5190 {
lab=#net31}
N 2880 -5210 2900 -5210 {
lab=rowon_n[15]}
N 2880 -5230 2900 -5230 {
lab=row_n[15]}
N 2700 -5090 2700 -5080 {
lab=VSS}
N 2700 -5320 2700 -5310 {
lab=VDD}
N 3040 -5090 3050 -5100 {
lab=col_n[9]}
N 3050 -5300 3050 -5100 {
lab=col_n[9]}
N 3040 -5310 3050 -5300 {
lab=col_n[9]}
N 3040 -5090 3040 -5070 {
lab=col_n[9]}
N 3040 -5330 3040 -5310 {
lab=col_n[9]}
N 2920 -5230 2930 -5240 {
lab=row_n[15]}
N 2930 -5240 3130 -5240 {
lab=row_n[15]}
N 3130 -5240 3140 -5230 {
lab=row_n[15]}
N 2920 -5210 2930 -5220 {
lab=rowon_n[15]}
N 2930 -5220 3130 -5220 {
lab=rowon_n[15]}
N 3130 -5220 3140 -5210 {
lab=rowon_n[15]}
N 2920 -5190 2930 -5200 {
lab=#net31}
N 2930 -5200 3130 -5200 {
lab=#net31}
N 3130 -5200 3140 -5190 {
lab=#net31}
N 2920 -5170 2930 -5180 {
lab=#net32}
N 2930 -5180 3130 -5180 {
lab=#net32}
N 3130 -5180 3140 -5170 {
lab=#net32}
N 2980 -5330 2980 -5310 {
lab=vcm}
N 3020 -5330 3020 -5310 {
lab=ctop}
N 2900 -5230 2920 -5230 {
lab=row_n[15]}
N 2900 -5210 2920 -5210 {
lab=rowon_n[15]}
N 2900 -5190 2920 -5190 {
lab=#net31}
N 2900 -5170 2920 -5170 {
lab=#net32}
N 3140 -5170 3160 -5170 {
lab=#net32}
N 3140 -5190 3160 -5190 {
lab=#net31}
N 3140 -5210 3160 -5210 {
lab=rowon_n[15]}
N 3140 -5230 3160 -5230 {
lab=row_n[15]}
N 2960 -5090 2960 -5080 {
lab=VSS}
N 2960 -5320 2960 -5310 {
lab=VDD}
N 3300 -5090 3310 -5100 {
lab=col_n[10]}
N 3310 -5300 3310 -5100 {
lab=col_n[10]}
N 3300 -5310 3310 -5300 {
lab=col_n[10]}
N 3300 -5090 3300 -5070 {
lab=col_n[10]}
N 3300 -5330 3300 -5310 {
lab=col_n[10]}
N 3180 -5230 3190 -5240 {
lab=row_n[15]}
N 3190 -5240 3390 -5240 {
lab=row_n[15]}
N 3390 -5240 3400 -5230 {
lab=row_n[15]}
N 3180 -5210 3190 -5220 {
lab=rowon_n[15]}
N 3190 -5220 3390 -5220 {
lab=rowon_n[15]}
N 3390 -5220 3400 -5210 {
lab=rowon_n[15]}
N 3180 -5190 3190 -5200 {
lab=#net31}
N 3190 -5200 3390 -5200 {
lab=#net31}
N 3390 -5200 3400 -5190 {
lab=#net31}
N 3180 -5170 3190 -5180 {
lab=#net32}
N 3190 -5180 3390 -5180 {
lab=#net32}
N 3390 -5180 3400 -5170 {
lab=#net32}
N 3240 -5330 3240 -5310 {
lab=vcm}
N 3280 -5330 3280 -5310 {
lab=ctop}
N 3160 -5230 3180 -5230 {
lab=row_n[15]}
N 3160 -5210 3180 -5210 {
lab=rowon_n[15]}
N 3160 -5190 3180 -5190 {
lab=#net31}
N 3160 -5170 3180 -5170 {
lab=#net32}
N 3400 -5170 3420 -5170 {
lab=#net32}
N 3400 -5190 3420 -5190 {
lab=#net31}
N 3400 -5210 3420 -5210 {
lab=rowon_n[15]}
N 3400 -5230 3420 -5230 {
lab=row_n[15]}
N 3220 -5090 3220 -5080 {
lab=VSS}
N 3220 -5320 3220 -5310 {
lab=VDD}
N 3560 -5090 3570 -5100 {
lab=col_n[11]}
N 3570 -5300 3570 -5100 {
lab=col_n[11]}
N 3560 -5310 3570 -5300 {
lab=col_n[11]}
N 3560 -5090 3560 -5070 {
lab=col_n[11]}
N 3560 -5330 3560 -5310 {
lab=col_n[11]}
N 3440 -5230 3450 -5240 {
lab=row_n[15]}
N 3450 -5240 3650 -5240 {
lab=row_n[15]}
N 3650 -5240 3660 -5230 {
lab=row_n[15]}
N 3440 -5210 3450 -5220 {
lab=rowon_n[15]}
N 3450 -5220 3650 -5220 {
lab=rowon_n[15]}
N 3650 -5220 3660 -5210 {
lab=rowon_n[15]}
N 3440 -5190 3450 -5200 {
lab=#net31}
N 3450 -5200 3650 -5200 {
lab=#net31}
N 3650 -5200 3660 -5190 {
lab=#net31}
N 3440 -5170 3450 -5180 {
lab=#net32}
N 3450 -5180 3650 -5180 {
lab=#net32}
N 3650 -5180 3660 -5170 {
lab=#net32}
N 3500 -5330 3500 -5310 {
lab=vcm}
N 3540 -5330 3540 -5310 {
lab=ctop}
N 3420 -5230 3440 -5230 {
lab=row_n[15]}
N 3420 -5210 3440 -5210 {
lab=rowon_n[15]}
N 3420 -5190 3440 -5190 {
lab=#net31}
N 3420 -5170 3440 -5170 {
lab=#net32}
N 3660 -5170 3680 -5170 {
lab=#net32}
N 3660 -5190 3680 -5190 {
lab=#net31}
N 3660 -5210 3680 -5210 {
lab=rowon_n[15]}
N 3660 -5230 3680 -5230 {
lab=row_n[15]}
N 3480 -5090 3480 -5080 {
lab=VSS}
N 3480 -5320 3480 -5310 {
lab=VDD}
N 3820 -5090 3830 -5100 {
lab=col_n[12]}
N 3830 -5300 3830 -5100 {
lab=col_n[12]}
N 3820 -5310 3830 -5300 {
lab=col_n[12]}
N 3820 -5090 3820 -5070 {
lab=col_n[12]}
N 3820 -5330 3820 -5310 {
lab=col_n[12]}
N 3700 -5230 3710 -5240 {
lab=row_n[15]}
N 3710 -5240 3910 -5240 {
lab=row_n[15]}
N 3910 -5240 3920 -5230 {
lab=row_n[15]}
N 3700 -5210 3710 -5220 {
lab=rowon_n[15]}
N 3710 -5220 3910 -5220 {
lab=rowon_n[15]}
N 3910 -5220 3920 -5210 {
lab=rowon_n[15]}
N 3700 -5190 3710 -5200 {
lab=#net31}
N 3710 -5200 3910 -5200 {
lab=#net31}
N 3910 -5200 3920 -5190 {
lab=#net31}
N 3700 -5170 3710 -5180 {
lab=#net32}
N 3710 -5180 3910 -5180 {
lab=#net32}
N 3910 -5180 3920 -5170 {
lab=#net32}
N 3760 -5330 3760 -5310 {
lab=vcm}
N 3800 -5330 3800 -5310 {
lab=ctop}
N 3680 -5230 3700 -5230 {
lab=row_n[15]}
N 3680 -5210 3700 -5210 {
lab=rowon_n[15]}
N 3680 -5190 3700 -5190 {
lab=#net31}
N 3680 -5170 3700 -5170 {
lab=#net32}
N 3920 -5170 3940 -5170 {
lab=#net32}
N 3920 -5190 3940 -5190 {
lab=#net31}
N 3920 -5210 3940 -5210 {
lab=rowon_n[15]}
N 3920 -5230 3940 -5230 {
lab=row_n[15]}
N 3740 -5090 3740 -5080 {
lab=VSS}
N 3740 -5320 3740 -5310 {
lab=VDD}
N 4080 -5090 4090 -5100 {
lab=col_n[13]}
N 4090 -5300 4090 -5100 {
lab=col_n[13]}
N 4080 -5310 4090 -5300 {
lab=col_n[13]}
N 4080 -5090 4080 -5070 {
lab=col_n[13]}
N 4080 -5330 4080 -5310 {
lab=col_n[13]}
N 3960 -5230 3970 -5240 {
lab=row_n[15]}
N 3970 -5240 4170 -5240 {
lab=row_n[15]}
N 4170 -5240 4180 -5230 {
lab=row_n[15]}
N 3960 -5210 3970 -5220 {
lab=rowon_n[15]}
N 3970 -5220 4170 -5220 {
lab=rowon_n[15]}
N 4170 -5220 4180 -5210 {
lab=rowon_n[15]}
N 3960 -5190 3970 -5200 {
lab=#net31}
N 3970 -5200 4170 -5200 {
lab=#net31}
N 4170 -5200 4180 -5190 {
lab=#net31}
N 3960 -5170 3970 -5180 {
lab=#net32}
N 3970 -5180 4170 -5180 {
lab=#net32}
N 4170 -5180 4180 -5170 {
lab=#net32}
N 4020 -5330 4020 -5310 {
lab=vcm}
N 4060 -5330 4060 -5310 {
lab=ctop}
N 3940 -5230 3960 -5230 {
lab=row_n[15]}
N 3940 -5210 3960 -5210 {
lab=rowon_n[15]}
N 3940 -5190 3960 -5190 {
lab=#net31}
N 3940 -5170 3960 -5170 {
lab=#net32}
N 4180 -5170 4200 -5170 {
lab=#net32}
N 4180 -5190 4200 -5190 {
lab=#net31}
N 4180 -5210 4200 -5210 {
lab=rowon_n[15]}
N 4180 -5230 4200 -5230 {
lab=row_n[15]}
N 4000 -5090 4000 -5080 {
lab=VSS}
N 4000 -5320 4000 -5310 {
lab=VDD}
N 4340 -5090 4350 -5100 {
lab=col_n[14]}
N 4350 -5300 4350 -5100 {
lab=col_n[14]}
N 4340 -5310 4350 -5300 {
lab=col_n[14]}
N 4340 -5090 4340 -5070 {
lab=col_n[14]}
N 4340 -5330 4340 -5310 {
lab=col_n[14]}
N 4220 -5230 4230 -5240 {
lab=row_n[15]}
N 4230 -5240 4430 -5240 {
lab=row_n[15]}
N 4430 -5240 4440 -5230 {
lab=row_n[15]}
N 4220 -5210 4230 -5220 {
lab=rowon_n[15]}
N 4230 -5220 4430 -5220 {
lab=rowon_n[15]}
N 4430 -5220 4440 -5210 {
lab=rowon_n[15]}
N 4220 -5190 4230 -5200 {
lab=#net31}
N 4230 -5200 4430 -5200 {
lab=#net31}
N 4430 -5200 4440 -5190 {
lab=#net31}
N 4220 -5170 4230 -5180 {
lab=#net32}
N 4230 -5180 4430 -5180 {
lab=#net32}
N 4430 -5180 4440 -5170 {
lab=#net32}
N 4280 -5330 4280 -5310 {
lab=vcm}
N 4320 -5330 4320 -5310 {
lab=ctop}
N 4200 -5230 4220 -5230 {
lab=row_n[15]}
N 4200 -5210 4220 -5210 {
lab=rowon_n[15]}
N 4200 -5190 4220 -5190 {
lab=#net31}
N 4200 -5170 4220 -5170 {
lab=#net32}
N 4440 -5170 4460 -5170 {
lab=#net32}
N 4440 -5190 4460 -5190 {
lab=#net31}
N 4440 -5210 4460 -5210 {
lab=rowon_n[15]}
N 4440 -5230 4460 -5230 {
lab=row_n[15]}
N 4260 -5090 4260 -5080 {
lab=VSS}
N 4260 -5320 4260 -5310 {
lab=VDD}
N 4600 -5090 4610 -5100 {
lab=col_n[15]}
N 4610 -5300 4610 -5100 {
lab=col_n[15]}
N 4600 -5310 4610 -5300 {
lab=col_n[15]}
N 4600 -5090 4600 -5070 {
lab=col_n[15]}
N 4600 -5330 4600 -5310 {
lab=col_n[15]}
N 4480 -5230 4490 -5240 {
lab=row_n[15]}
N 4490 -5240 4690 -5240 {
lab=row_n[15]}
N 4690 -5240 4700 -5230 {
lab=row_n[15]}
N 4480 -5210 4490 -5220 {
lab=rowon_n[15]}
N 4490 -5220 4690 -5220 {
lab=rowon_n[15]}
N 4690 -5220 4700 -5210 {
lab=rowon_n[15]}
N 4480 -5190 4490 -5200 {
lab=#net31}
N 4490 -5200 4690 -5200 {
lab=#net31}
N 4690 -5200 4700 -5190 {
lab=#net31}
N 4480 -5170 4490 -5180 {
lab=#net32}
N 4490 -5180 4690 -5180 {
lab=#net32}
N 4690 -5180 4700 -5170 {
lab=#net32}
N 4540 -5330 4540 -5310 {
lab=vcm}
N 4580 -5330 4580 -5310 {
lab=ctop}
N 4460 -5230 4480 -5230 {
lab=row_n[15]}
N 4460 -5210 4480 -5210 {
lab=rowon_n[15]}
N 4460 -5190 4480 -5190 {
lab=#net31}
N 4460 -5170 4480 -5170 {
lab=#net32}
N 4700 -5170 4720 -5170 {
lab=#net32}
N 4700 -5190 4720 -5190 {
lab=#net31}
N 4700 -5210 4720 -5210 {
lab=rowon_n[15]}
N 4700 -5230 4720 -5230 {
lab=row_n[15]}
N 4520 -5090 4520 -5080 {
lab=VSS}
N 4520 -5320 4520 -5310 {
lab=VDD}
N 4860 -5090 4870 -5100 {
lab=col_n[16]}
N 4870 -5300 4870 -5100 {
lab=col_n[16]}
N 4860 -5310 4870 -5300 {
lab=col_n[16]}
N 4860 -5090 4860 -5070 {
lab=col_n[16]}
N 4860 -5330 4860 -5310 {
lab=col_n[16]}
N 4740 -5230 4750 -5240 {
lab=row_n[15]}
N 4750 -5240 4950 -5240 {
lab=row_n[15]}
N 4950 -5240 4960 -5230 {
lab=row_n[15]}
N 4740 -5210 4750 -5220 {
lab=rowon_n[15]}
N 4750 -5220 4950 -5220 {
lab=rowon_n[15]}
N 4950 -5220 4960 -5210 {
lab=rowon_n[15]}
N 4740 -5190 4750 -5200 {
lab=#net31}
N 4750 -5200 4950 -5200 {
lab=#net31}
N 4950 -5200 4960 -5190 {
lab=#net31}
N 4740 -5170 4750 -5180 {
lab=#net32}
N 4750 -5180 4950 -5180 {
lab=#net32}
N 4950 -5180 4960 -5170 {
lab=#net32}
N 4800 -5330 4800 -5310 {
lab=vcm}
N 4840 -5330 4840 -5310 {
lab=ctop}
N 4720 -5230 4740 -5230 {
lab=row_n[15]}
N 4720 -5210 4740 -5210 {
lab=rowon_n[15]}
N 4720 -5190 4740 -5190 {
lab=#net31}
N 4720 -5170 4740 -5170 {
lab=#net32}
N 4960 -5170 4980 -5170 {
lab=#net32}
N 4960 -5190 4980 -5190 {
lab=#net31}
N 4960 -5210 4980 -5210 {
lab=rowon_n[15]}
N 4960 -5230 4980 -5230 {
lab=row_n[15]}
N 4780 -5090 4780 -5080 {
lab=VSS}
N 4780 -5320 4780 -5310 {
lab=VDD}
N 5120 -5090 5130 -5100 {
lab=col_n[17]}
N 5130 -5300 5130 -5100 {
lab=col_n[17]}
N 5120 -5310 5130 -5300 {
lab=col_n[17]}
N 5120 -5090 5120 -5070 {
lab=col_n[17]}
N 5120 -5330 5120 -5310 {
lab=col_n[17]}
N 5000 -5230 5010 -5240 {
lab=row_n[15]}
N 5010 -5240 5210 -5240 {
lab=row_n[15]}
N 5210 -5240 5220 -5230 {
lab=row_n[15]}
N 5000 -5210 5010 -5220 {
lab=rowon_n[15]}
N 5010 -5220 5210 -5220 {
lab=rowon_n[15]}
N 5210 -5220 5220 -5210 {
lab=rowon_n[15]}
N 5000 -5190 5010 -5200 {
lab=#net31}
N 5010 -5200 5210 -5200 {
lab=#net31}
N 5210 -5200 5220 -5190 {
lab=#net31}
N 5000 -5170 5010 -5180 {
lab=#net32}
N 5010 -5180 5210 -5180 {
lab=#net32}
N 5210 -5180 5220 -5170 {
lab=#net32}
N 5060 -5330 5060 -5310 {
lab=vcm}
N 5100 -5330 5100 -5310 {
lab=ctop}
N 4980 -5230 5000 -5230 {
lab=row_n[15]}
N 4980 -5210 5000 -5210 {
lab=rowon_n[15]}
N 4980 -5190 5000 -5190 {
lab=#net31}
N 4980 -5170 5000 -5170 {
lab=#net32}
N 5220 -5170 5240 -5170 {
lab=#net32}
N 5220 -5190 5240 -5190 {
lab=#net31}
N 5220 -5210 5240 -5210 {
lab=rowon_n[15]}
N 5220 -5230 5240 -5230 {
lab=row_n[15]}
N 5040 -5090 5040 -5080 {
lab=VSS}
N 5040 -5320 5040 -5310 {
lab=VDD}
N 5380 -5090 5390 -5100 {
lab=col_n[18]}
N 5390 -5300 5390 -5100 {
lab=col_n[18]}
N 5380 -5310 5390 -5300 {
lab=col_n[18]}
N 5380 -5090 5380 -5070 {
lab=col_n[18]}
N 5380 -5330 5380 -5310 {
lab=col_n[18]}
N 5260 -5230 5270 -5240 {
lab=row_n[15]}
N 5270 -5240 5470 -5240 {
lab=row_n[15]}
N 5470 -5240 5480 -5230 {
lab=row_n[15]}
N 5260 -5210 5270 -5220 {
lab=rowon_n[15]}
N 5270 -5220 5470 -5220 {
lab=rowon_n[15]}
N 5470 -5220 5480 -5210 {
lab=rowon_n[15]}
N 5260 -5190 5270 -5200 {
lab=#net31}
N 5270 -5200 5470 -5200 {
lab=#net31}
N 5470 -5200 5480 -5190 {
lab=#net31}
N 5260 -5170 5270 -5180 {
lab=#net32}
N 5270 -5180 5470 -5180 {
lab=#net32}
N 5470 -5180 5480 -5170 {
lab=#net32}
N 5320 -5330 5320 -5310 {
lab=vcm}
N 5360 -5330 5360 -5310 {
lab=ctop}
N 5240 -5230 5260 -5230 {
lab=row_n[15]}
N 5240 -5210 5260 -5210 {
lab=rowon_n[15]}
N 5240 -5190 5260 -5190 {
lab=#net31}
N 5240 -5170 5260 -5170 {
lab=#net32}
N 5480 -5170 5500 -5170 {
lab=#net32}
N 5480 -5190 5500 -5190 {
lab=#net31}
N 5480 -5210 5500 -5210 {
lab=rowon_n[15]}
N 5480 -5230 5500 -5230 {
lab=row_n[15]}
N 5300 -5090 5300 -5080 {
lab=VSS}
N 5300 -5320 5300 -5310 {
lab=VDD}
N 5640 -5090 5650 -5100 {
lab=col_n[19]}
N 5650 -5300 5650 -5100 {
lab=col_n[19]}
N 5640 -5310 5650 -5300 {
lab=col_n[19]}
N 5640 -5090 5640 -5070 {
lab=col_n[19]}
N 5640 -5330 5640 -5310 {
lab=col_n[19]}
N 5520 -5230 5530 -5240 {
lab=row_n[15]}
N 5530 -5240 5730 -5240 {
lab=row_n[15]}
N 5730 -5240 5740 -5230 {
lab=row_n[15]}
N 5520 -5210 5530 -5220 {
lab=rowon_n[15]}
N 5530 -5220 5730 -5220 {
lab=rowon_n[15]}
N 5730 -5220 5740 -5210 {
lab=rowon_n[15]}
N 5520 -5190 5530 -5200 {
lab=#net31}
N 5530 -5200 5730 -5200 {
lab=#net31}
N 5730 -5200 5740 -5190 {
lab=#net31}
N 5520 -5170 5530 -5180 {
lab=#net32}
N 5530 -5180 5730 -5180 {
lab=#net32}
N 5730 -5180 5740 -5170 {
lab=#net32}
N 5580 -5330 5580 -5310 {
lab=vcm}
N 5620 -5330 5620 -5310 {
lab=ctop}
N 5500 -5230 5520 -5230 {
lab=row_n[15]}
N 5500 -5210 5520 -5210 {
lab=rowon_n[15]}
N 5500 -5190 5520 -5190 {
lab=#net31}
N 5500 -5170 5520 -5170 {
lab=#net32}
N 5740 -5170 5760 -5170 {
lab=#net32}
N 5740 -5190 5760 -5190 {
lab=#net31}
N 5740 -5210 5760 -5210 {
lab=rowon_n[15]}
N 5740 -5230 5760 -5230 {
lab=row_n[15]}
N 5560 -5090 5560 -5080 {
lab=VSS}
N 5560 -5320 5560 -5310 {
lab=VDD}
N 5900 -5090 5910 -5100 {
lab=col_n[20]}
N 5910 -5300 5910 -5100 {
lab=col_n[20]}
N 5900 -5310 5910 -5300 {
lab=col_n[20]}
N 5900 -5090 5900 -5070 {
lab=col_n[20]}
N 5900 -5330 5900 -5310 {
lab=col_n[20]}
N 5780 -5230 5790 -5240 {
lab=row_n[15]}
N 5790 -5240 5990 -5240 {
lab=row_n[15]}
N 5990 -5240 6000 -5230 {
lab=row_n[15]}
N 5780 -5210 5790 -5220 {
lab=rowon_n[15]}
N 5790 -5220 5990 -5220 {
lab=rowon_n[15]}
N 5990 -5220 6000 -5210 {
lab=rowon_n[15]}
N 5780 -5190 5790 -5200 {
lab=#net31}
N 5790 -5200 5990 -5200 {
lab=#net31}
N 5990 -5200 6000 -5190 {
lab=#net31}
N 5780 -5170 5790 -5180 {
lab=#net32}
N 5790 -5180 5990 -5180 {
lab=#net32}
N 5990 -5180 6000 -5170 {
lab=#net32}
N 5840 -5330 5840 -5310 {
lab=vcm}
N 5880 -5330 5880 -5310 {
lab=ctop}
N 5760 -5230 5780 -5230 {
lab=row_n[15]}
N 5760 -5210 5780 -5210 {
lab=rowon_n[15]}
N 5760 -5190 5780 -5190 {
lab=#net31}
N 5760 -5170 5780 -5170 {
lab=#net32}
N 6000 -5170 6020 -5170 {
lab=#net32}
N 6000 -5190 6020 -5190 {
lab=#net31}
N 6000 -5210 6020 -5210 {
lab=rowon_n[15]}
N 6000 -5230 6020 -5230 {
lab=row_n[15]}
N 5820 -5090 5820 -5080 {
lab=VSS}
N 5820 -5320 5820 -5310 {
lab=VDD}
N 6160 -5090 6170 -5100 {
lab=col_n[21]}
N 6170 -5300 6170 -5100 {
lab=col_n[21]}
N 6160 -5310 6170 -5300 {
lab=col_n[21]}
N 6160 -5090 6160 -5070 {
lab=col_n[21]}
N 6160 -5330 6160 -5310 {
lab=col_n[21]}
N 6040 -5230 6050 -5240 {
lab=row_n[15]}
N 6050 -5240 6250 -5240 {
lab=row_n[15]}
N 6250 -5240 6260 -5230 {
lab=row_n[15]}
N 6040 -5210 6050 -5220 {
lab=rowon_n[15]}
N 6050 -5220 6250 -5220 {
lab=rowon_n[15]}
N 6250 -5220 6260 -5210 {
lab=rowon_n[15]}
N 6040 -5190 6050 -5200 {
lab=#net31}
N 6050 -5200 6250 -5200 {
lab=#net31}
N 6250 -5200 6260 -5190 {
lab=#net31}
N 6040 -5170 6050 -5180 {
lab=#net32}
N 6050 -5180 6250 -5180 {
lab=#net32}
N 6250 -5180 6260 -5170 {
lab=#net32}
N 6100 -5330 6100 -5310 {
lab=vcm}
N 6140 -5330 6140 -5310 {
lab=ctop}
N 6020 -5230 6040 -5230 {
lab=row_n[15]}
N 6020 -5210 6040 -5210 {
lab=rowon_n[15]}
N 6020 -5190 6040 -5190 {
lab=#net31}
N 6020 -5170 6040 -5170 {
lab=#net32}
N 6260 -5170 6280 -5170 {
lab=#net32}
N 6260 -5190 6280 -5190 {
lab=#net31}
N 6260 -5210 6280 -5210 {
lab=rowon_n[15]}
N 6260 -5230 6280 -5230 {
lab=row_n[15]}
N 6080 -5090 6080 -5080 {
lab=VSS}
N 6080 -5320 6080 -5310 {
lab=VDD}
N 6420 -5090 6430 -5100 {
lab=col_n[22]}
N 6430 -5300 6430 -5100 {
lab=col_n[22]}
N 6420 -5310 6430 -5300 {
lab=col_n[22]}
N 6420 -5090 6420 -5070 {
lab=col_n[22]}
N 6420 -5330 6420 -5310 {
lab=col_n[22]}
N 6300 -5230 6310 -5240 {
lab=row_n[15]}
N 6310 -5240 6510 -5240 {
lab=row_n[15]}
N 6510 -5240 6520 -5230 {
lab=row_n[15]}
N 6300 -5210 6310 -5220 {
lab=rowon_n[15]}
N 6310 -5220 6510 -5220 {
lab=rowon_n[15]}
N 6510 -5220 6520 -5210 {
lab=rowon_n[15]}
N 6300 -5190 6310 -5200 {
lab=#net31}
N 6310 -5200 6510 -5200 {
lab=#net31}
N 6510 -5200 6520 -5190 {
lab=#net31}
N 6300 -5170 6310 -5180 {
lab=#net32}
N 6310 -5180 6510 -5180 {
lab=#net32}
N 6510 -5180 6520 -5170 {
lab=#net32}
N 6360 -5330 6360 -5310 {
lab=vcm}
N 6400 -5330 6400 -5310 {
lab=ctop}
N 6280 -5230 6300 -5230 {
lab=row_n[15]}
N 6280 -5210 6300 -5210 {
lab=rowon_n[15]}
N 6280 -5190 6300 -5190 {
lab=#net31}
N 6280 -5170 6300 -5170 {
lab=#net32}
N 6520 -5170 6540 -5170 {
lab=#net32}
N 6520 -5190 6540 -5190 {
lab=#net31}
N 6520 -5210 6540 -5210 {
lab=rowon_n[15]}
N 6520 -5230 6540 -5230 {
lab=row_n[15]}
N 6340 -5090 6340 -5080 {
lab=VSS}
N 6340 -5320 6340 -5310 {
lab=VDD}
N 6680 -5090 6690 -5100 {
lab=col_n[23]}
N 6690 -5300 6690 -5100 {
lab=col_n[23]}
N 6680 -5310 6690 -5300 {
lab=col_n[23]}
N 6680 -5090 6680 -5070 {
lab=col_n[23]}
N 6680 -5330 6680 -5310 {
lab=col_n[23]}
N 6560 -5230 6570 -5240 {
lab=row_n[15]}
N 6570 -5240 6770 -5240 {
lab=row_n[15]}
N 6770 -5240 6780 -5230 {
lab=row_n[15]}
N 6560 -5210 6570 -5220 {
lab=rowon_n[15]}
N 6570 -5220 6770 -5220 {
lab=rowon_n[15]}
N 6770 -5220 6780 -5210 {
lab=rowon_n[15]}
N 6560 -5190 6570 -5200 {
lab=#net31}
N 6570 -5200 6770 -5200 {
lab=#net31}
N 6770 -5200 6780 -5190 {
lab=#net31}
N 6560 -5170 6570 -5180 {
lab=#net32}
N 6570 -5180 6770 -5180 {
lab=#net32}
N 6770 -5180 6780 -5170 {
lab=#net32}
N 6620 -5330 6620 -5310 {
lab=vcm}
N 6660 -5330 6660 -5310 {
lab=ctop}
N 6540 -5230 6560 -5230 {
lab=row_n[15]}
N 6540 -5210 6560 -5210 {
lab=rowon_n[15]}
N 6540 -5190 6560 -5190 {
lab=#net31}
N 6540 -5170 6560 -5170 {
lab=#net32}
N 6780 -5170 6800 -5170 {
lab=#net32}
N 6780 -5190 6800 -5190 {
lab=#net31}
N 6780 -5210 6800 -5210 {
lab=rowon_n[15]}
N 6780 -5230 6800 -5230 {
lab=row_n[15]}
N 6600 -5090 6600 -5080 {
lab=VSS}
N 6600 -5320 6600 -5310 {
lab=VDD}
N 6940 -5090 6950 -5100 {
lab=col_n[24]}
N 6950 -5300 6950 -5100 {
lab=col_n[24]}
N 6940 -5310 6950 -5300 {
lab=col_n[24]}
N 6940 -5090 6940 -5070 {
lab=col_n[24]}
N 6940 -5330 6940 -5310 {
lab=col_n[24]}
N 6820 -5230 6830 -5240 {
lab=row_n[15]}
N 6830 -5240 7030 -5240 {
lab=row_n[15]}
N 7030 -5240 7040 -5230 {
lab=row_n[15]}
N 6820 -5210 6830 -5220 {
lab=rowon_n[15]}
N 6830 -5220 7030 -5220 {
lab=rowon_n[15]}
N 7030 -5220 7040 -5210 {
lab=rowon_n[15]}
N 6820 -5190 6830 -5200 {
lab=#net31}
N 6830 -5200 7030 -5200 {
lab=#net31}
N 7030 -5200 7040 -5190 {
lab=#net31}
N 6820 -5170 6830 -5180 {
lab=#net32}
N 6830 -5180 7030 -5180 {
lab=#net32}
N 7030 -5180 7040 -5170 {
lab=#net32}
N 6880 -5330 6880 -5310 {
lab=vcm}
N 6920 -5330 6920 -5310 {
lab=ctop}
N 6800 -5230 6820 -5230 {
lab=row_n[15]}
N 6800 -5210 6820 -5210 {
lab=rowon_n[15]}
N 6800 -5190 6820 -5190 {
lab=#net31}
N 6800 -5170 6820 -5170 {
lab=#net32}
N 7040 -5170 7060 -5170 {
lab=#net32}
N 7040 -5190 7060 -5190 {
lab=#net31}
N 7040 -5210 7060 -5210 {
lab=rowon_n[15]}
N 7040 -5230 7060 -5230 {
lab=row_n[15]}
N 6860 -5090 6860 -5080 {
lab=VSS}
N 6860 -5320 6860 -5310 {
lab=VDD}
N 7200 -5090 7210 -5100 {
lab=col_n[25]}
N 7210 -5300 7210 -5100 {
lab=col_n[25]}
N 7200 -5310 7210 -5300 {
lab=col_n[25]}
N 7200 -5090 7200 -5070 {
lab=col_n[25]}
N 7200 -5330 7200 -5310 {
lab=col_n[25]}
N 7080 -5230 7090 -5240 {
lab=row_n[15]}
N 7090 -5240 7290 -5240 {
lab=row_n[15]}
N 7290 -5240 7300 -5230 {
lab=row_n[15]}
N 7080 -5210 7090 -5220 {
lab=rowon_n[15]}
N 7090 -5220 7290 -5220 {
lab=rowon_n[15]}
N 7290 -5220 7300 -5210 {
lab=rowon_n[15]}
N 7080 -5190 7090 -5200 {
lab=#net31}
N 7090 -5200 7290 -5200 {
lab=#net31}
N 7290 -5200 7300 -5190 {
lab=#net31}
N 7080 -5170 7090 -5180 {
lab=#net32}
N 7090 -5180 7290 -5180 {
lab=#net32}
N 7290 -5180 7300 -5170 {
lab=#net32}
N 7140 -5330 7140 -5310 {
lab=vcm}
N 7180 -5330 7180 -5310 {
lab=ctop}
N 7060 -5230 7080 -5230 {
lab=row_n[15]}
N 7060 -5210 7080 -5210 {
lab=rowon_n[15]}
N 7060 -5190 7080 -5190 {
lab=#net31}
N 7060 -5170 7080 -5170 {
lab=#net32}
N 7300 -5170 7320 -5170 {
lab=#net32}
N 7300 -5190 7320 -5190 {
lab=#net31}
N 7300 -5210 7320 -5210 {
lab=rowon_n[15]}
N 7300 -5230 7320 -5230 {
lab=row_n[15]}
N 7120 -5090 7120 -5080 {
lab=VSS}
N 7120 -5320 7120 -5310 {
lab=VDD}
N 7460 -5090 7470 -5100 {
lab=col_n[26]}
N 7470 -5300 7470 -5100 {
lab=col_n[26]}
N 7460 -5310 7470 -5300 {
lab=col_n[26]}
N 7460 -5090 7460 -5070 {
lab=col_n[26]}
N 7460 -5330 7460 -5310 {
lab=col_n[26]}
N 7340 -5230 7350 -5240 {
lab=row_n[15]}
N 7350 -5240 7550 -5240 {
lab=row_n[15]}
N 7550 -5240 7560 -5230 {
lab=row_n[15]}
N 7340 -5210 7350 -5220 {
lab=rowon_n[15]}
N 7350 -5220 7550 -5220 {
lab=rowon_n[15]}
N 7550 -5220 7560 -5210 {
lab=rowon_n[15]}
N 7340 -5190 7350 -5200 {
lab=#net31}
N 7350 -5200 7550 -5200 {
lab=#net31}
N 7550 -5200 7560 -5190 {
lab=#net31}
N 7340 -5170 7350 -5180 {
lab=#net32}
N 7350 -5180 7550 -5180 {
lab=#net32}
N 7550 -5180 7560 -5170 {
lab=#net32}
N 7400 -5330 7400 -5310 {
lab=vcm}
N 7440 -5330 7440 -5310 {
lab=ctop}
N 7320 -5230 7340 -5230 {
lab=row_n[15]}
N 7320 -5210 7340 -5210 {
lab=rowon_n[15]}
N 7320 -5190 7340 -5190 {
lab=#net31}
N 7320 -5170 7340 -5170 {
lab=#net32}
N 7560 -5170 7580 -5170 {
lab=#net32}
N 7560 -5190 7580 -5190 {
lab=#net31}
N 7560 -5210 7580 -5210 {
lab=rowon_n[15]}
N 7560 -5230 7580 -5230 {
lab=row_n[15]}
N 7380 -5090 7380 -5080 {
lab=VSS}
N 7380 -5320 7380 -5310 {
lab=VDD}
N 7720 -5090 7730 -5100 {
lab=col_n[27]}
N 7730 -5300 7730 -5100 {
lab=col_n[27]}
N 7720 -5310 7730 -5300 {
lab=col_n[27]}
N 7720 -5090 7720 -5070 {
lab=col_n[27]}
N 7720 -5330 7720 -5310 {
lab=col_n[27]}
N 7600 -5230 7610 -5240 {
lab=row_n[15]}
N 7610 -5240 7810 -5240 {
lab=row_n[15]}
N 7810 -5240 7820 -5230 {
lab=row_n[15]}
N 7600 -5210 7610 -5220 {
lab=rowon_n[15]}
N 7610 -5220 7810 -5220 {
lab=rowon_n[15]}
N 7810 -5220 7820 -5210 {
lab=rowon_n[15]}
N 7600 -5190 7610 -5200 {
lab=#net31}
N 7610 -5200 7810 -5200 {
lab=#net31}
N 7810 -5200 7820 -5190 {
lab=#net31}
N 7600 -5170 7610 -5180 {
lab=#net32}
N 7610 -5180 7810 -5180 {
lab=#net32}
N 7810 -5180 7820 -5170 {
lab=#net32}
N 7660 -5330 7660 -5310 {
lab=vcm}
N 7700 -5330 7700 -5310 {
lab=ctop}
N 7580 -5230 7600 -5230 {
lab=row_n[15]}
N 7580 -5210 7600 -5210 {
lab=rowon_n[15]}
N 7580 -5190 7600 -5190 {
lab=#net31}
N 7580 -5170 7600 -5170 {
lab=#net32}
N 7820 -5170 7840 -5170 {
lab=#net32}
N 7820 -5190 7840 -5190 {
lab=#net31}
N 7820 -5210 7840 -5210 {
lab=rowon_n[15]}
N 7820 -5230 7840 -5230 {
lab=row_n[15]}
N 7640 -5090 7640 -5080 {
lab=VSS}
N 7640 -5320 7640 -5310 {
lab=VDD}
N 7980 -5090 7990 -5100 {
lab=col_n[28]}
N 7990 -5300 7990 -5100 {
lab=col_n[28]}
N 7980 -5310 7990 -5300 {
lab=col_n[28]}
N 7980 -5090 7980 -5070 {
lab=col_n[28]}
N 7980 -5330 7980 -5310 {
lab=col_n[28]}
N 7860 -5230 7870 -5240 {
lab=row_n[15]}
N 7870 -5240 8070 -5240 {
lab=row_n[15]}
N 8070 -5240 8080 -5230 {
lab=row_n[15]}
N 7860 -5210 7870 -5220 {
lab=rowon_n[15]}
N 7870 -5220 8070 -5220 {
lab=rowon_n[15]}
N 8070 -5220 8080 -5210 {
lab=rowon_n[15]}
N 7860 -5190 7870 -5200 {
lab=#net31}
N 7870 -5200 8070 -5200 {
lab=#net31}
N 8070 -5200 8080 -5190 {
lab=#net31}
N 7860 -5170 7870 -5180 {
lab=#net32}
N 7870 -5180 8070 -5180 {
lab=#net32}
N 8070 -5180 8080 -5170 {
lab=#net32}
N 7920 -5330 7920 -5310 {
lab=vcm}
N 7960 -5330 7960 -5310 {
lab=ctop}
N 7840 -5230 7860 -5230 {
lab=row_n[15]}
N 7840 -5210 7860 -5210 {
lab=rowon_n[15]}
N 7840 -5190 7860 -5190 {
lab=#net31}
N 7840 -5170 7860 -5170 {
lab=#net32}
N 8080 -5170 8100 -5170 {
lab=#net32}
N 8080 -5190 8100 -5190 {
lab=#net31}
N 8080 -5210 8100 -5210 {
lab=rowon_n[15]}
N 8080 -5230 8100 -5230 {
lab=row_n[15]}
N 7900 -5090 7900 -5080 {
lab=VSS}
N 7900 -5320 7900 -5310 {
lab=VDD}
N 8240 -5090 8250 -5100 {
lab=col_n[29]}
N 8250 -5300 8250 -5100 {
lab=col_n[29]}
N 8240 -5310 8250 -5300 {
lab=col_n[29]}
N 8240 -5090 8240 -5070 {
lab=col_n[29]}
N 8240 -5330 8240 -5310 {
lab=col_n[29]}
N 8120 -5230 8130 -5240 {
lab=row_n[15]}
N 8130 -5240 8330 -5240 {
lab=row_n[15]}
N 8330 -5240 8340 -5230 {
lab=row_n[15]}
N 8120 -5210 8130 -5220 {
lab=rowon_n[15]}
N 8130 -5220 8330 -5220 {
lab=rowon_n[15]}
N 8330 -5220 8340 -5210 {
lab=rowon_n[15]}
N 8120 -5190 8130 -5200 {
lab=#net31}
N 8130 -5200 8330 -5200 {
lab=#net31}
N 8330 -5200 8340 -5190 {
lab=#net31}
N 8120 -5170 8130 -5180 {
lab=#net32}
N 8130 -5180 8330 -5180 {
lab=#net32}
N 8330 -5180 8340 -5170 {
lab=#net32}
N 8180 -5330 8180 -5310 {
lab=vcm}
N 8220 -5330 8220 -5310 {
lab=ctop}
N 8100 -5230 8120 -5230 {
lab=row_n[15]}
N 8100 -5210 8120 -5210 {
lab=rowon_n[15]}
N 8100 -5190 8120 -5190 {
lab=#net31}
N 8100 -5170 8120 -5170 {
lab=#net32}
N 8340 -5170 8360 -5170 {
lab=#net32}
N 8340 -5190 8360 -5190 {
lab=#net31}
N 8340 -5210 8360 -5210 {
lab=rowon_n[15]}
N 8340 -5230 8360 -5230 {
lab=row_n[15]}
N 8160 -5090 8160 -5080 {
lab=VSS}
N 8160 -5320 8160 -5310 {
lab=VDD}
N 8500 -5090 8510 -5100 {
lab=col_n[30]}
N 8510 -5300 8510 -5100 {
lab=col_n[30]}
N 8500 -5310 8510 -5300 {
lab=col_n[30]}
N 8500 -5090 8500 -5070 {
lab=col_n[30]}
N 8500 -5330 8500 -5310 {
lab=col_n[30]}
N 8380 -5230 8390 -5240 {
lab=row_n[15]}
N 8390 -5240 8590 -5240 {
lab=row_n[15]}
N 8590 -5240 8600 -5230 {
lab=row_n[15]}
N 8380 -5210 8390 -5220 {
lab=rowon_n[15]}
N 8390 -5220 8590 -5220 {
lab=rowon_n[15]}
N 8590 -5220 8600 -5210 {
lab=rowon_n[15]}
N 8380 -5190 8390 -5200 {
lab=#net31}
N 8390 -5200 8590 -5200 {
lab=#net31}
N 8590 -5200 8600 -5190 {
lab=#net31}
N 8380 -5170 8390 -5180 {
lab=#net32}
N 8390 -5180 8590 -5180 {
lab=#net32}
N 8590 -5180 8600 -5170 {
lab=#net32}
N 8440 -5330 8440 -5310 {
lab=vcm}
N 8480 -5330 8480 -5310 {
lab=ctop}
N 8360 -5230 8380 -5230 {
lab=row_n[15]}
N 8360 -5210 8380 -5210 {
lab=rowon_n[15]}
N 8360 -5190 8380 -5190 {
lab=#net31}
N 8360 -5170 8380 -5170 {
lab=#net32}
N 8600 -5170 8620 -5170 {
lab=#net32}
N 8600 -5190 8620 -5190 {
lab=#net31}
N 8600 -5210 8620 -5210 {
lab=rowon_n[15]}
N 8600 -5230 8620 -5230 {
lab=row_n[15]}
N 8420 -5090 8420 -5080 {
lab=VSS}
N 8420 -5320 8420 -5310 {
lab=VDD}
N 8760 -5090 8770 -5100 {
lab=col_n[31]}
N 8770 -5300 8770 -5100 {
lab=col_n[31]}
N 8760 -5310 8770 -5300 {
lab=col_n[31]}
N 8760 -5090 8760 -5070 {
lab=col_n[31]}
N 8760 -5330 8760 -5310 {
lab=col_n[31]}
N 8640 -5230 8650 -5240 {
lab=row_n[15]}
N 8650 -5240 8850 -5240 {
lab=row_n[15]}
N 8850 -5240 8860 -5230 {
lab=row_n[15]}
N 8640 -5210 8650 -5220 {
lab=rowon_n[15]}
N 8650 -5220 8850 -5220 {
lab=rowon_n[15]}
N 8850 -5220 8860 -5210 {
lab=rowon_n[15]}
N 8640 -5190 8650 -5200 {
lab=#net31}
N 8650 -5200 8850 -5200 {
lab=#net31}
N 8850 -5200 8860 -5190 {
lab=#net31}
N 8640 -5170 8650 -5180 {
lab=#net32}
N 8650 -5180 8850 -5180 {
lab=#net32}
N 8850 -5180 8860 -5170 {
lab=#net32}
N 8700 -5330 8700 -5310 {
lab=vcm}
N 8740 -5330 8740 -5310 {
lab=ctop}
N 8620 -5230 8640 -5230 {
lab=row_n[15]}
N 8620 -5210 8640 -5210 {
lab=rowon_n[15]}
N 8620 -5190 8640 -5190 {
lab=#net31}
N 8620 -5170 8640 -5170 {
lab=#net32}
N 8860 -5170 8880 -5170 {
lab=#net32}
N 8860 -5190 8880 -5190 {
lab=#net31}
N 8860 -5210 8880 -5210 {
lab=rowon_n[15]}
N 8860 -5230 8880 -5230 {
lab=row_n[15]}
N 8680 -5090 8680 -5080 {
lab=VSS}
N 8680 -5320 8680 -5310 {
lab=VDD}
N 5900 -5350 5900 -5330 {
lab=col_n[20]}
N 540 -1290 560 -1290 {
lab=#net1}
N 540 -1270 560 -1270 {
lab=#net2}
N 300 -1270 320 -1270 {
lab=sample_n}
N 300 -1290 320 -1290 {
lab=sample}
N 300 -1310 320 -1310 {
lab=rowon_n[0]}
N 300 -1330 320 -1330 {
lab=row_n[0]}
N 380 -1430 380 -1410 {
lab=vcm}
N 420 -1430 420 -1410 {
lab=ctop}
N 360 -1420 360 -1410 {
lab=VDD}
N 440 -1190 440 -1170 {
lab=VDD}
N 440 -1190 450 -1200 {
lab=VDD}
N 450 -1400 450 -1200 {
lab=VDD}
N 440 -1410 450 -1400 {
lab=VDD}
N 440 -1430 440 -1410 {
lab=VDD}
N 360 -1190 360 -1180 {
lab=VSS}
N 320 -1330 330 -1340 {
lab=row_n[0]}
N 330 -1340 530 -1340 {
lab=row_n[0]}
N 530 -1340 540 -1330 {
lab=row_n[0]}
N 540 -1330 560 -1330 {
lab=row_n[0]}
N 320 -1310 330 -1320 {
lab=rowon_n[0]}
N 330 -1320 530 -1320 {
lab=rowon_n[0]}
N 530 -1320 540 -1310 {
lab=rowon_n[0]}
N 540 -1310 560 -1310 {
lab=rowon_n[0]}
N 540 -1550 560 -1550 {
lab=#net3}
N 540 -1530 560 -1530 {
lab=#net4}
N 300 -1530 320 -1530 {
lab=sample_n}
N 300 -1550 320 -1550 {
lab=sample}
N 300 -1570 320 -1570 {
lab=rowon_n[1]}
N 300 -1590 320 -1590 {
lab=row_n[1]}
N 380 -1690 380 -1670 {
lab=vcm}
N 420 -1690 420 -1670 {
lab=ctop}
N 360 -1680 360 -1670 {
lab=VDD}
N 440 -1450 440 -1430 {
lab=VDD}
N 440 -1450 450 -1460 {
lab=VDD}
N 450 -1660 450 -1460 {
lab=VDD}
N 440 -1670 450 -1660 {
lab=VDD}
N 440 -1690 440 -1670 {
lab=VDD}
N 360 -1450 360 -1440 {
lab=VSS}
N 320 -1590 330 -1600 {
lab=row_n[1]}
N 330 -1600 530 -1600 {
lab=row_n[1]}
N 530 -1600 540 -1590 {
lab=row_n[1]}
N 540 -1590 560 -1590 {
lab=row_n[1]}
N 320 -1570 330 -1580 {
lab=rowon_n[1]}
N 330 -1580 530 -1580 {
lab=rowon_n[1]}
N 530 -1580 540 -1570 {
lab=rowon_n[1]}
N 540 -1570 560 -1570 {
lab=rowon_n[1]}
N 540 -1810 560 -1810 {
lab=#net5}
N 540 -1790 560 -1790 {
lab=#net6}
N 300 -1790 320 -1790 {
lab=sample_n}
N 300 -1810 320 -1810 {
lab=sample}
N 300 -1830 320 -1830 {
lab=rowon_n[2]}
N 300 -1850 320 -1850 {
lab=row_n[2]}
N 380 -1950 380 -1930 {
lab=vcm}
N 420 -1950 420 -1930 {
lab=ctop}
N 360 -1940 360 -1930 {
lab=VDD}
N 440 -1710 440 -1690 {
lab=VDD}
N 440 -1710 450 -1720 {
lab=VDD}
N 450 -1920 450 -1720 {
lab=VDD}
N 440 -1930 450 -1920 {
lab=VDD}
N 440 -1950 440 -1930 {
lab=VDD}
N 360 -1710 360 -1700 {
lab=VSS}
N 320 -1850 330 -1860 {
lab=row_n[2]}
N 330 -1860 530 -1860 {
lab=row_n[2]}
N 530 -1860 540 -1850 {
lab=row_n[2]}
N 540 -1850 560 -1850 {
lab=row_n[2]}
N 320 -1830 330 -1840 {
lab=rowon_n[2]}
N 330 -1840 530 -1840 {
lab=rowon_n[2]}
N 530 -1840 540 -1830 {
lab=rowon_n[2]}
N 540 -1830 560 -1830 {
lab=rowon_n[2]}
N 540 -2070 560 -2070 {
lab=#net7}
N 540 -2050 560 -2050 {
lab=#net8}
N 300 -2050 320 -2050 {
lab=sample_n}
N 300 -2070 320 -2070 {
lab=sample}
N 300 -2090 320 -2090 {
lab=rowon_n[3]}
N 300 -2110 320 -2110 {
lab=row_n[3]}
N 380 -2210 380 -2190 {
lab=vcm}
N 420 -2210 420 -2190 {
lab=ctop}
N 360 -2200 360 -2190 {
lab=VDD}
N 440 -1970 450 -1980 {
lab=VDD}
N 450 -2180 450 -1980 {
lab=VDD}
N 440 -2190 450 -2180 {
lab=VDD}
N 440 -2210 440 -2190 {
lab=VDD}
N 360 -1970 360 -1960 {
lab=VSS}
N 320 -2110 330 -2120 {
lab=row_n[3]}
N 330 -2120 530 -2120 {
lab=row_n[3]}
N 530 -2120 540 -2110 {
lab=row_n[3]}
N 540 -2110 560 -2110 {
lab=row_n[3]}
N 320 -2090 330 -2100 {
lab=rowon_n[3]}
N 330 -2100 530 -2100 {
lab=rowon_n[3]}
N 530 -2100 540 -2090 {
lab=rowon_n[3]}
N 540 -2090 560 -2090 {
lab=rowon_n[3]}
N 540 -2330 560 -2330 {
lab=#net9}
N 540 -2310 560 -2310 {
lab=#net10}
N 300 -2310 320 -2310 {
lab=sample_n}
N 300 -2330 320 -2330 {
lab=sample}
N 300 -2350 320 -2350 {
lab=rowon_n[4]}
N 300 -2370 320 -2370 {
lab=row_n[4]}
N 380 -2470 380 -2450 {
lab=vcm}
N 420 -2470 420 -2450 {
lab=ctop}
N 360 -2460 360 -2450 {
lab=VDD}
N 440 -2230 440 -2210 {
lab=VDD}
N 440 -2230 450 -2240 {
lab=VDD}
N 450 -2440 450 -2240 {
lab=VDD}
N 440 -2450 450 -2440 {
lab=VDD}
N 440 -2470 440 -2450 {
lab=VDD}
N 360 -2230 360 -2220 {
lab=VSS}
N 320 -2370 330 -2380 {
lab=row_n[4]}
N 330 -2380 530 -2380 {
lab=row_n[4]}
N 530 -2380 540 -2370 {
lab=row_n[4]}
N 540 -2370 560 -2370 {
lab=row_n[4]}
N 320 -2350 330 -2360 {
lab=rowon_n[4]}
N 330 -2360 530 -2360 {
lab=rowon_n[4]}
N 530 -2360 540 -2350 {
lab=rowon_n[4]}
N 540 -2350 560 -2350 {
lab=rowon_n[4]}
N 440 -1970 440 -1950 {
lab=VDD}
N 540 -2590 560 -2590 {
lab=#net11}
N 540 -2570 560 -2570 {
lab=#net12}
N 300 -2570 320 -2570 {
lab=sample_n}
N 300 -2590 320 -2590 {
lab=sample}
N 300 -2610 320 -2610 {
lab=rowon_n[5]}
N 300 -2630 320 -2630 {
lab=row_n[5]}
N 380 -2730 380 -2710 {
lab=vcm}
N 420 -2730 420 -2710 {
lab=ctop}
N 360 -2720 360 -2710 {
lab=VDD}
N 440 -2490 440 -2470 {
lab=VDD}
N 440 -2490 450 -2500 {
lab=VDD}
N 450 -2700 450 -2500 {
lab=VDD}
N 440 -2710 450 -2700 {
lab=VDD}
N 440 -2730 440 -2710 {
lab=VDD}
N 360 -2490 360 -2480 {
lab=VSS}
N 320 -2630 330 -2640 {
lab=row_n[5]}
N 330 -2640 530 -2640 {
lab=row_n[5]}
N 530 -2640 540 -2630 {
lab=row_n[5]}
N 540 -2630 560 -2630 {
lab=row_n[5]}
N 320 -2610 330 -2620 {
lab=rowon_n[5]}
N 330 -2620 530 -2620 {
lab=rowon_n[5]}
N 530 -2620 540 -2610 {
lab=rowon_n[5]}
N 540 -2610 560 -2610 {
lab=rowon_n[5]}
N 540 -2850 560 -2850 {
lab=#net13}
N 540 -2830 560 -2830 {
lab=#net14}
N 300 -2830 320 -2830 {
lab=sample_n}
N 300 -2850 320 -2850 {
lab=sample}
N 300 -2870 320 -2870 {
lab=rowon_n[6]}
N 300 -2890 320 -2890 {
lab=row_n[6]}
N 380 -2990 380 -2970 {
lab=vcm}
N 420 -2990 420 -2970 {
lab=ctop}
N 360 -2980 360 -2970 {
lab=VDD}
N 440 -2750 440 -2730 {
lab=VDD}
N 440 -2750 450 -2760 {
lab=VDD}
N 450 -2960 450 -2760 {
lab=VDD}
N 440 -2970 450 -2960 {
lab=VDD}
N 440 -2990 440 -2970 {
lab=VDD}
N 360 -2750 360 -2740 {
lab=VSS}
N 320 -2890 330 -2900 {
lab=row_n[6]}
N 330 -2900 530 -2900 {
lab=row_n[6]}
N 530 -2900 540 -2890 {
lab=row_n[6]}
N 540 -2890 560 -2890 {
lab=row_n[6]}
N 320 -2870 330 -2880 {
lab=rowon_n[6]}
N 330 -2880 530 -2880 {
lab=rowon_n[6]}
N 530 -2880 540 -2870 {
lab=rowon_n[6]}
N 540 -2870 560 -2870 {
lab=rowon_n[6]}
N 540 -3110 560 -3110 {
lab=#net15}
N 540 -3090 560 -3090 {
lab=#net16}
N 300 -3090 320 -3090 {
lab=sample_n}
N 300 -3110 320 -3110 {
lab=sample}
N 300 -3130 320 -3130 {
lab=rowon_n[7]}
N 300 -3150 320 -3150 {
lab=row_n[7]}
N 380 -3250 380 -3230 {
lab=vcm}
N 420 -3250 420 -3230 {
lab=ctop}
N 360 -3240 360 -3230 {
lab=VDD}
N 440 -3010 440 -2990 {
lab=VDD}
N 440 -3010 450 -3020 {
lab=VDD}
N 450 -3220 450 -3020 {
lab=VDD}
N 440 -3230 450 -3220 {
lab=VDD}
N 440 -3250 440 -3230 {
lab=VDD}
N 360 -3010 360 -3000 {
lab=VSS}
N 320 -3150 330 -3160 {
lab=row_n[7]}
N 330 -3160 530 -3160 {
lab=row_n[7]}
N 530 -3160 540 -3150 {
lab=row_n[7]}
N 540 -3150 560 -3150 {
lab=row_n[7]}
N 320 -3130 330 -3140 {
lab=rowon_n[7]}
N 330 -3140 530 -3140 {
lab=rowon_n[7]}
N 530 -3140 540 -3130 {
lab=rowon_n[7]}
N 540 -3130 560 -3130 {
lab=rowon_n[7]}
N 540 -3370 560 -3370 {
lab=#net17}
N 540 -3350 560 -3350 {
lab=#net18}
N 300 -3350 320 -3350 {
lab=sample_n}
N 300 -3370 320 -3370 {
lab=sample}
N 300 -3390 320 -3390 {
lab=rowon_n[8]}
N 300 -3410 320 -3410 {
lab=row_n[8]}
N 380 -3510 380 -3490 {
lab=vcm}
N 420 -3510 420 -3490 {
lab=ctop}
N 360 -3500 360 -3490 {
lab=VDD}
N 440 -3270 450 -3280 {
lab=VDD}
N 450 -3480 450 -3280 {
lab=VDD}
N 440 -3490 450 -3480 {
lab=VDD}
N 440 -3510 440 -3490 {
lab=VDD}
N 360 -3270 360 -3260 {
lab=VSS}
N 320 -3410 330 -3420 {
lab=row_n[8]}
N 330 -3420 530 -3420 {
lab=row_n[8]}
N 530 -3420 540 -3410 {
lab=row_n[8]}
N 540 -3410 560 -3410 {
lab=row_n[8]}
N 320 -3390 330 -3400 {
lab=rowon_n[8]}
N 330 -3400 530 -3400 {
lab=rowon_n[8]}
N 530 -3400 540 -3390 {
lab=rowon_n[8]}
N 540 -3390 560 -3390 {
lab=rowon_n[8]}
N 540 -3630 560 -3630 {
lab=#net19}
N 540 -3610 560 -3610 {
lab=#net20}
N 300 -3610 320 -3610 {
lab=sample_n}
N 300 -3630 320 -3630 {
lab=sample}
N 300 -3650 320 -3650 {
lab=rowon_n[9]}
N 300 -3670 320 -3670 {
lab=row_n[9]}
N 380 -3770 380 -3750 {
lab=vcm}
N 420 -3770 420 -3750 {
lab=ctop}
N 360 -3760 360 -3750 {
lab=VDD}
N 440 -3530 440 -3510 {
lab=VDD}
N 440 -3530 450 -3540 {
lab=VDD}
N 450 -3740 450 -3540 {
lab=VDD}
N 440 -3750 450 -3740 {
lab=VDD}
N 440 -3770 440 -3750 {
lab=VDD}
N 360 -3530 360 -3520 {
lab=VSS}
N 320 -3670 330 -3680 {
lab=row_n[9]}
N 330 -3680 530 -3680 {
lab=row_n[9]}
N 530 -3680 540 -3670 {
lab=row_n[9]}
N 540 -3670 560 -3670 {
lab=row_n[9]}
N 320 -3650 330 -3660 {
lab=rowon_n[9]}
N 330 -3660 530 -3660 {
lab=rowon_n[9]}
N 530 -3660 540 -3650 {
lab=rowon_n[9]}
N 540 -3650 560 -3650 {
lab=rowon_n[9]}
N 440 -3270 440 -3250 {
lab=VDD}
N 540 -3890 560 -3890 {
lab=#net21}
N 540 -3870 560 -3870 {
lab=#net22}
N 300 -3870 320 -3870 {
lab=sample_n}
N 300 -3890 320 -3890 {
lab=sample}
N 300 -3910 320 -3910 {
lab=rowon_n[10]}
N 300 -3930 320 -3930 {
lab=row_n[10]}
N 380 -4030 380 -4010 {
lab=vcm}
N 420 -4030 420 -4010 {
lab=ctop}
N 360 -4020 360 -4010 {
lab=VDD}
N 440 -3790 440 -3770 {
lab=VDD}
N 440 -3790 450 -3800 {
lab=VDD}
N 450 -4000 450 -3800 {
lab=VDD}
N 440 -4010 450 -4000 {
lab=VDD}
N 440 -4030 440 -4010 {
lab=VDD}
N 360 -3790 360 -3780 {
lab=VSS}
N 320 -3930 330 -3940 {
lab=row_n[10]}
N 330 -3940 530 -3940 {
lab=row_n[10]}
N 530 -3940 540 -3930 {
lab=row_n[10]}
N 540 -3930 560 -3930 {
lab=row_n[10]}
N 320 -3910 330 -3920 {
lab=rowon_n[10]}
N 330 -3920 530 -3920 {
lab=rowon_n[10]}
N 530 -3920 540 -3910 {
lab=rowon_n[10]}
N 540 -3910 560 -3910 {
lab=rowon_n[10]}
N 540 -4150 560 -4150 {
lab=#net23}
N 540 -4130 560 -4130 {
lab=#net24}
N 300 -4130 320 -4130 {
lab=sample_n}
N 300 -4150 320 -4150 {
lab=sample}
N 300 -4170 320 -4170 {
lab=rowon_n[11]}
N 300 -4190 320 -4190 {
lab=row_n[11]}
N 380 -4290 380 -4270 {
lab=vcm}
N 420 -4290 420 -4270 {
lab=ctop}
N 360 -4280 360 -4270 {
lab=VDD}
N 440 -4050 440 -4030 {
lab=VDD}
N 440 -4050 450 -4060 {
lab=VDD}
N 450 -4260 450 -4060 {
lab=VDD}
N 440 -4270 450 -4260 {
lab=VDD}
N 440 -4290 440 -4270 {
lab=VDD}
N 360 -4050 360 -4040 {
lab=VSS}
N 320 -4190 330 -4200 {
lab=row_n[11]}
N 330 -4200 530 -4200 {
lab=row_n[11]}
N 530 -4200 540 -4190 {
lab=row_n[11]}
N 540 -4190 560 -4190 {
lab=row_n[11]}
N 320 -4170 330 -4180 {
lab=rowon_n[11]}
N 330 -4180 530 -4180 {
lab=rowon_n[11]}
N 530 -4180 540 -4170 {
lab=rowon_n[11]}
N 540 -4170 560 -4170 {
lab=rowon_n[11]}
N 540 -4410 560 -4410 {
lab=#net25}
N 540 -4390 560 -4390 {
lab=#net26}
N 300 -4390 320 -4390 {
lab=sample_n}
N 300 -4410 320 -4410 {
lab=sample}
N 300 -4430 320 -4430 {
lab=rowon_n[12]}
N 300 -4450 320 -4450 {
lab=row_n[12]}
N 380 -4550 380 -4530 {
lab=vcm}
N 420 -4550 420 -4530 {
lab=ctop}
N 360 -4540 360 -4530 {
lab=VDD}
N 440 -4310 440 -4290 {
lab=VDD}
N 440 -4310 450 -4320 {
lab=VDD}
N 450 -4520 450 -4320 {
lab=VDD}
N 440 -4530 450 -4520 {
lab=VDD}
N 440 -4550 440 -4530 {
lab=VDD}
N 360 -4310 360 -4300 {
lab=VSS}
N 320 -4450 330 -4460 {
lab=row_n[12]}
N 330 -4460 530 -4460 {
lab=row_n[12]}
N 530 -4460 540 -4450 {
lab=row_n[12]}
N 540 -4450 560 -4450 {
lab=row_n[12]}
N 320 -4430 330 -4440 {
lab=rowon_n[12]}
N 330 -4440 530 -4440 {
lab=rowon_n[12]}
N 530 -4440 540 -4430 {
lab=rowon_n[12]}
N 540 -4430 560 -4430 {
lab=rowon_n[12]}
N 540 -4670 560 -4670 {
lab=#net27}
N 540 -4650 560 -4650 {
lab=#net28}
N 300 -4650 320 -4650 {
lab=sample_n}
N 300 -4670 320 -4670 {
lab=sample}
N 300 -4690 320 -4690 {
lab=rowon_n[13]}
N 300 -4710 320 -4710 {
lab=row_n[13]}
N 380 -4810 380 -4790 {
lab=vcm}
N 420 -4810 420 -4790 {
lab=ctop}
N 360 -4800 360 -4790 {
lab=VDD}
N 440 -4570 450 -4580 {
lab=VDD}
N 450 -4780 450 -4580 {
lab=VDD}
N 440 -4790 450 -4780 {
lab=VDD}
N 440 -4810 440 -4790 {
lab=VDD}
N 360 -4570 360 -4560 {
lab=VSS}
N 320 -4710 330 -4720 {
lab=row_n[13]}
N 330 -4720 530 -4720 {
lab=row_n[13]}
N 530 -4720 540 -4710 {
lab=row_n[13]}
N 540 -4710 560 -4710 {
lab=row_n[13]}
N 320 -4690 330 -4700 {
lab=rowon_n[13]}
N 330 -4700 530 -4700 {
lab=rowon_n[13]}
N 530 -4700 540 -4690 {
lab=rowon_n[13]}
N 540 -4690 560 -4690 {
lab=rowon_n[13]}
N 540 -4930 560 -4930 {
lab=#net29}
N 540 -4910 560 -4910 {
lab=#net30}
N 300 -4910 320 -4910 {
lab=sample_n}
N 300 -4930 320 -4930 {
lab=sample}
N 300 -4950 320 -4950 {
lab=rowon_n[14]}
N 300 -4970 320 -4970 {
lab=row_n[14]}
N 380 -5070 380 -5050 {
lab=vcm}
N 420 -5070 420 -5050 {
lab=ctop}
N 360 -5060 360 -5050 {
lab=VDD}
N 440 -4830 440 -4810 {
lab=VDD}
N 440 -4830 450 -4840 {
lab=VDD}
N 450 -5040 450 -4840 {
lab=VDD}
N 440 -5050 450 -5040 {
lab=VDD}
N 440 -5070 440 -5050 {
lab=VDD}
N 360 -4830 360 -4820 {
lab=VSS}
N 320 -4970 330 -4980 {
lab=row_n[14]}
N 330 -4980 530 -4980 {
lab=row_n[14]}
N 530 -4980 540 -4970 {
lab=row_n[14]}
N 540 -4970 560 -4970 {
lab=row_n[14]}
N 320 -4950 330 -4960 {
lab=rowon_n[14]}
N 330 -4960 530 -4960 {
lab=rowon_n[14]}
N 530 -4960 540 -4950 {
lab=rowon_n[14]}
N 540 -4950 560 -4950 {
lab=rowon_n[14]}
N 440 -4570 440 -4550 {
lab=VDD}
N 540 -5190 560 -5190 {
lab=#net31}
N 540 -5170 560 -5170 {
lab=#net32}
N 300 -5170 320 -5170 {
lab=sample_n}
N 300 -5190 320 -5190 {
lab=sample}
N 300 -5210 320 -5210 {
lab=rowon_n[15]}
N 300 -5230 320 -5230 {
lab=row_n[15]}
N 380 -5330 380 -5310 {
lab=vcm}
N 420 -5330 420 -5310 {
lab=ctop}
N 360 -5320 360 -5310 {
lab=VDD}
N 440 -5090 440 -5070 {
lab=VDD}
N 440 -5090 450 -5100 {
lab=VDD}
N 450 -5300 450 -5100 {
lab=VDD}
N 440 -5310 450 -5300 {
lab=VDD}
N 440 -5330 440 -5310 {
lab=VDD}
N 360 -5090 360 -5080 {
lab=VSS}
N 320 -5230 330 -5240 {
lab=row_n[15]}
N 330 -5240 530 -5240 {
lab=row_n[15]}
N 530 -5240 540 -5230 {
lab=row_n[15]}
N 540 -5230 560 -5230 {
lab=row_n[15]}
N 320 -5210 330 -5220 {
lab=rowon_n[15]}
N 330 -5220 530 -5220 {
lab=rowon_n[15]}
N 530 -5220 540 -5210 {
lab=rowon_n[15]}
N 540 -5210 560 -5210 {
lab=rowon_n[15]}
N 440 -930 450 -940 {
lab=VDD}
N 450 -1140 450 -940 {
lab=VDD}
N 440 -1150 450 -1140 {
lab=VDD}
N 440 -1170 440 -1150 {
lab=VDD}
N 320 -1070 330 -1080 {
lab=VSS}
N 330 -1080 530 -1080 {
lab=VSS}
N 530 -1080 540 -1070 {
lab=VSS}
N 320 -1050 330 -1060 {
lab=VSS}
N 330 -1060 530 -1060 {
lab=VSS}
N 530 -1060 540 -1050 {
lab=VSS}
N 320 -1030 330 -1040 {
lab=VSS}
N 330 -1040 530 -1040 {
lab=VSS}
N 530 -1040 540 -1030 {
lab=VSS}
N 320 -1010 330 -1020 {
lab=VDD}
N 330 -1020 530 -1020 {
lab=VDD}
N 530 -1020 540 -1010 {
lab=VDD}
N 540 -1010 560 -1010 {
lab=VDD}
N 540 -1030 560 -1030 {
lab=VSS}
N 540 -1050 560 -1050 {
lab=VSS}
N 540 -1070 560 -1070 {
lab=VSS}
N 300 -1070 320 -1070 {
lab=VSS}
N 300 -1050 320 -1050 {
lab=VSS}
N 300 -1030 320 -1030 {
lab=VSS}
N 300 -1010 320 -1010 {
lab=VDD}
N 360 -930 360 -920 {
lab=VSS}
N 380 -1170 380 -1150 {
lab=vcm}
N 360 -1160 360 -1150 {
lab=VDD}
N 700 -930 710 -940 {
lab=col_n[0]}
N 710 -1140 710 -940 {
lab=col_n[0]}
N 700 -1150 710 -1140 {
lab=col_n[0]}
N 700 -1170 700 -1150 {
lab=col_n[0]}
N 580 -1070 590 -1080 {
lab=VSS}
N 590 -1080 790 -1080 {
lab=VSS}
N 790 -1080 800 -1070 {
lab=VSS}
N 580 -1050 590 -1060 {
lab=VSS}
N 590 -1060 790 -1060 {
lab=VSS}
N 790 -1060 800 -1050 {
lab=VSS}
N 580 -1030 590 -1040 {
lab=VSS}
N 590 -1040 790 -1040 {
lab=VSS}
N 790 -1040 800 -1030 {
lab=VSS}
N 580 -1010 590 -1020 {
lab=VDD}
N 590 -1020 790 -1020 {
lab=VDD}
N 790 -1020 800 -1010 {
lab=VDD}
N 800 -1010 820 -1010 {
lab=VDD}
N 800 -1030 820 -1030 {
lab=VSS}
N 800 -1050 820 -1050 {
lab=VSS}
N 800 -1070 820 -1070 {
lab=VSS}
N 560 -1070 580 -1070 {
lab=VSS}
N 560 -1050 580 -1050 {
lab=VSS}
N 560 -1030 580 -1030 {
lab=VSS}
N 560 -1010 580 -1010 {
lab=VDD}
N 620 -930 620 -920 {
lab=VSS}
N 640 -1170 640 -1150 {
lab=vcm}
N 620 -1160 620 -1150 {
lab=VDD}
N 700 -930 700 -910 {
lab=col_n[0]}
N 420 -1170 420 -1150 {
lab=ctop}
N 680 -1170 680 -1150 {
lab=ctop}
N 960 -930 970 -940 {
lab=col_n[1]}
N 970 -1140 970 -940 {
lab=col_n[1]}
N 960 -1150 970 -1140 {
lab=col_n[1]}
N 960 -1170 960 -1150 {
lab=col_n[1]}
N 840 -1070 850 -1080 {
lab=VSS}
N 850 -1080 1050 -1080 {
lab=VSS}
N 1050 -1080 1060 -1070 {
lab=VSS}
N 840 -1050 850 -1060 {
lab=VSS}
N 850 -1060 1050 -1060 {
lab=VSS}
N 1050 -1060 1060 -1050 {
lab=VSS}
N 840 -1030 850 -1040 {
lab=VSS}
N 850 -1040 1050 -1040 {
lab=VSS}
N 1050 -1040 1060 -1030 {
lab=VSS}
N 840 -1010 850 -1020 {
lab=VDD}
N 850 -1020 1050 -1020 {
lab=VDD}
N 1050 -1020 1060 -1010 {
lab=VDD}
N 1060 -1010 1080 -1010 {
lab=VDD}
N 1060 -1030 1080 -1030 {
lab=VSS}
N 1060 -1050 1080 -1050 {
lab=VSS}
N 1060 -1070 1080 -1070 {
lab=VSS}
N 820 -1070 840 -1070 {
lab=VSS}
N 820 -1050 840 -1050 {
lab=VSS}
N 820 -1030 840 -1030 {
lab=VSS}
N 820 -1010 840 -1010 {
lab=VDD}
N 880 -930 880 -920 {
lab=VSS}
N 900 -1170 900 -1150 {
lab=vcm}
N 880 -1160 880 -1150 {
lab=VDD}
N 960 -930 960 -910 {
lab=col_n[1]}
N 1220 -930 1230 -940 {
lab=col_n[2]}
N 1230 -1140 1230 -940 {
lab=col_n[2]}
N 1220 -1150 1230 -1140 {
lab=col_n[2]}
N 1220 -1170 1220 -1150 {
lab=col_n[2]}
N 1100 -1070 1110 -1080 {
lab=VSS}
N 1110 -1080 1310 -1080 {
lab=VSS}
N 1310 -1080 1320 -1070 {
lab=VSS}
N 1100 -1050 1110 -1060 {
lab=VSS}
N 1110 -1060 1310 -1060 {
lab=VSS}
N 1310 -1060 1320 -1050 {
lab=VSS}
N 1100 -1030 1110 -1040 {
lab=VSS}
N 1110 -1040 1310 -1040 {
lab=VSS}
N 1310 -1040 1320 -1030 {
lab=VSS}
N 1100 -1010 1110 -1020 {
lab=VDD}
N 1110 -1020 1310 -1020 {
lab=VDD}
N 1310 -1020 1320 -1010 {
lab=VDD}
N 1320 -1010 1340 -1010 {
lab=VDD}
N 1320 -1030 1340 -1030 {
lab=VSS}
N 1320 -1050 1340 -1050 {
lab=VSS}
N 1320 -1070 1340 -1070 {
lab=VSS}
N 1080 -1070 1100 -1070 {
lab=VSS}
N 1080 -1050 1100 -1050 {
lab=VSS}
N 1080 -1030 1100 -1030 {
lab=VSS}
N 1080 -1010 1100 -1010 {
lab=VDD}
N 1140 -930 1140 -920 {
lab=VSS}
N 1160 -1170 1160 -1150 {
lab=vcm}
N 1140 -1160 1140 -1150 {
lab=VDD}
N 1220 -930 1220 -910 {
lab=col_n[2]}
N 940 -1170 940 -1150 {
lab=ctop}
N 1200 -1170 1200 -1150 {
lab=ctop}
N 1480 -930 1490 -940 {
lab=col_n[3]}
N 1490 -1140 1490 -940 {
lab=col_n[3]}
N 1480 -1150 1490 -1140 {
lab=col_n[3]}
N 1480 -1170 1480 -1150 {
lab=col_n[3]}
N 1360 -1070 1370 -1080 {
lab=VSS}
N 1370 -1080 1570 -1080 {
lab=VSS}
N 1570 -1080 1580 -1070 {
lab=VSS}
N 1360 -1050 1370 -1060 {
lab=VSS}
N 1370 -1060 1570 -1060 {
lab=VSS}
N 1570 -1060 1580 -1050 {
lab=VSS}
N 1360 -1030 1370 -1040 {
lab=VSS}
N 1370 -1040 1570 -1040 {
lab=VSS}
N 1570 -1040 1580 -1030 {
lab=VSS}
N 1360 -1010 1370 -1020 {
lab=VDD}
N 1370 -1020 1570 -1020 {
lab=VDD}
N 1570 -1020 1580 -1010 {
lab=VDD}
N 1580 -1010 1600 -1010 {
lab=VDD}
N 1580 -1030 1600 -1030 {
lab=VSS}
N 1580 -1050 1600 -1050 {
lab=VSS}
N 1580 -1070 1600 -1070 {
lab=VSS}
N 1340 -1070 1360 -1070 {
lab=VSS}
N 1340 -1050 1360 -1050 {
lab=VSS}
N 1340 -1030 1360 -1030 {
lab=VSS}
N 1340 -1010 1360 -1010 {
lab=VDD}
N 1400 -930 1400 -920 {
lab=VSS}
N 1420 -1170 1420 -1150 {
lab=vcm}
N 1400 -1160 1400 -1150 {
lab=VDD}
N 1480 -930 1480 -910 {
lab=col_n[3]}
N 1740 -930 1750 -940 {
lab=col_n[4]}
N 1750 -1140 1750 -940 {
lab=col_n[4]}
N 1740 -1150 1750 -1140 {
lab=col_n[4]}
N 1740 -1170 1740 -1150 {
lab=col_n[4]}
N 1620 -1070 1630 -1080 {
lab=VSS}
N 1630 -1080 1830 -1080 {
lab=VSS}
N 1830 -1080 1840 -1070 {
lab=VSS}
N 1620 -1050 1630 -1060 {
lab=VSS}
N 1630 -1060 1830 -1060 {
lab=VSS}
N 1830 -1060 1840 -1050 {
lab=VSS}
N 1620 -1030 1630 -1040 {
lab=VSS}
N 1630 -1040 1830 -1040 {
lab=VSS}
N 1830 -1040 1840 -1030 {
lab=VSS}
N 1620 -1010 1630 -1020 {
lab=VDD}
N 1630 -1020 1830 -1020 {
lab=VDD}
N 1830 -1020 1840 -1010 {
lab=VDD}
N 1840 -1010 1860 -1010 {
lab=VDD}
N 1840 -1030 1860 -1030 {
lab=VSS}
N 1840 -1050 1860 -1050 {
lab=VSS}
N 1840 -1070 1860 -1070 {
lab=VSS}
N 1600 -1070 1620 -1070 {
lab=VSS}
N 1600 -1050 1620 -1050 {
lab=VSS}
N 1600 -1030 1620 -1030 {
lab=VSS}
N 1600 -1010 1620 -1010 {
lab=VDD}
N 1660 -930 1660 -920 {
lab=VSS}
N 1680 -1170 1680 -1150 {
lab=vcm}
N 1660 -1160 1660 -1150 {
lab=VDD}
N 1740 -930 1740 -910 {
lab=col_n[4]}
N 1460 -1170 1460 -1150 {
lab=ctop}
N 1720 -1170 1720 -1150 {
lab=ctop}
N 2000 -930 2010 -940 {
lab=col_n[5]}
N 2010 -1140 2010 -940 {
lab=col_n[5]}
N 2000 -1150 2010 -1140 {
lab=col_n[5]}
N 2000 -1170 2000 -1150 {
lab=col_n[5]}
N 1880 -1070 1890 -1080 {
lab=VSS}
N 1890 -1080 2090 -1080 {
lab=VSS}
N 2090 -1080 2100 -1070 {
lab=VSS}
N 1880 -1050 1890 -1060 {
lab=VSS}
N 1890 -1060 2090 -1060 {
lab=VSS}
N 2090 -1060 2100 -1050 {
lab=VSS}
N 1880 -1030 1890 -1040 {
lab=VSS}
N 1890 -1040 2090 -1040 {
lab=VSS}
N 2090 -1040 2100 -1030 {
lab=VSS}
N 1880 -1010 1890 -1020 {
lab=VDD}
N 1890 -1020 2090 -1020 {
lab=VDD}
N 2090 -1020 2100 -1010 {
lab=VDD}
N 2100 -1010 2120 -1010 {
lab=VDD}
N 2100 -1030 2120 -1030 {
lab=VSS}
N 2100 -1050 2120 -1050 {
lab=VSS}
N 2100 -1070 2120 -1070 {
lab=VSS}
N 1860 -1070 1880 -1070 {
lab=VSS}
N 1860 -1050 1880 -1050 {
lab=VSS}
N 1860 -1030 1880 -1030 {
lab=VSS}
N 1860 -1010 1880 -1010 {
lab=VDD}
N 1920 -930 1920 -920 {
lab=VSS}
N 1940 -1170 1940 -1150 {
lab=vcm}
N 1920 -1160 1920 -1150 {
lab=VDD}
N 2000 -930 2000 -910 {
lab=col_n[5]}
N 2260 -930 2270 -940 {
lab=col_n[6]}
N 2270 -1140 2270 -940 {
lab=col_n[6]}
N 2260 -1150 2270 -1140 {
lab=col_n[6]}
N 2260 -1170 2260 -1150 {
lab=col_n[6]}
N 2140 -1070 2150 -1080 {
lab=VSS}
N 2150 -1080 2350 -1080 {
lab=VSS}
N 2350 -1080 2360 -1070 {
lab=VSS}
N 2140 -1050 2150 -1060 {
lab=VSS}
N 2150 -1060 2350 -1060 {
lab=VSS}
N 2350 -1060 2360 -1050 {
lab=VSS}
N 2140 -1030 2150 -1040 {
lab=VSS}
N 2150 -1040 2350 -1040 {
lab=VSS}
N 2350 -1040 2360 -1030 {
lab=VSS}
N 2140 -1010 2150 -1020 {
lab=VDD}
N 2150 -1020 2350 -1020 {
lab=VDD}
N 2350 -1020 2360 -1010 {
lab=VDD}
N 2360 -1010 2380 -1010 {
lab=VDD}
N 2360 -1030 2380 -1030 {
lab=VSS}
N 2360 -1050 2380 -1050 {
lab=VSS}
N 2360 -1070 2380 -1070 {
lab=VSS}
N 2120 -1070 2140 -1070 {
lab=VSS}
N 2120 -1050 2140 -1050 {
lab=VSS}
N 2120 -1030 2140 -1030 {
lab=VSS}
N 2120 -1010 2140 -1010 {
lab=VDD}
N 2180 -930 2180 -920 {
lab=VSS}
N 2200 -1170 2200 -1150 {
lab=vcm}
N 2180 -1160 2180 -1150 {
lab=VDD}
N 2260 -930 2260 -910 {
lab=col_n[6]}
N 1980 -1170 1980 -1150 {
lab=ctop}
N 2240 -1170 2240 -1150 {
lab=ctop}
N 2520 -930 2530 -940 {
lab=col_n[7]}
N 2530 -1140 2530 -940 {
lab=col_n[7]}
N 2520 -1150 2530 -1140 {
lab=col_n[7]}
N 2520 -1170 2520 -1150 {
lab=col_n[7]}
N 2400 -1070 2410 -1080 {
lab=VSS}
N 2410 -1080 2610 -1080 {
lab=VSS}
N 2610 -1080 2620 -1070 {
lab=VSS}
N 2400 -1050 2410 -1060 {
lab=VSS}
N 2410 -1060 2610 -1060 {
lab=VSS}
N 2610 -1060 2620 -1050 {
lab=VSS}
N 2400 -1030 2410 -1040 {
lab=VSS}
N 2410 -1040 2610 -1040 {
lab=VSS}
N 2610 -1040 2620 -1030 {
lab=VSS}
N 2400 -1010 2410 -1020 {
lab=VDD}
N 2410 -1020 2610 -1020 {
lab=VDD}
N 2610 -1020 2620 -1010 {
lab=VDD}
N 2620 -1010 2640 -1010 {
lab=VDD}
N 2620 -1030 2640 -1030 {
lab=VSS}
N 2620 -1050 2640 -1050 {
lab=VSS}
N 2620 -1070 2640 -1070 {
lab=VSS}
N 2380 -1070 2400 -1070 {
lab=VSS}
N 2380 -1050 2400 -1050 {
lab=VSS}
N 2380 -1030 2400 -1030 {
lab=VSS}
N 2380 -1010 2400 -1010 {
lab=VDD}
N 2440 -930 2440 -920 {
lab=VSS}
N 2460 -1170 2460 -1150 {
lab=vcm}
N 2440 -1160 2440 -1150 {
lab=VDD}
N 2520 -930 2520 -910 {
lab=col_n[7]}
N 2780 -930 2790 -940 {
lab=col_n[8]}
N 2790 -1140 2790 -940 {
lab=col_n[8]}
N 2780 -1150 2790 -1140 {
lab=col_n[8]}
N 2780 -1170 2780 -1150 {
lab=col_n[8]}
N 2660 -1070 2670 -1080 {
lab=VSS}
N 2670 -1080 2870 -1080 {
lab=VSS}
N 2870 -1080 2880 -1070 {
lab=VSS}
N 2660 -1050 2670 -1060 {
lab=VSS}
N 2670 -1060 2870 -1060 {
lab=VSS}
N 2870 -1060 2880 -1050 {
lab=VSS}
N 2660 -1030 2670 -1040 {
lab=VSS}
N 2670 -1040 2870 -1040 {
lab=VSS}
N 2870 -1040 2880 -1030 {
lab=VSS}
N 2660 -1010 2670 -1020 {
lab=VDD}
N 2670 -1020 2870 -1020 {
lab=VDD}
N 2870 -1020 2880 -1010 {
lab=VDD}
N 2880 -1010 2900 -1010 {
lab=VDD}
N 2880 -1030 2900 -1030 {
lab=VSS}
N 2880 -1050 2900 -1050 {
lab=VSS}
N 2880 -1070 2900 -1070 {
lab=VSS}
N 2640 -1070 2660 -1070 {
lab=VSS}
N 2640 -1050 2660 -1050 {
lab=VSS}
N 2640 -1030 2660 -1030 {
lab=VSS}
N 2640 -1010 2660 -1010 {
lab=VDD}
N 2700 -930 2700 -920 {
lab=VSS}
N 2720 -1170 2720 -1150 {
lab=vcm}
N 2700 -1160 2700 -1150 {
lab=VDD}
N 2780 -930 2780 -910 {
lab=col_n[8]}
N 2500 -1170 2500 -1150 {
lab=ctop}
N 2760 -1170 2760 -1150 {
lab=ctop}
N 3040 -930 3050 -940 {
lab=col_n[9]}
N 3050 -1140 3050 -940 {
lab=col_n[9]}
N 3040 -1150 3050 -1140 {
lab=col_n[9]}
N 3040 -1170 3040 -1150 {
lab=col_n[9]}
N 2920 -1070 2930 -1080 {
lab=VSS}
N 2930 -1080 3130 -1080 {
lab=VSS}
N 3130 -1080 3140 -1070 {
lab=VSS}
N 2920 -1050 2930 -1060 {
lab=VSS}
N 2930 -1060 3130 -1060 {
lab=VSS}
N 3130 -1060 3140 -1050 {
lab=VSS}
N 2920 -1030 2930 -1040 {
lab=VSS}
N 2930 -1040 3130 -1040 {
lab=VSS}
N 3130 -1040 3140 -1030 {
lab=VSS}
N 2920 -1010 2930 -1020 {
lab=VDD}
N 2930 -1020 3130 -1020 {
lab=VDD}
N 3130 -1020 3140 -1010 {
lab=VDD}
N 3140 -1010 3160 -1010 {
lab=VDD}
N 3140 -1030 3160 -1030 {
lab=VSS}
N 3140 -1050 3160 -1050 {
lab=VSS}
N 3140 -1070 3160 -1070 {
lab=VSS}
N 2900 -1070 2920 -1070 {
lab=VSS}
N 2900 -1050 2920 -1050 {
lab=VSS}
N 2900 -1030 2920 -1030 {
lab=VSS}
N 2900 -1010 2920 -1010 {
lab=VDD}
N 2960 -930 2960 -920 {
lab=VSS}
N 2980 -1170 2980 -1150 {
lab=vcm}
N 2960 -1160 2960 -1150 {
lab=VDD}
N 3040 -930 3040 -910 {
lab=col_n[9]}
N 3300 -930 3310 -940 {
lab=col_n[10]}
N 3310 -1140 3310 -940 {
lab=col_n[10]}
N 3300 -1150 3310 -1140 {
lab=col_n[10]}
N 3300 -1170 3300 -1150 {
lab=col_n[10]}
N 3180 -1070 3190 -1080 {
lab=VSS}
N 3190 -1080 3390 -1080 {
lab=VSS}
N 3390 -1080 3400 -1070 {
lab=VSS}
N 3180 -1050 3190 -1060 {
lab=VSS}
N 3190 -1060 3390 -1060 {
lab=VSS}
N 3390 -1060 3400 -1050 {
lab=VSS}
N 3180 -1030 3190 -1040 {
lab=VSS}
N 3190 -1040 3390 -1040 {
lab=VSS}
N 3390 -1040 3400 -1030 {
lab=VSS}
N 3180 -1010 3190 -1020 {
lab=VDD}
N 3190 -1020 3390 -1020 {
lab=VDD}
N 3390 -1020 3400 -1010 {
lab=VDD}
N 3400 -1010 3420 -1010 {
lab=VDD}
N 3400 -1030 3420 -1030 {
lab=VSS}
N 3400 -1050 3420 -1050 {
lab=VSS}
N 3400 -1070 3420 -1070 {
lab=VSS}
N 3160 -1070 3180 -1070 {
lab=VSS}
N 3160 -1050 3180 -1050 {
lab=VSS}
N 3160 -1030 3180 -1030 {
lab=VSS}
N 3160 -1010 3180 -1010 {
lab=VDD}
N 3220 -930 3220 -920 {
lab=VSS}
N 3240 -1170 3240 -1150 {
lab=vcm}
N 3220 -1160 3220 -1150 {
lab=VDD}
N 3300 -930 3300 -910 {
lab=col_n[10]}
N 3020 -1170 3020 -1150 {
lab=ctop}
N 3280 -1170 3280 -1150 {
lab=ctop}
N 3560 -930 3570 -940 {
lab=col_n[11]}
N 3570 -1140 3570 -940 {
lab=col_n[11]}
N 3560 -1150 3570 -1140 {
lab=col_n[11]}
N 3560 -1170 3560 -1150 {
lab=col_n[11]}
N 3440 -1070 3450 -1080 {
lab=VSS}
N 3450 -1080 3650 -1080 {
lab=VSS}
N 3650 -1080 3660 -1070 {
lab=VSS}
N 3440 -1050 3450 -1060 {
lab=VSS}
N 3450 -1060 3650 -1060 {
lab=VSS}
N 3650 -1060 3660 -1050 {
lab=VSS}
N 3440 -1030 3450 -1040 {
lab=VSS}
N 3450 -1040 3650 -1040 {
lab=VSS}
N 3650 -1040 3660 -1030 {
lab=VSS}
N 3440 -1010 3450 -1020 {
lab=VDD}
N 3450 -1020 3650 -1020 {
lab=VDD}
N 3650 -1020 3660 -1010 {
lab=VDD}
N 3660 -1010 3680 -1010 {
lab=VDD}
N 3660 -1030 3680 -1030 {
lab=VSS}
N 3660 -1050 3680 -1050 {
lab=VSS}
N 3660 -1070 3680 -1070 {
lab=VSS}
N 3420 -1070 3440 -1070 {
lab=VSS}
N 3420 -1050 3440 -1050 {
lab=VSS}
N 3420 -1030 3440 -1030 {
lab=VSS}
N 3420 -1010 3440 -1010 {
lab=VDD}
N 3480 -930 3480 -920 {
lab=VSS}
N 3500 -1170 3500 -1150 {
lab=vcm}
N 3480 -1160 3480 -1150 {
lab=VDD}
N 3560 -930 3560 -910 {
lab=col_n[11]}
N 3820 -930 3830 -940 {
lab=col_n[12]}
N 3830 -1140 3830 -940 {
lab=col_n[12]}
N 3820 -1150 3830 -1140 {
lab=col_n[12]}
N 3820 -1170 3820 -1150 {
lab=col_n[12]}
N 3700 -1070 3710 -1080 {
lab=VSS}
N 3710 -1080 3910 -1080 {
lab=VSS}
N 3910 -1080 3920 -1070 {
lab=VSS}
N 3700 -1050 3710 -1060 {
lab=VSS}
N 3710 -1060 3910 -1060 {
lab=VSS}
N 3910 -1060 3920 -1050 {
lab=VSS}
N 3700 -1030 3710 -1040 {
lab=VSS}
N 3710 -1040 3910 -1040 {
lab=VSS}
N 3910 -1040 3920 -1030 {
lab=VSS}
N 3700 -1010 3710 -1020 {
lab=VDD}
N 3710 -1020 3910 -1020 {
lab=VDD}
N 3910 -1020 3920 -1010 {
lab=VDD}
N 3920 -1010 3940 -1010 {
lab=VDD}
N 3920 -1030 3940 -1030 {
lab=VSS}
N 3920 -1050 3940 -1050 {
lab=VSS}
N 3920 -1070 3940 -1070 {
lab=VSS}
N 3680 -1070 3700 -1070 {
lab=VSS}
N 3680 -1050 3700 -1050 {
lab=VSS}
N 3680 -1030 3700 -1030 {
lab=VSS}
N 3680 -1010 3700 -1010 {
lab=VDD}
N 3740 -930 3740 -920 {
lab=VSS}
N 3760 -1170 3760 -1150 {
lab=vcm}
N 3740 -1160 3740 -1150 {
lab=VDD}
N 3820 -930 3820 -910 {
lab=col_n[12]}
N 3540 -1170 3540 -1150 {
lab=ctop}
N 3800 -1170 3800 -1150 {
lab=ctop}
N 4080 -930 4090 -940 {
lab=col_n[13]}
N 4090 -1140 4090 -940 {
lab=col_n[13]}
N 4080 -1150 4090 -1140 {
lab=col_n[13]}
N 4080 -1170 4080 -1150 {
lab=col_n[13]}
N 3960 -1070 3970 -1080 {
lab=VSS}
N 3970 -1080 4170 -1080 {
lab=VSS}
N 4170 -1080 4180 -1070 {
lab=VSS}
N 3960 -1050 3970 -1060 {
lab=VSS}
N 3970 -1060 4170 -1060 {
lab=VSS}
N 4170 -1060 4180 -1050 {
lab=VSS}
N 3960 -1030 3970 -1040 {
lab=VSS}
N 3970 -1040 4170 -1040 {
lab=VSS}
N 4170 -1040 4180 -1030 {
lab=VSS}
N 3960 -1010 3970 -1020 {
lab=VDD}
N 3970 -1020 4170 -1020 {
lab=VDD}
N 4170 -1020 4180 -1010 {
lab=VDD}
N 4180 -1010 4200 -1010 {
lab=VDD}
N 4180 -1030 4200 -1030 {
lab=VSS}
N 4180 -1050 4200 -1050 {
lab=VSS}
N 4180 -1070 4200 -1070 {
lab=VSS}
N 3940 -1070 3960 -1070 {
lab=VSS}
N 3940 -1050 3960 -1050 {
lab=VSS}
N 3940 -1030 3960 -1030 {
lab=VSS}
N 3940 -1010 3960 -1010 {
lab=VDD}
N 4000 -930 4000 -920 {
lab=VSS}
N 4020 -1170 4020 -1150 {
lab=vcm}
N 4000 -1160 4000 -1150 {
lab=VDD}
N 4080 -930 4080 -910 {
lab=col_n[13]}
N 4340 -930 4350 -940 {
lab=col_n[14]}
N 4350 -1140 4350 -940 {
lab=col_n[14]}
N 4340 -1150 4350 -1140 {
lab=col_n[14]}
N 4340 -1170 4340 -1150 {
lab=col_n[14]}
N 4220 -1070 4230 -1080 {
lab=VSS}
N 4230 -1080 4430 -1080 {
lab=VSS}
N 4430 -1080 4440 -1070 {
lab=VSS}
N 4220 -1050 4230 -1060 {
lab=VSS}
N 4230 -1060 4430 -1060 {
lab=VSS}
N 4430 -1060 4440 -1050 {
lab=VSS}
N 4220 -1030 4230 -1040 {
lab=VSS}
N 4230 -1040 4430 -1040 {
lab=VSS}
N 4430 -1040 4440 -1030 {
lab=VSS}
N 4220 -1010 4230 -1020 {
lab=VDD}
N 4230 -1020 4430 -1020 {
lab=VDD}
N 4430 -1020 4440 -1010 {
lab=VDD}
N 4440 -1010 4460 -1010 {
lab=VDD}
N 4440 -1030 4460 -1030 {
lab=VSS}
N 4440 -1050 4460 -1050 {
lab=VSS}
N 4440 -1070 4460 -1070 {
lab=VSS}
N 4200 -1070 4220 -1070 {
lab=VSS}
N 4200 -1050 4220 -1050 {
lab=VSS}
N 4200 -1030 4220 -1030 {
lab=VSS}
N 4200 -1010 4220 -1010 {
lab=VDD}
N 4260 -930 4260 -920 {
lab=VSS}
N 4280 -1170 4280 -1150 {
lab=vcm}
N 4260 -1160 4260 -1150 {
lab=VDD}
N 4340 -930 4340 -910 {
lab=col_n[14]}
N 4060 -1170 4060 -1150 {
lab=ctop}
N 4320 -1170 4320 -1150 {
lab=ctop}
N 4600 -930 4610 -940 {
lab=col_n[15]}
N 4610 -1140 4610 -940 {
lab=col_n[15]}
N 4600 -1150 4610 -1140 {
lab=col_n[15]}
N 4600 -1170 4600 -1150 {
lab=col_n[15]}
N 4480 -1070 4490 -1080 {
lab=VSS}
N 4490 -1080 4690 -1080 {
lab=VSS}
N 4690 -1080 4700 -1070 {
lab=VSS}
N 4480 -1050 4490 -1060 {
lab=VSS}
N 4490 -1060 4690 -1060 {
lab=VSS}
N 4690 -1060 4700 -1050 {
lab=VSS}
N 4480 -1030 4490 -1040 {
lab=VSS}
N 4490 -1040 4690 -1040 {
lab=VSS}
N 4690 -1040 4700 -1030 {
lab=VSS}
N 4480 -1010 4490 -1020 {
lab=VDD}
N 4490 -1020 4690 -1020 {
lab=VDD}
N 4690 -1020 4700 -1010 {
lab=VDD}
N 4700 -1010 4720 -1010 {
lab=VDD}
N 4700 -1030 4720 -1030 {
lab=VSS}
N 4700 -1050 4720 -1050 {
lab=VSS}
N 4700 -1070 4720 -1070 {
lab=VSS}
N 4460 -1070 4480 -1070 {
lab=VSS}
N 4460 -1050 4480 -1050 {
lab=VSS}
N 4460 -1030 4480 -1030 {
lab=VSS}
N 4460 -1010 4480 -1010 {
lab=VDD}
N 4520 -930 4520 -920 {
lab=VSS}
N 4540 -1170 4540 -1150 {
lab=vcm}
N 4520 -1160 4520 -1150 {
lab=VDD}
N 4600 -930 4600 -910 {
lab=col_n[15]}
N 4860 -930 4870 -940 {
lab=col_n[16]}
N 4870 -1140 4870 -940 {
lab=col_n[16]}
N 4860 -1150 4870 -1140 {
lab=col_n[16]}
N 4860 -1170 4860 -1150 {
lab=col_n[16]}
N 4740 -1070 4750 -1080 {
lab=VSS}
N 4750 -1080 4950 -1080 {
lab=VSS}
N 4950 -1080 4960 -1070 {
lab=VSS}
N 4740 -1050 4750 -1060 {
lab=VSS}
N 4750 -1060 4950 -1060 {
lab=VSS}
N 4950 -1060 4960 -1050 {
lab=VSS}
N 4740 -1030 4750 -1040 {
lab=VSS}
N 4750 -1040 4950 -1040 {
lab=VSS}
N 4950 -1040 4960 -1030 {
lab=VSS}
N 4740 -1010 4750 -1020 {
lab=VDD}
N 4750 -1020 4950 -1020 {
lab=VDD}
N 4950 -1020 4960 -1010 {
lab=VDD}
N 4960 -1010 4980 -1010 {
lab=VDD}
N 4960 -1030 4980 -1030 {
lab=VSS}
N 4960 -1050 4980 -1050 {
lab=VSS}
N 4960 -1070 4980 -1070 {
lab=VSS}
N 4720 -1070 4740 -1070 {
lab=VSS}
N 4720 -1050 4740 -1050 {
lab=VSS}
N 4720 -1030 4740 -1030 {
lab=VSS}
N 4720 -1010 4740 -1010 {
lab=VDD}
N 4780 -930 4780 -920 {
lab=VSS}
N 4800 -1170 4800 -1150 {
lab=vcm}
N 4780 -1160 4780 -1150 {
lab=VDD}
N 4860 -930 4860 -910 {
lab=col_n[16]}
N 4580 -1170 4580 -1150 {
lab=ctop}
N 4840 -1170 4840 -1150 {
lab=ctop}
N 5120 -930 5130 -940 {
lab=col_n[17]}
N 5130 -1140 5130 -940 {
lab=col_n[17]}
N 5120 -1150 5130 -1140 {
lab=col_n[17]}
N 5120 -1170 5120 -1150 {
lab=col_n[17]}
N 5000 -1070 5010 -1080 {
lab=VSS}
N 5010 -1080 5210 -1080 {
lab=VSS}
N 5210 -1080 5220 -1070 {
lab=VSS}
N 5000 -1050 5010 -1060 {
lab=VSS}
N 5010 -1060 5210 -1060 {
lab=VSS}
N 5210 -1060 5220 -1050 {
lab=VSS}
N 5000 -1030 5010 -1040 {
lab=VSS}
N 5010 -1040 5210 -1040 {
lab=VSS}
N 5210 -1040 5220 -1030 {
lab=VSS}
N 5000 -1010 5010 -1020 {
lab=VDD}
N 5010 -1020 5210 -1020 {
lab=VDD}
N 5210 -1020 5220 -1010 {
lab=VDD}
N 5220 -1010 5240 -1010 {
lab=VDD}
N 5220 -1030 5240 -1030 {
lab=VSS}
N 5220 -1050 5240 -1050 {
lab=VSS}
N 5220 -1070 5240 -1070 {
lab=VSS}
N 4980 -1070 5000 -1070 {
lab=VSS}
N 4980 -1050 5000 -1050 {
lab=VSS}
N 4980 -1030 5000 -1030 {
lab=VSS}
N 4980 -1010 5000 -1010 {
lab=VDD}
N 5040 -930 5040 -920 {
lab=VSS}
N 5060 -1170 5060 -1150 {
lab=vcm}
N 5040 -1160 5040 -1150 {
lab=VDD}
N 5120 -930 5120 -910 {
lab=col_n[17]}
N 5380 -930 5390 -940 {
lab=col_n[18]}
N 5390 -1140 5390 -940 {
lab=col_n[18]}
N 5380 -1150 5390 -1140 {
lab=col_n[18]}
N 5380 -1170 5380 -1150 {
lab=col_n[18]}
N 5260 -1070 5270 -1080 {
lab=VSS}
N 5270 -1080 5470 -1080 {
lab=VSS}
N 5470 -1080 5480 -1070 {
lab=VSS}
N 5260 -1050 5270 -1060 {
lab=VSS}
N 5270 -1060 5470 -1060 {
lab=VSS}
N 5470 -1060 5480 -1050 {
lab=VSS}
N 5260 -1030 5270 -1040 {
lab=VSS}
N 5270 -1040 5470 -1040 {
lab=VSS}
N 5470 -1040 5480 -1030 {
lab=VSS}
N 5260 -1010 5270 -1020 {
lab=VDD}
N 5270 -1020 5470 -1020 {
lab=VDD}
N 5470 -1020 5480 -1010 {
lab=VDD}
N 5480 -1010 5500 -1010 {
lab=VDD}
N 5480 -1030 5500 -1030 {
lab=VSS}
N 5480 -1050 5500 -1050 {
lab=VSS}
N 5480 -1070 5500 -1070 {
lab=VSS}
N 5240 -1070 5260 -1070 {
lab=VSS}
N 5240 -1050 5260 -1050 {
lab=VSS}
N 5240 -1030 5260 -1030 {
lab=VSS}
N 5240 -1010 5260 -1010 {
lab=VDD}
N 5300 -930 5300 -920 {
lab=VSS}
N 5320 -1170 5320 -1150 {
lab=vcm}
N 5300 -1160 5300 -1150 {
lab=VDD}
N 5380 -930 5380 -910 {
lab=col_n[18]}
N 5100 -1170 5100 -1150 {
lab=ctop}
N 5360 -1170 5360 -1150 {
lab=ctop}
N 5640 -930 5650 -940 {
lab=col_n[19]}
N 5650 -1140 5650 -940 {
lab=col_n[19]}
N 5640 -1150 5650 -1140 {
lab=col_n[19]}
N 5640 -1170 5640 -1150 {
lab=col_n[19]}
N 5520 -1070 5530 -1080 {
lab=VSS}
N 5530 -1080 5730 -1080 {
lab=VSS}
N 5730 -1080 5740 -1070 {
lab=VSS}
N 5520 -1050 5530 -1060 {
lab=VSS}
N 5530 -1060 5730 -1060 {
lab=VSS}
N 5730 -1060 5740 -1050 {
lab=VSS}
N 5520 -1030 5530 -1040 {
lab=VSS}
N 5530 -1040 5730 -1040 {
lab=VSS}
N 5730 -1040 5740 -1030 {
lab=VSS}
N 5520 -1010 5530 -1020 {
lab=VDD}
N 5530 -1020 5730 -1020 {
lab=VDD}
N 5730 -1020 5740 -1010 {
lab=VDD}
N 5740 -1010 5760 -1010 {
lab=VDD}
N 5740 -1030 5760 -1030 {
lab=VSS}
N 5740 -1050 5760 -1050 {
lab=VSS}
N 5740 -1070 5760 -1070 {
lab=VSS}
N 5500 -1070 5520 -1070 {
lab=VSS}
N 5500 -1050 5520 -1050 {
lab=VSS}
N 5500 -1030 5520 -1030 {
lab=VSS}
N 5500 -1010 5520 -1010 {
lab=VDD}
N 5560 -930 5560 -920 {
lab=VSS}
N 5580 -1170 5580 -1150 {
lab=vcm}
N 5560 -1160 5560 -1150 {
lab=VDD}
N 5640 -930 5640 -910 {
lab=col_n[19]}
N 5900 -930 5910 -940 {
lab=col_n[20]}
N 5910 -1140 5910 -940 {
lab=col_n[20]}
N 5900 -1150 5910 -1140 {
lab=col_n[20]}
N 5900 -1170 5900 -1150 {
lab=col_n[20]}
N 5780 -1070 5790 -1080 {
lab=VSS}
N 5790 -1080 5990 -1080 {
lab=VSS}
N 5990 -1080 6000 -1070 {
lab=VSS}
N 5780 -1050 5790 -1060 {
lab=VSS}
N 5790 -1060 5990 -1060 {
lab=VSS}
N 5990 -1060 6000 -1050 {
lab=VSS}
N 5780 -1030 5790 -1040 {
lab=VSS}
N 5790 -1040 5990 -1040 {
lab=VSS}
N 5990 -1040 6000 -1030 {
lab=VSS}
N 5780 -1010 5790 -1020 {
lab=VDD}
N 5790 -1020 5990 -1020 {
lab=VDD}
N 5990 -1020 6000 -1010 {
lab=VDD}
N 6000 -1010 6020 -1010 {
lab=VDD}
N 6000 -1030 6020 -1030 {
lab=VSS}
N 6000 -1050 6020 -1050 {
lab=VSS}
N 6000 -1070 6020 -1070 {
lab=VSS}
N 5760 -1070 5780 -1070 {
lab=VSS}
N 5760 -1050 5780 -1050 {
lab=VSS}
N 5760 -1030 5780 -1030 {
lab=VSS}
N 5760 -1010 5780 -1010 {
lab=VDD}
N 5820 -930 5820 -920 {
lab=VSS}
N 5840 -1170 5840 -1150 {
lab=vcm}
N 5820 -1160 5820 -1150 {
lab=VDD}
N 5900 -930 5900 -910 {
lab=col_n[20]}
N 5620 -1170 5620 -1150 {
lab=ctop}
N 5880 -1170 5880 -1150 {
lab=ctop}
N 6160 -930 6170 -940 {
lab=col_n[21]}
N 6170 -1140 6170 -940 {
lab=col_n[21]}
N 6160 -1150 6170 -1140 {
lab=col_n[21]}
N 6160 -1170 6160 -1150 {
lab=col_n[21]}
N 6040 -1070 6050 -1080 {
lab=VSS}
N 6050 -1080 6250 -1080 {
lab=VSS}
N 6250 -1080 6260 -1070 {
lab=VSS}
N 6040 -1050 6050 -1060 {
lab=VSS}
N 6050 -1060 6250 -1060 {
lab=VSS}
N 6250 -1060 6260 -1050 {
lab=VSS}
N 6040 -1030 6050 -1040 {
lab=VSS}
N 6050 -1040 6250 -1040 {
lab=VSS}
N 6250 -1040 6260 -1030 {
lab=VSS}
N 6040 -1010 6050 -1020 {
lab=VDD}
N 6050 -1020 6250 -1020 {
lab=VDD}
N 6250 -1020 6260 -1010 {
lab=VDD}
N 6260 -1010 6280 -1010 {
lab=VDD}
N 6260 -1030 6280 -1030 {
lab=VSS}
N 6260 -1050 6280 -1050 {
lab=VSS}
N 6260 -1070 6280 -1070 {
lab=VSS}
N 6020 -1070 6040 -1070 {
lab=VSS}
N 6020 -1050 6040 -1050 {
lab=VSS}
N 6020 -1030 6040 -1030 {
lab=VSS}
N 6020 -1010 6040 -1010 {
lab=VDD}
N 6080 -930 6080 -920 {
lab=VSS}
N 6100 -1170 6100 -1150 {
lab=vcm}
N 6080 -1160 6080 -1150 {
lab=VDD}
N 6160 -930 6160 -910 {
lab=col_n[21]}
N 6420 -930 6430 -940 {
lab=col_n[22]}
N 6430 -1140 6430 -940 {
lab=col_n[22]}
N 6420 -1150 6430 -1140 {
lab=col_n[22]}
N 6420 -1170 6420 -1150 {
lab=col_n[22]}
N 6300 -1070 6310 -1080 {
lab=VSS}
N 6310 -1080 6510 -1080 {
lab=VSS}
N 6510 -1080 6520 -1070 {
lab=VSS}
N 6300 -1050 6310 -1060 {
lab=VSS}
N 6310 -1060 6510 -1060 {
lab=VSS}
N 6510 -1060 6520 -1050 {
lab=VSS}
N 6300 -1030 6310 -1040 {
lab=VSS}
N 6310 -1040 6510 -1040 {
lab=VSS}
N 6510 -1040 6520 -1030 {
lab=VSS}
N 6300 -1010 6310 -1020 {
lab=VDD}
N 6310 -1020 6510 -1020 {
lab=VDD}
N 6510 -1020 6520 -1010 {
lab=VDD}
N 6520 -1010 6540 -1010 {
lab=VDD}
N 6520 -1030 6540 -1030 {
lab=VSS}
N 6520 -1050 6540 -1050 {
lab=VSS}
N 6520 -1070 6540 -1070 {
lab=VSS}
N 6280 -1070 6300 -1070 {
lab=VSS}
N 6280 -1050 6300 -1050 {
lab=VSS}
N 6280 -1030 6300 -1030 {
lab=VSS}
N 6280 -1010 6300 -1010 {
lab=VDD}
N 6340 -930 6340 -920 {
lab=VSS}
N 6360 -1170 6360 -1150 {
lab=vcm}
N 6340 -1160 6340 -1150 {
lab=VDD}
N 6420 -930 6420 -910 {
lab=col_n[22]}
N 6140 -1170 6140 -1150 {
lab=ctop}
N 6400 -1170 6400 -1150 {
lab=ctop}
N 6680 -930 6690 -940 {
lab=col_n[23]}
N 6690 -1140 6690 -940 {
lab=col_n[23]}
N 6680 -1150 6690 -1140 {
lab=col_n[23]}
N 6680 -1170 6680 -1150 {
lab=col_n[23]}
N 6560 -1070 6570 -1080 {
lab=VSS}
N 6570 -1080 6770 -1080 {
lab=VSS}
N 6770 -1080 6780 -1070 {
lab=VSS}
N 6560 -1050 6570 -1060 {
lab=VSS}
N 6570 -1060 6770 -1060 {
lab=VSS}
N 6770 -1060 6780 -1050 {
lab=VSS}
N 6560 -1030 6570 -1040 {
lab=VSS}
N 6570 -1040 6770 -1040 {
lab=VSS}
N 6770 -1040 6780 -1030 {
lab=VSS}
N 6560 -1010 6570 -1020 {
lab=VDD}
N 6570 -1020 6770 -1020 {
lab=VDD}
N 6770 -1020 6780 -1010 {
lab=VDD}
N 6780 -1010 6800 -1010 {
lab=VDD}
N 6780 -1030 6800 -1030 {
lab=VSS}
N 6780 -1050 6800 -1050 {
lab=VSS}
N 6780 -1070 6800 -1070 {
lab=VSS}
N 6540 -1070 6560 -1070 {
lab=VSS}
N 6540 -1050 6560 -1050 {
lab=VSS}
N 6540 -1030 6560 -1030 {
lab=VSS}
N 6540 -1010 6560 -1010 {
lab=VDD}
N 6600 -930 6600 -920 {
lab=VSS}
N 6620 -1170 6620 -1150 {
lab=vcm}
N 6600 -1160 6600 -1150 {
lab=VDD}
N 6680 -930 6680 -910 {
lab=col_n[23]}
N 6940 -930 6950 -940 {
lab=col_n[24]}
N 6950 -1140 6950 -940 {
lab=col_n[24]}
N 6940 -1150 6950 -1140 {
lab=col_n[24]}
N 6940 -1170 6940 -1150 {
lab=col_n[24]}
N 6820 -1070 6830 -1080 {
lab=VSS}
N 6830 -1080 7030 -1080 {
lab=VSS}
N 7030 -1080 7040 -1070 {
lab=VSS}
N 6820 -1050 6830 -1060 {
lab=VSS}
N 6830 -1060 7030 -1060 {
lab=VSS}
N 7030 -1060 7040 -1050 {
lab=VSS}
N 6820 -1030 6830 -1040 {
lab=VSS}
N 6830 -1040 7030 -1040 {
lab=VSS}
N 7030 -1040 7040 -1030 {
lab=VSS}
N 6820 -1010 6830 -1020 {
lab=VDD}
N 6830 -1020 7030 -1020 {
lab=VDD}
N 7030 -1020 7040 -1010 {
lab=VDD}
N 7040 -1010 7060 -1010 {
lab=VDD}
N 7040 -1030 7060 -1030 {
lab=VSS}
N 7040 -1050 7060 -1050 {
lab=VSS}
N 7040 -1070 7060 -1070 {
lab=VSS}
N 6800 -1070 6820 -1070 {
lab=VSS}
N 6800 -1050 6820 -1050 {
lab=VSS}
N 6800 -1030 6820 -1030 {
lab=VSS}
N 6800 -1010 6820 -1010 {
lab=VDD}
N 6860 -930 6860 -920 {
lab=VSS}
N 6880 -1170 6880 -1150 {
lab=vcm}
N 6860 -1160 6860 -1150 {
lab=VDD}
N 6940 -930 6940 -910 {
lab=col_n[24]}
N 6660 -1170 6660 -1150 {
lab=ctop}
N 6920 -1170 6920 -1150 {
lab=ctop}
N 7200 -930 7210 -940 {
lab=col_n[25]}
N 7210 -1140 7210 -940 {
lab=col_n[25]}
N 7200 -1150 7210 -1140 {
lab=col_n[25]}
N 7200 -1170 7200 -1150 {
lab=col_n[25]}
N 7080 -1070 7090 -1080 {
lab=VSS}
N 7090 -1080 7290 -1080 {
lab=VSS}
N 7290 -1080 7300 -1070 {
lab=VSS}
N 7080 -1050 7090 -1060 {
lab=VSS}
N 7090 -1060 7290 -1060 {
lab=VSS}
N 7290 -1060 7300 -1050 {
lab=VSS}
N 7080 -1030 7090 -1040 {
lab=VSS}
N 7090 -1040 7290 -1040 {
lab=VSS}
N 7290 -1040 7300 -1030 {
lab=VSS}
N 7080 -1010 7090 -1020 {
lab=VDD}
N 7090 -1020 7290 -1020 {
lab=VDD}
N 7290 -1020 7300 -1010 {
lab=VDD}
N 7300 -1010 7320 -1010 {
lab=VDD}
N 7300 -1030 7320 -1030 {
lab=VSS}
N 7300 -1050 7320 -1050 {
lab=VSS}
N 7300 -1070 7320 -1070 {
lab=VSS}
N 7060 -1070 7080 -1070 {
lab=VSS}
N 7060 -1050 7080 -1050 {
lab=VSS}
N 7060 -1030 7080 -1030 {
lab=VSS}
N 7060 -1010 7080 -1010 {
lab=VDD}
N 7120 -930 7120 -920 {
lab=VSS}
N 7140 -1170 7140 -1150 {
lab=vcm}
N 7120 -1160 7120 -1150 {
lab=VDD}
N 7200 -930 7200 -910 {
lab=col_n[25]}
N 7460 -930 7470 -940 {
lab=col_n[26]}
N 7470 -1140 7470 -940 {
lab=col_n[26]}
N 7460 -1150 7470 -1140 {
lab=col_n[26]}
N 7460 -1170 7460 -1150 {
lab=col_n[26]}
N 7340 -1070 7350 -1080 {
lab=VSS}
N 7350 -1080 7550 -1080 {
lab=VSS}
N 7550 -1080 7560 -1070 {
lab=VSS}
N 7340 -1050 7350 -1060 {
lab=VSS}
N 7350 -1060 7550 -1060 {
lab=VSS}
N 7550 -1060 7560 -1050 {
lab=VSS}
N 7340 -1030 7350 -1040 {
lab=VSS}
N 7350 -1040 7550 -1040 {
lab=VSS}
N 7550 -1040 7560 -1030 {
lab=VSS}
N 7340 -1010 7350 -1020 {
lab=VDD}
N 7350 -1020 7550 -1020 {
lab=VDD}
N 7550 -1020 7560 -1010 {
lab=VDD}
N 7560 -1010 7580 -1010 {
lab=VDD}
N 7560 -1030 7580 -1030 {
lab=VSS}
N 7560 -1050 7580 -1050 {
lab=VSS}
N 7560 -1070 7580 -1070 {
lab=VSS}
N 7320 -1070 7340 -1070 {
lab=VSS}
N 7320 -1050 7340 -1050 {
lab=VSS}
N 7320 -1030 7340 -1030 {
lab=VSS}
N 7320 -1010 7340 -1010 {
lab=VDD}
N 7380 -930 7380 -920 {
lab=VSS}
N 7400 -1170 7400 -1150 {
lab=vcm}
N 7380 -1160 7380 -1150 {
lab=VDD}
N 7460 -930 7460 -910 {
lab=col_n[26]}
N 7180 -1170 7180 -1150 {
lab=ctop}
N 7440 -1170 7440 -1150 {
lab=ctop}
N 7720 -930 7730 -940 {
lab=col_n[27]}
N 7730 -1140 7730 -940 {
lab=col_n[27]}
N 7720 -1150 7730 -1140 {
lab=col_n[27]}
N 7720 -1170 7720 -1150 {
lab=col_n[27]}
N 7600 -1070 7610 -1080 {
lab=VSS}
N 7610 -1080 7810 -1080 {
lab=VSS}
N 7810 -1080 7820 -1070 {
lab=VSS}
N 7600 -1050 7610 -1060 {
lab=VSS}
N 7610 -1060 7810 -1060 {
lab=VSS}
N 7810 -1060 7820 -1050 {
lab=VSS}
N 7600 -1030 7610 -1040 {
lab=VSS}
N 7610 -1040 7810 -1040 {
lab=VSS}
N 7810 -1040 7820 -1030 {
lab=VSS}
N 7600 -1010 7610 -1020 {
lab=VDD}
N 7610 -1020 7810 -1020 {
lab=VDD}
N 7810 -1020 7820 -1010 {
lab=VDD}
N 7820 -1010 7840 -1010 {
lab=VDD}
N 7820 -1030 7840 -1030 {
lab=VSS}
N 7820 -1050 7840 -1050 {
lab=VSS}
N 7820 -1070 7840 -1070 {
lab=VSS}
N 7580 -1070 7600 -1070 {
lab=VSS}
N 7580 -1050 7600 -1050 {
lab=VSS}
N 7580 -1030 7600 -1030 {
lab=VSS}
N 7580 -1010 7600 -1010 {
lab=VDD}
N 7640 -930 7640 -920 {
lab=VSS}
N 7660 -1170 7660 -1150 {
lab=vcm}
N 7640 -1160 7640 -1150 {
lab=VDD}
N 7720 -930 7720 -910 {
lab=col_n[27]}
N 7980 -930 7990 -940 {
lab=col_n[28]}
N 7990 -1140 7990 -940 {
lab=col_n[28]}
N 7980 -1150 7990 -1140 {
lab=col_n[28]}
N 7980 -1170 7980 -1150 {
lab=col_n[28]}
N 7860 -1070 7870 -1080 {
lab=VSS}
N 7870 -1080 8070 -1080 {
lab=VSS}
N 8070 -1080 8080 -1070 {
lab=VSS}
N 7860 -1050 7870 -1060 {
lab=VSS}
N 7870 -1060 8070 -1060 {
lab=VSS}
N 8070 -1060 8080 -1050 {
lab=VSS}
N 7860 -1030 7870 -1040 {
lab=VSS}
N 7870 -1040 8070 -1040 {
lab=VSS}
N 8070 -1040 8080 -1030 {
lab=VSS}
N 7860 -1010 7870 -1020 {
lab=VDD}
N 7870 -1020 8070 -1020 {
lab=VDD}
N 8070 -1020 8080 -1010 {
lab=VDD}
N 8080 -1010 8100 -1010 {
lab=VDD}
N 8080 -1030 8100 -1030 {
lab=VSS}
N 8080 -1050 8100 -1050 {
lab=VSS}
N 8080 -1070 8100 -1070 {
lab=VSS}
N 7840 -1070 7860 -1070 {
lab=VSS}
N 7840 -1050 7860 -1050 {
lab=VSS}
N 7840 -1030 7860 -1030 {
lab=VSS}
N 7840 -1010 7860 -1010 {
lab=VDD}
N 7900 -930 7900 -920 {
lab=VSS}
N 7920 -1170 7920 -1150 {
lab=vcm}
N 7900 -1160 7900 -1150 {
lab=VDD}
N 7980 -930 7980 -910 {
lab=col_n[28]}
N 7700 -1170 7700 -1150 {
lab=ctop}
N 7960 -1170 7960 -1150 {
lab=ctop}
N 8240 -930 8250 -940 {
lab=col_n[29]}
N 8250 -1140 8250 -940 {
lab=col_n[29]}
N 8240 -1150 8250 -1140 {
lab=col_n[29]}
N 8240 -1170 8240 -1150 {
lab=col_n[29]}
N 8120 -1070 8130 -1080 {
lab=VSS}
N 8130 -1080 8330 -1080 {
lab=VSS}
N 8330 -1080 8340 -1070 {
lab=VSS}
N 8120 -1050 8130 -1060 {
lab=VSS}
N 8130 -1060 8330 -1060 {
lab=VSS}
N 8330 -1060 8340 -1050 {
lab=VSS}
N 8120 -1030 8130 -1040 {
lab=VSS}
N 8130 -1040 8330 -1040 {
lab=VSS}
N 8330 -1040 8340 -1030 {
lab=VSS}
N 8120 -1010 8130 -1020 {
lab=VDD}
N 8130 -1020 8330 -1020 {
lab=VDD}
N 8330 -1020 8340 -1010 {
lab=VDD}
N 8340 -1010 8360 -1010 {
lab=VDD}
N 8340 -1030 8360 -1030 {
lab=VSS}
N 8340 -1050 8360 -1050 {
lab=VSS}
N 8340 -1070 8360 -1070 {
lab=VSS}
N 8100 -1070 8120 -1070 {
lab=VSS}
N 8100 -1050 8120 -1050 {
lab=VSS}
N 8100 -1030 8120 -1030 {
lab=VSS}
N 8100 -1010 8120 -1010 {
lab=VDD}
N 8160 -930 8160 -920 {
lab=VSS}
N 8180 -1170 8180 -1150 {
lab=vcm}
N 8160 -1160 8160 -1150 {
lab=VDD}
N 8240 -930 8240 -910 {
lab=col_n[29]}
N 8500 -930 8510 -940 {
lab=col_n[30]}
N 8510 -1140 8510 -940 {
lab=col_n[30]}
N 8500 -1150 8510 -1140 {
lab=col_n[30]}
N 8500 -1170 8500 -1150 {
lab=col_n[30]}
N 8380 -1070 8390 -1080 {
lab=VSS}
N 8390 -1080 8590 -1080 {
lab=VSS}
N 8590 -1080 8600 -1070 {
lab=VSS}
N 8380 -1050 8390 -1060 {
lab=VSS}
N 8390 -1060 8590 -1060 {
lab=VSS}
N 8590 -1060 8600 -1050 {
lab=VSS}
N 8380 -1030 8390 -1040 {
lab=VSS}
N 8390 -1040 8590 -1040 {
lab=VSS}
N 8590 -1040 8600 -1030 {
lab=VSS}
N 8380 -1010 8390 -1020 {
lab=VDD}
N 8390 -1020 8590 -1020 {
lab=VDD}
N 8590 -1020 8600 -1010 {
lab=VDD}
N 8600 -1010 8620 -1010 {
lab=VDD}
N 8600 -1030 8620 -1030 {
lab=VSS}
N 8600 -1050 8620 -1050 {
lab=VSS}
N 8600 -1070 8620 -1070 {
lab=VSS}
N 8360 -1070 8380 -1070 {
lab=VSS}
N 8360 -1050 8380 -1050 {
lab=VSS}
N 8360 -1030 8380 -1030 {
lab=VSS}
N 8360 -1010 8380 -1010 {
lab=VDD}
N 8420 -930 8420 -920 {
lab=VSS}
N 8440 -1170 8440 -1150 {
lab=vcm}
N 8420 -1160 8420 -1150 {
lab=VDD}
N 8500 -930 8500 -910 {
lab=col_n[30]}
N 8220 -1170 8220 -1150 {
lab=ctop}
N 8480 -1170 8480 -1150 {
lab=ctop}
N 8760 -930 8770 -940 {
lab=col_n[31]}
N 8770 -1140 8770 -940 {
lab=col_n[31]}
N 8760 -1150 8770 -1140 {
lab=col_n[31]}
N 8760 -1170 8760 -1150 {
lab=col_n[31]}
N 8640 -1070 8650 -1080 {
lab=VSS}
N 8650 -1080 8850 -1080 {
lab=VSS}
N 8850 -1080 8860 -1070 {
lab=VSS}
N 8640 -1050 8650 -1060 {
lab=VSS}
N 8650 -1060 8850 -1060 {
lab=VSS}
N 8850 -1060 8860 -1050 {
lab=VSS}
N 8640 -1030 8650 -1040 {
lab=VSS}
N 8650 -1040 8850 -1040 {
lab=VSS}
N 8850 -1040 8860 -1030 {
lab=VSS}
N 8640 -1010 8650 -1020 {
lab=VDD}
N 8650 -1020 8850 -1020 {
lab=VDD}
N 8850 -1020 8860 -1010 {
lab=VDD}
N 8860 -1010 8880 -1010 {
lab=VDD}
N 8860 -1030 8880 -1030 {
lab=VSS}
N 8860 -1050 8880 -1050 {
lab=VSS}
N 8860 -1070 8880 -1070 {
lab=VSS}
N 8620 -1070 8640 -1070 {
lab=VSS}
N 8620 -1050 8640 -1050 {
lab=VSS}
N 8620 -1030 8640 -1030 {
lab=VSS}
N 8620 -1010 8640 -1010 {
lab=VDD}
N 8680 -930 8680 -920 {
lab=VSS}
N 8700 -1170 8700 -1150 {
lab=vcm}
N 8680 -1160 8680 -1150 {
lab=VDD}
N 8760 -930 8760 -910 {
lab=col_n[31]}
N 8740 -1170 8740 -1150 {
lab=ctop}
N 9020 -930 9030 -940 {
lab=VDD}
N 9030 -1140 9030 -940 {
lab=VDD}
N 9020 -1150 9030 -1140 {
lab=VDD}
N 9020 -1170 9020 -1150 {
lab=VDD}
N 8900 -1070 8910 -1080 {
lab=VSS}
N 8910 -1080 9110 -1080 {
lab=VSS}
N 9110 -1080 9120 -1070 {
lab=VSS}
N 8900 -1050 8910 -1060 {
lab=VSS}
N 8910 -1060 9110 -1060 {
lab=VSS}
N 9110 -1060 9120 -1050 {
lab=VSS}
N 8900 -1030 8910 -1040 {
lab=VSS}
N 8910 -1040 9110 -1040 {
lab=VSS}
N 9110 -1040 9120 -1030 {
lab=VSS}
N 8900 -1010 8910 -1020 {
lab=VDD}
N 8910 -1020 9110 -1020 {
lab=VDD}
N 9110 -1020 9120 -1010 {
lab=VDD}
N 9120 -1010 9140 -1010 {
lab=VDD}
N 9120 -1030 9140 -1030 {
lab=VSS}
N 9120 -1050 9140 -1050 {
lab=VSS}
N 9120 -1070 9140 -1070 {
lab=VSS}
N 8880 -1070 8900 -1070 {
lab=VSS}
N 8880 -1050 8900 -1050 {
lab=VSS}
N 8880 -1030 8900 -1030 {
lab=VSS}
N 8880 -1010 8900 -1010 {
lab=VDD}
N 8940 -930 8940 -920 {
lab=VSS}
N 8960 -1170 8960 -1150 {
lab=vcm}
N 8940 -1160 8940 -1150 {
lab=VDD}
N 9020 -930 9020 -910 {
lab=VDD}
N 9000 -1170 9000 -1150 {
lab=ctop}
N 440 -5350 450 -5360 {
lab=VDD}
N 450 -5560 450 -5360 {
lab=VDD}
N 440 -5570 450 -5560 {
lab=VDD}
N 440 -5590 440 -5570 {
lab=VDD}
N 320 -5490 330 -5500 {
lab=VDD}
N 330 -5500 530 -5500 {
lab=VDD}
N 530 -5500 540 -5490 {
lab=VDD}
N 320 -5470 330 -5480 {
lab=VDD}
N 330 -5480 530 -5480 {
lab=VDD}
N 530 -5480 540 -5470 {
lab=VDD}
N 320 -5450 330 -5460 {
lab=VSS}
N 330 -5460 530 -5460 {
lab=VSS}
N 530 -5460 540 -5450 {
lab=VSS}
N 320 -5430 330 -5440 {
lab=VDD}
N 330 -5440 530 -5440 {
lab=VDD}
N 530 -5440 540 -5430 {
lab=VDD}
N 540 -5430 560 -5430 {
lab=VDD}
N 540 -5450 560 -5450 {
lab=VSS}
N 540 -5470 560 -5470 {
lab=VDD}
N 540 -5490 560 -5490 {
lab=VDD}
N 300 -5490 320 -5490 {
lab=VDD}
N 300 -5470 320 -5470 {
lab=VDD}
N 300 -5450 320 -5450 {
lab=VSS}
N 300 -5430 320 -5430 {
lab=VDD}
N 360 -5350 360 -5340 {
lab=VSS}
N 380 -5590 380 -5570 {
lab=vcm}
N 360 -5580 360 -5570 {
lab=VDD}
N 440 -5350 440 -5330 {
lab=VDD}
N 700 -5350 710 -5360 {
lab=col_n[0]}
N 710 -5560 710 -5360 {
lab=col_n[0]}
N 700 -5570 710 -5560 {
lab=col_n[0]}
N 700 -5590 700 -5570 {
lab=col_n[0]}
N 580 -5490 590 -5500 {
lab=VDD}
N 590 -5500 790 -5500 {
lab=VDD}
N 790 -5500 800 -5490 {
lab=VDD}
N 580 -5470 590 -5480 {
lab=VDD}
N 590 -5480 790 -5480 {
lab=VDD}
N 790 -5480 800 -5470 {
lab=VDD}
N 580 -5450 590 -5460 {
lab=VSS}
N 590 -5460 790 -5460 {
lab=VSS}
N 790 -5460 800 -5450 {
lab=VSS}
N 580 -5430 590 -5440 {
lab=VDD}
N 590 -5440 790 -5440 {
lab=VDD}
N 790 -5440 800 -5430 {
lab=VDD}
N 800 -5430 820 -5430 {
lab=VDD}
N 800 -5450 820 -5450 {
lab=VSS}
N 800 -5470 820 -5470 {
lab=VDD}
N 800 -5490 820 -5490 {
lab=VDD}
N 560 -5490 580 -5490 {
lab=VDD}
N 560 -5470 580 -5470 {
lab=VDD}
N 560 -5450 580 -5450 {
lab=VSS}
N 560 -5430 580 -5430 {
lab=VDD}
N 620 -5350 620 -5340 {
lab=VSS}
N 640 -5590 640 -5570 {
lab=vcm}
N 620 -5580 620 -5570 {
lab=VDD}
N 700 -5350 700 -5330 {
lab=col_n[0]}
N 420 -5590 420 -5570 {
lab=ctop}
N 680 -5590 680 -5570 {
lab=ctop}
N 960 -5350 970 -5360 {
lab=col_n[1]}
N 970 -5560 970 -5360 {
lab=col_n[1]}
N 960 -5570 970 -5560 {
lab=col_n[1]}
N 960 -5590 960 -5570 {
lab=col_n[1]}
N 840 -5490 850 -5500 {
lab=VDD}
N 850 -5500 1050 -5500 {
lab=VDD}
N 1050 -5500 1060 -5490 {
lab=VDD}
N 840 -5470 850 -5480 {
lab=VDD}
N 850 -5480 1050 -5480 {
lab=VDD}
N 1050 -5480 1060 -5470 {
lab=VDD}
N 840 -5450 850 -5460 {
lab=VSS}
N 850 -5460 1050 -5460 {
lab=VSS}
N 1050 -5460 1060 -5450 {
lab=VSS}
N 840 -5430 850 -5440 {
lab=VDD}
N 850 -5440 1050 -5440 {
lab=VDD}
N 1050 -5440 1060 -5430 {
lab=VDD}
N 1060 -5430 1080 -5430 {
lab=VDD}
N 1060 -5450 1080 -5450 {
lab=VSS}
N 1060 -5470 1080 -5470 {
lab=VDD}
N 1060 -5490 1080 -5490 {
lab=VDD}
N 820 -5490 840 -5490 {
lab=VDD}
N 820 -5470 840 -5470 {
lab=VDD}
N 820 -5450 840 -5450 {
lab=VSS}
N 820 -5430 840 -5430 {
lab=VDD}
N 880 -5350 880 -5340 {
lab=VSS}
N 900 -5590 900 -5570 {
lab=vcm}
N 880 -5580 880 -5570 {
lab=VDD}
N 960 -5350 960 -5330 {
lab=col_n[1]}
N 1220 -5350 1230 -5360 {
lab=col_n[2]}
N 1230 -5560 1230 -5360 {
lab=col_n[2]}
N 1220 -5570 1230 -5560 {
lab=col_n[2]}
N 1220 -5590 1220 -5570 {
lab=col_n[2]}
N 1100 -5490 1110 -5500 {
lab=VDD}
N 1110 -5500 1310 -5500 {
lab=VDD}
N 1310 -5500 1320 -5490 {
lab=VDD}
N 1100 -5470 1110 -5480 {
lab=VDD}
N 1110 -5480 1310 -5480 {
lab=VDD}
N 1310 -5480 1320 -5470 {
lab=VDD}
N 1100 -5450 1110 -5460 {
lab=VSS}
N 1110 -5460 1310 -5460 {
lab=VSS}
N 1310 -5460 1320 -5450 {
lab=VSS}
N 1100 -5430 1110 -5440 {
lab=VDD}
N 1110 -5440 1310 -5440 {
lab=VDD}
N 1310 -5440 1320 -5430 {
lab=VDD}
N 1320 -5430 1340 -5430 {
lab=VDD}
N 1320 -5450 1340 -5450 {
lab=VSS}
N 1320 -5470 1340 -5470 {
lab=VDD}
N 1320 -5490 1340 -5490 {
lab=VDD}
N 1080 -5490 1100 -5490 {
lab=VDD}
N 1080 -5470 1100 -5470 {
lab=VDD}
N 1080 -5450 1100 -5450 {
lab=VSS}
N 1080 -5430 1100 -5430 {
lab=VDD}
N 1140 -5350 1140 -5340 {
lab=VSS}
N 1160 -5590 1160 -5570 {
lab=vcm}
N 1140 -5580 1140 -5570 {
lab=VDD}
N 1220 -5350 1220 -5330 {
lab=col_n[2]}
N 940 -5590 940 -5570 {
lab=ctop}
N 1200 -5590 1200 -5570 {
lab=ctop}
N 1480 -5350 1490 -5360 {
lab=col_n[3]}
N 1490 -5560 1490 -5360 {
lab=col_n[3]}
N 1480 -5570 1490 -5560 {
lab=col_n[3]}
N 1480 -5590 1480 -5570 {
lab=col_n[3]}
N 1360 -5490 1370 -5500 {
lab=VDD}
N 1370 -5500 1570 -5500 {
lab=VDD}
N 1570 -5500 1580 -5490 {
lab=VDD}
N 1360 -5470 1370 -5480 {
lab=VDD}
N 1370 -5480 1570 -5480 {
lab=VDD}
N 1570 -5480 1580 -5470 {
lab=VDD}
N 1360 -5450 1370 -5460 {
lab=VSS}
N 1370 -5460 1570 -5460 {
lab=VSS}
N 1570 -5460 1580 -5450 {
lab=VSS}
N 1360 -5430 1370 -5440 {
lab=VDD}
N 1370 -5440 1570 -5440 {
lab=VDD}
N 1570 -5440 1580 -5430 {
lab=VDD}
N 1580 -5430 1600 -5430 {
lab=VDD}
N 1580 -5450 1600 -5450 {
lab=VSS}
N 1580 -5470 1600 -5470 {
lab=VDD}
N 1580 -5490 1600 -5490 {
lab=VDD}
N 1340 -5490 1360 -5490 {
lab=VDD}
N 1340 -5470 1360 -5470 {
lab=VDD}
N 1340 -5450 1360 -5450 {
lab=VSS}
N 1340 -5430 1360 -5430 {
lab=VDD}
N 1400 -5350 1400 -5340 {
lab=VSS}
N 1420 -5590 1420 -5570 {
lab=vcm}
N 1400 -5580 1400 -5570 {
lab=VDD}
N 1480 -5350 1480 -5330 {
lab=col_n[3]}
N 1740 -5350 1750 -5360 {
lab=col_n[4]}
N 1750 -5560 1750 -5360 {
lab=col_n[4]}
N 1740 -5570 1750 -5560 {
lab=col_n[4]}
N 1740 -5590 1740 -5570 {
lab=col_n[4]}
N 1620 -5490 1630 -5500 {
lab=VDD}
N 1630 -5500 1830 -5500 {
lab=VDD}
N 1830 -5500 1840 -5490 {
lab=VDD}
N 1620 -5470 1630 -5480 {
lab=VDD}
N 1630 -5480 1830 -5480 {
lab=VDD}
N 1830 -5480 1840 -5470 {
lab=VDD}
N 1620 -5450 1630 -5460 {
lab=VSS}
N 1630 -5460 1830 -5460 {
lab=VSS}
N 1830 -5460 1840 -5450 {
lab=VSS}
N 1620 -5430 1630 -5440 {
lab=VDD}
N 1630 -5440 1830 -5440 {
lab=VDD}
N 1830 -5440 1840 -5430 {
lab=VDD}
N 1840 -5430 1860 -5430 {
lab=VDD}
N 1840 -5450 1860 -5450 {
lab=VSS}
N 1840 -5470 1860 -5470 {
lab=VDD}
N 1840 -5490 1860 -5490 {
lab=VDD}
N 1600 -5490 1620 -5490 {
lab=VDD}
N 1600 -5470 1620 -5470 {
lab=VDD}
N 1600 -5450 1620 -5450 {
lab=VSS}
N 1600 -5430 1620 -5430 {
lab=VDD}
N 1660 -5350 1660 -5340 {
lab=VSS}
N 1680 -5590 1680 -5570 {
lab=vcm}
N 1660 -5580 1660 -5570 {
lab=VDD}
N 1740 -5350 1740 -5330 {
lab=col_n[4]}
N 1460 -5590 1460 -5570 {
lab=ctop}
N 1720 -5590 1720 -5570 {
lab=ctop}
N 2000 -5350 2010 -5360 {
lab=col_n[5]}
N 2010 -5560 2010 -5360 {
lab=col_n[5]}
N 2000 -5570 2010 -5560 {
lab=col_n[5]}
N 2000 -5590 2000 -5570 {
lab=col_n[5]}
N 1880 -5490 1890 -5500 {
lab=VDD}
N 1890 -5500 2090 -5500 {
lab=VDD}
N 2090 -5500 2100 -5490 {
lab=VDD}
N 1880 -5470 1890 -5480 {
lab=VDD}
N 1890 -5480 2090 -5480 {
lab=VDD}
N 2090 -5480 2100 -5470 {
lab=VDD}
N 1880 -5450 1890 -5460 {
lab=VSS}
N 1890 -5460 2090 -5460 {
lab=VSS}
N 2090 -5460 2100 -5450 {
lab=VSS}
N 1880 -5430 1890 -5440 {
lab=VDD}
N 1890 -5440 2090 -5440 {
lab=VDD}
N 2090 -5440 2100 -5430 {
lab=VDD}
N 2100 -5430 2120 -5430 {
lab=VDD}
N 2100 -5450 2120 -5450 {
lab=VSS}
N 2100 -5470 2120 -5470 {
lab=VDD}
N 2100 -5490 2120 -5490 {
lab=VDD}
N 1860 -5490 1880 -5490 {
lab=VDD}
N 1860 -5470 1880 -5470 {
lab=VDD}
N 1860 -5450 1880 -5450 {
lab=VSS}
N 1860 -5430 1880 -5430 {
lab=VDD}
N 1920 -5350 1920 -5340 {
lab=VSS}
N 1940 -5590 1940 -5570 {
lab=vcm}
N 1920 -5580 1920 -5570 {
lab=VDD}
N 2000 -5350 2000 -5330 {
lab=col_n[5]}
N 2260 -5350 2270 -5360 {
lab=col_n[6]}
N 2270 -5560 2270 -5360 {
lab=col_n[6]}
N 2260 -5570 2270 -5560 {
lab=col_n[6]}
N 2260 -5590 2260 -5570 {
lab=col_n[6]}
N 2140 -5490 2150 -5500 {
lab=VDD}
N 2150 -5500 2350 -5500 {
lab=VDD}
N 2350 -5500 2360 -5490 {
lab=VDD}
N 2140 -5470 2150 -5480 {
lab=VDD}
N 2150 -5480 2350 -5480 {
lab=VDD}
N 2350 -5480 2360 -5470 {
lab=VDD}
N 2140 -5450 2150 -5460 {
lab=VSS}
N 2150 -5460 2350 -5460 {
lab=VSS}
N 2350 -5460 2360 -5450 {
lab=VSS}
N 2140 -5430 2150 -5440 {
lab=VDD}
N 2150 -5440 2350 -5440 {
lab=VDD}
N 2350 -5440 2360 -5430 {
lab=VDD}
N 2360 -5430 2380 -5430 {
lab=VDD}
N 2360 -5450 2380 -5450 {
lab=VSS}
N 2360 -5470 2380 -5470 {
lab=VDD}
N 2360 -5490 2380 -5490 {
lab=VDD}
N 2120 -5490 2140 -5490 {
lab=VDD}
N 2120 -5470 2140 -5470 {
lab=VDD}
N 2120 -5450 2140 -5450 {
lab=VSS}
N 2120 -5430 2140 -5430 {
lab=VDD}
N 2180 -5350 2180 -5340 {
lab=VSS}
N 2200 -5590 2200 -5570 {
lab=vcm}
N 2180 -5580 2180 -5570 {
lab=VDD}
N 2260 -5350 2260 -5330 {
lab=col_n[6]}
N 1980 -5590 1980 -5570 {
lab=ctop}
N 2240 -5590 2240 -5570 {
lab=ctop}
N 2520 -5350 2530 -5360 {
lab=col_n[7]}
N 2530 -5560 2530 -5360 {
lab=col_n[7]}
N 2520 -5570 2530 -5560 {
lab=col_n[7]}
N 2520 -5590 2520 -5570 {
lab=col_n[7]}
N 2400 -5490 2410 -5500 {
lab=VDD}
N 2410 -5500 2610 -5500 {
lab=VDD}
N 2610 -5500 2620 -5490 {
lab=VDD}
N 2400 -5470 2410 -5480 {
lab=VDD}
N 2410 -5480 2610 -5480 {
lab=VDD}
N 2610 -5480 2620 -5470 {
lab=VDD}
N 2400 -5450 2410 -5460 {
lab=VSS}
N 2410 -5460 2610 -5460 {
lab=VSS}
N 2610 -5460 2620 -5450 {
lab=VSS}
N 2400 -5430 2410 -5440 {
lab=VDD}
N 2410 -5440 2610 -5440 {
lab=VDD}
N 2610 -5440 2620 -5430 {
lab=VDD}
N 2620 -5430 2640 -5430 {
lab=VDD}
N 2620 -5450 2640 -5450 {
lab=VSS}
N 2620 -5470 2640 -5470 {
lab=VDD}
N 2620 -5490 2640 -5490 {
lab=VDD}
N 2380 -5490 2400 -5490 {
lab=VDD}
N 2380 -5470 2400 -5470 {
lab=VDD}
N 2380 -5450 2400 -5450 {
lab=VSS}
N 2380 -5430 2400 -5430 {
lab=VDD}
N 2440 -5350 2440 -5340 {
lab=VSS}
N 2460 -5590 2460 -5570 {
lab=vcm}
N 2440 -5580 2440 -5570 {
lab=VDD}
N 2520 -5350 2520 -5330 {
lab=col_n[7]}
N 2780 -5350 2790 -5360 {
lab=col_n[8]}
N 2790 -5560 2790 -5360 {
lab=col_n[8]}
N 2780 -5570 2790 -5560 {
lab=col_n[8]}
N 2780 -5590 2780 -5570 {
lab=col_n[8]}
N 2660 -5490 2670 -5500 {
lab=VDD}
N 2670 -5500 2870 -5500 {
lab=VDD}
N 2870 -5500 2880 -5490 {
lab=VDD}
N 2660 -5470 2670 -5480 {
lab=VDD}
N 2670 -5480 2870 -5480 {
lab=VDD}
N 2870 -5480 2880 -5470 {
lab=VDD}
N 2660 -5450 2670 -5460 {
lab=VSS}
N 2670 -5460 2870 -5460 {
lab=VSS}
N 2870 -5460 2880 -5450 {
lab=VSS}
N 2660 -5430 2670 -5440 {
lab=VDD}
N 2670 -5440 2870 -5440 {
lab=VDD}
N 2870 -5440 2880 -5430 {
lab=VDD}
N 2880 -5430 2900 -5430 {
lab=VDD}
N 2880 -5450 2900 -5450 {
lab=VSS}
N 2880 -5470 2900 -5470 {
lab=VDD}
N 2880 -5490 2900 -5490 {
lab=VDD}
N 2640 -5490 2660 -5490 {
lab=VDD}
N 2640 -5470 2660 -5470 {
lab=VDD}
N 2640 -5450 2660 -5450 {
lab=VSS}
N 2640 -5430 2660 -5430 {
lab=VDD}
N 2700 -5350 2700 -5340 {
lab=VSS}
N 2720 -5590 2720 -5570 {
lab=vcm}
N 2700 -5580 2700 -5570 {
lab=VDD}
N 2780 -5350 2780 -5330 {
lab=col_n[8]}
N 2500 -5590 2500 -5570 {
lab=ctop}
N 2760 -5590 2760 -5570 {
lab=ctop}
N 3040 -5350 3050 -5360 {
lab=col_n[9]}
N 3050 -5560 3050 -5360 {
lab=col_n[9]}
N 3040 -5570 3050 -5560 {
lab=col_n[9]}
N 3040 -5590 3040 -5570 {
lab=col_n[9]}
N 2920 -5490 2930 -5500 {
lab=VDD}
N 2930 -5500 3130 -5500 {
lab=VDD}
N 3130 -5500 3140 -5490 {
lab=VDD}
N 2920 -5470 2930 -5480 {
lab=VDD}
N 2930 -5480 3130 -5480 {
lab=VDD}
N 3130 -5480 3140 -5470 {
lab=VDD}
N 2920 -5450 2930 -5460 {
lab=VSS}
N 2930 -5460 3130 -5460 {
lab=VSS}
N 3130 -5460 3140 -5450 {
lab=VSS}
N 2920 -5430 2930 -5440 {
lab=VDD}
N 2930 -5440 3130 -5440 {
lab=VDD}
N 3130 -5440 3140 -5430 {
lab=VDD}
N 3140 -5430 3160 -5430 {
lab=VDD}
N 3140 -5450 3160 -5450 {
lab=VSS}
N 3140 -5470 3160 -5470 {
lab=VDD}
N 3140 -5490 3160 -5490 {
lab=VDD}
N 2900 -5490 2920 -5490 {
lab=VDD}
N 2900 -5470 2920 -5470 {
lab=VDD}
N 2900 -5450 2920 -5450 {
lab=VSS}
N 2900 -5430 2920 -5430 {
lab=VDD}
N 2960 -5350 2960 -5340 {
lab=VSS}
N 2980 -5590 2980 -5570 {
lab=vcm}
N 2960 -5580 2960 -5570 {
lab=VDD}
N 3040 -5350 3040 -5330 {
lab=col_n[9]}
N 3300 -5350 3310 -5360 {
lab=col_n[10]}
N 3310 -5560 3310 -5360 {
lab=col_n[10]}
N 3300 -5570 3310 -5560 {
lab=col_n[10]}
N 3300 -5590 3300 -5570 {
lab=col_n[10]}
N 3180 -5490 3190 -5500 {
lab=VDD}
N 3190 -5500 3390 -5500 {
lab=VDD}
N 3390 -5500 3400 -5490 {
lab=VDD}
N 3180 -5470 3190 -5480 {
lab=VDD}
N 3190 -5480 3390 -5480 {
lab=VDD}
N 3390 -5480 3400 -5470 {
lab=VDD}
N 3180 -5450 3190 -5460 {
lab=VSS}
N 3190 -5460 3390 -5460 {
lab=VSS}
N 3390 -5460 3400 -5450 {
lab=VSS}
N 3180 -5430 3190 -5440 {
lab=VDD}
N 3190 -5440 3390 -5440 {
lab=VDD}
N 3390 -5440 3400 -5430 {
lab=VDD}
N 3400 -5430 3420 -5430 {
lab=VDD}
N 3400 -5450 3420 -5450 {
lab=VSS}
N 3400 -5470 3420 -5470 {
lab=VDD}
N 3400 -5490 3420 -5490 {
lab=VDD}
N 3160 -5490 3180 -5490 {
lab=VDD}
N 3160 -5470 3180 -5470 {
lab=VDD}
N 3160 -5450 3180 -5450 {
lab=VSS}
N 3160 -5430 3180 -5430 {
lab=VDD}
N 3220 -5350 3220 -5340 {
lab=VSS}
N 3240 -5590 3240 -5570 {
lab=vcm}
N 3220 -5580 3220 -5570 {
lab=VDD}
N 3300 -5350 3300 -5330 {
lab=col_n[10]}
N 3020 -5590 3020 -5570 {
lab=ctop}
N 3280 -5590 3280 -5570 {
lab=ctop}
N 3560 -5350 3570 -5360 {
lab=col_n[11]}
N 3570 -5560 3570 -5360 {
lab=col_n[11]}
N 3560 -5570 3570 -5560 {
lab=col_n[11]}
N 3560 -5590 3560 -5570 {
lab=col_n[11]}
N 3440 -5490 3450 -5500 {
lab=VDD}
N 3450 -5500 3650 -5500 {
lab=VDD}
N 3650 -5500 3660 -5490 {
lab=VDD}
N 3440 -5470 3450 -5480 {
lab=VDD}
N 3450 -5480 3650 -5480 {
lab=VDD}
N 3650 -5480 3660 -5470 {
lab=VDD}
N 3440 -5450 3450 -5460 {
lab=VSS}
N 3450 -5460 3650 -5460 {
lab=VSS}
N 3650 -5460 3660 -5450 {
lab=VSS}
N 3440 -5430 3450 -5440 {
lab=VDD}
N 3450 -5440 3650 -5440 {
lab=VDD}
N 3650 -5440 3660 -5430 {
lab=VDD}
N 3660 -5430 3680 -5430 {
lab=VDD}
N 3660 -5450 3680 -5450 {
lab=VSS}
N 3660 -5470 3680 -5470 {
lab=VDD}
N 3660 -5490 3680 -5490 {
lab=VDD}
N 3420 -5490 3440 -5490 {
lab=VDD}
N 3420 -5470 3440 -5470 {
lab=VDD}
N 3420 -5450 3440 -5450 {
lab=VSS}
N 3420 -5430 3440 -5430 {
lab=VDD}
N 3480 -5350 3480 -5340 {
lab=VSS}
N 3500 -5590 3500 -5570 {
lab=vcm}
N 3480 -5580 3480 -5570 {
lab=VDD}
N 3560 -5350 3560 -5330 {
lab=col_n[11]}
N 3820 -5350 3830 -5360 {
lab=col_n[12]}
N 3830 -5560 3830 -5360 {
lab=col_n[12]}
N 3820 -5570 3830 -5560 {
lab=col_n[12]}
N 3820 -5590 3820 -5570 {
lab=col_n[12]}
N 3700 -5490 3710 -5500 {
lab=VDD}
N 3710 -5500 3910 -5500 {
lab=VDD}
N 3910 -5500 3920 -5490 {
lab=VDD}
N 3700 -5470 3710 -5480 {
lab=VDD}
N 3710 -5480 3910 -5480 {
lab=VDD}
N 3910 -5480 3920 -5470 {
lab=VDD}
N 3700 -5450 3710 -5460 {
lab=VSS}
N 3710 -5460 3910 -5460 {
lab=VSS}
N 3910 -5460 3920 -5450 {
lab=VSS}
N 3700 -5430 3710 -5440 {
lab=VDD}
N 3710 -5440 3910 -5440 {
lab=VDD}
N 3910 -5440 3920 -5430 {
lab=VDD}
N 3920 -5430 3940 -5430 {
lab=VDD}
N 3920 -5450 3940 -5450 {
lab=VSS}
N 3920 -5470 3940 -5470 {
lab=VDD}
N 3920 -5490 3940 -5490 {
lab=VDD}
N 3680 -5490 3700 -5490 {
lab=VDD}
N 3680 -5470 3700 -5470 {
lab=VDD}
N 3680 -5450 3700 -5450 {
lab=VSS}
N 3680 -5430 3700 -5430 {
lab=VDD}
N 3740 -5350 3740 -5340 {
lab=VSS}
N 3760 -5590 3760 -5570 {
lab=vcm}
N 3740 -5580 3740 -5570 {
lab=VDD}
N 3820 -5350 3820 -5330 {
lab=col_n[12]}
N 3540 -5590 3540 -5570 {
lab=ctop}
N 3800 -5590 3800 -5570 {
lab=ctop}
N 4080 -5350 4090 -5360 {
lab=col_n[13]}
N 4090 -5560 4090 -5360 {
lab=col_n[13]}
N 4080 -5570 4090 -5560 {
lab=col_n[13]}
N 4080 -5590 4080 -5570 {
lab=col_n[13]}
N 3960 -5490 3970 -5500 {
lab=VDD}
N 3970 -5500 4170 -5500 {
lab=VDD}
N 4170 -5500 4180 -5490 {
lab=VDD}
N 3960 -5470 3970 -5480 {
lab=VDD}
N 3970 -5480 4170 -5480 {
lab=VDD}
N 4170 -5480 4180 -5470 {
lab=VDD}
N 3960 -5450 3970 -5460 {
lab=VSS}
N 3970 -5460 4170 -5460 {
lab=VSS}
N 4170 -5460 4180 -5450 {
lab=VSS}
N 3960 -5430 3970 -5440 {
lab=VDD}
N 3970 -5440 4170 -5440 {
lab=VDD}
N 4170 -5440 4180 -5430 {
lab=VDD}
N 4180 -5430 4200 -5430 {
lab=VDD}
N 4180 -5450 4200 -5450 {
lab=VSS}
N 4180 -5470 4200 -5470 {
lab=VDD}
N 4180 -5490 4200 -5490 {
lab=VDD}
N 3940 -5490 3960 -5490 {
lab=VDD}
N 3940 -5470 3960 -5470 {
lab=VDD}
N 3940 -5450 3960 -5450 {
lab=VSS}
N 3940 -5430 3960 -5430 {
lab=VDD}
N 4000 -5350 4000 -5340 {
lab=VSS}
N 4020 -5590 4020 -5570 {
lab=vcm}
N 4000 -5580 4000 -5570 {
lab=VDD}
N 4080 -5350 4080 -5330 {
lab=col_n[13]}
N 4340 -5350 4350 -5360 {
lab=col_n[14]}
N 4350 -5560 4350 -5360 {
lab=col_n[14]}
N 4340 -5570 4350 -5560 {
lab=col_n[14]}
N 4340 -5590 4340 -5570 {
lab=col_n[14]}
N 4220 -5490 4230 -5500 {
lab=VDD}
N 4230 -5500 4430 -5500 {
lab=VDD}
N 4430 -5500 4440 -5490 {
lab=VDD}
N 4220 -5470 4230 -5480 {
lab=VDD}
N 4230 -5480 4430 -5480 {
lab=VDD}
N 4430 -5480 4440 -5470 {
lab=VDD}
N 4220 -5450 4230 -5460 {
lab=VSS}
N 4230 -5460 4430 -5460 {
lab=VSS}
N 4430 -5460 4440 -5450 {
lab=VSS}
N 4220 -5430 4230 -5440 {
lab=VDD}
N 4230 -5440 4430 -5440 {
lab=VDD}
N 4430 -5440 4440 -5430 {
lab=VDD}
N 4440 -5430 4460 -5430 {
lab=VDD}
N 4440 -5450 4460 -5450 {
lab=VSS}
N 4440 -5470 4460 -5470 {
lab=VDD}
N 4440 -5490 4460 -5490 {
lab=VDD}
N 4200 -5490 4220 -5490 {
lab=VDD}
N 4200 -5470 4220 -5470 {
lab=VDD}
N 4200 -5450 4220 -5450 {
lab=VSS}
N 4200 -5430 4220 -5430 {
lab=VDD}
N 4260 -5350 4260 -5340 {
lab=VSS}
N 4280 -5590 4280 -5570 {
lab=vcm}
N 4260 -5580 4260 -5570 {
lab=VDD}
N 4340 -5350 4340 -5330 {
lab=col_n[14]}
N 4060 -5590 4060 -5570 {
lab=ctop}
N 4320 -5590 4320 -5570 {
lab=ctop}
N 4600 -5350 4610 -5360 {
lab=col_n[15]}
N 4610 -5560 4610 -5360 {
lab=col_n[15]}
N 4600 -5570 4610 -5560 {
lab=col_n[15]}
N 4600 -5590 4600 -5570 {
lab=col_n[15]}
N 4480 -5490 4490 -5500 {
lab=VDD}
N 4490 -5500 4690 -5500 {
lab=VDD}
N 4690 -5500 4700 -5490 {
lab=VDD}
N 4480 -5470 4490 -5480 {
lab=VDD}
N 4490 -5480 4690 -5480 {
lab=VDD}
N 4690 -5480 4700 -5470 {
lab=VDD}
N 4480 -5450 4490 -5460 {
lab=VSS}
N 4490 -5460 4690 -5460 {
lab=VSS}
N 4690 -5460 4700 -5450 {
lab=VSS}
N 4480 -5430 4490 -5440 {
lab=VDD}
N 4490 -5440 4690 -5440 {
lab=VDD}
N 4690 -5440 4700 -5430 {
lab=VDD}
N 4700 -5430 4720 -5430 {
lab=VDD}
N 4700 -5450 4720 -5450 {
lab=VSS}
N 4700 -5470 4720 -5470 {
lab=VDD}
N 4700 -5490 4720 -5490 {
lab=VDD}
N 4460 -5490 4480 -5490 {
lab=VDD}
N 4460 -5470 4480 -5470 {
lab=VDD}
N 4460 -5450 4480 -5450 {
lab=VSS}
N 4460 -5430 4480 -5430 {
lab=VDD}
N 4520 -5350 4520 -5340 {
lab=VSS}
N 4540 -5590 4540 -5570 {
lab=vcm}
N 4520 -5580 4520 -5570 {
lab=VDD}
N 4600 -5350 4600 -5330 {
lab=col_n[15]}
N 4860 -5350 4870 -5360 {
lab=col_n[16]}
N 4870 -5560 4870 -5360 {
lab=col_n[16]}
N 4860 -5570 4870 -5560 {
lab=col_n[16]}
N 4860 -5590 4860 -5570 {
lab=col_n[16]}
N 4740 -5490 4750 -5500 {
lab=VDD}
N 4750 -5500 4950 -5500 {
lab=VDD}
N 4950 -5500 4960 -5490 {
lab=VDD}
N 4740 -5470 4750 -5480 {
lab=VDD}
N 4750 -5480 4950 -5480 {
lab=VDD}
N 4950 -5480 4960 -5470 {
lab=VDD}
N 4740 -5450 4750 -5460 {
lab=VSS}
N 4750 -5460 4950 -5460 {
lab=VSS}
N 4950 -5460 4960 -5450 {
lab=VSS}
N 4740 -5430 4750 -5440 {
lab=VDD}
N 4750 -5440 4950 -5440 {
lab=VDD}
N 4950 -5440 4960 -5430 {
lab=VDD}
N 4960 -5430 4980 -5430 {
lab=VDD}
N 4960 -5450 4980 -5450 {
lab=VSS}
N 4960 -5470 4980 -5470 {
lab=VDD}
N 4960 -5490 4980 -5490 {
lab=VDD}
N 4720 -5490 4740 -5490 {
lab=VDD}
N 4720 -5470 4740 -5470 {
lab=VDD}
N 4720 -5450 4740 -5450 {
lab=VSS}
N 4720 -5430 4740 -5430 {
lab=VDD}
N 4780 -5350 4780 -5340 {
lab=VSS}
N 4800 -5590 4800 -5570 {
lab=vcm}
N 4780 -5580 4780 -5570 {
lab=VDD}
N 4860 -5350 4860 -5330 {
lab=col_n[16]}
N 4580 -5590 4580 -5570 {
lab=ctop}
N 4840 -5590 4840 -5570 {
lab=ctop}
N 5120 -5350 5130 -5360 {
lab=col_n[17]}
N 5130 -5560 5130 -5360 {
lab=col_n[17]}
N 5120 -5570 5130 -5560 {
lab=col_n[17]}
N 5120 -5590 5120 -5570 {
lab=col_n[17]}
N 5000 -5490 5010 -5500 {
lab=VDD}
N 5010 -5500 5210 -5500 {
lab=VDD}
N 5210 -5500 5220 -5490 {
lab=VDD}
N 5000 -5470 5010 -5480 {
lab=VDD}
N 5010 -5480 5210 -5480 {
lab=VDD}
N 5210 -5480 5220 -5470 {
lab=VDD}
N 5000 -5450 5010 -5460 {
lab=VSS}
N 5010 -5460 5210 -5460 {
lab=VSS}
N 5210 -5460 5220 -5450 {
lab=VSS}
N 5000 -5430 5010 -5440 {
lab=VDD}
N 5010 -5440 5210 -5440 {
lab=VDD}
N 5210 -5440 5220 -5430 {
lab=VDD}
N 5220 -5430 5240 -5430 {
lab=VDD}
N 5220 -5450 5240 -5450 {
lab=VSS}
N 5220 -5470 5240 -5470 {
lab=VDD}
N 5220 -5490 5240 -5490 {
lab=VDD}
N 4980 -5490 5000 -5490 {
lab=VDD}
N 4980 -5470 5000 -5470 {
lab=VDD}
N 4980 -5450 5000 -5450 {
lab=VSS}
N 4980 -5430 5000 -5430 {
lab=VDD}
N 5040 -5350 5040 -5340 {
lab=VSS}
N 5060 -5590 5060 -5570 {
lab=vcm}
N 5040 -5580 5040 -5570 {
lab=VDD}
N 5120 -5350 5120 -5330 {
lab=col_n[17]}
N 5380 -5350 5390 -5360 {
lab=col_n[18]}
N 5390 -5560 5390 -5360 {
lab=col_n[18]}
N 5380 -5570 5390 -5560 {
lab=col_n[18]}
N 5380 -5590 5380 -5570 {
lab=col_n[18]}
N 5260 -5490 5270 -5500 {
lab=VDD}
N 5270 -5500 5470 -5500 {
lab=VDD}
N 5470 -5500 5480 -5490 {
lab=VDD}
N 5260 -5470 5270 -5480 {
lab=VDD}
N 5270 -5480 5470 -5480 {
lab=VDD}
N 5470 -5480 5480 -5470 {
lab=VDD}
N 5260 -5450 5270 -5460 {
lab=VSS}
N 5270 -5460 5470 -5460 {
lab=VSS}
N 5470 -5460 5480 -5450 {
lab=VSS}
N 5260 -5430 5270 -5440 {
lab=VDD}
N 5270 -5440 5470 -5440 {
lab=VDD}
N 5470 -5440 5480 -5430 {
lab=VDD}
N 5480 -5430 5500 -5430 {
lab=VDD}
N 5480 -5450 5500 -5450 {
lab=VSS}
N 5480 -5470 5500 -5470 {
lab=VDD}
N 5480 -5490 5500 -5490 {
lab=VDD}
N 5240 -5490 5260 -5490 {
lab=VDD}
N 5240 -5470 5260 -5470 {
lab=VDD}
N 5240 -5450 5260 -5450 {
lab=VSS}
N 5240 -5430 5260 -5430 {
lab=VDD}
N 5300 -5350 5300 -5340 {
lab=VSS}
N 5320 -5590 5320 -5570 {
lab=vcm}
N 5300 -5580 5300 -5570 {
lab=VDD}
N 5380 -5350 5380 -5330 {
lab=col_n[18]}
N 5100 -5590 5100 -5570 {
lab=ctop}
N 5360 -5590 5360 -5570 {
lab=ctop}
N 5640 -5350 5650 -5360 {
lab=col_n[19]}
N 5650 -5560 5650 -5360 {
lab=col_n[19]}
N 5640 -5570 5650 -5560 {
lab=col_n[19]}
N 5640 -5590 5640 -5570 {
lab=col_n[19]}
N 5520 -5490 5530 -5500 {
lab=VDD}
N 5530 -5500 5730 -5500 {
lab=VDD}
N 5730 -5500 5740 -5490 {
lab=VDD}
N 5520 -5470 5530 -5480 {
lab=VDD}
N 5530 -5480 5730 -5480 {
lab=VDD}
N 5730 -5480 5740 -5470 {
lab=VDD}
N 5520 -5450 5530 -5460 {
lab=VSS}
N 5530 -5460 5730 -5460 {
lab=VSS}
N 5730 -5460 5740 -5450 {
lab=VSS}
N 5520 -5430 5530 -5440 {
lab=VDD}
N 5530 -5440 5730 -5440 {
lab=VDD}
N 5730 -5440 5740 -5430 {
lab=VDD}
N 5740 -5430 5760 -5430 {
lab=VDD}
N 5740 -5450 5760 -5450 {
lab=VSS}
N 5740 -5470 5760 -5470 {
lab=VDD}
N 5740 -5490 5760 -5490 {
lab=VDD}
N 5500 -5490 5520 -5490 {
lab=VDD}
N 5500 -5470 5520 -5470 {
lab=VDD}
N 5500 -5450 5520 -5450 {
lab=VSS}
N 5500 -5430 5520 -5430 {
lab=VDD}
N 5560 -5350 5560 -5340 {
lab=VSS}
N 5580 -5590 5580 -5570 {
lab=vcm}
N 5560 -5580 5560 -5570 {
lab=VDD}
N 5640 -5350 5640 -5330 {
lab=col_n[19]}
N 5900 -5350 5910 -5360 {
lab=col_n[20]}
N 5910 -5560 5910 -5360 {
lab=col_n[20]}
N 5900 -5570 5910 -5560 {
lab=col_n[20]}
N 5900 -5590 5900 -5570 {
lab=col_n[20]}
N 5780 -5490 5790 -5500 {
lab=VDD}
N 5790 -5500 5990 -5500 {
lab=VDD}
N 5990 -5500 6000 -5490 {
lab=VDD}
N 5780 -5470 5790 -5480 {
lab=VDD}
N 5790 -5480 5990 -5480 {
lab=VDD}
N 5990 -5480 6000 -5470 {
lab=VDD}
N 5780 -5450 5790 -5460 {
lab=VSS}
N 5790 -5460 5990 -5460 {
lab=VSS}
N 5990 -5460 6000 -5450 {
lab=VSS}
N 5780 -5430 5790 -5440 {
lab=VDD}
N 5790 -5440 5990 -5440 {
lab=VDD}
N 5990 -5440 6000 -5430 {
lab=VDD}
N 6000 -5430 6020 -5430 {
lab=VDD}
N 6000 -5450 6020 -5450 {
lab=VSS}
N 6000 -5470 6020 -5470 {
lab=VDD}
N 6000 -5490 6020 -5490 {
lab=VDD}
N 5760 -5490 5780 -5490 {
lab=VDD}
N 5760 -5470 5780 -5470 {
lab=VDD}
N 5760 -5450 5780 -5450 {
lab=VSS}
N 5760 -5430 5780 -5430 {
lab=VDD}
N 5820 -5350 5820 -5340 {
lab=VSS}
N 5840 -5590 5840 -5570 {
lab=vcm}
N 5820 -5580 5820 -5570 {
lab=VDD}
N 5900 -5350 5900 -5330 {
lab=col_n[20]}
N 5620 -5590 5620 -5570 {
lab=ctop}
N 5880 -5590 5880 -5570 {
lab=ctop}
N 6160 -5350 6170 -5360 {
lab=col_n[21]}
N 6170 -5560 6170 -5360 {
lab=col_n[21]}
N 6160 -5570 6170 -5560 {
lab=col_n[21]}
N 6160 -5590 6160 -5570 {
lab=col_n[21]}
N 6040 -5490 6050 -5500 {
lab=VDD}
N 6050 -5500 6250 -5500 {
lab=VDD}
N 6250 -5500 6260 -5490 {
lab=VDD}
N 6040 -5470 6050 -5480 {
lab=VDD}
N 6050 -5480 6250 -5480 {
lab=VDD}
N 6250 -5480 6260 -5470 {
lab=VDD}
N 6040 -5450 6050 -5460 {
lab=VSS}
N 6050 -5460 6250 -5460 {
lab=VSS}
N 6250 -5460 6260 -5450 {
lab=VSS}
N 6040 -5430 6050 -5440 {
lab=VDD}
N 6050 -5440 6250 -5440 {
lab=VDD}
N 6250 -5440 6260 -5430 {
lab=VDD}
N 6260 -5430 6280 -5430 {
lab=VDD}
N 6260 -5450 6280 -5450 {
lab=VSS}
N 6260 -5470 6280 -5470 {
lab=VDD}
N 6260 -5490 6280 -5490 {
lab=VDD}
N 6020 -5490 6040 -5490 {
lab=VDD}
N 6020 -5470 6040 -5470 {
lab=VDD}
N 6020 -5450 6040 -5450 {
lab=VSS}
N 6020 -5430 6040 -5430 {
lab=VDD}
N 6080 -5350 6080 -5340 {
lab=VSS}
N 6100 -5590 6100 -5570 {
lab=vcm}
N 6080 -5580 6080 -5570 {
lab=VDD}
N 6160 -5350 6160 -5330 {
lab=col_n[21]}
N 6420 -5350 6430 -5360 {
lab=col_n[22]}
N 6430 -5560 6430 -5360 {
lab=col_n[22]}
N 6420 -5570 6430 -5560 {
lab=col_n[22]}
N 6420 -5590 6420 -5570 {
lab=col_n[22]}
N 6300 -5490 6310 -5500 {
lab=VDD}
N 6310 -5500 6510 -5500 {
lab=VDD}
N 6510 -5500 6520 -5490 {
lab=VDD}
N 6300 -5470 6310 -5480 {
lab=VDD}
N 6310 -5480 6510 -5480 {
lab=VDD}
N 6510 -5480 6520 -5470 {
lab=VDD}
N 6300 -5450 6310 -5460 {
lab=VSS}
N 6310 -5460 6510 -5460 {
lab=VSS}
N 6510 -5460 6520 -5450 {
lab=VSS}
N 6300 -5430 6310 -5440 {
lab=VDD}
N 6310 -5440 6510 -5440 {
lab=VDD}
N 6510 -5440 6520 -5430 {
lab=VDD}
N 6520 -5430 6540 -5430 {
lab=VDD}
N 6520 -5450 6540 -5450 {
lab=VSS}
N 6520 -5470 6540 -5470 {
lab=VDD}
N 6520 -5490 6540 -5490 {
lab=VDD}
N 6280 -5490 6300 -5490 {
lab=VDD}
N 6280 -5470 6300 -5470 {
lab=VDD}
N 6280 -5450 6300 -5450 {
lab=VSS}
N 6280 -5430 6300 -5430 {
lab=VDD}
N 6340 -5350 6340 -5340 {
lab=VSS}
N 6360 -5590 6360 -5570 {
lab=vcm}
N 6340 -5580 6340 -5570 {
lab=VDD}
N 6420 -5350 6420 -5330 {
lab=col_n[22]}
N 6140 -5590 6140 -5570 {
lab=ctop}
N 6400 -5590 6400 -5570 {
lab=ctop}
N 6680 -5350 6690 -5360 {
lab=col_n[23]}
N 6690 -5560 6690 -5360 {
lab=col_n[23]}
N 6680 -5570 6690 -5560 {
lab=col_n[23]}
N 6680 -5590 6680 -5570 {
lab=col_n[23]}
N 6560 -5490 6570 -5500 {
lab=VDD}
N 6570 -5500 6770 -5500 {
lab=VDD}
N 6770 -5500 6780 -5490 {
lab=VDD}
N 6560 -5470 6570 -5480 {
lab=VDD}
N 6570 -5480 6770 -5480 {
lab=VDD}
N 6770 -5480 6780 -5470 {
lab=VDD}
N 6560 -5450 6570 -5460 {
lab=VSS}
N 6570 -5460 6770 -5460 {
lab=VSS}
N 6770 -5460 6780 -5450 {
lab=VSS}
N 6560 -5430 6570 -5440 {
lab=VDD}
N 6570 -5440 6770 -5440 {
lab=VDD}
N 6770 -5440 6780 -5430 {
lab=VDD}
N 6780 -5430 6800 -5430 {
lab=VDD}
N 6780 -5450 6800 -5450 {
lab=VSS}
N 6780 -5470 6800 -5470 {
lab=VDD}
N 6780 -5490 6800 -5490 {
lab=VDD}
N 6540 -5490 6560 -5490 {
lab=VDD}
N 6540 -5470 6560 -5470 {
lab=VDD}
N 6540 -5450 6560 -5450 {
lab=VSS}
N 6540 -5430 6560 -5430 {
lab=VDD}
N 6600 -5350 6600 -5340 {
lab=VSS}
N 6620 -5590 6620 -5570 {
lab=vcm}
N 6600 -5580 6600 -5570 {
lab=VDD}
N 6680 -5350 6680 -5330 {
lab=col_n[23]}
N 6940 -5350 6950 -5360 {
lab=col_n[24]}
N 6950 -5560 6950 -5360 {
lab=col_n[24]}
N 6940 -5570 6950 -5560 {
lab=col_n[24]}
N 6940 -5590 6940 -5570 {
lab=col_n[24]}
N 6820 -5490 6830 -5500 {
lab=VDD}
N 6830 -5500 7030 -5500 {
lab=VDD}
N 7030 -5500 7040 -5490 {
lab=VDD}
N 6820 -5470 6830 -5480 {
lab=VDD}
N 6830 -5480 7030 -5480 {
lab=VDD}
N 7030 -5480 7040 -5470 {
lab=VDD}
N 6820 -5450 6830 -5460 {
lab=VSS}
N 6830 -5460 7030 -5460 {
lab=VSS}
N 7030 -5460 7040 -5450 {
lab=VSS}
N 6820 -5430 6830 -5440 {
lab=VDD}
N 6830 -5440 7030 -5440 {
lab=VDD}
N 7030 -5440 7040 -5430 {
lab=VDD}
N 7040 -5430 7060 -5430 {
lab=VDD}
N 7040 -5450 7060 -5450 {
lab=VSS}
N 7040 -5470 7060 -5470 {
lab=VDD}
N 7040 -5490 7060 -5490 {
lab=VDD}
N 6800 -5490 6820 -5490 {
lab=VDD}
N 6800 -5470 6820 -5470 {
lab=VDD}
N 6800 -5450 6820 -5450 {
lab=VSS}
N 6800 -5430 6820 -5430 {
lab=VDD}
N 6860 -5350 6860 -5340 {
lab=VSS}
N 6880 -5590 6880 -5570 {
lab=vcm}
N 6860 -5580 6860 -5570 {
lab=VDD}
N 6940 -5350 6940 -5330 {
lab=col_n[24]}
N 6660 -5590 6660 -5570 {
lab=ctop}
N 6920 -5590 6920 -5570 {
lab=ctop}
N 7200 -5350 7210 -5360 {
lab=col_n[25]}
N 7210 -5560 7210 -5360 {
lab=col_n[25]}
N 7200 -5570 7210 -5560 {
lab=col_n[25]}
N 7200 -5590 7200 -5570 {
lab=col_n[25]}
N 7080 -5490 7090 -5500 {
lab=VDD}
N 7090 -5500 7290 -5500 {
lab=VDD}
N 7290 -5500 7300 -5490 {
lab=VDD}
N 7080 -5470 7090 -5480 {
lab=VDD}
N 7090 -5480 7290 -5480 {
lab=VDD}
N 7290 -5480 7300 -5470 {
lab=VDD}
N 7080 -5450 7090 -5460 {
lab=VSS}
N 7090 -5460 7290 -5460 {
lab=VSS}
N 7290 -5460 7300 -5450 {
lab=VSS}
N 7080 -5430 7090 -5440 {
lab=VDD}
N 7090 -5440 7290 -5440 {
lab=VDD}
N 7290 -5440 7300 -5430 {
lab=VDD}
N 7300 -5430 7320 -5430 {
lab=VDD}
N 7300 -5450 7320 -5450 {
lab=VSS}
N 7300 -5470 7320 -5470 {
lab=VDD}
N 7300 -5490 7320 -5490 {
lab=VDD}
N 7060 -5490 7080 -5490 {
lab=VDD}
N 7060 -5470 7080 -5470 {
lab=VDD}
N 7060 -5450 7080 -5450 {
lab=VSS}
N 7060 -5430 7080 -5430 {
lab=VDD}
N 7120 -5350 7120 -5340 {
lab=VSS}
N 7140 -5590 7140 -5570 {
lab=vcm}
N 7120 -5580 7120 -5570 {
lab=VDD}
N 7200 -5350 7200 -5330 {
lab=col_n[25]}
N 7460 -5350 7470 -5360 {
lab=col_n[26]}
N 7470 -5560 7470 -5360 {
lab=col_n[26]}
N 7460 -5570 7470 -5560 {
lab=col_n[26]}
N 7460 -5590 7460 -5570 {
lab=col_n[26]}
N 7340 -5490 7350 -5500 {
lab=VDD}
N 7350 -5500 7550 -5500 {
lab=VDD}
N 7550 -5500 7560 -5490 {
lab=VDD}
N 7340 -5470 7350 -5480 {
lab=VDD}
N 7350 -5480 7550 -5480 {
lab=VDD}
N 7550 -5480 7560 -5470 {
lab=VDD}
N 7340 -5450 7350 -5460 {
lab=VSS}
N 7350 -5460 7550 -5460 {
lab=VSS}
N 7550 -5460 7560 -5450 {
lab=VSS}
N 7340 -5430 7350 -5440 {
lab=VDD}
N 7350 -5440 7550 -5440 {
lab=VDD}
N 7550 -5440 7560 -5430 {
lab=VDD}
N 7560 -5430 7580 -5430 {
lab=VDD}
N 7560 -5450 7580 -5450 {
lab=VSS}
N 7560 -5470 7580 -5470 {
lab=VDD}
N 7560 -5490 7580 -5490 {
lab=VDD}
N 7320 -5490 7340 -5490 {
lab=VDD}
N 7320 -5470 7340 -5470 {
lab=VDD}
N 7320 -5450 7340 -5450 {
lab=VSS}
N 7320 -5430 7340 -5430 {
lab=VDD}
N 7380 -5350 7380 -5340 {
lab=VSS}
N 7400 -5590 7400 -5570 {
lab=vcm}
N 7380 -5580 7380 -5570 {
lab=VDD}
N 7460 -5350 7460 -5330 {
lab=col_n[26]}
N 7180 -5590 7180 -5570 {
lab=ctop}
N 7440 -5590 7440 -5570 {
lab=ctop}
N 7720 -5350 7730 -5360 {
lab=col_n[27]}
N 7730 -5560 7730 -5360 {
lab=col_n[27]}
N 7720 -5570 7730 -5560 {
lab=col_n[27]}
N 7720 -5590 7720 -5570 {
lab=col_n[27]}
N 7600 -5490 7610 -5500 {
lab=VDD}
N 7610 -5500 7810 -5500 {
lab=VDD}
N 7810 -5500 7820 -5490 {
lab=VDD}
N 7600 -5470 7610 -5480 {
lab=VDD}
N 7610 -5480 7810 -5480 {
lab=VDD}
N 7810 -5480 7820 -5470 {
lab=VDD}
N 7600 -5450 7610 -5460 {
lab=VSS}
N 7610 -5460 7810 -5460 {
lab=VSS}
N 7810 -5460 7820 -5450 {
lab=VSS}
N 7600 -5430 7610 -5440 {
lab=VDD}
N 7610 -5440 7810 -5440 {
lab=VDD}
N 7810 -5440 7820 -5430 {
lab=VDD}
N 7820 -5430 7840 -5430 {
lab=VDD}
N 7820 -5450 7840 -5450 {
lab=VSS}
N 7820 -5470 7840 -5470 {
lab=VDD}
N 7820 -5490 7840 -5490 {
lab=VDD}
N 7580 -5490 7600 -5490 {
lab=VDD}
N 7580 -5470 7600 -5470 {
lab=VDD}
N 7580 -5450 7600 -5450 {
lab=VSS}
N 7580 -5430 7600 -5430 {
lab=VDD}
N 7640 -5350 7640 -5340 {
lab=VSS}
N 7660 -5590 7660 -5570 {
lab=vcm}
N 7640 -5580 7640 -5570 {
lab=VDD}
N 7720 -5350 7720 -5330 {
lab=col_n[27]}
N 7980 -5350 7990 -5360 {
lab=col_n[28]}
N 7990 -5560 7990 -5360 {
lab=col_n[28]}
N 7980 -5570 7990 -5560 {
lab=col_n[28]}
N 7980 -5590 7980 -5570 {
lab=col_n[28]}
N 7860 -5490 7870 -5500 {
lab=VDD}
N 7870 -5500 8070 -5500 {
lab=VDD}
N 8070 -5500 8080 -5490 {
lab=VDD}
N 7860 -5470 7870 -5480 {
lab=VDD}
N 7870 -5480 8070 -5480 {
lab=VDD}
N 8070 -5480 8080 -5470 {
lab=VDD}
N 7860 -5450 7870 -5460 {
lab=VSS}
N 7870 -5460 8070 -5460 {
lab=VSS}
N 8070 -5460 8080 -5450 {
lab=VSS}
N 7860 -5430 7870 -5440 {
lab=VDD}
N 7870 -5440 8070 -5440 {
lab=VDD}
N 8070 -5440 8080 -5430 {
lab=VDD}
N 8080 -5430 8100 -5430 {
lab=VDD}
N 8080 -5450 8100 -5450 {
lab=VSS}
N 8080 -5470 8100 -5470 {
lab=VDD}
N 8080 -5490 8100 -5490 {
lab=VDD}
N 7840 -5490 7860 -5490 {
lab=VDD}
N 7840 -5470 7860 -5470 {
lab=VDD}
N 7840 -5450 7860 -5450 {
lab=VSS}
N 7840 -5430 7860 -5430 {
lab=VDD}
N 7900 -5350 7900 -5340 {
lab=VSS}
N 7920 -5590 7920 -5570 {
lab=vcm}
N 7900 -5580 7900 -5570 {
lab=VDD}
N 7980 -5350 7980 -5330 {
lab=col_n[28]}
N 7700 -5590 7700 -5570 {
lab=ctop}
N 7960 -5590 7960 -5570 {
lab=ctop}
N 8240 -5350 8250 -5360 {
lab=col_n[29]}
N 8250 -5560 8250 -5360 {
lab=col_n[29]}
N 8240 -5570 8250 -5560 {
lab=col_n[29]}
N 8240 -5590 8240 -5570 {
lab=col_n[29]}
N 8120 -5490 8130 -5500 {
lab=VDD}
N 8130 -5500 8330 -5500 {
lab=VDD}
N 8330 -5500 8340 -5490 {
lab=VDD}
N 8120 -5470 8130 -5480 {
lab=VDD}
N 8130 -5480 8330 -5480 {
lab=VDD}
N 8330 -5480 8340 -5470 {
lab=VDD}
N 8120 -5450 8130 -5460 {
lab=VSS}
N 8130 -5460 8330 -5460 {
lab=VSS}
N 8330 -5460 8340 -5450 {
lab=VSS}
N 8120 -5430 8130 -5440 {
lab=VDD}
N 8130 -5440 8330 -5440 {
lab=VDD}
N 8330 -5440 8340 -5430 {
lab=VDD}
N 8340 -5430 8360 -5430 {
lab=VDD}
N 8340 -5450 8360 -5450 {
lab=VSS}
N 8340 -5470 8360 -5470 {
lab=VDD}
N 8340 -5490 8360 -5490 {
lab=VDD}
N 8100 -5490 8120 -5490 {
lab=VDD}
N 8100 -5470 8120 -5470 {
lab=VDD}
N 8100 -5450 8120 -5450 {
lab=VSS}
N 8100 -5430 8120 -5430 {
lab=VDD}
N 8160 -5350 8160 -5340 {
lab=VSS}
N 8180 -5590 8180 -5570 {
lab=vcm}
N 8160 -5580 8160 -5570 {
lab=VDD}
N 8240 -5350 8240 -5330 {
lab=col_n[29]}
N 8500 -5350 8510 -5360 {
lab=col_n[30]}
N 8510 -5560 8510 -5360 {
lab=col_n[30]}
N 8500 -5570 8510 -5560 {
lab=col_n[30]}
N 8500 -5590 8500 -5570 {
lab=col_n[30]}
N 8380 -5490 8390 -5500 {
lab=VDD}
N 8390 -5500 8590 -5500 {
lab=VDD}
N 8590 -5500 8600 -5490 {
lab=VDD}
N 8380 -5470 8390 -5480 {
lab=VDD}
N 8390 -5480 8590 -5480 {
lab=VDD}
N 8590 -5480 8600 -5470 {
lab=VDD}
N 8380 -5450 8390 -5460 {
lab=VSS}
N 8390 -5460 8590 -5460 {
lab=VSS}
N 8590 -5460 8600 -5450 {
lab=VSS}
N 8380 -5430 8390 -5440 {
lab=VDD}
N 8390 -5440 8590 -5440 {
lab=VDD}
N 8590 -5440 8600 -5430 {
lab=VDD}
N 8600 -5430 8620 -5430 {
lab=VDD}
N 8600 -5450 8620 -5450 {
lab=VSS}
N 8600 -5470 8620 -5470 {
lab=VDD}
N 8600 -5490 8620 -5490 {
lab=VDD}
N 8360 -5490 8380 -5490 {
lab=VDD}
N 8360 -5470 8380 -5470 {
lab=VDD}
N 8360 -5450 8380 -5450 {
lab=VSS}
N 8360 -5430 8380 -5430 {
lab=VDD}
N 8420 -5350 8420 -5340 {
lab=VSS}
N 8440 -5590 8440 -5570 {
lab=vcm}
N 8420 -5580 8420 -5570 {
lab=VDD}
N 8500 -5350 8500 -5330 {
lab=col_n[30]}
N 8220 -5590 8220 -5570 {
lab=ctop}
N 8480 -5590 8480 -5570 {
lab=ctop}
N 8760 -5350 8770 -5360 {
lab=col_n[31]}
N 8770 -5560 8770 -5360 {
lab=col_n[31]}
N 8760 -5570 8770 -5560 {
lab=col_n[31]}
N 8760 -5590 8760 -5570 {
lab=col_n[31]}
N 8640 -5490 8650 -5500 {
lab=VDD}
N 8650 -5500 8850 -5500 {
lab=VDD}
N 8850 -5500 8860 -5490 {
lab=VDD}
N 8640 -5470 8650 -5480 {
lab=VDD}
N 8650 -5480 8850 -5480 {
lab=VDD}
N 8850 -5480 8860 -5470 {
lab=VDD}
N 8640 -5450 8650 -5460 {
lab=VSS}
N 8650 -5460 8850 -5460 {
lab=VSS}
N 8850 -5460 8860 -5450 {
lab=VSS}
N 8640 -5430 8650 -5440 {
lab=VDD}
N 8650 -5440 8850 -5440 {
lab=VDD}
N 8850 -5440 8860 -5430 {
lab=VDD}
N 8860 -5430 8880 -5430 {
lab=VDD}
N 8860 -5450 8880 -5450 {
lab=VSS}
N 8860 -5470 8880 -5470 {
lab=VDD}
N 8860 -5490 8880 -5490 {
lab=VDD}
N 8620 -5490 8640 -5490 {
lab=VDD}
N 8620 -5470 8640 -5470 {
lab=VDD}
N 8620 -5450 8640 -5450 {
lab=VSS}
N 8620 -5430 8640 -5430 {
lab=VDD}
N 8680 -5350 8680 -5340 {
lab=VSS}
N 8700 -5590 8700 -5570 {
lab=vcm}
N 8680 -5580 8680 -5570 {
lab=VDD}
N 8760 -5350 8760 -5330 {
lab=col_n[31]}
N 8740 -5590 8740 -5570 {
lab=ctop}
N 9020 -5350 9030 -5360 {
lab=VDD}
N 9030 -5560 9030 -5360 {
lab=VDD}
N 9020 -5570 9030 -5560 {
lab=VDD}
N 9020 -5590 9020 -5570 {
lab=VDD}
N 8900 -5490 8910 -5500 {
lab=VDD}
N 8910 -5500 9110 -5500 {
lab=VDD}
N 9110 -5500 9120 -5490 {
lab=VDD}
N 8900 -5470 8910 -5480 {
lab=VDD}
N 8910 -5480 9110 -5480 {
lab=VDD}
N 9110 -5480 9120 -5470 {
lab=VDD}
N 8900 -5450 8910 -5460 {
lab=VSS}
N 8910 -5460 9110 -5460 {
lab=VSS}
N 9110 -5460 9120 -5450 {
lab=VSS}
N 8900 -5430 8910 -5440 {
lab=VDD}
N 8910 -5440 9110 -5440 {
lab=VDD}
N 9110 -5440 9120 -5430 {
lab=VDD}
N 9120 -5430 9140 -5430 {
lab=VDD}
N 9120 -5450 9140 -5450 {
lab=VSS}
N 9120 -5470 9140 -5470 {
lab=VDD}
N 9120 -5490 9140 -5490 {
lab=VDD}
N 8880 -5490 8900 -5490 {
lab=VDD}
N 8880 -5470 8900 -5470 {
lab=VDD}
N 8880 -5450 8900 -5450 {
lab=VSS}
N 8880 -5430 8900 -5430 {
lab=VDD}
N 8940 -5350 8940 -5340 {
lab=VSS}
N 8960 -5590 8960 -5570 {
lab=vcm}
N 8940 -5580 8940 -5570 {
lab=VDD}
N 9020 -5350 9020 -5330 {
lab=VDD}
N 9000 -5590 9000 -5570 {
lab=ctop}
N 9020 -1190 9030 -1200 {
lab=VDD}
N 9030 -1400 9030 -1200 {
lab=VDD}
N 9020 -1410 9030 -1400 {
lab=VDD}
N 9020 -1430 9020 -1410 {
lab=VDD}
N 8900 -1330 8910 -1340 {
lab=row_n[0]}
N 8910 -1340 9110 -1340 {
lab=row_n[0]}
N 9110 -1340 9120 -1330 {
lab=row_n[0]}
N 8900 -1310 8910 -1320 {
lab=rowon_n[0]}
N 8910 -1320 9110 -1320 {
lab=rowon_n[0]}
N 9110 -1320 9120 -1310 {
lab=rowon_n[0]}
N 8900 -1290 8910 -1300 {
lab=#net1}
N 8910 -1300 9110 -1300 {
lab=#net1}
N 9110 -1300 9120 -1290 {
lab=#net1}
N 8900 -1270 8910 -1280 {
lab=#net2}
N 8910 -1280 9110 -1280 {
lab=#net2}
N 9110 -1280 9120 -1270 {
lab=#net2}
N 9120 -1270 9140 -1270 {
lab=#net2}
N 9120 -1290 9140 -1290 {
lab=#net1}
N 9120 -1310 9140 -1310 {
lab=rowon_n[0]}
N 9120 -1330 9140 -1330 {
lab=row_n[0]}
N 8880 -1330 8900 -1330 {
lab=row_n[0]}
N 8880 -1310 8900 -1310 {
lab=rowon_n[0]}
N 8880 -1290 8900 -1290 {
lab=#net1}
N 8880 -1270 8900 -1270 {
lab=#net2}
N 8940 -1190 8940 -1180 {
lab=VSS}
N 8960 -1430 8960 -1410 {
lab=vcm}
N 8940 -1420 8940 -1410 {
lab=VDD}
N 9000 -1430 9000 -1410 {
lab=ctop}
N 9020 -1190 9020 -1170 {
lab=VDD}
N 9020 -1450 9030 -1460 {
lab=VDD}
N 9030 -1660 9030 -1460 {
lab=VDD}
N 9020 -1670 9030 -1660 {
lab=VDD}
N 9020 -1690 9020 -1670 {
lab=VDD}
N 8900 -1590 8910 -1600 {
lab=row_n[1]}
N 8910 -1600 9110 -1600 {
lab=row_n[1]}
N 9110 -1600 9120 -1590 {
lab=row_n[1]}
N 8900 -1570 8910 -1580 {
lab=rowon_n[1]}
N 8910 -1580 9110 -1580 {
lab=rowon_n[1]}
N 9110 -1580 9120 -1570 {
lab=rowon_n[1]}
N 8900 -1550 8910 -1560 {
lab=#net3}
N 8910 -1560 9110 -1560 {
lab=#net3}
N 9110 -1560 9120 -1550 {
lab=#net3}
N 8900 -1530 8910 -1540 {
lab=#net4}
N 8910 -1540 9110 -1540 {
lab=#net4}
N 9110 -1540 9120 -1530 {
lab=#net4}
N 9120 -1530 9140 -1530 {
lab=#net4}
N 9120 -1550 9140 -1550 {
lab=#net3}
N 9120 -1570 9140 -1570 {
lab=rowon_n[1]}
N 9120 -1590 9140 -1590 {
lab=row_n[1]}
N 8880 -1590 8900 -1590 {
lab=row_n[1]}
N 8880 -1570 8900 -1570 {
lab=rowon_n[1]}
N 8880 -1550 8900 -1550 {
lab=#net3}
N 8880 -1530 8900 -1530 {
lab=#net4}
N 8940 -1450 8940 -1440 {
lab=VSS}
N 8960 -1690 8960 -1670 {
lab=vcm}
N 8940 -1680 8940 -1670 {
lab=VDD}
N 9000 -1690 9000 -1670 {
lab=ctop}
N 9020 -1450 9020 -1430 {
lab=VDD}
N 9020 -1710 9030 -1720 {
lab=VDD}
N 9030 -1920 9030 -1720 {
lab=VDD}
N 9020 -1930 9030 -1920 {
lab=VDD}
N 9020 -1950 9020 -1930 {
lab=VDD}
N 8900 -1850 8910 -1860 {
lab=row_n[2]}
N 8910 -1860 9110 -1860 {
lab=row_n[2]}
N 9110 -1860 9120 -1850 {
lab=row_n[2]}
N 8900 -1830 8910 -1840 {
lab=rowon_n[2]}
N 8910 -1840 9110 -1840 {
lab=rowon_n[2]}
N 9110 -1840 9120 -1830 {
lab=rowon_n[2]}
N 8900 -1810 8910 -1820 {
lab=#net5}
N 8910 -1820 9110 -1820 {
lab=#net5}
N 9110 -1820 9120 -1810 {
lab=#net5}
N 8900 -1790 8910 -1800 {
lab=#net6}
N 8910 -1800 9110 -1800 {
lab=#net6}
N 9110 -1800 9120 -1790 {
lab=#net6}
N 9120 -1790 9140 -1790 {
lab=#net6}
N 9120 -1810 9140 -1810 {
lab=#net5}
N 9120 -1830 9140 -1830 {
lab=rowon_n[2]}
N 9120 -1850 9140 -1850 {
lab=row_n[2]}
N 8880 -1850 8900 -1850 {
lab=row_n[2]}
N 8880 -1830 8900 -1830 {
lab=rowon_n[2]}
N 8880 -1810 8900 -1810 {
lab=#net5}
N 8880 -1790 8900 -1790 {
lab=#net6}
N 8940 -1710 8940 -1700 {
lab=VSS}
N 8960 -1950 8960 -1930 {
lab=vcm}
N 8940 -1940 8940 -1930 {
lab=VDD}
N 9000 -1950 9000 -1930 {
lab=ctop}
N 9020 -1710 9020 -1690 {
lab=VDD}
N 9020 -1970 9030 -1980 {
lab=VDD}
N 9030 -2180 9030 -1980 {
lab=VDD}
N 9020 -2190 9030 -2180 {
lab=VDD}
N 9020 -2210 9020 -2190 {
lab=VDD}
N 8900 -2110 8910 -2120 {
lab=row_n[3]}
N 8910 -2120 9110 -2120 {
lab=row_n[3]}
N 9110 -2120 9120 -2110 {
lab=row_n[3]}
N 8900 -2090 8910 -2100 {
lab=rowon_n[3]}
N 8910 -2100 9110 -2100 {
lab=rowon_n[3]}
N 9110 -2100 9120 -2090 {
lab=rowon_n[3]}
N 8900 -2070 8910 -2080 {
lab=#net7}
N 8910 -2080 9110 -2080 {
lab=#net7}
N 9110 -2080 9120 -2070 {
lab=#net7}
N 8900 -2050 8910 -2060 {
lab=#net8}
N 8910 -2060 9110 -2060 {
lab=#net8}
N 9110 -2060 9120 -2050 {
lab=#net8}
N 9120 -2050 9140 -2050 {
lab=#net8}
N 9120 -2070 9140 -2070 {
lab=#net7}
N 9120 -2090 9140 -2090 {
lab=rowon_n[3]}
N 9120 -2110 9140 -2110 {
lab=row_n[3]}
N 8880 -2110 8900 -2110 {
lab=row_n[3]}
N 8880 -2090 8900 -2090 {
lab=rowon_n[3]}
N 8880 -2070 8900 -2070 {
lab=#net7}
N 8880 -2050 8900 -2050 {
lab=#net8}
N 8940 -1970 8940 -1960 {
lab=VSS}
N 8960 -2210 8960 -2190 {
lab=vcm}
N 8940 -2200 8940 -2190 {
lab=VDD}
N 9000 -2210 9000 -2190 {
lab=ctop}
N 9020 -1970 9020 -1950 {
lab=VDD}
N 9020 -2230 9030 -2240 {
lab=VDD}
N 9030 -2440 9030 -2240 {
lab=VDD}
N 9020 -2450 9030 -2440 {
lab=VDD}
N 9020 -2470 9020 -2450 {
lab=VDD}
N 8900 -2370 8910 -2380 {
lab=row_n[4]}
N 8910 -2380 9110 -2380 {
lab=row_n[4]}
N 9110 -2380 9120 -2370 {
lab=row_n[4]}
N 8900 -2350 8910 -2360 {
lab=rowon_n[4]}
N 8910 -2360 9110 -2360 {
lab=rowon_n[4]}
N 9110 -2360 9120 -2350 {
lab=rowon_n[4]}
N 8900 -2330 8910 -2340 {
lab=#net9}
N 8910 -2340 9110 -2340 {
lab=#net9}
N 9110 -2340 9120 -2330 {
lab=#net9}
N 8900 -2310 8910 -2320 {
lab=#net10}
N 8910 -2320 9110 -2320 {
lab=#net10}
N 9110 -2320 9120 -2310 {
lab=#net10}
N 9120 -2310 9140 -2310 {
lab=#net10}
N 9120 -2330 9140 -2330 {
lab=#net9}
N 9120 -2350 9140 -2350 {
lab=rowon_n[4]}
N 9120 -2370 9140 -2370 {
lab=row_n[4]}
N 8880 -2370 8900 -2370 {
lab=row_n[4]}
N 8880 -2350 8900 -2350 {
lab=rowon_n[4]}
N 8880 -2330 8900 -2330 {
lab=#net9}
N 8880 -2310 8900 -2310 {
lab=#net10}
N 8940 -2230 8940 -2220 {
lab=VSS}
N 8960 -2470 8960 -2450 {
lab=vcm}
N 8940 -2460 8940 -2450 {
lab=VDD}
N 9000 -2470 9000 -2450 {
lab=ctop}
N 9020 -2230 9020 -2210 {
lab=VDD}
N 9020 -2490 9030 -2500 {
lab=VDD}
N 9030 -2700 9030 -2500 {
lab=VDD}
N 9020 -2710 9030 -2700 {
lab=VDD}
N 9020 -2730 9020 -2710 {
lab=VDD}
N 8900 -2630 8910 -2640 {
lab=row_n[5]}
N 8910 -2640 9110 -2640 {
lab=row_n[5]}
N 9110 -2640 9120 -2630 {
lab=row_n[5]}
N 8900 -2610 8910 -2620 {
lab=rowon_n[5]}
N 8910 -2620 9110 -2620 {
lab=rowon_n[5]}
N 9110 -2620 9120 -2610 {
lab=rowon_n[5]}
N 8900 -2590 8910 -2600 {
lab=#net11}
N 8910 -2600 9110 -2600 {
lab=#net11}
N 9110 -2600 9120 -2590 {
lab=#net11}
N 8900 -2570 8910 -2580 {
lab=#net12}
N 8910 -2580 9110 -2580 {
lab=#net12}
N 9110 -2580 9120 -2570 {
lab=#net12}
N 9120 -2570 9140 -2570 {
lab=#net12}
N 9120 -2590 9140 -2590 {
lab=#net11}
N 9120 -2610 9140 -2610 {
lab=rowon_n[5]}
N 9120 -2630 9140 -2630 {
lab=row_n[5]}
N 8880 -2630 8900 -2630 {
lab=row_n[5]}
N 8880 -2610 8900 -2610 {
lab=rowon_n[5]}
N 8880 -2590 8900 -2590 {
lab=#net11}
N 8880 -2570 8900 -2570 {
lab=#net12}
N 8940 -2490 8940 -2480 {
lab=VSS}
N 8960 -2730 8960 -2710 {
lab=vcm}
N 8940 -2720 8940 -2710 {
lab=VDD}
N 9000 -2730 9000 -2710 {
lab=ctop}
N 9020 -2490 9020 -2470 {
lab=VDD}
N 9020 -2750 9030 -2760 {
lab=VDD}
N 9030 -2960 9030 -2760 {
lab=VDD}
N 9020 -2970 9030 -2960 {
lab=VDD}
N 9020 -2990 9020 -2970 {
lab=VDD}
N 8900 -2890 8910 -2900 {
lab=row_n[6]}
N 8910 -2900 9110 -2900 {
lab=row_n[6]}
N 9110 -2900 9120 -2890 {
lab=row_n[6]}
N 8900 -2870 8910 -2880 {
lab=rowon_n[6]}
N 8910 -2880 9110 -2880 {
lab=rowon_n[6]}
N 9110 -2880 9120 -2870 {
lab=rowon_n[6]}
N 8900 -2850 8910 -2860 {
lab=#net13}
N 8910 -2860 9110 -2860 {
lab=#net13}
N 9110 -2860 9120 -2850 {
lab=#net13}
N 8900 -2830 8910 -2840 {
lab=#net14}
N 8910 -2840 9110 -2840 {
lab=#net14}
N 9110 -2840 9120 -2830 {
lab=#net14}
N 9120 -2830 9140 -2830 {
lab=#net14}
N 9120 -2850 9140 -2850 {
lab=#net13}
N 9120 -2870 9140 -2870 {
lab=rowon_n[6]}
N 9120 -2890 9140 -2890 {
lab=row_n[6]}
N 8880 -2890 8900 -2890 {
lab=row_n[6]}
N 8880 -2870 8900 -2870 {
lab=rowon_n[6]}
N 8880 -2850 8900 -2850 {
lab=#net13}
N 8880 -2830 8900 -2830 {
lab=#net14}
N 8940 -2750 8940 -2740 {
lab=VSS}
N 8960 -2990 8960 -2970 {
lab=vcm}
N 8940 -2980 8940 -2970 {
lab=VDD}
N 9000 -2990 9000 -2970 {
lab=ctop}
N 9020 -2750 9020 -2730 {
lab=VDD}
N 9020 -3010 9030 -3020 {
lab=VDD}
N 9030 -3220 9030 -3020 {
lab=VDD}
N 9020 -3230 9030 -3220 {
lab=VDD}
N 9020 -3250 9020 -3230 {
lab=VDD}
N 8900 -3150 8910 -3160 {
lab=row_n[7]}
N 8910 -3160 9110 -3160 {
lab=row_n[7]}
N 9110 -3160 9120 -3150 {
lab=row_n[7]}
N 8900 -3130 8910 -3140 {
lab=rowon_n[7]}
N 8910 -3140 9110 -3140 {
lab=rowon_n[7]}
N 9110 -3140 9120 -3130 {
lab=rowon_n[7]}
N 8900 -3110 8910 -3120 {
lab=#net15}
N 8910 -3120 9110 -3120 {
lab=#net15}
N 9110 -3120 9120 -3110 {
lab=#net15}
N 8900 -3090 8910 -3100 {
lab=#net16}
N 8910 -3100 9110 -3100 {
lab=#net16}
N 9110 -3100 9120 -3090 {
lab=#net16}
N 9120 -3090 9140 -3090 {
lab=#net16}
N 9120 -3110 9140 -3110 {
lab=#net15}
N 9120 -3130 9140 -3130 {
lab=rowon_n[7]}
N 9120 -3150 9140 -3150 {
lab=row_n[7]}
N 8880 -3150 8900 -3150 {
lab=row_n[7]}
N 8880 -3130 8900 -3130 {
lab=rowon_n[7]}
N 8880 -3110 8900 -3110 {
lab=#net15}
N 8880 -3090 8900 -3090 {
lab=#net16}
N 8940 -3010 8940 -3000 {
lab=VSS}
N 8960 -3250 8960 -3230 {
lab=vcm}
N 8940 -3240 8940 -3230 {
lab=VDD}
N 9000 -3250 9000 -3230 {
lab=ctop}
N 9020 -3010 9020 -2990 {
lab=VDD}
N 9020 -3270 9030 -3280 {
lab=VDD}
N 9030 -3480 9030 -3280 {
lab=VDD}
N 9020 -3490 9030 -3480 {
lab=VDD}
N 9020 -3510 9020 -3490 {
lab=VDD}
N 8900 -3410 8910 -3420 {
lab=row_n[8]}
N 8910 -3420 9110 -3420 {
lab=row_n[8]}
N 9110 -3420 9120 -3410 {
lab=row_n[8]}
N 8900 -3390 8910 -3400 {
lab=rowon_n[8]}
N 8910 -3400 9110 -3400 {
lab=rowon_n[8]}
N 9110 -3400 9120 -3390 {
lab=rowon_n[8]}
N 8900 -3370 8910 -3380 {
lab=#net17}
N 8910 -3380 9110 -3380 {
lab=#net17}
N 9110 -3380 9120 -3370 {
lab=#net17}
N 8900 -3350 8910 -3360 {
lab=#net18}
N 8910 -3360 9110 -3360 {
lab=#net18}
N 9110 -3360 9120 -3350 {
lab=#net18}
N 9120 -3350 9140 -3350 {
lab=#net18}
N 9120 -3370 9140 -3370 {
lab=#net17}
N 9120 -3390 9140 -3390 {
lab=rowon_n[8]}
N 9120 -3410 9140 -3410 {
lab=row_n[8]}
N 8880 -3410 8900 -3410 {
lab=row_n[8]}
N 8880 -3390 8900 -3390 {
lab=rowon_n[8]}
N 8880 -3370 8900 -3370 {
lab=#net17}
N 8880 -3350 8900 -3350 {
lab=#net18}
N 8940 -3270 8940 -3260 {
lab=VSS}
N 8960 -3510 8960 -3490 {
lab=vcm}
N 8940 -3500 8940 -3490 {
lab=VDD}
N 9000 -3510 9000 -3490 {
lab=ctop}
N 9020 -3270 9020 -3250 {
lab=VDD}
N 9020 -3530 9030 -3540 {
lab=VDD}
N 9030 -3740 9030 -3540 {
lab=VDD}
N 9020 -3750 9030 -3740 {
lab=VDD}
N 9020 -3770 9020 -3750 {
lab=VDD}
N 8900 -3670 8910 -3680 {
lab=row_n[9]}
N 8910 -3680 9110 -3680 {
lab=row_n[9]}
N 9110 -3680 9120 -3670 {
lab=row_n[9]}
N 8900 -3650 8910 -3660 {
lab=rowon_n[9]}
N 8910 -3660 9110 -3660 {
lab=rowon_n[9]}
N 9110 -3660 9120 -3650 {
lab=rowon_n[9]}
N 8900 -3630 8910 -3640 {
lab=#net19}
N 8910 -3640 9110 -3640 {
lab=#net19}
N 9110 -3640 9120 -3630 {
lab=#net19}
N 8900 -3610 8910 -3620 {
lab=#net20}
N 8910 -3620 9110 -3620 {
lab=#net20}
N 9110 -3620 9120 -3610 {
lab=#net20}
N 9120 -3610 9140 -3610 {
lab=#net20}
N 9120 -3630 9140 -3630 {
lab=#net19}
N 9120 -3650 9140 -3650 {
lab=rowon_n[9]}
N 9120 -3670 9140 -3670 {
lab=row_n[9]}
N 8880 -3670 8900 -3670 {
lab=row_n[9]}
N 8880 -3650 8900 -3650 {
lab=rowon_n[9]}
N 8880 -3630 8900 -3630 {
lab=#net19}
N 8880 -3610 8900 -3610 {
lab=#net20}
N 8940 -3530 8940 -3520 {
lab=VSS}
N 8960 -3770 8960 -3750 {
lab=vcm}
N 8940 -3760 8940 -3750 {
lab=VDD}
N 9000 -3770 9000 -3750 {
lab=ctop}
N 9020 -3530 9020 -3510 {
lab=VDD}
N 9020 -3790 9030 -3800 {
lab=VDD}
N 9030 -4000 9030 -3800 {
lab=VDD}
N 9020 -4010 9030 -4000 {
lab=VDD}
N 9020 -4030 9020 -4010 {
lab=VDD}
N 8900 -3930 8910 -3940 {
lab=row_n[10]}
N 8910 -3940 9110 -3940 {
lab=row_n[10]}
N 9110 -3940 9120 -3930 {
lab=row_n[10]}
N 8900 -3910 8910 -3920 {
lab=rowon_n[10]}
N 8910 -3920 9110 -3920 {
lab=rowon_n[10]}
N 9110 -3920 9120 -3910 {
lab=rowon_n[10]}
N 8900 -3890 8910 -3900 {
lab=#net21}
N 8910 -3900 9110 -3900 {
lab=#net21}
N 9110 -3900 9120 -3890 {
lab=#net21}
N 8900 -3870 8910 -3880 {
lab=#net22}
N 8910 -3880 9110 -3880 {
lab=#net22}
N 9110 -3880 9120 -3870 {
lab=#net22}
N 9120 -3870 9140 -3870 {
lab=#net22}
N 9120 -3890 9140 -3890 {
lab=#net21}
N 9120 -3910 9140 -3910 {
lab=rowon_n[10]}
N 9120 -3930 9140 -3930 {
lab=row_n[10]}
N 8880 -3930 8900 -3930 {
lab=row_n[10]}
N 8880 -3910 8900 -3910 {
lab=rowon_n[10]}
N 8880 -3890 8900 -3890 {
lab=#net21}
N 8880 -3870 8900 -3870 {
lab=#net22}
N 8940 -3790 8940 -3780 {
lab=VSS}
N 8960 -4030 8960 -4010 {
lab=vcm}
N 8940 -4020 8940 -4010 {
lab=VDD}
N 9000 -4030 9000 -4010 {
lab=ctop}
N 9020 -3790 9020 -3770 {
lab=VDD}
N 9020 -4050 9030 -4060 {
lab=VDD}
N 9030 -4260 9030 -4060 {
lab=VDD}
N 9020 -4270 9030 -4260 {
lab=VDD}
N 9020 -4290 9020 -4270 {
lab=VDD}
N 8900 -4190 8910 -4200 {
lab=row_n[11]}
N 8910 -4200 9110 -4200 {
lab=row_n[11]}
N 9110 -4200 9120 -4190 {
lab=row_n[11]}
N 8900 -4170 8910 -4180 {
lab=rowon_n[11]}
N 8910 -4180 9110 -4180 {
lab=rowon_n[11]}
N 9110 -4180 9120 -4170 {
lab=rowon_n[11]}
N 8900 -4150 8910 -4160 {
lab=#net23}
N 8910 -4160 9110 -4160 {
lab=#net23}
N 9110 -4160 9120 -4150 {
lab=#net23}
N 8900 -4130 8910 -4140 {
lab=#net24}
N 8910 -4140 9110 -4140 {
lab=#net24}
N 9110 -4140 9120 -4130 {
lab=#net24}
N 9120 -4130 9140 -4130 {
lab=#net24}
N 9120 -4150 9140 -4150 {
lab=#net23}
N 9120 -4170 9140 -4170 {
lab=rowon_n[11]}
N 9120 -4190 9140 -4190 {
lab=row_n[11]}
N 8880 -4190 8900 -4190 {
lab=row_n[11]}
N 8880 -4170 8900 -4170 {
lab=rowon_n[11]}
N 8880 -4150 8900 -4150 {
lab=#net23}
N 8880 -4130 8900 -4130 {
lab=#net24}
N 8940 -4050 8940 -4040 {
lab=VSS}
N 8960 -4290 8960 -4270 {
lab=vcm}
N 8940 -4280 8940 -4270 {
lab=VDD}
N 9000 -4290 9000 -4270 {
lab=ctop}
N 9020 -4050 9020 -4030 {
lab=VDD}
N 9020 -4310 9030 -4320 {
lab=VDD}
N 9030 -4520 9030 -4320 {
lab=VDD}
N 9020 -4530 9030 -4520 {
lab=VDD}
N 9020 -4550 9020 -4530 {
lab=VDD}
N 8900 -4450 8910 -4460 {
lab=row_n[12]}
N 8910 -4460 9110 -4460 {
lab=row_n[12]}
N 9110 -4460 9120 -4450 {
lab=row_n[12]}
N 8900 -4430 8910 -4440 {
lab=rowon_n[12]}
N 8910 -4440 9110 -4440 {
lab=rowon_n[12]}
N 9110 -4440 9120 -4430 {
lab=rowon_n[12]}
N 8900 -4410 8910 -4420 {
lab=#net25}
N 8910 -4420 9110 -4420 {
lab=#net25}
N 9110 -4420 9120 -4410 {
lab=#net25}
N 8900 -4390 8910 -4400 {
lab=#net26}
N 8910 -4400 9110 -4400 {
lab=#net26}
N 9110 -4400 9120 -4390 {
lab=#net26}
N 9120 -4390 9140 -4390 {
lab=#net26}
N 9120 -4410 9140 -4410 {
lab=#net25}
N 9120 -4430 9140 -4430 {
lab=rowon_n[12]}
N 9120 -4450 9140 -4450 {
lab=row_n[12]}
N 8880 -4450 8900 -4450 {
lab=row_n[12]}
N 8880 -4430 8900 -4430 {
lab=rowon_n[12]}
N 8880 -4410 8900 -4410 {
lab=#net25}
N 8880 -4390 8900 -4390 {
lab=#net26}
N 8960 -4550 8960 -4530 {
lab=vcm}
N 8940 -4540 8940 -4530 {
lab=VDD}
N 9000 -4550 9000 -4530 {
lab=ctop}
N 9020 -4310 9020 -4290 {
lab=VDD}
N 9020 -4570 9030 -4580 {
lab=VDD}
N 9030 -4780 9030 -4580 {
lab=VDD}
N 9020 -4790 9030 -4780 {
lab=VDD}
N 9020 -4810 9020 -4790 {
lab=VDD}
N 8900 -4710 8910 -4720 {
lab=row_n[13]}
N 8910 -4720 9110 -4720 {
lab=row_n[13]}
N 9110 -4720 9120 -4710 {
lab=row_n[13]}
N 8900 -4690 8910 -4700 {
lab=rowon_n[13]}
N 8910 -4700 9110 -4700 {
lab=rowon_n[13]}
N 9110 -4700 9120 -4690 {
lab=rowon_n[13]}
N 8900 -4670 8910 -4680 {
lab=#net27}
N 8910 -4680 9110 -4680 {
lab=#net27}
N 9110 -4680 9120 -4670 {
lab=#net27}
N 8900 -4650 8910 -4660 {
lab=#net28}
N 8910 -4660 9110 -4660 {
lab=#net28}
N 9110 -4660 9120 -4650 {
lab=#net28}
N 9120 -4650 9140 -4650 {
lab=#net28}
N 9120 -4670 9140 -4670 {
lab=#net27}
N 9120 -4690 9140 -4690 {
lab=rowon_n[13]}
N 9120 -4710 9140 -4710 {
lab=row_n[13]}
N 8880 -4710 8900 -4710 {
lab=row_n[13]}
N 8880 -4690 8900 -4690 {
lab=rowon_n[13]}
N 8880 -4670 8900 -4670 {
lab=#net27}
N 8880 -4650 8900 -4650 {
lab=#net28}
N 8940 -4570 8940 -4560 {
lab=VSS}
N 8960 -4810 8960 -4790 {
lab=vcm}
N 8940 -4800 8940 -4790 {
lab=VDD}
N 9000 -4810 9000 -4790 {
lab=ctop}
N 9020 -4570 9020 -4550 {
lab=VDD}
N 9020 -4830 9030 -4840 {
lab=VDD}
N 9030 -5040 9030 -4840 {
lab=VDD}
N 9020 -5050 9030 -5040 {
lab=VDD}
N 9020 -5070 9020 -5050 {
lab=VDD}
N 8900 -4970 8910 -4980 {
lab=row_n[14]}
N 8910 -4980 9110 -4980 {
lab=row_n[14]}
N 9110 -4980 9120 -4970 {
lab=row_n[14]}
N 8900 -4950 8910 -4960 {
lab=rowon_n[14]}
N 8910 -4960 9110 -4960 {
lab=rowon_n[14]}
N 9110 -4960 9120 -4950 {
lab=rowon_n[14]}
N 8900 -4930 8910 -4940 {
lab=#net29}
N 8910 -4940 9110 -4940 {
lab=#net29}
N 9110 -4940 9120 -4930 {
lab=#net29}
N 8900 -4910 8910 -4920 {
lab=#net30}
N 8910 -4920 9110 -4920 {
lab=#net30}
N 9110 -4920 9120 -4910 {
lab=#net30}
N 9120 -4910 9140 -4910 {
lab=#net30}
N 9120 -4930 9140 -4930 {
lab=#net29}
N 9120 -4950 9140 -4950 {
lab=rowon_n[14]}
N 9120 -4970 9140 -4970 {
lab=row_n[14]}
N 8880 -4970 8900 -4970 {
lab=row_n[14]}
N 8880 -4950 8900 -4950 {
lab=rowon_n[14]}
N 8880 -4930 8900 -4930 {
lab=#net29}
N 8880 -4910 8900 -4910 {
lab=#net30}
N 8940 -4830 8940 -4820 {
lab=VSS}
N 8960 -5070 8960 -5050 {
lab=vcm}
N 8940 -5060 8940 -5050 {
lab=VDD}
N 9000 -5070 9000 -5050 {
lab=ctop}
N 9020 -4830 9020 -4810 {
lab=VDD}
N 9020 -5090 9030 -5100 {
lab=VDD}
N 9030 -5300 9030 -5100 {
lab=VDD}
N 9020 -5310 9030 -5300 {
lab=VDD}
N 9020 -5330 9020 -5310 {
lab=VDD}
N 8900 -5230 8910 -5240 {
lab=row_n[15]}
N 8910 -5240 9110 -5240 {
lab=row_n[15]}
N 9110 -5240 9120 -5230 {
lab=row_n[15]}
N 8900 -5210 8910 -5220 {
lab=rowon_n[15]}
N 8910 -5220 9110 -5220 {
lab=rowon_n[15]}
N 9110 -5220 9120 -5210 {
lab=rowon_n[15]}
N 8900 -5190 8910 -5200 {
lab=#net31}
N 8910 -5200 9110 -5200 {
lab=#net31}
N 9110 -5200 9120 -5190 {
lab=#net31}
N 8900 -5170 8910 -5180 {
lab=#net32}
N 8910 -5180 9110 -5180 {
lab=#net32}
N 9110 -5180 9120 -5170 {
lab=#net32}
N 9120 -5170 9140 -5170 {
lab=#net32}
N 9120 -5190 9140 -5190 {
lab=#net31}
N 9120 -5210 9140 -5210 {
lab=rowon_n[15]}
N 9120 -5230 9140 -5230 {
lab=row_n[15]}
N 8880 -5230 8900 -5230 {
lab=row_n[15]}
N 8880 -5210 8900 -5210 {
lab=rowon_n[15]}
N 8880 -5190 8900 -5190 {
lab=#net31}
N 8880 -5170 8900 -5170 {
lab=#net32}
N 8940 -5090 8940 -5080 {
lab=VSS}
N 8960 -5330 8960 -5310 {
lab=vcm}
N 8940 -5320 8940 -5310 {
lab=VDD}
N 9000 -5330 9000 -5310 {
lab=ctop}
N 9020 -5090 9020 -5070 {
lab=VDD}
N 440 -930 440 -920 {
lab=VDD}
N 8940 -1190 8940 -1180 {
lab=VSS}
N 8940 -1450 8940 -1440 {
lab=VSS}
N 8940 -1710 8940 -1700 {
lab=VSS}
N 8940 -1970 8940 -1960 {
lab=VSS}
N 8940 -2230 8940 -2220 {
lab=VSS}
N 8940 -2490 8940 -2480 {
lab=VSS}
N 8940 -2750 8940 -2740 {
lab=VSS}
N 8940 -3010 8940 -3000 {
lab=VSS}
N 8940 -3270 8940 -3260 {
lab=VSS}
N 8940 -3530 8940 -3520 {
lab=VSS}
N 8940 -3790 8940 -3780 {
lab=VSS}
N 8940 -4050 8940 -4040 {
lab=VSS}
N 8940 -4310 8940 -4300 {
lab=VSS}
N 8940 -4310 8940 -4300 {
lab=VSS}
N 5070 -930 5070 -920 {
lab=en_n_bit[0]}
N 4550 -930 4550 -910 {
lab=en_n_bit[1]}
N 4810 -930 4810 -910 {
lab=en_n_bit[2]}
N 8780 -930 8780 -910 {
lab=sw}
N 8820 -930 8820 -910 {
lab=sw_n}
N 8800 -930 8800 -910 {
lab=analog_in}
N 520 -560 520 -550 {
lab=VDD}
N 520 -560 620 -560 {
lab=VDD}
N 620 -560 620 -550 {
lab=VDD}
N 520 -490 520 -480 {
lab=VSS}
N 520 -480 620 -480 {
lab=VSS}
N 620 -490 620 -480 {
lab=VSS}
N 570 -490 570 -480 {
lab=VSS}
N 570 -580 570 -560 {
lab=VDD}
N 520 -580 570 -580 {
lab=VDD}
N 570 -480 570 -470 {
lab=VSS}
N 570 -470 570 -460 {
lab=VSS}
N 520 -460 570 -460 {
lab=VSS}
N 910 -930 910 -920 {
lab=VSS}
N 910 -920 910 -910 {}
C {devices/title.sym} 170 -40 0 0 {name=l1 author="Manuel Moser"}
C {devices/iopin.sym} 240 -670 1 1 {name=p1 lab=VDD}
C {devices/iopin.sym} 250 -290 3 1 {name=p2 lab=VSS}
C {devices/iopin.sym} 260 -670 1 1 {name=p9 lab=vcm}
C {devices/ipin.sym} 200 -590 0 0 {name=p3 lab=sample}
C {devices/ipin.sym} 200 -570 0 0 {name=p4 lab=sample_n}
C {devices/ipin.sym} 200 -510 0 0 {name=p5 lab=row_n[15:0]}
C {devices/lab_wire.sym} 1200 -1430 3 0 {name=l12 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1920 -1180 0 0 {name=l25 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3740 -1420 2 1 {name=l50 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 620 -1420 2 1 {name=l2 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 640 -1430 1 1 {name=l3 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 680 -1430 3 0 {name=l4 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 620 -1180 0 0 {name=l5 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 950 -1300 0 0 {name=x2}
C {devices/lab_wire.sym} 880 -1420 2 1 {name=l6 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 900 -1430 1 1 {name=l7 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 940 -1430 3 0 {name=l8 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 880 -1180 0 0 {name=l9 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1210 -1300 0 0 {name=x3}
C {devices/lab_wire.sym} 1140 -1420 2 1 {name=l10 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1160 -1430 1 1 {name=l11 sig_type=std_logic lab=vcm}
C {devices/ipin.sym} 200 -490 0 0 {name=p6 lab=rowon_n[15:0]}
C {devices/lab_wire.sym} 1140 -1180 0 0 {name=l13 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1470 -1300 0 0 {name=x4}
C {devices/lab_wire.sym} 1400 -1420 2 1 {name=l14 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 -1430 1 1 {name=l15 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1460 -1430 3 0 {name=l16 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1400 -1180 0 0 {name=l17 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1730 -1300 0 0 {name=x5}
C {devices/lab_wire.sym} 1660 -1420 2 1 {name=l18 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1680 -1430 1 1 {name=l19 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1720 -1430 3 0 {name=l20 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1660 -1180 0 0 {name=l21 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1990 -1300 0 0 {name=x6}
C {devices/lab_wire.sym} 1920 -1420 2 1 {name=l22 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1940 -1430 1 1 {name=l23 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1980 -1430 3 0 {name=l24 sig_type=std_logic lab=ctop}
C {devices/ipin.sym} 200 -470 0 0 {name=p7 lab=col_n[31:0]}
C {adc_array_wafflecap_8_8.sym} 2250 -1300 0 0 {name=x7}
C {devices/lab_wire.sym} 2180 -1420 2 1 {name=l26 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2200 -1430 1 1 {name=l27 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2240 -1430 3 0 {name=l28 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2180 -1180 0 0 {name=l29 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2510 -1300 0 0 {name=x8}
C {devices/lab_wire.sym} 2440 -1420 2 1 {name=l30 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2460 -1430 1 1 {name=l31 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2500 -1430 3 0 {name=l32 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2440 -1180 0 0 {name=l33 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2770 -1300 0 0 {name=x9}
C {devices/lab_wire.sym} 2700 -1420 2 1 {name=l34 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2720 -1430 1 1 {name=l35 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2760 -1430 3 0 {name=l36 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2700 -1180 0 0 {name=l37 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3030 -1300 0 0 {name=x10}
C {devices/lab_wire.sym} 2960 -1420 2 1 {name=l38 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2980 -1430 1 1 {name=l39 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3020 -1430 3 0 {name=l40 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2960 -1180 0 0 {name=l41 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3290 -1300 0 0 {name=x11}
C {devices/lab_wire.sym} 3220 -1420 2 1 {name=l42 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3240 -1430 1 1 {name=l43 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3280 -1430 3 0 {name=l44 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3220 -1180 0 0 {name=l45 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3550 -1300 0 0 {name=x12}
C {devices/lab_wire.sym} 3480 -1420 2 1 {name=l46 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3500 -1430 1 1 {name=l47 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3540 -1430 3 0 {name=l48 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3480 -1180 0 0 {name=l49 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3810 -1300 0 0 {name=x13}
C {devices/ipin.sym} 200 -450 0 0 {name=p10 lab=en_bit_n[2:0]}
C {devices/lab_wire.sym} 3760 -1430 1 1 {name=l51 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3800 -1430 3 0 {name=l52 sig_type=std_logic lab=ctop}
C {devices/ipin.sym} 200 -410 0 0 {name=p8 lab=en_C0_n}
C {devices/ipin.sym} 200 -370 0 0 {name=p11 lab=sw}
C {devices/ipin.sym} 200 -350 0 0 {name=p12 lab=sw_n}
C {devices/ipin.sym} 200 -390 0 0 {name=p8 lab=analog_in}
C {devices/iopin.sym} 300 -630 0 0 {name=p14 lab=ctop}
C {devices/lab_wire.sym} 4000 -1180 0 0 {name=l57 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4330 -1300 0 0 {name=x15}
C {devices/lab_wire.sym} 4260 -1420 2 1 {name=l58 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4280 -1430 1 1 {name=l59 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4320 -1430 3 0 {name=l60 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4260 -1180 0 0 {name=l61 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4590 -1300 0 0 {name=x16}
C {devices/lab_wire.sym} 4520 -1420 2 1 {name=l62 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4540 -1430 1 1 {name=l63 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4580 -1430 3 0 {name=l64 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4520 -1180 0 0 {name=l65 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4850 -1300 0 0 {name=x17}
C {devices/lab_wire.sym} 4780 -1420 2 1 {name=l66 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4800 -1430 1 1 {name=l67 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4840 -1430 3 0 {name=l68 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4780 -1180 0 0 {name=l69 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5110 -1300 0 0 {name=x18}
C {devices/lab_wire.sym} 5040 -1420 2 1 {name=l70 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5060 -1430 1 1 {name=l71 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5100 -1430 3 0 {name=l72 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5040 -1180 0 0 {name=l73 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5370 -1300 0 0 {name=x19}
C {devices/lab_wire.sym} 5300 -1420 2 1 {name=l74 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5320 -1430 1 1 {name=l75 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5360 -1430 3 0 {name=l76 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5300 -1180 0 0 {name=l77 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5630 -1300 0 0 {name=x20}
C {devices/lab_wire.sym} 5560 -1420 2 1 {name=l78 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5580 -1430 1 1 {name=l79 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5620 -1430 3 0 {name=l80 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5560 -1180 0 0 {name=l81 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5890 -1300 0 0 {name=x21}
C {devices/lab_wire.sym} 5820 -1420 2 1 {name=l82 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5840 -1430 1 1 {name=l83 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5880 -1430 3 0 {name=l84 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5820 -1180 0 0 {name=l85 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6150 -1300 0 0 {name=x22}
C {devices/lab_wire.sym} 6080 -1420 2 1 {name=l86 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6100 -1430 1 1 {name=l87 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6140 -1430 3 0 {name=l88 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6080 -1180 0 0 {name=l89 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6410 -1300 0 0 {name=x23}
C {devices/lab_wire.sym} 6340 -1420 2 1 {name=l90 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6360 -1430 1 1 {name=l91 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6400 -1430 3 0 {name=l92 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6340 -1180 0 0 {name=l93 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6670 -1300 0 0 {name=x24}
C {devices/lab_wire.sym} 6600 -1420 2 1 {name=l94 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6620 -1430 1 1 {name=l95 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6660 -1430 3 0 {name=l96 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6600 -1180 0 0 {name=l97 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6930 -1300 0 0 {name=x25}
C {devices/lab_wire.sym} 6860 -1420 2 1 {name=l98 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6880 -1430 1 1 {name=l99 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6920 -1430 3 0 {name=l100 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6860 -1180 0 0 {name=l101 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7190 -1300 0 0 {name=x26}
C {devices/lab_wire.sym} 7120 -1420 2 1 {name=l102 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7140 -1430 1 1 {name=l103 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7180 -1430 3 0 {name=l104 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7120 -1180 0 0 {name=l105 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7450 -1300 0 0 {name=x27}
C {devices/lab_wire.sym} 7380 -1420 2 1 {name=l106 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7400 -1430 1 1 {name=l107 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7440 -1430 3 0 {name=l108 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7380 -1180 0 0 {name=l109 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7710 -1300 0 0 {name=x28}
C {devices/lab_wire.sym} 7640 -1420 2 1 {name=l110 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7660 -1430 1 1 {name=l111 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7700 -1430 3 0 {name=l112 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7640 -1180 0 0 {name=l113 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7970 -1300 0 0 {name=x29}
C {devices/lab_wire.sym} 7900 -1420 2 1 {name=l114 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7920 -1430 1 1 {name=l115 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7960 -1430 3 0 {name=l116 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7900 -1180 0 0 {name=l117 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8230 -1300 0 0 {name=x30}
C {devices/lab_wire.sym} 8160 -1420 2 1 {name=l118 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8180 -1430 1 1 {name=l119 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8220 -1430 3 0 {name=l120 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8160 -1180 0 0 {name=l121 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8490 -1300 0 0 {name=x31}
C {devices/lab_wire.sym} 8420 -1420 2 1 {name=l122 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8440 -1430 1 1 {name=l123 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8480 -1430 3 0 {name=l124 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8420 -1180 0 0 {name=l125 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8750 -1300 0 0 {name=x32}
C {devices/lab_wire.sym} 8680 -1420 2 1 {name=l126 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8700 -1430 1 1 {name=l127 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8740 -1430 3 0 {name=l128 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8680 -1180 0 0 {name=l129 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 690 -1560 0 0 {name=x33}
C {devices/lab_wire.sym} 620 -1680 2 1 {name=l130 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 640 -1690 1 1 {name=l131 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 680 -1690 3 0 {name=l132 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 620 -1440 0 0 {name=l133 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 950 -1560 0 0 {name=x34}
C {devices/lab_wire.sym} 880 -1680 2 1 {name=l134 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 900 -1690 1 1 {name=l135 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 940 -1690 3 0 {name=l136 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 880 -1440 0 0 {name=l137 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1210 -1560 0 0 {name=x35}
C {devices/lab_wire.sym} 1140 -1680 2 1 {name=l138 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1160 -1690 1 1 {name=l139 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1200 -1690 3 0 {name=l140 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1140 -1440 0 0 {name=l141 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1470 -1560 0 0 {name=x36}
C {devices/lab_wire.sym} 1400 -1680 2 1 {name=l142 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 -1690 1 1 {name=l143 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1460 -1690 3 0 {name=l144 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1400 -1440 0 0 {name=l145 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1730 -1560 0 0 {name=x37}
C {devices/lab_wire.sym} 1660 -1680 2 1 {name=l146 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1680 -1690 1 1 {name=l147 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1720 -1690 3 0 {name=l148 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1660 -1440 0 0 {name=l149 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1990 -1560 0 0 {name=x38}
C {devices/lab_wire.sym} 1920 -1680 2 1 {name=l150 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1940 -1690 1 1 {name=l151 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1980 -1690 3 0 {name=l152 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1920 -1440 0 0 {name=l153 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2250 -1560 0 0 {name=x39}
C {devices/lab_wire.sym} 2180 -1680 2 1 {name=l154 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2200 -1690 1 1 {name=l155 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2240 -1690 3 0 {name=l156 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2180 -1440 0 0 {name=l157 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2510 -1560 0 0 {name=x40}
C {devices/lab_wire.sym} 2440 -1680 2 1 {name=l158 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2460 -1690 1 1 {name=l159 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2500 -1690 3 0 {name=l160 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2440 -1440 0 0 {name=l161 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2770 -1560 0 0 {name=x41}
C {devices/lab_wire.sym} 2700 -1680 2 1 {name=l162 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2720 -1690 1 1 {name=l163 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2760 -1690 3 0 {name=l164 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2700 -1440 0 0 {name=l165 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3030 -1560 0 0 {name=x42}
C {devices/lab_wire.sym} 2960 -1680 2 1 {name=l166 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2980 -1690 1 1 {name=l167 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3020 -1690 3 0 {name=l168 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2960 -1440 0 0 {name=l169 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3290 -1560 0 0 {name=x43}
C {devices/lab_wire.sym} 3220 -1680 2 1 {name=l170 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3240 -1690 1 1 {name=l171 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3280 -1690 3 0 {name=l172 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3220 -1440 0 0 {name=l173 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3550 -1560 0 0 {name=x44}
C {devices/lab_wire.sym} 3480 -1680 2 1 {name=l174 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3500 -1690 1 1 {name=l175 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3540 -1690 3 0 {name=l176 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3480 -1440 0 0 {name=l177 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3810 -1560 0 0 {name=x45}
C {devices/lab_wire.sym} 3740 -1680 2 1 {name=l178 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3760 -1690 1 1 {name=l179 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3800 -1690 3 0 {name=l180 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3740 -1440 0 0 {name=l181 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4070 -1560 0 0 {name=x46}
C {devices/lab_wire.sym} 4000 -1680 2 1 {name=l182 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4020 -1690 1 1 {name=l183 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4060 -1690 3 0 {name=l184 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4000 -1440 0 0 {name=l185 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4330 -1560 0 0 {name=x47}
C {devices/lab_wire.sym} 4260 -1680 2 1 {name=l186 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4280 -1690 1 1 {name=l187 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4320 -1690 3 0 {name=l188 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4260 -1440 0 0 {name=l189 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4590 -1560 0 0 {name=x48}
C {devices/lab_wire.sym} 4520 -1680 2 1 {name=l190 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4540 -1690 1 1 {name=l191 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4580 -1690 3 0 {name=l192 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4520 -1440 0 0 {name=l193 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4850 -1560 0 0 {name=x49}
C {devices/lab_wire.sym} 4780 -1680 2 1 {name=l194 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4800 -1690 1 1 {name=l195 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4840 -1690 3 0 {name=l196 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4780 -1440 0 0 {name=l197 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5110 -1560 0 0 {name=x50}
C {devices/lab_wire.sym} 5040 -1680 2 1 {name=l198 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5060 -1690 1 1 {name=l199 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5100 -1690 3 0 {name=l200 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5040 -1440 0 0 {name=l201 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5370 -1560 0 0 {name=x51}
C {devices/lab_wire.sym} 5300 -1680 2 1 {name=l202 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5320 -1690 1 1 {name=l203 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5360 -1690 3 0 {name=l204 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5300 -1440 0 0 {name=l205 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5630 -1560 0 0 {name=x52}
C {devices/lab_wire.sym} 5560 -1680 2 1 {name=l206 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5580 -1690 1 1 {name=l207 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5620 -1690 3 0 {name=l208 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5560 -1440 0 0 {name=l209 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5890 -1560 0 0 {name=x53}
C {devices/lab_wire.sym} 5820 -1680 2 1 {name=l210 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5840 -1690 1 1 {name=l211 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5880 -1690 3 0 {name=l212 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5820 -1440 0 0 {name=l213 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6150 -1560 0 0 {name=x54}
C {devices/lab_wire.sym} 6080 -1680 2 1 {name=l214 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6100 -1690 1 1 {name=l215 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6140 -1690 3 0 {name=l216 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6080 -1440 0 0 {name=l217 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6410 -1560 0 0 {name=x55}
C {devices/lab_wire.sym} 6340 -1680 2 1 {name=l218 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6360 -1690 1 1 {name=l219 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6400 -1690 3 0 {name=l220 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6340 -1440 0 0 {name=l221 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6670 -1560 0 0 {name=x56}
C {devices/lab_wire.sym} 6600 -1680 2 1 {name=l222 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6620 -1690 1 1 {name=l223 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6660 -1690 3 0 {name=l224 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6600 -1440 0 0 {name=l225 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6930 -1560 0 0 {name=x57}
C {devices/lab_wire.sym} 6860 -1680 2 1 {name=l226 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6880 -1690 1 1 {name=l227 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6920 -1690 3 0 {name=l228 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6860 -1440 0 0 {name=l229 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7190 -1560 0 0 {name=x58}
C {devices/lab_wire.sym} 7120 -1680 2 1 {name=l230 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7140 -1690 1 1 {name=l231 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7180 -1690 3 0 {name=l232 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7120 -1440 0 0 {name=l233 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7450 -1560 0 0 {name=x59}
C {devices/lab_wire.sym} 7380 -1680 2 1 {name=l234 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7400 -1690 1 1 {name=l235 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7440 -1690 3 0 {name=l236 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7380 -1440 0 0 {name=l237 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7710 -1560 0 0 {name=x60}
C {devices/lab_wire.sym} 7640 -1680 2 1 {name=l238 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7660 -1690 1 1 {name=l239 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7700 -1690 3 0 {name=l240 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7640 -1440 0 0 {name=l241 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7970 -1560 0 0 {name=x61}
C {devices/lab_wire.sym} 7900 -1680 2 1 {name=l242 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7920 -1690 1 1 {name=l243 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7960 -1690 3 0 {name=l244 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7900 -1440 0 0 {name=l245 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8230 -1560 0 0 {name=x62}
C {devices/lab_wire.sym} 8160 -1680 2 1 {name=l246 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8180 -1690 1 1 {name=l247 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8220 -1690 3 0 {name=l248 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8160 -1440 0 0 {name=l249 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8490 -1560 0 0 {name=x63}
C {devices/lab_wire.sym} 8420 -1680 2 1 {name=l250 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8440 -1690 1 1 {name=l251 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8480 -1690 3 0 {name=l252 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8420 -1440 0 0 {name=l253 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8750 -1560 0 0 {name=x64}
C {devices/lab_wire.sym} 8680 -1680 2 1 {name=l254 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8700 -1690 1 1 {name=l255 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8740 -1690 3 0 {name=l256 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8680 -1440 0 0 {name=l257 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 690 -1820 0 0 {name=x65}
C {devices/lab_wire.sym} 620 -1940 2 1 {name=l258 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 640 -1950 1 1 {name=l259 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 680 -1950 3 0 {name=l260 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 620 -1700 0 0 {name=l261 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 950 -1820 0 0 {name=x66}
C {devices/lab_wire.sym} 880 -1940 2 1 {name=l262 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 900 -1950 1 1 {name=l263 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 940 -1950 3 0 {name=l264 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 880 -1700 0 0 {name=l265 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1210 -1820 0 0 {name=x67}
C {devices/lab_wire.sym} 1140 -1940 2 1 {name=l266 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1160 -1950 1 1 {name=l267 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1200 -1950 3 0 {name=l268 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1140 -1700 0 0 {name=l269 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1470 -1820 0 0 {name=x68}
C {devices/lab_wire.sym} 1400 -1940 2 1 {name=l270 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 -1950 1 1 {name=l271 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1460 -1950 3 0 {name=l272 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1400 -1700 0 0 {name=l273 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1730 -1820 0 0 {name=x69}
C {devices/lab_wire.sym} 1660 -1940 2 1 {name=l274 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1680 -1950 1 1 {name=l275 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1720 -1950 3 0 {name=l276 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1660 -1700 0 0 {name=l277 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1990 -1820 0 0 {name=x70}
C {devices/lab_wire.sym} 1920 -1940 2 1 {name=l278 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1940 -1950 1 1 {name=l279 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1980 -1950 3 0 {name=l280 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1920 -1700 0 0 {name=l281 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2250 -1820 0 0 {name=x71}
C {devices/lab_wire.sym} 2180 -1940 2 1 {name=l282 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2200 -1950 1 1 {name=l283 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2240 -1950 3 0 {name=l284 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2180 -1700 0 0 {name=l285 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2510 -1820 0 0 {name=x72}
C {devices/lab_wire.sym} 2440 -1940 2 1 {name=l286 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2460 -1950 1 1 {name=l287 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2500 -1950 3 0 {name=l288 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2440 -1700 0 0 {name=l289 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2770 -1820 0 0 {name=x73}
C {devices/lab_wire.sym} 2700 -1940 2 1 {name=l290 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2720 -1950 1 1 {name=l291 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2760 -1950 3 0 {name=l292 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2700 -1700 0 0 {name=l293 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3030 -1820 0 0 {name=x74}
C {devices/lab_wire.sym} 2960 -1940 2 1 {name=l294 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2980 -1950 1 1 {name=l295 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3020 -1950 3 0 {name=l296 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2960 -1700 0 0 {name=l297 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3290 -1820 0 0 {name=x75}
C {devices/lab_wire.sym} 3220 -1940 2 1 {name=l298 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3240 -1950 1 1 {name=l299 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3280 -1950 3 0 {name=l300 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3220 -1700 0 0 {name=l301 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3550 -1820 0 0 {name=x76}
C {devices/lab_wire.sym} 3480 -1940 2 1 {name=l302 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3500 -1950 1 1 {name=l303 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3540 -1950 3 0 {name=l304 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3480 -1700 0 0 {name=l305 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3810 -1820 0 0 {name=x77}
C {devices/lab_wire.sym} 3740 -1940 2 1 {name=l306 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3760 -1950 1 1 {name=l307 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3800 -1950 3 0 {name=l308 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3740 -1700 0 0 {name=l309 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4070 -1820 0 0 {name=x78}
C {devices/lab_wire.sym} 4000 -1940 2 1 {name=l310 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4020 -1950 1 1 {name=l311 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4060 -1950 3 0 {name=l312 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4000 -1700 0 0 {name=l313 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4330 -1820 0 0 {name=x79}
C {devices/lab_wire.sym} 4260 -1940 2 1 {name=l314 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4280 -1950 1 1 {name=l315 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4320 -1950 3 0 {name=l316 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4260 -1700 0 0 {name=l317 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4590 -1820 0 0 {name=x80}
C {devices/lab_wire.sym} 4520 -1940 2 1 {name=l318 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4540 -1950 1 1 {name=l319 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4580 -1950 3 0 {name=l320 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4520 -1700 0 0 {name=l321 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4850 -1820 0 0 {name=x81}
C {devices/lab_wire.sym} 4780 -1940 2 1 {name=l322 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4800 -1950 1 1 {name=l323 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4840 -1950 3 0 {name=l324 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4780 -1700 0 0 {name=l325 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5110 -1820 0 0 {name=x82}
C {devices/lab_wire.sym} 5040 -1940 2 1 {name=l326 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5060 -1950 1 1 {name=l327 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5100 -1950 3 0 {name=l328 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5040 -1700 0 0 {name=l329 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5370 -1820 0 0 {name=x83}
C {devices/lab_wire.sym} 5300 -1940 2 1 {name=l330 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5320 -1950 1 1 {name=l331 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5360 -1950 3 0 {name=l332 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5300 -1700 0 0 {name=l333 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5630 -1820 0 0 {name=x84}
C {devices/lab_wire.sym} 5560 -1940 2 1 {name=l334 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5580 -1950 1 1 {name=l335 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5620 -1950 3 0 {name=l336 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5560 -1700 0 0 {name=l337 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5890 -1820 0 0 {name=x85}
C {devices/lab_wire.sym} 5820 -1940 2 1 {name=l338 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5840 -1950 1 1 {name=l339 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5880 -1950 3 0 {name=l340 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5820 -1700 0 0 {name=l341 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6150 -1820 0 0 {name=x86}
C {devices/lab_wire.sym} 6080 -1940 2 1 {name=l342 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6100 -1950 1 1 {name=l343 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6140 -1950 3 0 {name=l344 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6080 -1700 0 0 {name=l345 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6410 -1820 0 0 {name=x87}
C {devices/lab_wire.sym} 6340 -1940 2 1 {name=l346 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6360 -1950 1 1 {name=l347 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6400 -1950 3 0 {name=l348 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6340 -1700 0 0 {name=l349 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6670 -1820 0 0 {name=x88}
C {devices/lab_wire.sym} 6600 -1940 2 1 {name=l350 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6620 -1950 1 1 {name=l351 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6660 -1950 3 0 {name=l352 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6600 -1700 0 0 {name=l353 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6930 -1820 0 0 {name=x89}
C {devices/lab_wire.sym} 6860 -1940 2 1 {name=l354 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6880 -1950 1 1 {name=l355 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6920 -1950 3 0 {name=l356 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6860 -1700 0 0 {name=l357 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7190 -1820 0 0 {name=x90}
C {devices/lab_wire.sym} 7120 -1940 2 1 {name=l358 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7140 -1950 1 1 {name=l359 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7180 -1950 3 0 {name=l360 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7120 -1700 0 0 {name=l361 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7450 -1820 0 0 {name=x91}
C {devices/lab_wire.sym} 7380 -1940 2 1 {name=l362 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7400 -1950 1 1 {name=l363 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7440 -1950 3 0 {name=l364 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7380 -1700 0 0 {name=l365 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7710 -1820 0 0 {name=x92}
C {devices/lab_wire.sym} 7640 -1940 2 1 {name=l366 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7660 -1950 1 1 {name=l367 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7700 -1950 3 0 {name=l368 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7640 -1700 0 0 {name=l369 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7970 -1820 0 0 {name=x93}
C {devices/lab_wire.sym} 7900 -1940 2 1 {name=l370 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7920 -1950 1 1 {name=l371 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7960 -1950 3 0 {name=l372 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7900 -1700 0 0 {name=l373 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8230 -1820 0 0 {name=x94}
C {devices/lab_wire.sym} 8160 -1940 2 1 {name=l374 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8180 -1950 1 1 {name=l375 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8220 -1950 3 0 {name=l376 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8160 -1700 0 0 {name=l377 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8490 -1820 0 0 {name=x95}
C {devices/lab_wire.sym} 8420 -1940 2 1 {name=l378 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8440 -1950 1 1 {name=l379 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8480 -1950 3 0 {name=l380 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8420 -1700 0 0 {name=l381 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8750 -1820 0 0 {name=x96}
C {devices/lab_wire.sym} 8680 -1940 2 1 {name=l382 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8700 -1950 1 1 {name=l383 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8740 -1950 3 0 {name=l384 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8680 -1700 0 0 {name=l385 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 690 -2080 0 0 {name=x97}
C {devices/lab_wire.sym} 620 -2200 2 1 {name=l386 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 640 -2210 1 1 {name=l387 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 680 -2210 3 0 {name=l388 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 620 -1960 0 0 {name=l389 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 950 -2080 0 0 {name=x98}
C {devices/lab_wire.sym} 880 -2200 2 1 {name=l390 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 900 -2210 1 1 {name=l391 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 940 -2210 3 0 {name=l392 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 880 -1960 0 0 {name=l393 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1210 -2080 0 0 {name=x99}
C {devices/lab_wire.sym} 1140 -2200 2 1 {name=l394 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1160 -2210 1 1 {name=l395 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1200 -2210 3 0 {name=l396 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1140 -1960 0 0 {name=l397 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1470 -2080 0 0 {name=x100}
C {devices/lab_wire.sym} 1400 -2200 2 1 {name=l398 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 -2210 1 1 {name=l399 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1460 -2210 3 0 {name=l400 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1400 -1960 0 0 {name=l401 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1730 -2080 0 0 {name=x101}
C {devices/lab_wire.sym} 1660 -2200 2 1 {name=l402 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1680 -2210 1 1 {name=l403 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1720 -2210 3 0 {name=l404 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1660 -1960 0 0 {name=l405 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1990 -2080 0 0 {name=x102}
C {devices/lab_wire.sym} 1920 -2200 2 1 {name=l406 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1940 -2210 1 1 {name=l407 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1980 -2210 3 0 {name=l408 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1920 -1960 0 0 {name=l409 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2250 -2080 0 0 {name=x103}
C {devices/lab_wire.sym} 2180 -2200 2 1 {name=l410 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2200 -2210 1 1 {name=l411 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2240 -2210 3 0 {name=l412 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2180 -1960 0 0 {name=l413 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2510 -2080 0 0 {name=x104}
C {devices/lab_wire.sym} 2440 -2200 2 1 {name=l414 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2460 -2210 1 1 {name=l415 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2500 -2210 3 0 {name=l416 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2440 -1960 0 0 {name=l417 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2770 -2080 0 0 {name=x105}
C {devices/lab_wire.sym} 2700 -2200 2 1 {name=l418 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2720 -2210 1 1 {name=l419 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2760 -2210 3 0 {name=l420 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2700 -1960 0 0 {name=l421 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3030 -2080 0 0 {name=x106}
C {devices/lab_wire.sym} 2960 -2200 2 1 {name=l422 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2980 -2210 1 1 {name=l423 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3020 -2210 3 0 {name=l424 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2960 -1960 0 0 {name=l425 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3290 -2080 0 0 {name=x107}
C {devices/lab_wire.sym} 3220 -2200 2 1 {name=l426 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3240 -2210 1 1 {name=l427 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3280 -2210 3 0 {name=l428 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3220 -1960 0 0 {name=l429 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3550 -2080 0 0 {name=x108}
C {devices/lab_wire.sym} 3480 -2200 2 1 {name=l430 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3500 -2210 1 1 {name=l431 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3540 -2210 3 0 {name=l432 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3480 -1960 0 0 {name=l433 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3810 -2080 0 0 {name=x109}
C {devices/lab_wire.sym} 3740 -2200 2 1 {name=l434 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3760 -2210 1 1 {name=l435 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3800 -2210 3 0 {name=l436 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3740 -1960 0 0 {name=l437 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4070 -2080 0 0 {name=x110}
C {devices/lab_wire.sym} 4000 -2200 2 1 {name=l438 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4020 -2210 1 1 {name=l439 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4060 -2210 3 0 {name=l440 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4000 -1960 0 0 {name=l441 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4330 -2080 0 0 {name=x111}
C {devices/lab_wire.sym} 4260 -2200 2 1 {name=l442 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4280 -2210 1 1 {name=l443 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4320 -2210 3 0 {name=l444 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4260 -1960 0 0 {name=l445 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4590 -2080 0 0 {name=x112}
C {devices/lab_wire.sym} 4520 -2200 2 1 {name=l446 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4540 -2210 1 1 {name=l447 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4580 -2210 3 0 {name=l448 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4520 -1960 0 0 {name=l449 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4850 -2080 0 0 {name=x113}
C {devices/lab_wire.sym} 4780 -2200 2 1 {name=l450 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4800 -2210 1 1 {name=l451 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4840 -2210 3 0 {name=l452 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4780 -1960 0 0 {name=l453 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5110 -2080 0 0 {name=x114}
C {devices/lab_wire.sym} 5040 -2200 2 1 {name=l454 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5060 -2210 1 1 {name=l455 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5100 -2210 3 0 {name=l456 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5040 -1960 0 0 {name=l457 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5370 -2080 0 0 {name=x115}
C {devices/lab_wire.sym} 5300 -2200 2 1 {name=l458 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5320 -2210 1 1 {name=l459 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5360 -2210 3 0 {name=l460 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5300 -1960 0 0 {name=l461 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5630 -2080 0 0 {name=x116}
C {devices/lab_wire.sym} 5560 -2200 2 1 {name=l462 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5580 -2210 1 1 {name=l463 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5620 -2210 3 0 {name=l464 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5560 -1960 0 0 {name=l465 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5890 -2080 0 0 {name=x117}
C {devices/lab_wire.sym} 5820 -2200 2 1 {name=l466 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5840 -2210 1 1 {name=l467 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5880 -2210 3 0 {name=l468 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5820 -1960 0 0 {name=l469 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6150 -2080 0 0 {name=x118}
C {devices/lab_wire.sym} 6080 -2200 2 1 {name=l470 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6100 -2210 1 1 {name=l471 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6140 -2210 3 0 {name=l472 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6080 -1960 0 0 {name=l473 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6410 -2080 0 0 {name=x119}
C {devices/lab_wire.sym} 6340 -2200 2 1 {name=l474 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6360 -2210 1 1 {name=l475 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6400 -2210 3 0 {name=l476 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6340 -1960 0 0 {name=l477 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6670 -2080 0 0 {name=x120}
C {devices/lab_wire.sym} 6600 -2200 2 1 {name=l478 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6620 -2210 1 1 {name=l479 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6660 -2210 3 0 {name=l480 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6600 -1960 0 0 {name=l481 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6930 -2080 0 0 {name=x121}
C {devices/lab_wire.sym} 6860 -2200 2 1 {name=l482 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6880 -2210 1 1 {name=l483 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6920 -2210 3 0 {name=l484 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6860 -1960 0 0 {name=l485 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7190 -2080 0 0 {name=x122}
C {devices/lab_wire.sym} 7120 -2200 2 1 {name=l486 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7140 -2210 1 1 {name=l487 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7180 -2210 3 0 {name=l488 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7120 -1960 0 0 {name=l489 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7450 -2080 0 0 {name=x123}
C {devices/lab_wire.sym} 7380 -2200 2 1 {name=l490 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7400 -2210 1 1 {name=l491 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7440 -2210 3 0 {name=l492 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7380 -1960 0 0 {name=l493 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7710 -2080 0 0 {name=x124}
C {devices/lab_wire.sym} 7640 -2200 2 1 {name=l494 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7660 -2210 1 1 {name=l495 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7700 -2210 3 0 {name=l496 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7640 -1960 0 0 {name=l497 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7970 -2080 0 0 {name=x125}
C {devices/lab_wire.sym} 7900 -2200 2 1 {name=l498 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7920 -2210 1 1 {name=l499 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7960 -2210 3 0 {name=l500 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7900 -1960 0 0 {name=l501 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8230 -2080 0 0 {name=x126}
C {devices/lab_wire.sym} 8160 -2200 2 1 {name=l502 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8180 -2210 1 1 {name=l503 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8220 -2210 3 0 {name=l504 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8160 -1960 0 0 {name=l505 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8490 -2080 0 0 {name=x127}
C {devices/lab_wire.sym} 8420 -2200 2 1 {name=l506 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8440 -2210 1 1 {name=l507 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8480 -2210 3 0 {name=l508 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8420 -1960 0 0 {name=l509 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8750 -2080 0 0 {name=x128}
C {devices/lab_wire.sym} 8680 -2200 2 1 {name=l510 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8700 -2210 1 1 {name=l511 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8740 -2210 3 0 {name=l512 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8680 -1960 0 0 {name=l513 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 690 -2340 0 0 {name=x129}
C {devices/lab_wire.sym} 620 -2460 2 1 {name=l514 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 640 -2470 1 1 {name=l515 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 680 -2470 3 0 {name=l516 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 620 -2220 0 0 {name=l517 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 950 -2340 0 0 {name=x130}
C {devices/lab_wire.sym} 880 -2460 2 1 {name=l518 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 900 -2470 1 1 {name=l519 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 940 -2470 3 0 {name=l520 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 880 -2220 0 0 {name=l521 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1210 -2340 0 0 {name=x131}
C {devices/lab_wire.sym} 1140 -2460 2 1 {name=l522 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1160 -2470 1 1 {name=l523 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1200 -2470 3 0 {name=l524 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1140 -2220 0 0 {name=l525 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1470 -2340 0 0 {name=x132}
C {devices/lab_wire.sym} 1400 -2460 2 1 {name=l526 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 -2470 1 1 {name=l527 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1460 -2470 3 0 {name=l528 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1400 -2220 0 0 {name=l529 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1730 -2340 0 0 {name=x133}
C {devices/lab_wire.sym} 1660 -2460 2 1 {name=l530 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1680 -2470 1 1 {name=l531 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1720 -2470 3 0 {name=l532 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1660 -2220 0 0 {name=l533 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1990 -2340 0 0 {name=x134}
C {devices/lab_wire.sym} 1920 -2460 2 1 {name=l534 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1940 -2470 1 1 {name=l535 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1980 -2470 3 0 {name=l536 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1920 -2220 0 0 {name=l537 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2250 -2340 0 0 {name=x135}
C {devices/lab_wire.sym} 2180 -2460 2 1 {name=l538 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2200 -2470 1 1 {name=l539 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2240 -2470 3 0 {name=l540 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2180 -2220 0 0 {name=l541 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2510 -2340 0 0 {name=x136}
C {devices/lab_wire.sym} 2440 -2460 2 1 {name=l542 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2460 -2470 1 1 {name=l543 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2500 -2470 3 0 {name=l544 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2440 -2220 0 0 {name=l545 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2770 -2340 0 0 {name=x137}
C {devices/lab_wire.sym} 2700 -2460 2 1 {name=l546 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2720 -2470 1 1 {name=l547 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2760 -2470 3 0 {name=l548 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2700 -2220 0 0 {name=l549 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3030 -2340 0 0 {name=x138}
C {devices/lab_wire.sym} 2960 -2460 2 1 {name=l550 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2980 -2470 1 1 {name=l551 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3020 -2470 3 0 {name=l552 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2960 -2220 0 0 {name=l553 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3290 -2340 0 0 {name=x139}
C {devices/lab_wire.sym} 3220 -2460 2 1 {name=l554 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3240 -2470 1 1 {name=l555 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3280 -2470 3 0 {name=l556 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3220 -2220 0 0 {name=l557 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3550 -2340 0 0 {name=x140}
C {devices/lab_wire.sym} 3480 -2460 2 1 {name=l558 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3500 -2470 1 1 {name=l559 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3540 -2470 3 0 {name=l560 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3480 -2220 0 0 {name=l561 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3810 -2340 0 0 {name=x141}
C {devices/lab_wire.sym} 3740 -2460 2 1 {name=l562 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3760 -2470 1 1 {name=l563 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3800 -2470 3 0 {name=l564 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3740 -2220 0 0 {name=l565 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4070 -2340 0 0 {name=x142}
C {devices/lab_wire.sym} 4000 -2460 2 1 {name=l566 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4020 -2470 1 1 {name=l567 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4060 -2470 3 0 {name=l568 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4000 -2220 0 0 {name=l569 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4330 -2340 0 0 {name=x143}
C {devices/lab_wire.sym} 4260 -2460 2 1 {name=l570 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4280 -2470 1 1 {name=l571 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4320 -2470 3 0 {name=l572 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4260 -2220 0 0 {name=l573 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4590 -2340 0 0 {name=x144}
C {devices/lab_wire.sym} 4520 -2460 2 1 {name=l574 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4540 -2470 1 1 {name=l575 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4580 -2470 3 0 {name=l576 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4520 -2220 0 0 {name=l577 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4850 -2340 0 0 {name=x145}
C {devices/lab_wire.sym} 4780 -2460 2 1 {name=l578 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4800 -2470 1 1 {name=l579 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4840 -2470 3 0 {name=l580 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4780 -2220 0 0 {name=l581 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5110 -2340 0 0 {name=x146}
C {devices/lab_wire.sym} 5040 -2460 2 1 {name=l582 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5060 -2470 1 1 {name=l583 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5100 -2470 3 0 {name=l584 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5040 -2220 0 0 {name=l585 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5370 -2340 0 0 {name=x147}
C {devices/lab_wire.sym} 5300 -2460 2 1 {name=l586 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5320 -2470 1 1 {name=l587 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5360 -2470 3 0 {name=l588 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5300 -2220 0 0 {name=l589 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5630 -2340 0 0 {name=x148}
C {devices/lab_wire.sym} 5560 -2460 2 1 {name=l590 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5580 -2470 1 1 {name=l591 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5620 -2470 3 0 {name=l592 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5560 -2220 0 0 {name=l593 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5890 -2340 0 0 {name=x149}
C {devices/lab_wire.sym} 5820 -2460 2 1 {name=l594 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5840 -2470 1 1 {name=l595 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5880 -2470 3 0 {name=l596 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5820 -2220 0 0 {name=l597 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6150 -2340 0 0 {name=x150}
C {devices/lab_wire.sym} 6080 -2460 2 1 {name=l598 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6100 -2470 1 1 {name=l599 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6140 -2470 3 0 {name=l600 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6080 -2220 0 0 {name=l601 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6410 -2340 0 0 {name=x151}
C {devices/lab_wire.sym} 6340 -2460 2 1 {name=l602 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6360 -2470 1 1 {name=l603 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6400 -2470 3 0 {name=l604 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6340 -2220 0 0 {name=l605 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6670 -2340 0 0 {name=x152}
C {devices/lab_wire.sym} 6600 -2460 2 1 {name=l606 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6620 -2470 1 1 {name=l607 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6660 -2470 3 0 {name=l608 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6600 -2220 0 0 {name=l609 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6930 -2340 0 0 {name=x153}
C {devices/lab_wire.sym} 6860 -2460 2 1 {name=l610 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6880 -2470 1 1 {name=l611 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6920 -2470 3 0 {name=l612 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6860 -2220 0 0 {name=l613 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7190 -2340 0 0 {name=x154}
C {devices/lab_wire.sym} 7120 -2460 2 1 {name=l614 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7140 -2470 1 1 {name=l615 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7180 -2470 3 0 {name=l616 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7120 -2220 0 0 {name=l617 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7450 -2340 0 0 {name=x155}
C {devices/lab_wire.sym} 7380 -2460 2 1 {name=l618 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7400 -2470 1 1 {name=l619 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7440 -2470 3 0 {name=l620 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7380 -2220 0 0 {name=l621 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7710 -2340 0 0 {name=x156}
C {devices/lab_wire.sym} 7640 -2460 2 1 {name=l622 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7660 -2470 1 1 {name=l623 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7700 -2470 3 0 {name=l624 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7640 -2220 0 0 {name=l625 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7970 -2340 0 0 {name=x157}
C {devices/lab_wire.sym} 7900 -2460 2 1 {name=l626 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7920 -2470 1 1 {name=l627 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7960 -2470 3 0 {name=l628 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7900 -2220 0 0 {name=l629 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8230 -2340 0 0 {name=x158}
C {devices/lab_wire.sym} 8160 -2460 2 1 {name=l630 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8180 -2470 1 1 {name=l631 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8220 -2470 3 0 {name=l632 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8160 -2220 0 0 {name=l633 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8490 -2340 0 0 {name=x159}
C {devices/lab_wire.sym} 8420 -2460 2 1 {name=l634 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8440 -2470 1 1 {name=l635 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8480 -2470 3 0 {name=l636 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8420 -2220 0 0 {name=l637 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8750 -2340 0 0 {name=x160}
C {devices/lab_wire.sym} 8680 -2460 2 1 {name=l638 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8700 -2470 1 1 {name=l639 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8740 -2470 3 0 {name=l640 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8680 -2220 0 0 {name=l641 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 690 -2600 0 0 {name=x161}
C {devices/lab_wire.sym} 620 -2720 2 1 {name=l642 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 640 -2730 1 1 {name=l643 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 680 -2730 3 0 {name=l644 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 620 -2480 0 0 {name=l645 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 950 -2600 0 0 {name=x162}
C {devices/lab_wire.sym} 880 -2720 2 1 {name=l646 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 900 -2730 1 1 {name=l647 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 940 -2730 3 0 {name=l648 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 880 -2480 0 0 {name=l649 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1210 -2600 0 0 {name=x163}
C {devices/lab_wire.sym} 1140 -2720 2 1 {name=l650 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1160 -2730 1 1 {name=l651 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1200 -2730 3 0 {name=l652 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1140 -2480 0 0 {name=l653 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1470 -2600 0 0 {name=x164}
C {devices/lab_wire.sym} 1400 -2720 2 1 {name=l654 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 -2730 1 1 {name=l655 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1460 -2730 3 0 {name=l656 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1400 -2480 0 0 {name=l657 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1730 -2600 0 0 {name=x165}
C {devices/lab_wire.sym} 1660 -2720 2 1 {name=l658 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1680 -2730 1 1 {name=l659 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1720 -2730 3 0 {name=l660 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1660 -2480 0 0 {name=l661 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1990 -2600 0 0 {name=x166}
C {devices/lab_wire.sym} 1920 -2720 2 1 {name=l662 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1940 -2730 1 1 {name=l663 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1980 -2730 3 0 {name=l664 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1920 -2480 0 0 {name=l665 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2250 -2600 0 0 {name=x167}
C {devices/lab_wire.sym} 2180 -2720 2 1 {name=l666 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2200 -2730 1 1 {name=l667 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2240 -2730 3 0 {name=l668 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2180 -2480 0 0 {name=l669 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2510 -2600 0 0 {name=x168}
C {devices/lab_wire.sym} 2440 -2720 2 1 {name=l670 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2460 -2730 1 1 {name=l671 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2500 -2730 3 0 {name=l672 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2440 -2480 0 0 {name=l673 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2770 -2600 0 0 {name=x169}
C {devices/lab_wire.sym} 2700 -2720 2 1 {name=l674 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2720 -2730 1 1 {name=l675 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2760 -2730 3 0 {name=l676 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2700 -2480 0 0 {name=l677 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3030 -2600 0 0 {name=x170}
C {devices/lab_wire.sym} 2960 -2720 2 1 {name=l678 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2980 -2730 1 1 {name=l679 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3020 -2730 3 0 {name=l680 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2960 -2480 0 0 {name=l681 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3290 -2600 0 0 {name=x171}
C {devices/lab_wire.sym} 3220 -2720 2 1 {name=l682 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3240 -2730 1 1 {name=l683 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3280 -2730 3 0 {name=l684 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3220 -2480 0 0 {name=l685 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3550 -2600 0 0 {name=x172}
C {devices/lab_wire.sym} 3480 -2720 2 1 {name=l686 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3500 -2730 1 1 {name=l687 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3540 -2730 3 0 {name=l688 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3480 -2480 0 0 {name=l689 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3810 -2600 0 0 {name=x173}
C {devices/lab_wire.sym} 3740 -2720 2 1 {name=l690 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3760 -2730 1 1 {name=l691 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3800 -2730 3 0 {name=l692 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3740 -2480 0 0 {name=l693 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4070 -2600 0 0 {name=x174}
C {devices/lab_wire.sym} 4000 -2720 2 1 {name=l694 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4020 -2730 1 1 {name=l695 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4060 -2730 3 0 {name=l696 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4000 -2480 0 0 {name=l697 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4330 -2600 0 0 {name=x175}
C {devices/lab_wire.sym} 4260 -2720 2 1 {name=l698 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4280 -2730 1 1 {name=l699 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4320 -2730 3 0 {name=l700 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4260 -2480 0 0 {name=l701 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4590 -2600 0 0 {name=x176}
C {devices/lab_wire.sym} 4520 -2720 2 1 {name=l702 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4540 -2730 1 1 {name=l703 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4580 -2730 3 0 {name=l704 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4520 -2480 0 0 {name=l705 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4850 -2600 0 0 {name=x177}
C {devices/lab_wire.sym} 4780 -2720 2 1 {name=l706 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4800 -2730 1 1 {name=l707 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4840 -2730 3 0 {name=l708 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4780 -2480 0 0 {name=l709 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5110 -2600 0 0 {name=x178}
C {devices/lab_wire.sym} 5040 -2720 2 1 {name=l710 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5060 -2730 1 1 {name=l711 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5100 -2730 3 0 {name=l712 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5040 -2480 0 0 {name=l713 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5370 -2600 0 0 {name=x179}
C {devices/lab_wire.sym} 5300 -2720 2 1 {name=l714 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5320 -2730 1 1 {name=l715 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5360 -2730 3 0 {name=l716 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5300 -2480 0 0 {name=l717 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5630 -2600 0 0 {name=x180}
C {devices/lab_wire.sym} 5560 -2720 2 1 {name=l718 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5580 -2730 1 1 {name=l719 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5620 -2730 3 0 {name=l720 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5560 -2480 0 0 {name=l721 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5890 -2600 0 0 {name=x181}
C {devices/lab_wire.sym} 5820 -2720 2 1 {name=l722 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5840 -2730 1 1 {name=l723 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5880 -2730 3 0 {name=l724 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5820 -2480 0 0 {name=l725 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6150 -2600 0 0 {name=x182}
C {devices/lab_wire.sym} 6080 -2720 2 1 {name=l726 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6100 -2730 1 1 {name=l727 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6140 -2730 3 0 {name=l728 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6080 -2480 0 0 {name=l729 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6410 -2600 0 0 {name=x183}
C {devices/lab_wire.sym} 6340 -2720 2 1 {name=l730 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6360 -2730 1 1 {name=l731 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6400 -2730 3 0 {name=l732 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6340 -2480 0 0 {name=l733 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6670 -2600 0 0 {name=x184}
C {devices/lab_wire.sym} 6600 -2720 2 1 {name=l734 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6620 -2730 1 1 {name=l735 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6660 -2730 3 0 {name=l736 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6600 -2480 0 0 {name=l737 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6930 -2600 0 0 {name=x185}
C {devices/lab_wire.sym} 6860 -2720 2 1 {name=l738 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6880 -2730 1 1 {name=l739 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6920 -2730 3 0 {name=l740 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6860 -2480 0 0 {name=l741 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7190 -2600 0 0 {name=x186}
C {devices/lab_wire.sym} 7120 -2720 2 1 {name=l742 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7140 -2730 1 1 {name=l743 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7180 -2730 3 0 {name=l744 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7120 -2480 0 0 {name=l745 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7450 -2600 0 0 {name=x187}
C {devices/lab_wire.sym} 7380 -2720 2 1 {name=l746 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7400 -2730 1 1 {name=l747 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7440 -2730 3 0 {name=l748 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7380 -2480 0 0 {name=l749 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7710 -2600 0 0 {name=x188}
C {devices/lab_wire.sym} 7640 -2720 2 1 {name=l750 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7660 -2730 1 1 {name=l751 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7700 -2730 3 0 {name=l752 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7640 -2480 0 0 {name=l753 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7970 -2600 0 0 {name=x189}
C {devices/lab_wire.sym} 7900 -2720 2 1 {name=l754 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7920 -2730 1 1 {name=l755 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7960 -2730 3 0 {name=l756 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7900 -2480 0 0 {name=l757 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8230 -2600 0 0 {name=x190}
C {devices/lab_wire.sym} 8160 -2720 2 1 {name=l758 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8180 -2730 1 1 {name=l759 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8220 -2730 3 0 {name=l760 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8160 -2480 0 0 {name=l761 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8490 -2600 0 0 {name=x191}
C {devices/lab_wire.sym} 8420 -2720 2 1 {name=l762 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8440 -2730 1 1 {name=l763 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8480 -2730 3 0 {name=l764 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8420 -2480 0 0 {name=l765 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8750 -2600 0 0 {name=x192}
C {devices/lab_wire.sym} 8680 -2720 2 1 {name=l766 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8700 -2730 1 1 {name=l767 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8740 -2730 3 0 {name=l768 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8680 -2480 0 0 {name=l769 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 690 -2860 0 0 {name=x193}
C {devices/lab_wire.sym} 620 -2980 2 1 {name=l770 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 640 -2990 1 1 {name=l771 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 680 -2990 3 0 {name=l772 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 620 -2740 0 0 {name=l773 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 950 -2860 0 0 {name=x194}
C {devices/lab_wire.sym} 880 -2980 2 1 {name=l774 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 900 -2990 1 1 {name=l775 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 940 -2990 3 0 {name=l776 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 880 -2740 0 0 {name=l777 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1210 -2860 0 0 {name=x195}
C {devices/lab_wire.sym} 1140 -2980 2 1 {name=l778 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1160 -2990 1 1 {name=l779 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1200 -2990 3 0 {name=l780 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1140 -2740 0 0 {name=l781 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1470 -2860 0 0 {name=x196}
C {devices/lab_wire.sym} 1400 -2980 2 1 {name=l782 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 -2990 1 1 {name=l783 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1460 -2990 3 0 {name=l784 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1400 -2740 0 0 {name=l785 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1730 -2860 0 0 {name=x197}
C {devices/lab_wire.sym} 1660 -2980 2 1 {name=l786 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1680 -2990 1 1 {name=l787 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1720 -2990 3 0 {name=l788 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1660 -2740 0 0 {name=l789 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1990 -2860 0 0 {name=x198}
C {devices/lab_wire.sym} 1920 -2980 2 1 {name=l790 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1940 -2990 1 1 {name=l791 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1980 -2990 3 0 {name=l792 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1920 -2740 0 0 {name=l793 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2250 -2860 0 0 {name=x199}
C {devices/lab_wire.sym} 2180 -2980 2 1 {name=l794 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2200 -2990 1 1 {name=l795 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2240 -2990 3 0 {name=l796 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2180 -2740 0 0 {name=l797 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2510 -2860 0 0 {name=x200}
C {devices/lab_wire.sym} 2440 -2980 2 1 {name=l798 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2460 -2990 1 1 {name=l799 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2500 -2990 3 0 {name=l800 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2440 -2740 0 0 {name=l801 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2770 -2860 0 0 {name=x201}
C {devices/lab_wire.sym} 2700 -2980 2 1 {name=l802 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2720 -2990 1 1 {name=l803 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2760 -2990 3 0 {name=l804 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2700 -2740 0 0 {name=l805 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3030 -2860 0 0 {name=x202}
C {devices/lab_wire.sym} 2960 -2980 2 1 {name=l806 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2980 -2990 1 1 {name=l807 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3020 -2990 3 0 {name=l808 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2960 -2740 0 0 {name=l809 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3290 -2860 0 0 {name=x203}
C {devices/lab_wire.sym} 3220 -2980 2 1 {name=l810 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3240 -2990 1 1 {name=l811 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3280 -2990 3 0 {name=l812 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3220 -2740 0 0 {name=l813 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3550 -2860 0 0 {name=x204}
C {devices/lab_wire.sym} 3480 -2980 2 1 {name=l814 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3500 -2990 1 1 {name=l815 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3540 -2990 3 0 {name=l816 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3480 -2740 0 0 {name=l817 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3810 -2860 0 0 {name=x205}
C {devices/lab_wire.sym} 3740 -2980 2 1 {name=l818 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3760 -2990 1 1 {name=l819 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3800 -2990 3 0 {name=l820 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3740 -2740 0 0 {name=l821 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4070 -2860 0 0 {name=x206}
C {devices/lab_wire.sym} 4000 -2980 2 1 {name=l822 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4020 -2990 1 1 {name=l823 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4060 -2990 3 0 {name=l824 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4000 -2740 0 0 {name=l825 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4330 -2860 0 0 {name=x207}
C {devices/lab_wire.sym} 4260 -2980 2 1 {name=l826 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4280 -2990 1 1 {name=l827 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4320 -2990 3 0 {name=l828 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4260 -2740 0 0 {name=l829 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4590 -2860 0 0 {name=x208}
C {devices/lab_wire.sym} 4520 -2980 2 1 {name=l830 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4540 -2990 1 1 {name=l831 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4580 -2990 3 0 {name=l832 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4520 -2740 0 0 {name=l833 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4850 -2860 0 0 {name=x209}
C {devices/lab_wire.sym} 4780 -2980 2 1 {name=l834 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4800 -2990 1 1 {name=l835 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4840 -2990 3 0 {name=l836 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4780 -2740 0 0 {name=l837 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5110 -2860 0 0 {name=x210}
C {devices/lab_wire.sym} 5040 -2980 2 1 {name=l838 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5060 -2990 1 1 {name=l839 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5100 -2990 3 0 {name=l840 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5040 -2740 0 0 {name=l841 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5370 -2860 0 0 {name=x211}
C {devices/lab_wire.sym} 5300 -2980 2 1 {name=l842 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5320 -2990 1 1 {name=l843 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5360 -2990 3 0 {name=l844 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5300 -2740 0 0 {name=l845 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5630 -2860 0 0 {name=x212}
C {devices/lab_wire.sym} 5560 -2980 2 1 {name=l846 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5580 -2990 1 1 {name=l847 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5620 -2990 3 0 {name=l848 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5560 -2740 0 0 {name=l849 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5890 -2860 0 0 {name=x213}
C {devices/lab_wire.sym} 5820 -2980 2 1 {name=l850 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5840 -2990 1 1 {name=l851 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5880 -2990 3 0 {name=l852 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5820 -2740 0 0 {name=l853 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6150 -2860 0 0 {name=x214}
C {devices/lab_wire.sym} 6080 -2980 2 1 {name=l854 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6100 -2990 1 1 {name=l855 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6140 -2990 3 0 {name=l856 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6080 -2740 0 0 {name=l857 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6410 -2860 0 0 {name=x215}
C {devices/lab_wire.sym} 6340 -2980 2 1 {name=l858 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6360 -2990 1 1 {name=l859 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6400 -2990 3 0 {name=l860 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6340 -2740 0 0 {name=l861 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6670 -2860 0 0 {name=x216}
C {devices/lab_wire.sym} 6600 -2980 2 1 {name=l862 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6620 -2990 1 1 {name=l863 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6660 -2990 3 0 {name=l864 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6600 -2740 0 0 {name=l865 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6930 -2860 0 0 {name=x217}
C {devices/lab_wire.sym} 6860 -2980 2 1 {name=l866 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6880 -2990 1 1 {name=l867 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6920 -2990 3 0 {name=l868 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6860 -2740 0 0 {name=l869 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7190 -2860 0 0 {name=x218}
C {devices/lab_wire.sym} 7120 -2980 2 1 {name=l870 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7140 -2990 1 1 {name=l871 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7180 -2990 3 0 {name=l872 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7120 -2740 0 0 {name=l873 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7450 -2860 0 0 {name=x219}
C {devices/lab_wire.sym} 7380 -2980 2 1 {name=l874 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7400 -2990 1 1 {name=l875 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7440 -2990 3 0 {name=l876 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7380 -2740 0 0 {name=l877 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7710 -2860 0 0 {name=x220}
C {devices/lab_wire.sym} 7640 -2980 2 1 {name=l878 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7660 -2990 1 1 {name=l879 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7700 -2990 3 0 {name=l880 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7640 -2740 0 0 {name=l881 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7970 -2860 0 0 {name=x221}
C {devices/lab_wire.sym} 7900 -2980 2 1 {name=l882 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7920 -2990 1 1 {name=l883 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7960 -2990 3 0 {name=l884 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7900 -2740 0 0 {name=l885 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8230 -2860 0 0 {name=x222}
C {devices/lab_wire.sym} 8160 -2980 2 1 {name=l886 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8180 -2990 1 1 {name=l887 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8220 -2990 3 0 {name=l888 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8160 -2740 0 0 {name=l889 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8490 -2860 0 0 {name=x223}
C {devices/lab_wire.sym} 8420 -2980 2 1 {name=l890 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8440 -2990 1 1 {name=l891 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8480 -2990 3 0 {name=l892 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8420 -2740 0 0 {name=l893 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8750 -2860 0 0 {name=x224}
C {devices/lab_wire.sym} 8680 -2980 2 1 {name=l894 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8700 -2990 1 1 {name=l895 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8740 -2990 3 0 {name=l896 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8680 -2740 0 0 {name=l897 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 690 -3120 0 0 {name=x225}
C {devices/lab_wire.sym} 620 -3240 2 1 {name=l898 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 640 -3250 1 1 {name=l899 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 680 -3250 3 0 {name=l900 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 620 -3000 0 0 {name=l901 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 950 -3120 0 0 {name=x226}
C {devices/lab_wire.sym} 880 -3240 2 1 {name=l902 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 900 -3250 1 1 {name=l903 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 940 -3250 3 0 {name=l904 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 880 -3000 0 0 {name=l905 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1210 -3120 0 0 {name=x227}
C {devices/lab_wire.sym} 1140 -3240 2 1 {name=l906 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1160 -3250 1 1 {name=l907 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1200 -3250 3 0 {name=l908 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1140 -3000 0 0 {name=l909 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1470 -3120 0 0 {name=x228}
C {devices/lab_wire.sym} 1400 -3240 2 1 {name=l910 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 -3250 1 1 {name=l911 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1460 -3250 3 0 {name=l912 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1400 -3000 0 0 {name=l913 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1730 -3120 0 0 {name=x229}
C {devices/lab_wire.sym} 1660 -3240 2 1 {name=l914 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1680 -3250 1 1 {name=l915 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1720 -3250 3 0 {name=l916 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1660 -3000 0 0 {name=l917 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1990 -3120 0 0 {name=x230}
C {devices/lab_wire.sym} 1920 -3240 2 1 {name=l918 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1940 -3250 1 1 {name=l919 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1980 -3250 3 0 {name=l920 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1920 -3000 0 0 {name=l921 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2250 -3120 0 0 {name=x231}
C {devices/lab_wire.sym} 2180 -3240 2 1 {name=l922 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2200 -3250 1 1 {name=l923 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2240 -3250 3 0 {name=l924 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2180 -3000 0 0 {name=l925 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2510 -3120 0 0 {name=x232}
C {devices/lab_wire.sym} 2440 -3240 2 1 {name=l926 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2460 -3250 1 1 {name=l927 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2500 -3250 3 0 {name=l928 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2440 -3000 0 0 {name=l929 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2770 -3120 0 0 {name=x233}
C {devices/lab_wire.sym} 2700 -3240 2 1 {name=l930 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2720 -3250 1 1 {name=l931 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2760 -3250 3 0 {name=l932 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2700 -3000 0 0 {name=l933 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3030 -3120 0 0 {name=x234}
C {devices/lab_wire.sym} 2960 -3240 2 1 {name=l934 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2980 -3250 1 1 {name=l935 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3020 -3250 3 0 {name=l936 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2960 -3000 0 0 {name=l937 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3290 -3120 0 0 {name=x235}
C {devices/lab_wire.sym} 3220 -3240 2 1 {name=l938 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3240 -3250 1 1 {name=l939 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3280 -3250 3 0 {name=l940 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3220 -3000 0 0 {name=l941 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3550 -3120 0 0 {name=x236}
C {devices/lab_wire.sym} 3480 -3240 2 1 {name=l942 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3500 -3250 1 1 {name=l943 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3540 -3250 3 0 {name=l944 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3480 -3000 0 0 {name=l945 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3810 -3120 0 0 {name=x237}
C {devices/lab_wire.sym} 3740 -3240 2 1 {name=l946 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3760 -3250 1 1 {name=l947 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3800 -3250 3 0 {name=l948 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3740 -3000 0 0 {name=l949 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4070 -3120 0 0 {name=x238}
C {devices/lab_wire.sym} 4000 -3240 2 1 {name=l950 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4020 -3250 1 1 {name=l951 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4060 -3250 3 0 {name=l952 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4000 -3000 0 0 {name=l953 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4330 -3120 0 0 {name=x239}
C {devices/lab_wire.sym} 4260 -3240 2 1 {name=l954 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4280 -3250 1 1 {name=l955 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4320 -3250 3 0 {name=l956 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4260 -3000 0 0 {name=l957 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4590 -3120 0 0 {name=x240}
C {devices/lab_wire.sym} 4520 -3240 2 1 {name=l958 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4540 -3250 1 1 {name=l959 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4580 -3250 3 0 {name=l960 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4520 -3000 0 0 {name=l961 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4850 -3120 0 0 {name=x241}
C {devices/lab_wire.sym} 4780 -3240 2 1 {name=l962 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4800 -3250 1 1 {name=l963 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4840 -3250 3 0 {name=l964 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4780 -3000 0 0 {name=l965 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5110 -3120 0 0 {name=x242}
C {devices/lab_wire.sym} 5040 -3240 2 1 {name=l966 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5060 -3250 1 1 {name=l967 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5100 -3250 3 0 {name=l968 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5040 -3000 0 0 {name=l969 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5370 -3120 0 0 {name=x243}
C {devices/lab_wire.sym} 5300 -3240 2 1 {name=l970 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5320 -3250 1 1 {name=l971 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5360 -3250 3 0 {name=l972 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5300 -3000 0 0 {name=l973 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5630 -3120 0 0 {name=x244}
C {devices/lab_wire.sym} 5560 -3240 2 1 {name=l974 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5580 -3250 1 1 {name=l975 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5620 -3250 3 0 {name=l976 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5560 -3000 0 0 {name=l977 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5890 -3120 0 0 {name=x245}
C {devices/lab_wire.sym} 5820 -3240 2 1 {name=l978 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5840 -3250 1 1 {name=l979 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5880 -3250 3 0 {name=l980 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5820 -3000 0 0 {name=l981 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6150 -3120 0 0 {name=x246}
C {devices/lab_wire.sym} 6080 -3240 2 1 {name=l982 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6100 -3250 1 1 {name=l983 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6140 -3250 3 0 {name=l984 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6080 -3000 0 0 {name=l985 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6410 -3120 0 0 {name=x247}
C {devices/lab_wire.sym} 6340 -3240 2 1 {name=l986 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6360 -3250 1 1 {name=l987 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6400 -3250 3 0 {name=l988 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6340 -3000 0 0 {name=l989 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6670 -3120 0 0 {name=x248}
C {devices/lab_wire.sym} 6600 -3240 2 1 {name=l990 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6620 -3250 1 1 {name=l991 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6660 -3250 3 0 {name=l992 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6600 -3000 0 0 {name=l993 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6930 -3120 0 0 {name=x249}
C {devices/lab_wire.sym} 6860 -3240 2 1 {name=l994 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6880 -3250 1 1 {name=l995 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6920 -3250 3 0 {name=l996 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6860 -3000 0 0 {name=l997 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7190 -3120 0 0 {name=x250}
C {devices/lab_wire.sym} 7120 -3240 2 1 {name=l998 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7140 -3250 1 1 {name=l999 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7180 -3250 3 0 {name=l1000 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7120 -3000 0 0 {name=l1001 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7450 -3120 0 0 {name=x251}
C {devices/lab_wire.sym} 7380 -3240 2 1 {name=l1002 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7400 -3250 1 1 {name=l1003 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7440 -3250 3 0 {name=l1004 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7380 -3000 0 0 {name=l1005 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7710 -3120 0 0 {name=x252}
C {devices/lab_wire.sym} 7640 -3240 2 1 {name=l1006 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7660 -3250 1 1 {name=l1007 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7700 -3250 3 0 {name=l1008 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7640 -3000 0 0 {name=l1009 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7970 -3120 0 0 {name=x253}
C {devices/lab_wire.sym} 7900 -3240 2 1 {name=l1010 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7920 -3250 1 1 {name=l1011 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7960 -3250 3 0 {name=l1012 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7900 -3000 0 0 {name=l1013 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8230 -3120 0 0 {name=x254}
C {devices/lab_wire.sym} 8160 -3240 2 1 {name=l1014 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8180 -3250 1 1 {name=l1015 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8220 -3250 3 0 {name=l1016 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8160 -3000 0 0 {name=l1017 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8490 -3120 0 0 {name=x255}
C {devices/lab_wire.sym} 8420 -3240 2 1 {name=l1018 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8440 -3250 1 1 {name=l1019 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8480 -3250 3 0 {name=l1020 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8420 -3000 0 0 {name=l1021 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8750 -3120 0 0 {name=x256}
C {devices/lab_wire.sym} 8680 -3240 2 1 {name=l1022 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8700 -3250 1 1 {name=l1023 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8740 -3250 3 0 {name=l1024 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8680 -3000 0 0 {name=l1025 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 690 -3380 0 0 {name=x257}
C {devices/lab_wire.sym} 620 -3500 2 1 {name=l1026 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 640 -3510 1 1 {name=l1027 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 680 -3510 3 0 {name=l1028 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 620 -3260 0 0 {name=l1029 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 950 -3380 0 0 {name=x258}
C {devices/lab_wire.sym} 880 -3500 2 1 {name=l1030 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 900 -3510 1 1 {name=l1031 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 940 -3510 3 0 {name=l1032 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 880 -3260 0 0 {name=l1033 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1210 -3380 0 0 {name=x259}
C {devices/lab_wire.sym} 1140 -3500 2 1 {name=l1034 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1160 -3510 1 1 {name=l1035 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1200 -3510 3 0 {name=l1036 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1140 -3260 0 0 {name=l1037 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1470 -3380 0 0 {name=x260}
C {devices/lab_wire.sym} 1400 -3500 2 1 {name=l1038 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 -3510 1 1 {name=l1039 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1460 -3510 3 0 {name=l1040 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1400 -3260 0 0 {name=l1041 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1730 -3380 0 0 {name=x261}
C {devices/lab_wire.sym} 1660 -3500 2 1 {name=l1042 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1680 -3510 1 1 {name=l1043 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1720 -3510 3 0 {name=l1044 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1660 -3260 0 0 {name=l1045 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1990 -3380 0 0 {name=x262}
C {devices/lab_wire.sym} 1920 -3500 2 1 {name=l1046 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1940 -3510 1 1 {name=l1047 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1980 -3510 3 0 {name=l1048 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1920 -3260 0 0 {name=l1049 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2250 -3380 0 0 {name=x263}
C {devices/lab_wire.sym} 2180 -3500 2 1 {name=l1050 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2200 -3510 1 1 {name=l1051 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2240 -3510 3 0 {name=l1052 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2180 -3260 0 0 {name=l1053 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2510 -3380 0 0 {name=x264}
C {devices/lab_wire.sym} 2440 -3500 2 1 {name=l1054 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2460 -3510 1 1 {name=l1055 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2500 -3510 3 0 {name=l1056 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2440 -3260 0 0 {name=l1057 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2770 -3380 0 0 {name=x265}
C {devices/lab_wire.sym} 2700 -3500 2 1 {name=l1058 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2720 -3510 1 1 {name=l1059 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2760 -3510 3 0 {name=l1060 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2700 -3260 0 0 {name=l1061 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3030 -3380 0 0 {name=x266}
C {devices/lab_wire.sym} 2960 -3500 2 1 {name=l1062 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2980 -3510 1 1 {name=l1063 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3020 -3510 3 0 {name=l1064 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2960 -3260 0 0 {name=l1065 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3290 -3380 0 0 {name=x267}
C {devices/lab_wire.sym} 3220 -3500 2 1 {name=l1066 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3240 -3510 1 1 {name=l1067 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3280 -3510 3 0 {name=l1068 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3220 -3260 0 0 {name=l1069 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3550 -3380 0 0 {name=x268}
C {devices/lab_wire.sym} 3480 -3500 2 1 {name=l1070 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3500 -3510 1 1 {name=l1071 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3540 -3510 3 0 {name=l1072 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3480 -3260 0 0 {name=l1073 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3810 -3380 0 0 {name=x269}
C {devices/lab_wire.sym} 3740 -3500 2 1 {name=l1074 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3760 -3510 1 1 {name=l1075 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3800 -3510 3 0 {name=l1076 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3740 -3260 0 0 {name=l1077 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4070 -3380 0 0 {name=x270}
C {devices/lab_wire.sym} 4000 -3500 2 1 {name=l1078 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4020 -3510 1 1 {name=l1079 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4060 -3510 3 0 {name=l1080 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4000 -3260 0 0 {name=l1081 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4330 -3380 0 0 {name=x271}
C {devices/lab_wire.sym} 4260 -3500 2 1 {name=l1082 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4280 -3510 1 1 {name=l1083 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4320 -3510 3 0 {name=l1084 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4260 -3260 0 0 {name=l1085 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4590 -3380 0 0 {name=x272}
C {devices/lab_wire.sym} 4520 -3500 2 1 {name=l1086 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4540 -3510 1 1 {name=l1087 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4580 -3510 3 0 {name=l1088 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4520 -3260 0 0 {name=l1089 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4850 -3380 0 0 {name=x273}
C {devices/lab_wire.sym} 4780 -3500 2 1 {name=l1090 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4800 -3510 1 1 {name=l1091 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4840 -3510 3 0 {name=l1092 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4780 -3260 0 0 {name=l1093 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5110 -3380 0 0 {name=x274}
C {devices/lab_wire.sym} 5040 -3500 2 1 {name=l1094 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5060 -3510 1 1 {name=l1095 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5100 -3510 3 0 {name=l1096 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5040 -3260 0 0 {name=l1097 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5370 -3380 0 0 {name=x275}
C {devices/lab_wire.sym} 5300 -3500 2 1 {name=l1098 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5320 -3510 1 1 {name=l1099 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5360 -3510 3 0 {name=l1100 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5300 -3260 0 0 {name=l1101 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5630 -3380 0 0 {name=x276}
C {devices/lab_wire.sym} 5560 -3500 2 1 {name=l1102 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5580 -3510 1 1 {name=l1103 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5620 -3510 3 0 {name=l1104 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5560 -3260 0 0 {name=l1105 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5890 -3380 0 0 {name=x277}
C {devices/lab_wire.sym} 5820 -3500 2 1 {name=l1106 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5840 -3510 1 1 {name=l1107 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5880 -3510 3 0 {name=l1108 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5820 -3260 0 0 {name=l1109 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6150 -3380 0 0 {name=x278}
C {devices/lab_wire.sym} 6080 -3500 2 1 {name=l1110 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6100 -3510 1 1 {name=l1111 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6140 -3510 3 0 {name=l1112 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6080 -3260 0 0 {name=l1113 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6410 -3380 0 0 {name=x279}
C {devices/lab_wire.sym} 6340 -3500 2 1 {name=l1114 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6360 -3510 1 1 {name=l1115 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6400 -3510 3 0 {name=l1116 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6340 -3260 0 0 {name=l1117 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6670 -3380 0 0 {name=x280}
C {devices/lab_wire.sym} 6600 -3500 2 1 {name=l1118 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6620 -3510 1 1 {name=l1119 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6660 -3510 3 0 {name=l1120 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6600 -3260 0 0 {name=l1121 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6930 -3380 0 0 {name=x281}
C {devices/lab_wire.sym} 6860 -3500 2 1 {name=l1122 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6880 -3510 1 1 {name=l1123 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6920 -3510 3 0 {name=l1124 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6860 -3260 0 0 {name=l1125 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7190 -3380 0 0 {name=x282}
C {devices/lab_wire.sym} 7120 -3500 2 1 {name=l1126 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7140 -3510 1 1 {name=l1127 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7180 -3510 3 0 {name=l1128 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7120 -3260 0 0 {name=l1129 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7450 -3380 0 0 {name=x283}
C {devices/lab_wire.sym} 7380 -3500 2 1 {name=l1130 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7400 -3510 1 1 {name=l1131 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7440 -3510 3 0 {name=l1132 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7380 -3260 0 0 {name=l1133 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7710 -3380 0 0 {name=x284}
C {devices/lab_wire.sym} 7640 -3500 2 1 {name=l1134 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7660 -3510 1 1 {name=l1135 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7700 -3510 3 0 {name=l1136 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7640 -3260 0 0 {name=l1137 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7970 -3380 0 0 {name=x285}
C {devices/lab_wire.sym} 7900 -3500 2 1 {name=l1138 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7920 -3510 1 1 {name=l1139 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7960 -3510 3 0 {name=l1140 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7900 -3260 0 0 {name=l1141 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8230 -3380 0 0 {name=x286}
C {devices/lab_wire.sym} 8160 -3500 2 1 {name=l1142 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8180 -3510 1 1 {name=l1143 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8220 -3510 3 0 {name=l1144 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8160 -3260 0 0 {name=l1145 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8490 -3380 0 0 {name=x287}
C {devices/lab_wire.sym} 8420 -3500 2 1 {name=l1146 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8440 -3510 1 1 {name=l1147 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8480 -3510 3 0 {name=l1148 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8420 -3260 0 0 {name=l1149 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8750 -3380 0 0 {name=x288}
C {devices/lab_wire.sym} 8680 -3500 2 1 {name=l1150 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8700 -3510 1 1 {name=l1151 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8740 -3510 3 0 {name=l1152 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8680 -3260 0 0 {name=l1153 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 690 -3640 0 0 {name=x289}
C {devices/lab_wire.sym} 620 -3760 2 1 {name=l1154 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 640 -3770 1 1 {name=l1155 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 680 -3770 3 0 {name=l1156 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 620 -3520 0 0 {name=l1157 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 950 -3640 0 0 {name=x290}
C {devices/lab_wire.sym} 880 -3760 2 1 {name=l1158 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 900 -3770 1 1 {name=l1159 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 940 -3770 3 0 {name=l1160 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 880 -3520 0 0 {name=l1161 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1210 -3640 0 0 {name=x291}
C {devices/lab_wire.sym} 1140 -3760 2 1 {name=l1162 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1160 -3770 1 1 {name=l1163 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1200 -3770 3 0 {name=l1164 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1140 -3520 0 0 {name=l1165 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1470 -3640 0 0 {name=x292}
C {devices/lab_wire.sym} 1400 -3760 2 1 {name=l1166 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 -3770 1 1 {name=l1167 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1460 -3770 3 0 {name=l1168 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1400 -3520 0 0 {name=l1169 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1730 -3640 0 0 {name=x293}
C {devices/lab_wire.sym} 1660 -3760 2 1 {name=l1170 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1680 -3770 1 1 {name=l1171 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1720 -3770 3 0 {name=l1172 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1660 -3520 0 0 {name=l1173 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1990 -3640 0 0 {name=x294}
C {devices/lab_wire.sym} 1920 -3760 2 1 {name=l1174 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1940 -3770 1 1 {name=l1175 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1980 -3770 3 0 {name=l1176 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1920 -3520 0 0 {name=l1177 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2250 -3640 0 0 {name=x295}
C {devices/lab_wire.sym} 2180 -3760 2 1 {name=l1178 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2200 -3770 1 1 {name=l1179 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2240 -3770 3 0 {name=l1180 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2180 -3520 0 0 {name=l1181 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2510 -3640 0 0 {name=x296}
C {devices/lab_wire.sym} 2440 -3760 2 1 {name=l1182 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2460 -3770 1 1 {name=l1183 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2500 -3770 3 0 {name=l1184 sig_type=std_logic lab=ctop}
