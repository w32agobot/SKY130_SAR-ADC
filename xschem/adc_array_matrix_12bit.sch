v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 4 220 -650 280 -650 {}
L 4 280 -650 280 -310 {}
L 4 240 -310 280 -310 {}
L 4 220 -310 240 -310 {}
L 4 220 -650 220 -310 {}
L 4 240 -670 240 -650 {}
L 4 250 -310 250 -290 {}
L 4 260 -670 260 -650 {}
L 4 200 -590 220 -590 {}
L 4 200 -570 220 -570 {}
L 4 200 -510 220 -510 {}
L 4 200 -490 220 -490 {}
L 4 200 -470 220 -470 {}
L 4 200 -450 220 -450 {}
L 4 200 -390 220 -390 {}
L 4 200 -370 220 -370 {}
L 4 200 -350 220 -350 {}
L 4 280 -630 300 -630 {}
L 4 200 -410 220 -410 {}
L 4 1990 -510 1990 -470 {}
L 4 1970 -510 2010 -510 {}
L 4 1910 -510 1910 -470 {}
L 4 1890 -510 1930 -510 {}
L 4 1830 -510 1830 -470 {}
L 4 1810 -510 1850 -510 {}
L 4 1750 -510 1750 -470 {}
L 4 1730 -510 1770 -510 {}
L 4 1670 -510 1670 -470 {}
L 4 1650 -510 1690 -510 {}
L 4 2130 -510 2130 -470 {}
L 4 2110 -510 2150 -510 {}
L 4 1630 -470 2190 -470 {}
L 4 2025 -515 2035 -515 {}
L 4 2045 -515 2055 -515 {}
L 4 2065 -515 2075 -515 {}
L 4 2085 -515 2095 -515 {}
L 4 1650 -520 1690 -520 {}
L 4 1730 -520 1770 -520 {}
L 4 1810 -520 1850 -520 {}
L 4 1890 -520 1930 -520 {}
L 4 1970 -520 2010 -520 {}
L 4 2110 -520 2150 -520 {}
L 4 1990 -560 1990 -520 {}
L 4 1910 -560 1910 -520 {}
L 4 1830 -560 1830 -520 {}
L 4 1750 -560 1750 -520 {}
L 4 1670 -560 1670 -520 {}
L 4 2130 -560 2130 -520 {}
L 4 1990 -380 1990 -340 {}
L 4 1970 -380 2010 -380 {}
L 4 1910 -380 1910 -340 {}
L 4 1890 -380 1930 -380 {}
L 4 1830 -380 1830 -340 {}
L 4 1810 -380 1850 -380 {}
L 4 1750 -380 1750 -340 {}
L 4 1730 -380 1770 -380 {}
L 4 1670 -380 1670 -340 {}
L 4 1650 -380 1690 -380 {}
L 4 2130 -380 2130 -340 {}
L 4 2110 -380 2150 -380 {}
L 4 1630 -430 2190 -430 {}
L 4 2025 -385 2035 -385 {}
L 4 2045 -385 2055 -385 {}
L 4 2065 -385 2075 -385 {}
L 4 2085 -385 2095 -385 {}
L 4 1650 -390 1690 -390 {}
L 4 1730 -390 1770 -390 {}
L 4 1810 -390 1850 -390 {}
L 4 1890 -390 1930 -390 {}
L 4 1970 -390 2010 -390 {}
L 4 2110 -390 2150 -390 {}
L 4 1990 -430 1990 -390 {}
L 4 1910 -430 1910 -390 {}
L 4 1830 -430 1830 -390 {}
L 4 1750 -430 1750 -390 {}
L 4 1670 -430 1670 -390 {}
L 4 2130 -430 2130 -390 {}
L 4 1590 -430 1630 -430 {}
L 4 1590 -470 1630 -470 {}
L 4 1560 -470 1590 -480 {}
L 4 1560 -430 1590 -420 {}
L 4 1530 -430 1560 -430 {}
L 4 1530 -470 1560 -470 {}
L 4 1490 -470 1530 -470 {}
L 4 1490 -430 1530 -430 {}
L 4 2230 -490 2230 -410 {}
L 4 2230 -410 2310 -450 {}
L 4 2230 -490 2310 -450 {}
L 4 2190 -470 2230 -470 {}
L 4 2190 -430 2230 -430 {}
L 4 1660 -570 1670 -560 {}
L 4 1660 -590 1660 -580 {}
L 4 1670 -610 1670 -580 {}
L 4 1740 -570 1750 -560 {}
L 4 1740 -590 1740 -580 {}
L 4 1750 -610 1750 -580 {}
L 4 1760 -630 1760 -580 {}
L 4 1820 -570 1830 -560 {}
L 4 1820 -590 1820 -580 {}
L 4 1830 -610 1830 -580 {}
L 4 1840 -630 1840 -580 {}
L 4 1900 -570 1910 -560 {}
L 4 1900 -590 1900 -580 {}
L 4 1910 -610 1910 -580 {}
L 4 1920 -630 1920 -580 {}
L 4 1980 -570 1990 -560 {}
L 4 1980 -590 1980 -580 {}
L 4 1990 -610 1990 -580 {}
L 4 2000 -630 2000 -580 {}
L 4 2120 -570 2130 -560 {}
L 4 2120 -590 2120 -580 {}
L 4 2130 -610 2130 -580 {}
L 4 2140 -630 2140 -580 {}
L 4 1630 -590 2120 -590 {}
L 4 1630 -610 2130 -610 {}
L 4 1630 -630 2140 -630 {}
L 4 1660 -330 1670 -340 {}
L 4 1670 -320 1670 -290 {}
L 4 1740 -330 1750 -340 {}
L 4 1740 -320 1740 -310 {}
L 4 1750 -320 1750 -290 {}
L 4 1760 -320 1760 -270 {}
L 4 1820 -330 1830 -340 {}
L 4 1820 -320 1820 -310 {}
L 4 1830 -320 1830 -290 {}
L 4 1840 -320 1840 -270 {}
L 4 1900 -330 1910 -340 {}
L 4 1900 -320 1900 -310 {}
L 4 1910 -320 1910 -290 {}
L 4 1920 -320 1920 -270 {}
L 4 1980 -330 1990 -340 {}
L 4 1980 -320 1980 -310 {}
L 4 1990 -320 1990 -290 {}
L 4 2000 -320 2000 -270 {}
L 4 2120 -330 2130 -340 {}
L 4 2120 -320 2120 -310 {}
L 4 2130 -320 2130 -290 {}
L 4 2140 -320 2140 -270 {}
L 4 1630 -310 2120 -310 {}
L 4 1630 -290 2130 -290 {}
L 4 1630 -270 2140 -270 {}
L 4 1660 -320 1660 -270 {}
L 4 2310 -450 2380 -450 {}
T {   Copyright 2022 Manuel Moser

   Licensed under the Apache License, Version 2.0 (the "License");
   you may not use this file except in compliance with the License.
   You may obtain a copy of the License at

       http://www.apache.org/licenses/LICENSE-2.0

   Unless required by applicable law or agreed to in writing, software
   distributed under the License is distributed on an "AS IS" BASIS,
   WITHOUT WARRANTIES OR CONDITIONS OF ANY KIND, either express or implied.
   See the License for the specific language governing permissions and
   limitations under the License.} 0 -240 0 0 0.2 0.2 {}
T {511 Wafflecaps (32x16-1) for 9 Bit. 
3 Bin-Caps (4/8F, 2/8F and 1/8F) for 3 extra Bit.
+1 Unitcap.
--> 4095 unitcaps + 1 unitcap = 4096 unitcaps for 12 Bit
512*4.77fF=2.44pF} 490 -390 0 0 0.6 0.6 {}
T {Noise decoupling caps} 470 -620 0 0 0.4 0.4 {}
T {C0} 920 -1020 0 0 0.6 0.6 {}
T {Tie C0 to VDD - Enable C0 at N-input
Tie C0 to VSS - Disable C0 at P-input} 850 -830 0 0 0.3 0.3 {}
T {INP} 1420 -500 0 0 0.6 0.6 {}
T {INN} 1420 -450 0 0 0.6 0.6 {}
T {+} 2230 -490 0 0 0.6 0.6 {}
T {-} 2230 -450 0 0 0.6 0.6 {}
T {C0} 1670 -510 0 0 0.6 0.6 {}
T {C} 1750 -510 0 0 0.6 0.6 {}
T {2C} 1830 -510 0 0 0.6 0.6 {}
T {4C} 1910 -510 0 0 0.6 0.6 {}
T {8C} 1990 -510 0 0 0.6 0.6 {}
T {2048C} 2130 -510 0 0 0.6 0.6 {}
T {VDD} 1580 -650 0 0 0.4 0.4 {}
T {vcm} 1580 -630 0 0 0.4 0.4 {}
T {VSS} 1580 -610 0 0 0.4 0.4 {}
T {VDD} 1580 -250 2 1 0.4 0.4 {}
T {vcm} 1580 -270 2 1 0.4 0.4 {}
T {VSS} 1580 -290 2 1 0.4 0.4 {}
T {C0} 1670 -430 0 0 0.6 0.6 {}
T {C} 1750 -430 0 0 0.6 0.6 {}
T {2C} 1830 -430 0 0 0.6 0.6 {}
T {4C} 1910 -430 0 0 0.6 0.6 {}
T {8C} 1990 -430 0 0 0.6 0.6 {}
T {1C+4095C thermometer-coded} 1700 -670 0 0 0.4 0.4 {}
T {2048C} 2130 -430 0 0 0.6 0.6 {}
T {extra} 1680 -540 0 0 0.2 0.2 {}
T {bin1} 1760 -540 0 0 0.2 0.2 {}
T {bin2} 1840 -540 0 0 0.2 0.2 {}
T {bin4} 1920 -540 0 0 0.2 0.2 {}
T {waffle8} 2140 -540 0 0 0.2 0.2 {}
T {waffle8} 2000 -540 0 0 0.2 0.2 {}
T {extra} 1680 -370 0 0 0.2 0.2 {}
T {bin1} 1760 -370 0 0 0.2 0.2 {}
T {bin2} 1840 -370 0 0 0.2 0.2 {}
T {bin4} 1920 -370 0 0 0.2 0.2 {}
T {waffle8} 2140 -370 0 0 0.2 0.2 {}
T {waffle8} 2000 -370 0 0 0.2 0.2 {}
N 700 -1190 710 -1200 {
lab=col_n[0]}
N 710 -1400 710 -1200 {
lab=col_n[0]}
N 700 -1410 710 -1400 {
lab=col_n[0]}
N 700 -1190 700 -1170 {
lab=col_n[0]}
N 700 -1430 700 -1410 {
lab=col_n[0]}
N 580 -1330 590 -1340 {
lab=row_n[0]}
N 590 -1340 790 -1340 {
lab=row_n[0]}
N 790 -1340 800 -1330 {
lab=row_n[0]}
N 580 -1310 590 -1320 {
lab=rowon_n[0]}
N 590 -1320 790 -1320 {
lab=rowon_n[0]}
N 790 -1320 800 -1310 {
lab=rowon_n[0]}
N 580 -1290 590 -1300 {
lab=#net1}
N 590 -1300 790 -1300 {
lab=#net1}
N 790 -1300 800 -1290 {
lab=#net1}
N 580 -1270 590 -1280 {
lab=#net2}
N 590 -1280 790 -1280 {
lab=#net2}
N 790 -1280 800 -1270 {
lab=#net2}
N 640 -1430 640 -1410 {
lab=vcm}
N 680 -1430 680 -1410 {
lab=ctop}
N 560 -1330 580 -1330 {
lab=row_n[0]}
N 560 -1310 580 -1310 {
lab=rowon_n[0]}
N 560 -1290 580 -1290 {
lab=#net1}
N 560 -1270 580 -1270 {
lab=#net2}
N 800 -1270 820 -1270 {
lab=#net2}
N 800 -1290 820 -1290 {
lab=#net1}
N 800 -1310 820 -1310 {
lab=rowon_n[0]}
N 800 -1330 820 -1330 {
lab=row_n[0]}
N 620 -1190 620 -1180 {
lab=VSS}
N 620 -1420 620 -1410 {
lab=VDD}
N 960 -1190 970 -1200 {
lab=col_n[1]}
N 970 -1400 970 -1200 {
lab=col_n[1]}
N 960 -1410 970 -1400 {
lab=col_n[1]}
N 960 -1190 960 -1170 {
lab=col_n[1]}
N 960 -1430 960 -1410 {
lab=col_n[1]}
N 840 -1330 850 -1340 {
lab=row_n[0]}
N 850 -1340 1050 -1340 {
lab=row_n[0]}
N 1050 -1340 1060 -1330 {
lab=row_n[0]}
N 840 -1310 850 -1320 {
lab=rowon_n[0]}
N 850 -1320 1050 -1320 {
lab=rowon_n[0]}
N 1050 -1320 1060 -1310 {
lab=rowon_n[0]}
N 840 -1290 850 -1300 {
lab=#net1}
N 850 -1300 1050 -1300 {
lab=#net1}
N 1050 -1300 1060 -1290 {
lab=#net1}
N 840 -1270 850 -1280 {
lab=#net2}
N 850 -1280 1050 -1280 {
lab=#net2}
N 1050 -1280 1060 -1270 {
lab=#net2}
N 900 -1430 900 -1410 {
lab=vcm}
N 940 -1430 940 -1410 {
lab=ctop}
N 820 -1330 840 -1330 {
lab=row_n[0]}
N 820 -1310 840 -1310 {
lab=rowon_n[0]}
N 820 -1290 840 -1290 {
lab=#net1}
N 820 -1270 840 -1270 {
lab=#net2}
N 1060 -1270 1080 -1270 {
lab=#net2}
N 1060 -1290 1080 -1290 {
lab=#net1}
N 1060 -1310 1080 -1310 {
lab=rowon_n[0]}
N 1060 -1330 1080 -1330 {
lab=row_n[0]}
N 880 -1190 880 -1180 {
lab=VSS}
N 880 -1420 880 -1410 {
lab=VDD}
N 1220 -1190 1230 -1200 {
lab=col_n[2]}
N 1230 -1400 1230 -1200 {
lab=col_n[2]}
N 1220 -1410 1230 -1400 {
lab=col_n[2]}
N 1220 -1190 1220 -1170 {
lab=col_n[2]}
N 1220 -1430 1220 -1410 {
lab=col_n[2]}
N 1100 -1330 1110 -1340 {
lab=row_n[0]}
N 1110 -1340 1310 -1340 {
lab=row_n[0]}
N 1310 -1340 1320 -1330 {
lab=row_n[0]}
N 1100 -1310 1110 -1320 {
lab=rowon_n[0]}
N 1110 -1320 1310 -1320 {
lab=rowon_n[0]}
N 1310 -1320 1320 -1310 {
lab=rowon_n[0]}
N 1100 -1290 1110 -1300 {
lab=#net1}
N 1110 -1300 1310 -1300 {
lab=#net1}
N 1310 -1300 1320 -1290 {
lab=#net1}
N 1100 -1270 1110 -1280 {
lab=#net2}
N 1110 -1280 1310 -1280 {
lab=#net2}
N 1310 -1280 1320 -1270 {
lab=#net2}
N 1160 -1430 1160 -1410 {
lab=vcm}
N 1200 -1430 1200 -1410 {
lab=ctop}
N 1080 -1330 1100 -1330 {
lab=row_n[0]}
N 1080 -1310 1100 -1310 {
lab=rowon_n[0]}
N 1080 -1290 1100 -1290 {
lab=#net1}
N 1080 -1270 1100 -1270 {
lab=#net2}
N 1320 -1270 1340 -1270 {
lab=#net2}
N 1320 -1290 1340 -1290 {
lab=#net1}
N 1320 -1310 1340 -1310 {
lab=rowon_n[0]}
N 1320 -1330 1340 -1330 {
lab=row_n[0]}
N 1140 -1190 1140 -1180 {
lab=VSS}
N 1140 -1420 1140 -1410 {
lab=VDD}
N 1480 -1190 1490 -1200 {
lab=col_n[3]}
N 1490 -1400 1490 -1200 {
lab=col_n[3]}
N 1480 -1410 1490 -1400 {
lab=col_n[3]}
N 1480 -1190 1480 -1170 {
lab=col_n[3]}
N 1480 -1430 1480 -1410 {
lab=col_n[3]}
N 1360 -1330 1370 -1340 {
lab=row_n[0]}
N 1370 -1340 1570 -1340 {
lab=row_n[0]}
N 1570 -1340 1580 -1330 {
lab=row_n[0]}
N 1360 -1310 1370 -1320 {
lab=rowon_n[0]}
N 1370 -1320 1570 -1320 {
lab=rowon_n[0]}
N 1570 -1320 1580 -1310 {
lab=rowon_n[0]}
N 1360 -1290 1370 -1300 {
lab=#net1}
N 1370 -1300 1570 -1300 {
lab=#net1}
N 1570 -1300 1580 -1290 {
lab=#net1}
N 1360 -1270 1370 -1280 {
lab=#net2}
N 1370 -1280 1570 -1280 {
lab=#net2}
N 1570 -1280 1580 -1270 {
lab=#net2}
N 1420 -1430 1420 -1410 {
lab=vcm}
N 1460 -1430 1460 -1410 {
lab=ctop}
N 1340 -1330 1360 -1330 {
lab=row_n[0]}
N 1340 -1310 1360 -1310 {
lab=rowon_n[0]}
N 1340 -1290 1360 -1290 {
lab=#net1}
N 1340 -1270 1360 -1270 {
lab=#net2}
N 1580 -1270 1600 -1270 {
lab=#net2}
N 1580 -1290 1600 -1290 {
lab=#net1}
N 1580 -1310 1600 -1310 {
lab=rowon_n[0]}
N 1580 -1330 1600 -1330 {
lab=row_n[0]}
N 1400 -1190 1400 -1180 {
lab=VSS}
N 1400 -1420 1400 -1410 {
lab=VDD}
N 1740 -1190 1750 -1200 {
lab=col_n[4]}
N 1750 -1400 1750 -1200 {
lab=col_n[4]}
N 1740 -1410 1750 -1400 {
lab=col_n[4]}
N 1740 -1190 1740 -1170 {
lab=col_n[4]}
N 1740 -1430 1740 -1410 {
lab=col_n[4]}
N 1620 -1330 1630 -1340 {
lab=row_n[0]}
N 1630 -1340 1830 -1340 {
lab=row_n[0]}
N 1830 -1340 1840 -1330 {
lab=row_n[0]}
N 1620 -1310 1630 -1320 {
lab=rowon_n[0]}
N 1630 -1320 1830 -1320 {
lab=rowon_n[0]}
N 1830 -1320 1840 -1310 {
lab=rowon_n[0]}
N 1620 -1290 1630 -1300 {
lab=#net1}
N 1630 -1300 1830 -1300 {
lab=#net1}
N 1830 -1300 1840 -1290 {
lab=#net1}
N 1620 -1270 1630 -1280 {
lab=#net2}
N 1630 -1280 1830 -1280 {
lab=#net2}
N 1830 -1280 1840 -1270 {
lab=#net2}
N 1680 -1430 1680 -1410 {
lab=vcm}
N 1720 -1430 1720 -1410 {
lab=ctop}
N 1600 -1330 1620 -1330 {
lab=row_n[0]}
N 1600 -1310 1620 -1310 {
lab=rowon_n[0]}
N 1600 -1290 1620 -1290 {
lab=#net1}
N 1600 -1270 1620 -1270 {
lab=#net2}
N 1840 -1270 1860 -1270 {
lab=#net2}
N 1840 -1290 1860 -1290 {
lab=#net1}
N 1840 -1310 1860 -1310 {
lab=rowon_n[0]}
N 1840 -1330 1860 -1330 {
lab=row_n[0]}
N 1660 -1190 1660 -1180 {
lab=VSS}
N 1660 -1420 1660 -1410 {
lab=VDD}
N 2000 -1190 2010 -1200 {
lab=col_n[5]}
N 2010 -1400 2010 -1200 {
lab=col_n[5]}
N 2000 -1410 2010 -1400 {
lab=col_n[5]}
N 2000 -1190 2000 -1170 {
lab=col_n[5]}
N 2000 -1430 2000 -1410 {
lab=col_n[5]}
N 1880 -1330 1890 -1340 {
lab=row_n[0]}
N 1890 -1340 2090 -1340 {
lab=row_n[0]}
N 2090 -1340 2100 -1330 {
lab=row_n[0]}
N 1880 -1310 1890 -1320 {
lab=rowon_n[0]}
N 1890 -1320 2090 -1320 {
lab=rowon_n[0]}
N 2090 -1320 2100 -1310 {
lab=rowon_n[0]}
N 1880 -1290 1890 -1300 {
lab=#net1}
N 1890 -1300 2090 -1300 {
lab=#net1}
N 2090 -1300 2100 -1290 {
lab=#net1}
N 1880 -1270 1890 -1280 {
lab=#net2}
N 1890 -1280 2090 -1280 {
lab=#net2}
N 2090 -1280 2100 -1270 {
lab=#net2}
N 1940 -1430 1940 -1410 {
lab=vcm}
N 1980 -1430 1980 -1410 {
lab=ctop}
N 1860 -1330 1880 -1330 {
lab=row_n[0]}
N 1860 -1310 1880 -1310 {
lab=rowon_n[0]}
N 1860 -1290 1880 -1290 {
lab=#net1}
N 1860 -1270 1880 -1270 {
lab=#net2}
N 2100 -1270 2120 -1270 {
lab=#net2}
N 2100 -1290 2120 -1290 {
lab=#net1}
N 2100 -1310 2120 -1310 {
lab=rowon_n[0]}
N 2100 -1330 2120 -1330 {
lab=row_n[0]}
N 1920 -1190 1920 -1180 {
lab=VSS}
N 1920 -1420 1920 -1410 {
lab=VDD}
N 2260 -1190 2270 -1200 {
lab=col_n[6]}
N 2270 -1400 2270 -1200 {
lab=col_n[6]}
N 2260 -1410 2270 -1400 {
lab=col_n[6]}
N 2260 -1190 2260 -1170 {
lab=col_n[6]}
N 2260 -1430 2260 -1410 {
lab=col_n[6]}
N 2140 -1330 2150 -1340 {
lab=row_n[0]}
N 2150 -1340 2350 -1340 {
lab=row_n[0]}
N 2350 -1340 2360 -1330 {
lab=row_n[0]}
N 2140 -1310 2150 -1320 {
lab=rowon_n[0]}
N 2150 -1320 2350 -1320 {
lab=rowon_n[0]}
N 2350 -1320 2360 -1310 {
lab=rowon_n[0]}
N 2140 -1290 2150 -1300 {
lab=#net1}
N 2150 -1300 2350 -1300 {
lab=#net1}
N 2350 -1300 2360 -1290 {
lab=#net1}
N 2140 -1270 2150 -1280 {
lab=#net2}
N 2150 -1280 2350 -1280 {
lab=#net2}
N 2350 -1280 2360 -1270 {
lab=#net2}
N 2200 -1430 2200 -1410 {
lab=vcm}
N 2240 -1430 2240 -1410 {
lab=ctop}
N 2120 -1330 2140 -1330 {
lab=row_n[0]}
N 2120 -1310 2140 -1310 {
lab=rowon_n[0]}
N 2120 -1290 2140 -1290 {
lab=#net1}
N 2120 -1270 2140 -1270 {
lab=#net2}
N 2360 -1270 2380 -1270 {
lab=#net2}
N 2360 -1290 2380 -1290 {
lab=#net1}
N 2360 -1310 2380 -1310 {
lab=rowon_n[0]}
N 2360 -1330 2380 -1330 {
lab=row_n[0]}
N 2180 -1190 2180 -1180 {
lab=VSS}
N 2180 -1420 2180 -1410 {
lab=VDD}
N 2520 -1190 2530 -1200 {
lab=col_n[7]}
N 2530 -1400 2530 -1200 {
lab=col_n[7]}
N 2520 -1410 2530 -1400 {
lab=col_n[7]}
N 2520 -1190 2520 -1170 {
lab=col_n[7]}
N 2520 -1430 2520 -1410 {
lab=col_n[7]}
N 2400 -1330 2410 -1340 {
lab=row_n[0]}
N 2410 -1340 2610 -1340 {
lab=row_n[0]}
N 2610 -1340 2620 -1330 {
lab=row_n[0]}
N 2400 -1310 2410 -1320 {
lab=rowon_n[0]}
N 2410 -1320 2610 -1320 {
lab=rowon_n[0]}
N 2610 -1320 2620 -1310 {
lab=rowon_n[0]}
N 2400 -1290 2410 -1300 {
lab=#net1}
N 2410 -1300 2610 -1300 {
lab=#net1}
N 2610 -1300 2620 -1290 {
lab=#net1}
N 2400 -1270 2410 -1280 {
lab=#net2}
N 2410 -1280 2610 -1280 {
lab=#net2}
N 2610 -1280 2620 -1270 {
lab=#net2}
N 2460 -1430 2460 -1410 {
lab=vcm}
N 2500 -1430 2500 -1410 {
lab=ctop}
N 2380 -1330 2400 -1330 {
lab=row_n[0]}
N 2380 -1310 2400 -1310 {
lab=rowon_n[0]}
N 2380 -1290 2400 -1290 {
lab=#net1}
N 2380 -1270 2400 -1270 {
lab=#net2}
N 2620 -1270 2640 -1270 {
lab=#net2}
N 2620 -1290 2640 -1290 {
lab=#net1}
N 2620 -1310 2640 -1310 {
lab=rowon_n[0]}
N 2620 -1330 2640 -1330 {
lab=row_n[0]}
N 2440 -1190 2440 -1180 {
lab=VSS}
N 2440 -1420 2440 -1410 {
lab=VDD}
N 2780 -1190 2790 -1200 {
lab=col_n[8]}
N 2790 -1400 2790 -1200 {
lab=col_n[8]}
N 2780 -1410 2790 -1400 {
lab=col_n[8]}
N 2780 -1190 2780 -1170 {
lab=col_n[8]}
N 2780 -1430 2780 -1410 {
lab=col_n[8]}
N 2660 -1330 2670 -1340 {
lab=row_n[0]}
N 2670 -1340 2870 -1340 {
lab=row_n[0]}
N 2870 -1340 2880 -1330 {
lab=row_n[0]}
N 2660 -1310 2670 -1320 {
lab=rowon_n[0]}
N 2670 -1320 2870 -1320 {
lab=rowon_n[0]}
N 2870 -1320 2880 -1310 {
lab=rowon_n[0]}
N 2660 -1290 2670 -1300 {
lab=#net1}
N 2670 -1300 2870 -1300 {
lab=#net1}
N 2870 -1300 2880 -1290 {
lab=#net1}
N 2660 -1270 2670 -1280 {
lab=#net2}
N 2670 -1280 2870 -1280 {
lab=#net2}
N 2870 -1280 2880 -1270 {
lab=#net2}
N 2720 -1430 2720 -1410 {
lab=vcm}
N 2760 -1430 2760 -1410 {
lab=ctop}
N 2640 -1330 2660 -1330 {
lab=row_n[0]}
N 2640 -1310 2660 -1310 {
lab=rowon_n[0]}
N 2640 -1290 2660 -1290 {
lab=#net1}
N 2640 -1270 2660 -1270 {
lab=#net2}
N 2880 -1270 2900 -1270 {
lab=#net2}
N 2880 -1290 2900 -1290 {
lab=#net1}
N 2880 -1310 2900 -1310 {
lab=rowon_n[0]}
N 2880 -1330 2900 -1330 {
lab=row_n[0]}
N 2700 -1190 2700 -1180 {
lab=VSS}
N 2700 -1420 2700 -1410 {
lab=VDD}
N 3040 -1190 3050 -1200 {
lab=col_n[9]}
N 3050 -1400 3050 -1200 {
lab=col_n[9]}
N 3040 -1410 3050 -1400 {
lab=col_n[9]}
N 3040 -1190 3040 -1170 {
lab=col_n[9]}
N 3040 -1430 3040 -1410 {
lab=col_n[9]}
N 2920 -1330 2930 -1340 {
lab=row_n[0]}
N 2930 -1340 3130 -1340 {
lab=row_n[0]}
N 3130 -1340 3140 -1330 {
lab=row_n[0]}
N 2920 -1310 2930 -1320 {
lab=rowon_n[0]}
N 2930 -1320 3130 -1320 {
lab=rowon_n[0]}
N 3130 -1320 3140 -1310 {
lab=rowon_n[0]}
N 2920 -1290 2930 -1300 {
lab=#net1}
N 2930 -1300 3130 -1300 {
lab=#net1}
N 3130 -1300 3140 -1290 {
lab=#net1}
N 2920 -1270 2930 -1280 {
lab=#net2}
N 2930 -1280 3130 -1280 {
lab=#net2}
N 3130 -1280 3140 -1270 {
lab=#net2}
N 2980 -1430 2980 -1410 {
lab=vcm}
N 3020 -1430 3020 -1410 {
lab=ctop}
N 2900 -1330 2920 -1330 {
lab=row_n[0]}
N 2900 -1310 2920 -1310 {
lab=rowon_n[0]}
N 2900 -1290 2920 -1290 {
lab=#net1}
N 2900 -1270 2920 -1270 {
lab=#net2}
N 3140 -1270 3160 -1270 {
lab=#net2}
N 3140 -1290 3160 -1290 {
lab=#net1}
N 3140 -1310 3160 -1310 {
lab=rowon_n[0]}
N 3140 -1330 3160 -1330 {
lab=row_n[0]}
N 2960 -1190 2960 -1180 {
lab=VSS}
N 2960 -1420 2960 -1410 {
lab=VDD}
N 3300 -1190 3310 -1200 {
lab=col_n[10]}
N 3310 -1400 3310 -1200 {
lab=col_n[10]}
N 3300 -1410 3310 -1400 {
lab=col_n[10]}
N 3300 -1190 3300 -1170 {
lab=col_n[10]}
N 3300 -1430 3300 -1410 {
lab=col_n[10]}
N 3180 -1330 3190 -1340 {
lab=row_n[0]}
N 3190 -1340 3390 -1340 {
lab=row_n[0]}
N 3390 -1340 3400 -1330 {
lab=row_n[0]}
N 3180 -1310 3190 -1320 {
lab=rowon_n[0]}
N 3190 -1320 3390 -1320 {
lab=rowon_n[0]}
N 3390 -1320 3400 -1310 {
lab=rowon_n[0]}
N 3180 -1290 3190 -1300 {
lab=#net1}
N 3190 -1300 3390 -1300 {
lab=#net1}
N 3390 -1300 3400 -1290 {
lab=#net1}
N 3180 -1270 3190 -1280 {
lab=#net2}
N 3190 -1280 3390 -1280 {
lab=#net2}
N 3390 -1280 3400 -1270 {
lab=#net2}
N 3240 -1430 3240 -1410 {
lab=vcm}
N 3280 -1430 3280 -1410 {
lab=ctop}
N 3160 -1330 3180 -1330 {
lab=row_n[0]}
N 3160 -1310 3180 -1310 {
lab=rowon_n[0]}
N 3160 -1290 3180 -1290 {
lab=#net1}
N 3160 -1270 3180 -1270 {
lab=#net2}
N 3400 -1270 3420 -1270 {
lab=#net2}
N 3400 -1290 3420 -1290 {
lab=#net1}
N 3400 -1310 3420 -1310 {
lab=rowon_n[0]}
N 3400 -1330 3420 -1330 {
lab=row_n[0]}
N 3220 -1190 3220 -1180 {
lab=VSS}
N 3220 -1420 3220 -1410 {
lab=VDD}
N 3560 -1190 3570 -1200 {
lab=col_n[11]}
N 3570 -1400 3570 -1200 {
lab=col_n[11]}
N 3560 -1410 3570 -1400 {
lab=col_n[11]}
N 3560 -1190 3560 -1170 {
lab=col_n[11]}
N 3560 -1430 3560 -1410 {
lab=col_n[11]}
N 3440 -1330 3450 -1340 {
lab=row_n[0]}
N 3450 -1340 3650 -1340 {
lab=row_n[0]}
N 3650 -1340 3660 -1330 {
lab=row_n[0]}
N 3440 -1310 3450 -1320 {
lab=rowon_n[0]}
N 3450 -1320 3650 -1320 {
lab=rowon_n[0]}
N 3650 -1320 3660 -1310 {
lab=rowon_n[0]}
N 3440 -1290 3450 -1300 {
lab=#net1}
N 3450 -1300 3650 -1300 {
lab=#net1}
N 3650 -1300 3660 -1290 {
lab=#net1}
N 3440 -1270 3450 -1280 {
lab=#net2}
N 3450 -1280 3650 -1280 {
lab=#net2}
N 3650 -1280 3660 -1270 {
lab=#net2}
N 3500 -1430 3500 -1410 {
lab=vcm}
N 3540 -1430 3540 -1410 {
lab=ctop}
N 3420 -1330 3440 -1330 {
lab=row_n[0]}
N 3420 -1310 3440 -1310 {
lab=rowon_n[0]}
N 3420 -1290 3440 -1290 {
lab=#net1}
N 3420 -1270 3440 -1270 {
lab=#net2}
N 3660 -1270 3680 -1270 {
lab=#net2}
N 3660 -1290 3680 -1290 {
lab=#net1}
N 3660 -1310 3680 -1310 {
lab=rowon_n[0]}
N 3660 -1330 3680 -1330 {
lab=row_n[0]}
N 3480 -1190 3480 -1180 {
lab=VSS}
N 3480 -1420 3480 -1410 {
lab=VDD}
N 3820 -1190 3830 -1200 {
lab=col_n[12]}
N 3830 -1400 3830 -1200 {
lab=col_n[12]}
N 3820 -1410 3830 -1400 {
lab=col_n[12]}
N 3820 -1190 3820 -1170 {
lab=col_n[12]}
N 3820 -1430 3820 -1410 {
lab=col_n[12]}
N 3700 -1330 3710 -1340 {
lab=row_n[0]}
N 3710 -1340 3910 -1340 {
lab=row_n[0]}
N 3910 -1340 3920 -1330 {
lab=row_n[0]}
N 3700 -1310 3710 -1320 {
lab=rowon_n[0]}
N 3710 -1320 3910 -1320 {
lab=rowon_n[0]}
N 3910 -1320 3920 -1310 {
lab=rowon_n[0]}
N 3700 -1290 3710 -1300 {
lab=#net1}
N 3710 -1300 3910 -1300 {
lab=#net1}
N 3910 -1300 3920 -1290 {
lab=#net1}
N 3700 -1270 3710 -1280 {
lab=#net2}
N 3710 -1280 3910 -1280 {
lab=#net2}
N 3910 -1280 3920 -1270 {
lab=#net2}
N 3760 -1430 3760 -1410 {
lab=vcm}
N 3800 -1430 3800 -1410 {
lab=ctop}
N 3680 -1330 3700 -1330 {
lab=row_n[0]}
N 3680 -1310 3700 -1310 {
lab=rowon_n[0]}
N 3680 -1290 3700 -1290 {
lab=#net1}
N 3680 -1270 3700 -1270 {
lab=#net2}
N 3920 -1270 3940 -1270 {
lab=#net2}
N 3920 -1290 3940 -1290 {
lab=#net1}
N 3920 -1310 3940 -1310 {
lab=rowon_n[0]}
N 3920 -1330 3940 -1330 {
lab=row_n[0]}
N 3740 -1190 3740 -1180 {
lab=VSS}
N 3740 -1420 3740 -1410 {
lab=VDD}
N 4080 -1190 4090 -1200 {
lab=col_n[13]}
N 4090 -1400 4090 -1200 {
lab=col_n[13]}
N 4080 -1410 4090 -1400 {
lab=col_n[13]}
N 4080 -1190 4080 -1170 {
lab=col_n[13]}
N 4080 -1430 4080 -1410 {
lab=col_n[13]}
N 3960 -1330 3970 -1340 {
lab=row_n[0]}
N 3970 -1340 4170 -1340 {
lab=row_n[0]}
N 4170 -1340 4180 -1330 {
lab=row_n[0]}
N 3960 -1310 3970 -1320 {
lab=rowon_n[0]}
N 3970 -1320 4170 -1320 {
lab=rowon_n[0]}
N 4170 -1320 4180 -1310 {
lab=rowon_n[0]}
N 3960 -1290 3970 -1300 {
lab=#net1}
N 3970 -1300 4170 -1300 {
lab=#net1}
N 4170 -1300 4180 -1290 {
lab=#net1}
N 3960 -1270 3970 -1280 {
lab=#net2}
N 3970 -1280 4170 -1280 {
lab=#net2}
N 4170 -1280 4180 -1270 {
lab=#net2}
N 4020 -1430 4020 -1410 {
lab=vcm}
N 4060 -1430 4060 -1410 {
lab=ctop}
N 3940 -1330 3960 -1330 {
lab=row_n[0]}
N 3940 -1310 3960 -1310 {
lab=rowon_n[0]}
N 3940 -1290 3960 -1290 {
lab=#net1}
N 3940 -1270 3960 -1270 {
lab=#net2}
N 4180 -1270 4200 -1270 {
lab=#net2}
N 4180 -1290 4200 -1290 {
lab=#net1}
N 4180 -1310 4200 -1310 {
lab=rowon_n[0]}
N 4180 -1330 4200 -1330 {
lab=row_n[0]}
N 4000 -1190 4000 -1180 {
lab=VSS}
N 4000 -1420 4000 -1410 {
lab=VDD}
N 4340 -1190 4350 -1200 {
lab=col_n[14]}
N 4350 -1400 4350 -1200 {
lab=col_n[14]}
N 4340 -1410 4350 -1400 {
lab=col_n[14]}
N 4340 -1190 4340 -1170 {
lab=col_n[14]}
N 4340 -1430 4340 -1410 {
lab=col_n[14]}
N 4220 -1330 4230 -1340 {
lab=row_n[0]}
N 4230 -1340 4430 -1340 {
lab=row_n[0]}
N 4430 -1340 4440 -1330 {
lab=row_n[0]}
N 4220 -1310 4230 -1320 {
lab=rowon_n[0]}
N 4230 -1320 4430 -1320 {
lab=rowon_n[0]}
N 4430 -1320 4440 -1310 {
lab=rowon_n[0]}
N 4220 -1290 4230 -1300 {
lab=#net1}
N 4230 -1300 4430 -1300 {
lab=#net1}
N 4430 -1300 4440 -1290 {
lab=#net1}
N 4220 -1270 4230 -1280 {
lab=#net2}
N 4230 -1280 4430 -1280 {
lab=#net2}
N 4430 -1280 4440 -1270 {
lab=#net2}
N 4280 -1430 4280 -1410 {
lab=vcm}
N 4320 -1430 4320 -1410 {
lab=ctop}
N 4200 -1330 4220 -1330 {
lab=row_n[0]}
N 4200 -1310 4220 -1310 {
lab=rowon_n[0]}
N 4200 -1290 4220 -1290 {
lab=#net1}
N 4200 -1270 4220 -1270 {
lab=#net2}
N 4440 -1270 4460 -1270 {
lab=#net2}
N 4440 -1290 4460 -1290 {
lab=#net1}
N 4440 -1310 4460 -1310 {
lab=rowon_n[0]}
N 4440 -1330 4460 -1330 {
lab=row_n[0]}
N 4260 -1190 4260 -1180 {
lab=VSS}
N 4260 -1420 4260 -1410 {
lab=VDD}
N 4600 -1190 4610 -1200 {
lab=col_n[15]}
N 4610 -1400 4610 -1200 {
lab=col_n[15]}
N 4600 -1410 4610 -1400 {
lab=col_n[15]}
N 4600 -1190 4600 -1170 {
lab=col_n[15]}
N 4600 -1430 4600 -1410 {
lab=col_n[15]}
N 4480 -1330 4490 -1340 {
lab=row_n[0]}
N 4490 -1340 4690 -1340 {
lab=row_n[0]}
N 4690 -1340 4700 -1330 {
lab=row_n[0]}
N 4480 -1310 4490 -1320 {
lab=rowon_n[0]}
N 4490 -1320 4690 -1320 {
lab=rowon_n[0]}
N 4690 -1320 4700 -1310 {
lab=rowon_n[0]}
N 4480 -1290 4490 -1300 {
lab=#net1}
N 4490 -1300 4690 -1300 {
lab=#net1}
N 4690 -1300 4700 -1290 {
lab=#net1}
N 4480 -1270 4490 -1280 {
lab=#net2}
N 4490 -1280 4690 -1280 {
lab=#net2}
N 4690 -1280 4700 -1270 {
lab=#net2}
N 4540 -1430 4540 -1410 {
lab=vcm}
N 4580 -1430 4580 -1410 {
lab=ctop}
N 4460 -1330 4480 -1330 {
lab=row_n[0]}
N 4460 -1310 4480 -1310 {
lab=rowon_n[0]}
N 4460 -1290 4480 -1290 {
lab=#net1}
N 4460 -1270 4480 -1270 {
lab=#net2}
N 4700 -1270 4720 -1270 {
lab=#net2}
N 4700 -1290 4720 -1290 {
lab=#net1}
N 4700 -1310 4720 -1310 {
lab=rowon_n[0]}
N 4700 -1330 4720 -1330 {
lab=row_n[0]}
N 4520 -1190 4520 -1180 {
lab=VSS}
N 4520 -1420 4520 -1410 {
lab=VDD}
N 4860 -1190 4870 -1200 {
lab=col_n[16]}
N 4870 -1400 4870 -1200 {
lab=col_n[16]}
N 4860 -1410 4870 -1400 {
lab=col_n[16]}
N 4860 -1190 4860 -1170 {
lab=col_n[16]}
N 4860 -1430 4860 -1410 {
lab=col_n[16]}
N 4740 -1330 4750 -1340 {
lab=row_n[0]}
N 4750 -1340 4950 -1340 {
lab=row_n[0]}
N 4950 -1340 4960 -1330 {
lab=row_n[0]}
N 4740 -1310 4750 -1320 {
lab=rowon_n[0]}
N 4750 -1320 4950 -1320 {
lab=rowon_n[0]}
N 4950 -1320 4960 -1310 {
lab=rowon_n[0]}
N 4740 -1290 4750 -1300 {
lab=#net1}
N 4750 -1300 4950 -1300 {
lab=#net1}
N 4950 -1300 4960 -1290 {
lab=#net1}
N 4740 -1270 4750 -1280 {
lab=#net2}
N 4750 -1280 4950 -1280 {
lab=#net2}
N 4950 -1280 4960 -1270 {
lab=#net2}
N 4800 -1430 4800 -1410 {
lab=vcm}
N 4840 -1430 4840 -1410 {
lab=ctop}
N 4720 -1330 4740 -1330 {
lab=row_n[0]}
N 4720 -1310 4740 -1310 {
lab=rowon_n[0]}
N 4720 -1290 4740 -1290 {
lab=#net1}
N 4720 -1270 4740 -1270 {
lab=#net2}
N 4960 -1270 4980 -1270 {
lab=#net2}
N 4960 -1290 4980 -1290 {
lab=#net1}
N 4960 -1310 4980 -1310 {
lab=rowon_n[0]}
N 4960 -1330 4980 -1330 {
lab=row_n[0]}
N 4780 -1190 4780 -1180 {
lab=VSS}
N 4780 -1420 4780 -1410 {
lab=VDD}
N 5120 -1190 5130 -1200 {
lab=col_n[17]}
N 5130 -1400 5130 -1200 {
lab=col_n[17]}
N 5120 -1410 5130 -1400 {
lab=col_n[17]}
N 5120 -1190 5120 -1170 {
lab=col_n[17]}
N 5120 -1430 5120 -1410 {
lab=col_n[17]}
N 5000 -1330 5010 -1340 {
lab=row_n[0]}
N 5010 -1340 5210 -1340 {
lab=row_n[0]}
N 5210 -1340 5220 -1330 {
lab=row_n[0]}
N 5000 -1310 5010 -1320 {
lab=rowon_n[0]}
N 5010 -1320 5210 -1320 {
lab=rowon_n[0]}
N 5210 -1320 5220 -1310 {
lab=rowon_n[0]}
N 5000 -1290 5010 -1300 {
lab=#net1}
N 5010 -1300 5210 -1300 {
lab=#net1}
N 5210 -1300 5220 -1290 {
lab=#net1}
N 5000 -1270 5010 -1280 {
lab=#net2}
N 5010 -1280 5210 -1280 {
lab=#net2}
N 5210 -1280 5220 -1270 {
lab=#net2}
N 5060 -1430 5060 -1410 {
lab=vcm}
N 5100 -1430 5100 -1410 {
lab=ctop}
N 4980 -1330 5000 -1330 {
lab=row_n[0]}
N 4980 -1310 5000 -1310 {
lab=rowon_n[0]}
N 4980 -1290 5000 -1290 {
lab=#net1}
N 4980 -1270 5000 -1270 {
lab=#net2}
N 5220 -1270 5240 -1270 {
lab=#net2}
N 5220 -1290 5240 -1290 {
lab=#net1}
N 5220 -1310 5240 -1310 {
lab=rowon_n[0]}
N 5220 -1330 5240 -1330 {
lab=row_n[0]}
N 5040 -1190 5040 -1180 {
lab=VSS}
N 5040 -1420 5040 -1410 {
lab=VDD}
N 5380 -1190 5390 -1200 {
lab=col_n[18]}
N 5390 -1400 5390 -1200 {
lab=col_n[18]}
N 5380 -1410 5390 -1400 {
lab=col_n[18]}
N 5380 -1190 5380 -1170 {
lab=col_n[18]}
N 5380 -1430 5380 -1410 {
lab=col_n[18]}
N 5260 -1330 5270 -1340 {
lab=row_n[0]}
N 5270 -1340 5470 -1340 {
lab=row_n[0]}
N 5470 -1340 5480 -1330 {
lab=row_n[0]}
N 5260 -1310 5270 -1320 {
lab=rowon_n[0]}
N 5270 -1320 5470 -1320 {
lab=rowon_n[0]}
N 5470 -1320 5480 -1310 {
lab=rowon_n[0]}
N 5260 -1290 5270 -1300 {
lab=#net1}
N 5270 -1300 5470 -1300 {
lab=#net1}
N 5470 -1300 5480 -1290 {
lab=#net1}
N 5260 -1270 5270 -1280 {
lab=#net2}
N 5270 -1280 5470 -1280 {
lab=#net2}
N 5470 -1280 5480 -1270 {
lab=#net2}
N 5320 -1430 5320 -1410 {
lab=vcm}
N 5360 -1430 5360 -1410 {
lab=ctop}
N 5240 -1330 5260 -1330 {
lab=row_n[0]}
N 5240 -1310 5260 -1310 {
lab=rowon_n[0]}
N 5240 -1290 5260 -1290 {
lab=#net1}
N 5240 -1270 5260 -1270 {
lab=#net2}
N 5480 -1270 5500 -1270 {
lab=#net2}
N 5480 -1290 5500 -1290 {
lab=#net1}
N 5480 -1310 5500 -1310 {
lab=rowon_n[0]}
N 5480 -1330 5500 -1330 {
lab=row_n[0]}
N 5300 -1190 5300 -1180 {
lab=VSS}
N 5300 -1420 5300 -1410 {
lab=VDD}
N 5640 -1190 5650 -1200 {
lab=col_n[19]}
N 5650 -1400 5650 -1200 {
lab=col_n[19]}
N 5640 -1410 5650 -1400 {
lab=col_n[19]}
N 5640 -1190 5640 -1170 {
lab=col_n[19]}
N 5640 -1430 5640 -1410 {
lab=col_n[19]}
N 5520 -1330 5530 -1340 {
lab=row_n[0]}
N 5530 -1340 5730 -1340 {
lab=row_n[0]}
N 5730 -1340 5740 -1330 {
lab=row_n[0]}
N 5520 -1310 5530 -1320 {
lab=rowon_n[0]}
N 5530 -1320 5730 -1320 {
lab=rowon_n[0]}
N 5730 -1320 5740 -1310 {
lab=rowon_n[0]}
N 5520 -1290 5530 -1300 {
lab=#net1}
N 5530 -1300 5730 -1300 {
lab=#net1}
N 5730 -1300 5740 -1290 {
lab=#net1}
N 5520 -1270 5530 -1280 {
lab=#net2}
N 5530 -1280 5730 -1280 {
lab=#net2}
N 5730 -1280 5740 -1270 {
lab=#net2}
N 5580 -1430 5580 -1410 {
lab=vcm}
N 5620 -1430 5620 -1410 {
lab=ctop}
N 5500 -1330 5520 -1330 {
lab=row_n[0]}
N 5500 -1310 5520 -1310 {
lab=rowon_n[0]}
N 5500 -1290 5520 -1290 {
lab=#net1}
N 5500 -1270 5520 -1270 {
lab=#net2}
N 5740 -1270 5760 -1270 {
lab=#net2}
N 5740 -1290 5760 -1290 {
lab=#net1}
N 5740 -1310 5760 -1310 {
lab=rowon_n[0]}
N 5740 -1330 5760 -1330 {
lab=row_n[0]}
N 5560 -1190 5560 -1180 {
lab=VSS}
N 5560 -1420 5560 -1410 {
lab=VDD}
N 5900 -1190 5910 -1200 {
lab=col_n[20]}
N 5910 -1400 5910 -1200 {
lab=col_n[20]}
N 5900 -1410 5910 -1400 {
lab=col_n[20]}
N 5900 -1190 5900 -1170 {
lab=col_n[20]}
N 5900 -1430 5900 -1410 {
lab=col_n[20]}
N 5780 -1330 5790 -1340 {
lab=row_n[0]}
N 5790 -1340 5990 -1340 {
lab=row_n[0]}
N 5990 -1340 6000 -1330 {
lab=row_n[0]}
N 5780 -1310 5790 -1320 {
lab=rowon_n[0]}
N 5790 -1320 5990 -1320 {
lab=rowon_n[0]}
N 5990 -1320 6000 -1310 {
lab=rowon_n[0]}
N 5780 -1290 5790 -1300 {
lab=#net1}
N 5790 -1300 5990 -1300 {
lab=#net1}
N 5990 -1300 6000 -1290 {
lab=#net1}
N 5780 -1270 5790 -1280 {
lab=#net2}
N 5790 -1280 5990 -1280 {
lab=#net2}
N 5990 -1280 6000 -1270 {
lab=#net2}
N 5840 -1430 5840 -1410 {
lab=vcm}
N 5880 -1430 5880 -1410 {
lab=ctop}
N 5760 -1330 5780 -1330 {
lab=row_n[0]}
N 5760 -1310 5780 -1310 {
lab=rowon_n[0]}
N 5760 -1290 5780 -1290 {
lab=#net1}
N 5760 -1270 5780 -1270 {
lab=#net2}
N 6000 -1270 6020 -1270 {
lab=#net2}
N 6000 -1290 6020 -1290 {
lab=#net1}
N 6000 -1310 6020 -1310 {
lab=rowon_n[0]}
N 6000 -1330 6020 -1330 {
lab=row_n[0]}
N 5820 -1190 5820 -1180 {
lab=VSS}
N 5820 -1420 5820 -1410 {
lab=VDD}
N 6160 -1190 6170 -1200 {
lab=col_n[21]}
N 6170 -1400 6170 -1200 {
lab=col_n[21]}
N 6160 -1410 6170 -1400 {
lab=col_n[21]}
N 6160 -1190 6160 -1170 {
lab=col_n[21]}
N 6160 -1430 6160 -1410 {
lab=col_n[21]}
N 6040 -1330 6050 -1340 {
lab=row_n[0]}
N 6050 -1340 6250 -1340 {
lab=row_n[0]}
N 6250 -1340 6260 -1330 {
lab=row_n[0]}
N 6040 -1310 6050 -1320 {
lab=rowon_n[0]}
N 6050 -1320 6250 -1320 {
lab=rowon_n[0]}
N 6250 -1320 6260 -1310 {
lab=rowon_n[0]}
N 6040 -1290 6050 -1300 {
lab=#net1}
N 6050 -1300 6250 -1300 {
lab=#net1}
N 6250 -1300 6260 -1290 {
lab=#net1}
N 6040 -1270 6050 -1280 {
lab=#net2}
N 6050 -1280 6250 -1280 {
lab=#net2}
N 6250 -1280 6260 -1270 {
lab=#net2}
N 6100 -1430 6100 -1410 {
lab=vcm}
N 6140 -1430 6140 -1410 {
lab=ctop}
N 6020 -1330 6040 -1330 {
lab=row_n[0]}
N 6020 -1310 6040 -1310 {
lab=rowon_n[0]}
N 6020 -1290 6040 -1290 {
lab=#net1}
N 6020 -1270 6040 -1270 {
lab=#net2}
N 6260 -1270 6280 -1270 {
lab=#net2}
N 6260 -1290 6280 -1290 {
lab=#net1}
N 6260 -1310 6280 -1310 {
lab=rowon_n[0]}
N 6260 -1330 6280 -1330 {
lab=row_n[0]}
N 6080 -1190 6080 -1180 {
lab=VSS}
N 6080 -1420 6080 -1410 {
lab=VDD}
N 6420 -1190 6430 -1200 {
lab=col_n[22]}
N 6430 -1400 6430 -1200 {
lab=col_n[22]}
N 6420 -1410 6430 -1400 {
lab=col_n[22]}
N 6420 -1190 6420 -1170 {
lab=col_n[22]}
N 6420 -1430 6420 -1410 {
lab=col_n[22]}
N 6300 -1330 6310 -1340 {
lab=row_n[0]}
N 6310 -1340 6510 -1340 {
lab=row_n[0]}
N 6510 -1340 6520 -1330 {
lab=row_n[0]}
N 6300 -1310 6310 -1320 {
lab=rowon_n[0]}
N 6310 -1320 6510 -1320 {
lab=rowon_n[0]}
N 6510 -1320 6520 -1310 {
lab=rowon_n[0]}
N 6300 -1290 6310 -1300 {
lab=#net1}
N 6310 -1300 6510 -1300 {
lab=#net1}
N 6510 -1300 6520 -1290 {
lab=#net1}
N 6300 -1270 6310 -1280 {
lab=#net2}
N 6310 -1280 6510 -1280 {
lab=#net2}
N 6510 -1280 6520 -1270 {
lab=#net2}
N 6360 -1430 6360 -1410 {
lab=vcm}
N 6400 -1430 6400 -1410 {
lab=ctop}
N 6280 -1330 6300 -1330 {
lab=row_n[0]}
N 6280 -1310 6300 -1310 {
lab=rowon_n[0]}
N 6280 -1290 6300 -1290 {
lab=#net1}
N 6280 -1270 6300 -1270 {
lab=#net2}
N 6520 -1270 6540 -1270 {
lab=#net2}
N 6520 -1290 6540 -1290 {
lab=#net1}
N 6520 -1310 6540 -1310 {
lab=rowon_n[0]}
N 6520 -1330 6540 -1330 {
lab=row_n[0]}
N 6340 -1190 6340 -1180 {
lab=VSS}
N 6340 -1420 6340 -1410 {
lab=VDD}
N 6680 -1190 6690 -1200 {
lab=col_n[23]}
N 6690 -1400 6690 -1200 {
lab=col_n[23]}
N 6680 -1410 6690 -1400 {
lab=col_n[23]}
N 6680 -1190 6680 -1170 {
lab=col_n[23]}
N 6680 -1430 6680 -1410 {
lab=col_n[23]}
N 6560 -1330 6570 -1340 {
lab=row_n[0]}
N 6570 -1340 6770 -1340 {
lab=row_n[0]}
N 6770 -1340 6780 -1330 {
lab=row_n[0]}
N 6560 -1310 6570 -1320 {
lab=rowon_n[0]}
N 6570 -1320 6770 -1320 {
lab=rowon_n[0]}
N 6770 -1320 6780 -1310 {
lab=rowon_n[0]}
N 6560 -1290 6570 -1300 {
lab=#net1}
N 6570 -1300 6770 -1300 {
lab=#net1}
N 6770 -1300 6780 -1290 {
lab=#net1}
N 6560 -1270 6570 -1280 {
lab=#net2}
N 6570 -1280 6770 -1280 {
lab=#net2}
N 6770 -1280 6780 -1270 {
lab=#net2}
N 6620 -1430 6620 -1410 {
lab=vcm}
N 6660 -1430 6660 -1410 {
lab=ctop}
N 6540 -1330 6560 -1330 {
lab=row_n[0]}
N 6540 -1310 6560 -1310 {
lab=rowon_n[0]}
N 6540 -1290 6560 -1290 {
lab=#net1}
N 6540 -1270 6560 -1270 {
lab=#net2}
N 6780 -1270 6800 -1270 {
lab=#net2}
N 6780 -1290 6800 -1290 {
lab=#net1}
N 6780 -1310 6800 -1310 {
lab=rowon_n[0]}
N 6780 -1330 6800 -1330 {
lab=row_n[0]}
N 6600 -1190 6600 -1180 {
lab=VSS}
N 6600 -1420 6600 -1410 {
lab=VDD}
N 6940 -1190 6950 -1200 {
lab=col_n[24]}
N 6950 -1400 6950 -1200 {
lab=col_n[24]}
N 6940 -1410 6950 -1400 {
lab=col_n[24]}
N 6940 -1190 6940 -1170 {
lab=col_n[24]}
N 6940 -1430 6940 -1410 {
lab=col_n[24]}
N 6820 -1330 6830 -1340 {
lab=row_n[0]}
N 6830 -1340 7030 -1340 {
lab=row_n[0]}
N 7030 -1340 7040 -1330 {
lab=row_n[0]}
N 6820 -1310 6830 -1320 {
lab=rowon_n[0]}
N 6830 -1320 7030 -1320 {
lab=rowon_n[0]}
N 7030 -1320 7040 -1310 {
lab=rowon_n[0]}
N 6820 -1290 6830 -1300 {
lab=#net1}
N 6830 -1300 7030 -1300 {
lab=#net1}
N 7030 -1300 7040 -1290 {
lab=#net1}
N 6820 -1270 6830 -1280 {
lab=#net2}
N 6830 -1280 7030 -1280 {
lab=#net2}
N 7030 -1280 7040 -1270 {
lab=#net2}
N 6880 -1430 6880 -1410 {
lab=vcm}
N 6920 -1430 6920 -1410 {
lab=ctop}
N 6800 -1330 6820 -1330 {
lab=row_n[0]}
N 6800 -1310 6820 -1310 {
lab=rowon_n[0]}
N 6800 -1290 6820 -1290 {
lab=#net1}
N 6800 -1270 6820 -1270 {
lab=#net2}
N 7040 -1270 7060 -1270 {
lab=#net2}
N 7040 -1290 7060 -1290 {
lab=#net1}
N 7040 -1310 7060 -1310 {
lab=rowon_n[0]}
N 7040 -1330 7060 -1330 {
lab=row_n[0]}
N 6860 -1190 6860 -1180 {
lab=VSS}
N 6860 -1420 6860 -1410 {
lab=VDD}
N 7200 -1190 7210 -1200 {
lab=col_n[25]}
N 7210 -1400 7210 -1200 {
lab=col_n[25]}
N 7200 -1410 7210 -1400 {
lab=col_n[25]}
N 7200 -1190 7200 -1170 {
lab=col_n[25]}
N 7200 -1430 7200 -1410 {
lab=col_n[25]}
N 7080 -1330 7090 -1340 {
lab=row_n[0]}
N 7090 -1340 7290 -1340 {
lab=row_n[0]}
N 7290 -1340 7300 -1330 {
lab=row_n[0]}
N 7080 -1310 7090 -1320 {
lab=rowon_n[0]}
N 7090 -1320 7290 -1320 {
lab=rowon_n[0]}
N 7290 -1320 7300 -1310 {
lab=rowon_n[0]}
N 7080 -1290 7090 -1300 {
lab=#net1}
N 7090 -1300 7290 -1300 {
lab=#net1}
N 7290 -1300 7300 -1290 {
lab=#net1}
N 7080 -1270 7090 -1280 {
lab=#net2}
N 7090 -1280 7290 -1280 {
lab=#net2}
N 7290 -1280 7300 -1270 {
lab=#net2}
N 7140 -1430 7140 -1410 {
lab=vcm}
N 7180 -1430 7180 -1410 {
lab=ctop}
N 7060 -1330 7080 -1330 {
lab=row_n[0]}
N 7060 -1310 7080 -1310 {
lab=rowon_n[0]}
N 7060 -1290 7080 -1290 {
lab=#net1}
N 7060 -1270 7080 -1270 {
lab=#net2}
N 7300 -1270 7320 -1270 {
lab=#net2}
N 7300 -1290 7320 -1290 {
lab=#net1}
N 7300 -1310 7320 -1310 {
lab=rowon_n[0]}
N 7300 -1330 7320 -1330 {
lab=row_n[0]}
N 7120 -1190 7120 -1180 {
lab=VSS}
N 7120 -1420 7120 -1410 {
lab=VDD}
N 7460 -1190 7470 -1200 {
lab=col_n[26]}
N 7470 -1400 7470 -1200 {
lab=col_n[26]}
N 7460 -1410 7470 -1400 {
lab=col_n[26]}
N 7460 -1190 7460 -1170 {
lab=col_n[26]}
N 7460 -1430 7460 -1410 {
lab=col_n[26]}
N 7340 -1330 7350 -1340 {
lab=row_n[0]}
N 7350 -1340 7550 -1340 {
lab=row_n[0]}
N 7550 -1340 7560 -1330 {
lab=row_n[0]}
N 7340 -1310 7350 -1320 {
lab=rowon_n[0]}
N 7350 -1320 7550 -1320 {
lab=rowon_n[0]}
N 7550 -1320 7560 -1310 {
lab=rowon_n[0]}
N 7340 -1290 7350 -1300 {
lab=#net1}
N 7350 -1300 7550 -1300 {
lab=#net1}
N 7550 -1300 7560 -1290 {
lab=#net1}
N 7340 -1270 7350 -1280 {
lab=#net2}
N 7350 -1280 7550 -1280 {
lab=#net2}
N 7550 -1280 7560 -1270 {
lab=#net2}
N 7400 -1430 7400 -1410 {
lab=vcm}
N 7440 -1430 7440 -1410 {
lab=ctop}
N 7320 -1330 7340 -1330 {
lab=row_n[0]}
N 7320 -1310 7340 -1310 {
lab=rowon_n[0]}
N 7320 -1290 7340 -1290 {
lab=#net1}
N 7320 -1270 7340 -1270 {
lab=#net2}
N 7560 -1270 7580 -1270 {
lab=#net2}
N 7560 -1290 7580 -1290 {
lab=#net1}
N 7560 -1310 7580 -1310 {
lab=rowon_n[0]}
N 7560 -1330 7580 -1330 {
lab=row_n[0]}
N 7380 -1190 7380 -1180 {
lab=VSS}
N 7380 -1420 7380 -1410 {
lab=VDD}
N 7720 -1190 7730 -1200 {
lab=col_n[27]}
N 7730 -1400 7730 -1200 {
lab=col_n[27]}
N 7720 -1410 7730 -1400 {
lab=col_n[27]}
N 7720 -1190 7720 -1170 {
lab=col_n[27]}
N 7720 -1430 7720 -1410 {
lab=col_n[27]}
N 7600 -1330 7610 -1340 {
lab=row_n[0]}
N 7610 -1340 7810 -1340 {
lab=row_n[0]}
N 7810 -1340 7820 -1330 {
lab=row_n[0]}
N 7600 -1310 7610 -1320 {
lab=rowon_n[0]}
N 7610 -1320 7810 -1320 {
lab=rowon_n[0]}
N 7810 -1320 7820 -1310 {
lab=rowon_n[0]}
N 7600 -1290 7610 -1300 {
lab=#net1}
N 7610 -1300 7810 -1300 {
lab=#net1}
N 7810 -1300 7820 -1290 {
lab=#net1}
N 7600 -1270 7610 -1280 {
lab=#net2}
N 7610 -1280 7810 -1280 {
lab=#net2}
N 7810 -1280 7820 -1270 {
lab=#net2}
N 7660 -1430 7660 -1410 {
lab=vcm}
N 7700 -1430 7700 -1410 {
lab=ctop}
N 7580 -1330 7600 -1330 {
lab=row_n[0]}
N 7580 -1310 7600 -1310 {
lab=rowon_n[0]}
N 7580 -1290 7600 -1290 {
lab=#net1}
N 7580 -1270 7600 -1270 {
lab=#net2}
N 7820 -1270 7840 -1270 {
lab=#net2}
N 7820 -1290 7840 -1290 {
lab=#net1}
N 7820 -1310 7840 -1310 {
lab=rowon_n[0]}
N 7820 -1330 7840 -1330 {
lab=row_n[0]}
N 7640 -1190 7640 -1180 {
lab=VSS}
N 7640 -1420 7640 -1410 {
lab=VDD}
N 7980 -1190 7990 -1200 {
lab=col_n[28]}
N 7990 -1400 7990 -1200 {
lab=col_n[28]}
N 7980 -1410 7990 -1400 {
lab=col_n[28]}
N 7980 -1190 7980 -1170 {
lab=col_n[28]}
N 7980 -1430 7980 -1410 {
lab=col_n[28]}
N 7860 -1330 7870 -1340 {
lab=row_n[0]}
N 7870 -1340 8070 -1340 {
lab=row_n[0]}
N 8070 -1340 8080 -1330 {
lab=row_n[0]}
N 7860 -1310 7870 -1320 {
lab=rowon_n[0]}
N 7870 -1320 8070 -1320 {
lab=rowon_n[0]}
N 8070 -1320 8080 -1310 {
lab=rowon_n[0]}
N 7860 -1290 7870 -1300 {
lab=#net1}
N 7870 -1300 8070 -1300 {
lab=#net1}
N 8070 -1300 8080 -1290 {
lab=#net1}
N 7860 -1270 7870 -1280 {
lab=#net2}
N 7870 -1280 8070 -1280 {
lab=#net2}
N 8070 -1280 8080 -1270 {
lab=#net2}
N 7920 -1430 7920 -1410 {
lab=vcm}
N 7960 -1430 7960 -1410 {
lab=ctop}
N 7840 -1330 7860 -1330 {
lab=row_n[0]}
N 7840 -1310 7860 -1310 {
lab=rowon_n[0]}
N 7840 -1290 7860 -1290 {
lab=#net1}
N 7840 -1270 7860 -1270 {
lab=#net2}
N 8080 -1270 8100 -1270 {
lab=#net2}
N 8080 -1290 8100 -1290 {
lab=#net1}
N 8080 -1310 8100 -1310 {
lab=rowon_n[0]}
N 8080 -1330 8100 -1330 {
lab=row_n[0]}
N 7900 -1190 7900 -1180 {
lab=VSS}
N 7900 -1420 7900 -1410 {
lab=VDD}
N 8240 -1190 8250 -1200 {
lab=col_n[29]}
N 8250 -1400 8250 -1200 {
lab=col_n[29]}
N 8240 -1410 8250 -1400 {
lab=col_n[29]}
N 8240 -1190 8240 -1170 {
lab=col_n[29]}
N 8240 -1430 8240 -1410 {
lab=col_n[29]}
N 8120 -1330 8130 -1340 {
lab=row_n[0]}
N 8130 -1340 8330 -1340 {
lab=row_n[0]}
N 8330 -1340 8340 -1330 {
lab=row_n[0]}
N 8120 -1310 8130 -1320 {
lab=rowon_n[0]}
N 8130 -1320 8330 -1320 {
lab=rowon_n[0]}
N 8330 -1320 8340 -1310 {
lab=rowon_n[0]}
N 8120 -1290 8130 -1300 {
lab=#net1}
N 8130 -1300 8330 -1300 {
lab=#net1}
N 8330 -1300 8340 -1290 {
lab=#net1}
N 8120 -1270 8130 -1280 {
lab=#net2}
N 8130 -1280 8330 -1280 {
lab=#net2}
N 8330 -1280 8340 -1270 {
lab=#net2}
N 8180 -1430 8180 -1410 {
lab=vcm}
N 8220 -1430 8220 -1410 {
lab=ctop}
N 8100 -1330 8120 -1330 {
lab=row_n[0]}
N 8100 -1310 8120 -1310 {
lab=rowon_n[0]}
N 8100 -1290 8120 -1290 {
lab=#net1}
N 8100 -1270 8120 -1270 {
lab=#net2}
N 8340 -1270 8360 -1270 {
lab=#net2}
N 8340 -1290 8360 -1290 {
lab=#net1}
N 8340 -1310 8360 -1310 {
lab=rowon_n[0]}
N 8340 -1330 8360 -1330 {
lab=row_n[0]}
N 8160 -1190 8160 -1180 {
lab=VSS}
N 8160 -1420 8160 -1410 {
lab=VDD}
N 8500 -1190 8510 -1200 {
lab=col_n[30]}
N 8510 -1400 8510 -1200 {
lab=col_n[30]}
N 8500 -1410 8510 -1400 {
lab=col_n[30]}
N 8500 -1190 8500 -1170 {
lab=col_n[30]}
N 8500 -1430 8500 -1410 {
lab=col_n[30]}
N 8380 -1330 8390 -1340 {
lab=row_n[0]}
N 8390 -1340 8590 -1340 {
lab=row_n[0]}
N 8590 -1340 8600 -1330 {
lab=row_n[0]}
N 8380 -1310 8390 -1320 {
lab=rowon_n[0]}
N 8390 -1320 8590 -1320 {
lab=rowon_n[0]}
N 8590 -1320 8600 -1310 {
lab=rowon_n[0]}
N 8380 -1290 8390 -1300 {
lab=#net1}
N 8390 -1300 8590 -1300 {
lab=#net1}
N 8590 -1300 8600 -1290 {
lab=#net1}
N 8380 -1270 8390 -1280 {
lab=#net2}
N 8390 -1280 8590 -1280 {
lab=#net2}
N 8590 -1280 8600 -1270 {
lab=#net2}
N 8440 -1430 8440 -1410 {
lab=vcm}
N 8480 -1430 8480 -1410 {
lab=ctop}
N 8360 -1330 8380 -1330 {
lab=row_n[0]}
N 8360 -1310 8380 -1310 {
lab=rowon_n[0]}
N 8360 -1290 8380 -1290 {
lab=#net1}
N 8360 -1270 8380 -1270 {
lab=#net2}
N 8600 -1270 8620 -1270 {
lab=#net2}
N 8600 -1290 8620 -1290 {
lab=#net1}
N 8600 -1310 8620 -1310 {
lab=rowon_n[0]}
N 8600 -1330 8620 -1330 {
lab=row_n[0]}
N 8420 -1190 8420 -1180 {
lab=VSS}
N 8420 -1420 8420 -1410 {
lab=VDD}
N 8760 -1190 8770 -1200 {
lab=col_n[31]}
N 8770 -1400 8770 -1200 {
lab=col_n[31]}
N 8760 -1410 8770 -1400 {
lab=col_n[31]}
N 8760 -1190 8760 -1170 {
lab=col_n[31]}
N 8760 -1430 8760 -1410 {
lab=col_n[31]}
N 8640 -1330 8650 -1340 {
lab=row_n[0]}
N 8650 -1340 8850 -1340 {
lab=row_n[0]}
N 8850 -1340 8860 -1330 {
lab=row_n[0]}
N 8640 -1310 8650 -1320 {
lab=rowon_n[0]}
N 8650 -1320 8850 -1320 {
lab=rowon_n[0]}
N 8850 -1320 8860 -1310 {
lab=rowon_n[0]}
N 8640 -1290 8650 -1300 {
lab=#net1}
N 8650 -1300 8850 -1300 {
lab=#net1}
N 8850 -1300 8860 -1290 {
lab=#net1}
N 8640 -1270 8650 -1280 {
lab=#net2}
N 8650 -1280 8850 -1280 {
lab=#net2}
N 8850 -1280 8860 -1270 {
lab=#net2}
N 8700 -1430 8700 -1410 {
lab=vcm}
N 8740 -1430 8740 -1410 {
lab=ctop}
N 8620 -1330 8640 -1330 {
lab=row_n[0]}
N 8620 -1310 8640 -1310 {
lab=rowon_n[0]}
N 8620 -1290 8640 -1290 {
lab=#net1}
N 8620 -1270 8640 -1270 {
lab=#net2}
N 8860 -1270 8880 -1270 {
lab=#net2}
N 8860 -1290 8880 -1290 {
lab=#net1}
N 8860 -1310 8880 -1310 {
lab=rowon_n[0]}
N 8860 -1330 8880 -1330 {
lab=row_n[0]}
N 8680 -1190 8680 -1180 {
lab=VSS}
N 8680 -1420 8680 -1410 {
lab=VDD}
N 700 -1450 710 -1460 {
lab=col_n[0]}
N 710 -1660 710 -1460 {
lab=col_n[0]}
N 700 -1670 710 -1660 {
lab=col_n[0]}
N 700 -1450 700 -1430 {
lab=col_n[0]}
N 700 -1690 700 -1670 {
lab=col_n[0]}
N 580 -1590 590 -1600 {
lab=row_n[1]}
N 590 -1600 790 -1600 {
lab=row_n[1]}
N 790 -1600 800 -1590 {
lab=row_n[1]}
N 580 -1570 590 -1580 {
lab=rowon_n[1]}
N 590 -1580 790 -1580 {
lab=rowon_n[1]}
N 790 -1580 800 -1570 {
lab=rowon_n[1]}
N 580 -1550 590 -1560 {
lab=#net3}
N 590 -1560 790 -1560 {
lab=#net3}
N 790 -1560 800 -1550 {
lab=#net3}
N 580 -1530 590 -1540 {
lab=#net4}
N 590 -1540 790 -1540 {
lab=#net4}
N 790 -1540 800 -1530 {
lab=#net4}
N 640 -1690 640 -1670 {
lab=vcm}
N 680 -1690 680 -1670 {
lab=ctop}
N 560 -1590 580 -1590 {
lab=row_n[1]}
N 560 -1570 580 -1570 {
lab=rowon_n[1]}
N 560 -1550 580 -1550 {
lab=#net3}
N 560 -1530 580 -1530 {
lab=#net4}
N 800 -1530 820 -1530 {
lab=#net4}
N 800 -1550 820 -1550 {
lab=#net3}
N 800 -1570 820 -1570 {
lab=rowon_n[1]}
N 800 -1590 820 -1590 {
lab=row_n[1]}
N 620 -1450 620 -1440 {
lab=VSS}
N 620 -1680 620 -1670 {
lab=VDD}
N 960 -1450 970 -1460 {
lab=col_n[1]}
N 970 -1660 970 -1460 {
lab=col_n[1]}
N 960 -1670 970 -1660 {
lab=col_n[1]}
N 960 -1450 960 -1430 {
lab=col_n[1]}
N 960 -1690 960 -1670 {
lab=col_n[1]}
N 840 -1590 850 -1600 {
lab=row_n[1]}
N 850 -1600 1050 -1600 {
lab=row_n[1]}
N 1050 -1600 1060 -1590 {
lab=row_n[1]}
N 840 -1570 850 -1580 {
lab=rowon_n[1]}
N 850 -1580 1050 -1580 {
lab=rowon_n[1]}
N 1050 -1580 1060 -1570 {
lab=rowon_n[1]}
N 840 -1550 850 -1560 {
lab=#net3}
N 850 -1560 1050 -1560 {
lab=#net3}
N 1050 -1560 1060 -1550 {
lab=#net3}
N 840 -1530 850 -1540 {
lab=#net4}
N 850 -1540 1050 -1540 {
lab=#net4}
N 1050 -1540 1060 -1530 {
lab=#net4}
N 900 -1690 900 -1670 {
lab=vcm}
N 940 -1690 940 -1670 {
lab=ctop}
N 820 -1590 840 -1590 {
lab=row_n[1]}
N 820 -1570 840 -1570 {
lab=rowon_n[1]}
N 820 -1550 840 -1550 {
lab=#net3}
N 820 -1530 840 -1530 {
lab=#net4}
N 1060 -1530 1080 -1530 {
lab=#net4}
N 1060 -1550 1080 -1550 {
lab=#net3}
N 1060 -1570 1080 -1570 {
lab=rowon_n[1]}
N 1060 -1590 1080 -1590 {
lab=row_n[1]}
N 880 -1450 880 -1440 {
lab=VSS}
N 880 -1680 880 -1670 {
lab=VDD}
N 1220 -1450 1230 -1460 {
lab=col_n[2]}
N 1230 -1660 1230 -1460 {
lab=col_n[2]}
N 1220 -1670 1230 -1660 {
lab=col_n[2]}
N 1220 -1450 1220 -1430 {
lab=col_n[2]}
N 1220 -1690 1220 -1670 {
lab=col_n[2]}
N 1100 -1590 1110 -1600 {
lab=row_n[1]}
N 1110 -1600 1310 -1600 {
lab=row_n[1]}
N 1310 -1600 1320 -1590 {
lab=row_n[1]}
N 1100 -1570 1110 -1580 {
lab=rowon_n[1]}
N 1110 -1580 1310 -1580 {
lab=rowon_n[1]}
N 1310 -1580 1320 -1570 {
lab=rowon_n[1]}
N 1100 -1550 1110 -1560 {
lab=#net3}
N 1110 -1560 1310 -1560 {
lab=#net3}
N 1310 -1560 1320 -1550 {
lab=#net3}
N 1100 -1530 1110 -1540 {
lab=#net4}
N 1110 -1540 1310 -1540 {
lab=#net4}
N 1310 -1540 1320 -1530 {
lab=#net4}
N 1160 -1690 1160 -1670 {
lab=vcm}
N 1200 -1690 1200 -1670 {
lab=ctop}
N 1080 -1590 1100 -1590 {
lab=row_n[1]}
N 1080 -1570 1100 -1570 {
lab=rowon_n[1]}
N 1080 -1550 1100 -1550 {
lab=#net3}
N 1080 -1530 1100 -1530 {
lab=#net4}
N 1320 -1530 1340 -1530 {
lab=#net4}
N 1320 -1550 1340 -1550 {
lab=#net3}
N 1320 -1570 1340 -1570 {
lab=rowon_n[1]}
N 1320 -1590 1340 -1590 {
lab=row_n[1]}
N 1140 -1450 1140 -1440 {
lab=VSS}
N 1140 -1680 1140 -1670 {
lab=VDD}
N 1480 -1450 1490 -1460 {
lab=col_n[3]}
N 1490 -1660 1490 -1460 {
lab=col_n[3]}
N 1480 -1670 1490 -1660 {
lab=col_n[3]}
N 1480 -1450 1480 -1430 {
lab=col_n[3]}
N 1480 -1690 1480 -1670 {
lab=col_n[3]}
N 1360 -1590 1370 -1600 {
lab=row_n[1]}
N 1370 -1600 1570 -1600 {
lab=row_n[1]}
N 1570 -1600 1580 -1590 {
lab=row_n[1]}
N 1360 -1570 1370 -1580 {
lab=rowon_n[1]}
N 1370 -1580 1570 -1580 {
lab=rowon_n[1]}
N 1570 -1580 1580 -1570 {
lab=rowon_n[1]}
N 1360 -1550 1370 -1560 {
lab=#net3}
N 1370 -1560 1570 -1560 {
lab=#net3}
N 1570 -1560 1580 -1550 {
lab=#net3}
N 1360 -1530 1370 -1540 {
lab=#net4}
N 1370 -1540 1570 -1540 {
lab=#net4}
N 1570 -1540 1580 -1530 {
lab=#net4}
N 1420 -1690 1420 -1670 {
lab=vcm}
N 1460 -1690 1460 -1670 {
lab=ctop}
N 1340 -1590 1360 -1590 {
lab=row_n[1]}
N 1340 -1570 1360 -1570 {
lab=rowon_n[1]}
N 1340 -1550 1360 -1550 {
lab=#net3}
N 1340 -1530 1360 -1530 {
lab=#net4}
N 1580 -1530 1600 -1530 {
lab=#net4}
N 1580 -1550 1600 -1550 {
lab=#net3}
N 1580 -1570 1600 -1570 {
lab=rowon_n[1]}
N 1580 -1590 1600 -1590 {
lab=row_n[1]}
N 1400 -1450 1400 -1440 {
lab=VSS}
N 1400 -1680 1400 -1670 {
lab=VDD}
N 1740 -1450 1750 -1460 {
lab=col_n[4]}
N 1750 -1660 1750 -1460 {
lab=col_n[4]}
N 1740 -1670 1750 -1660 {
lab=col_n[4]}
N 1740 -1450 1740 -1430 {
lab=col_n[4]}
N 1740 -1690 1740 -1670 {
lab=col_n[4]}
N 1620 -1590 1630 -1600 {
lab=row_n[1]}
N 1630 -1600 1830 -1600 {
lab=row_n[1]}
N 1830 -1600 1840 -1590 {
lab=row_n[1]}
N 1620 -1570 1630 -1580 {
lab=rowon_n[1]}
N 1630 -1580 1830 -1580 {
lab=rowon_n[1]}
N 1830 -1580 1840 -1570 {
lab=rowon_n[1]}
N 1620 -1550 1630 -1560 {
lab=#net3}
N 1630 -1560 1830 -1560 {
lab=#net3}
N 1830 -1560 1840 -1550 {
lab=#net3}
N 1620 -1530 1630 -1540 {
lab=#net4}
N 1630 -1540 1830 -1540 {
lab=#net4}
N 1830 -1540 1840 -1530 {
lab=#net4}
N 1680 -1690 1680 -1670 {
lab=vcm}
N 1720 -1690 1720 -1670 {
lab=ctop}
N 1600 -1590 1620 -1590 {
lab=row_n[1]}
N 1600 -1570 1620 -1570 {
lab=rowon_n[1]}
N 1600 -1550 1620 -1550 {
lab=#net3}
N 1600 -1530 1620 -1530 {
lab=#net4}
N 1840 -1530 1860 -1530 {
lab=#net4}
N 1840 -1550 1860 -1550 {
lab=#net3}
N 1840 -1570 1860 -1570 {
lab=rowon_n[1]}
N 1840 -1590 1860 -1590 {
lab=row_n[1]}
N 1660 -1450 1660 -1440 {
lab=VSS}
N 1660 -1680 1660 -1670 {
lab=VDD}
N 2000 -1450 2010 -1460 {
lab=col_n[5]}
N 2010 -1660 2010 -1460 {
lab=col_n[5]}
N 2000 -1670 2010 -1660 {
lab=col_n[5]}
N 2000 -1450 2000 -1430 {
lab=col_n[5]}
N 2000 -1690 2000 -1670 {
lab=col_n[5]}
N 1880 -1590 1890 -1600 {
lab=row_n[1]}
N 1890 -1600 2090 -1600 {
lab=row_n[1]}
N 2090 -1600 2100 -1590 {
lab=row_n[1]}
N 1880 -1570 1890 -1580 {
lab=rowon_n[1]}
N 1890 -1580 2090 -1580 {
lab=rowon_n[1]}
N 2090 -1580 2100 -1570 {
lab=rowon_n[1]}
N 1880 -1550 1890 -1560 {
lab=#net3}
N 1890 -1560 2090 -1560 {
lab=#net3}
N 2090 -1560 2100 -1550 {
lab=#net3}
N 1880 -1530 1890 -1540 {
lab=#net4}
N 1890 -1540 2090 -1540 {
lab=#net4}
N 2090 -1540 2100 -1530 {
lab=#net4}
N 1940 -1690 1940 -1670 {
lab=vcm}
N 1980 -1690 1980 -1670 {
lab=ctop}
N 1860 -1590 1880 -1590 {
lab=row_n[1]}
N 1860 -1570 1880 -1570 {
lab=rowon_n[1]}
N 1860 -1550 1880 -1550 {
lab=#net3}
N 1860 -1530 1880 -1530 {
lab=#net4}
N 2100 -1530 2120 -1530 {
lab=#net4}
N 2100 -1550 2120 -1550 {
lab=#net3}
N 2100 -1570 2120 -1570 {
lab=rowon_n[1]}
N 2100 -1590 2120 -1590 {
lab=row_n[1]}
N 1920 -1450 1920 -1440 {
lab=VSS}
N 1920 -1680 1920 -1670 {
lab=VDD}
N 2260 -1450 2270 -1460 {
lab=col_n[6]}
N 2270 -1660 2270 -1460 {
lab=col_n[6]}
N 2260 -1670 2270 -1660 {
lab=col_n[6]}
N 2260 -1450 2260 -1430 {
lab=col_n[6]}
N 2260 -1690 2260 -1670 {
lab=col_n[6]}
N 2140 -1590 2150 -1600 {
lab=row_n[1]}
N 2150 -1600 2350 -1600 {
lab=row_n[1]}
N 2350 -1600 2360 -1590 {
lab=row_n[1]}
N 2140 -1570 2150 -1580 {
lab=rowon_n[1]}
N 2150 -1580 2350 -1580 {
lab=rowon_n[1]}
N 2350 -1580 2360 -1570 {
lab=rowon_n[1]}
N 2140 -1550 2150 -1560 {
lab=#net3}
N 2150 -1560 2350 -1560 {
lab=#net3}
N 2350 -1560 2360 -1550 {
lab=#net3}
N 2140 -1530 2150 -1540 {
lab=#net4}
N 2150 -1540 2350 -1540 {
lab=#net4}
N 2350 -1540 2360 -1530 {
lab=#net4}
N 2200 -1690 2200 -1670 {
lab=vcm}
N 2240 -1690 2240 -1670 {
lab=ctop}
N 2120 -1590 2140 -1590 {
lab=row_n[1]}
N 2120 -1570 2140 -1570 {
lab=rowon_n[1]}
N 2120 -1550 2140 -1550 {
lab=#net3}
N 2120 -1530 2140 -1530 {
lab=#net4}
N 2360 -1530 2380 -1530 {
lab=#net4}
N 2360 -1550 2380 -1550 {
lab=#net3}
N 2360 -1570 2380 -1570 {
lab=rowon_n[1]}
N 2360 -1590 2380 -1590 {
lab=row_n[1]}
N 2180 -1450 2180 -1440 {
lab=VSS}
N 2180 -1680 2180 -1670 {
lab=VDD}
N 2520 -1450 2530 -1460 {
lab=col_n[7]}
N 2530 -1660 2530 -1460 {
lab=col_n[7]}
N 2520 -1670 2530 -1660 {
lab=col_n[7]}
N 2520 -1450 2520 -1430 {
lab=col_n[7]}
N 2520 -1690 2520 -1670 {
lab=col_n[7]}
N 2400 -1590 2410 -1600 {
lab=row_n[1]}
N 2410 -1600 2610 -1600 {
lab=row_n[1]}
N 2610 -1600 2620 -1590 {
lab=row_n[1]}
N 2400 -1570 2410 -1580 {
lab=rowon_n[1]}
N 2410 -1580 2610 -1580 {
lab=rowon_n[1]}
N 2610 -1580 2620 -1570 {
lab=rowon_n[1]}
N 2400 -1550 2410 -1560 {
lab=#net3}
N 2410 -1560 2610 -1560 {
lab=#net3}
N 2610 -1560 2620 -1550 {
lab=#net3}
N 2400 -1530 2410 -1540 {
lab=#net4}
N 2410 -1540 2610 -1540 {
lab=#net4}
N 2610 -1540 2620 -1530 {
lab=#net4}
N 2460 -1690 2460 -1670 {
lab=vcm}
N 2500 -1690 2500 -1670 {
lab=ctop}
N 2380 -1590 2400 -1590 {
lab=row_n[1]}
N 2380 -1570 2400 -1570 {
lab=rowon_n[1]}
N 2380 -1550 2400 -1550 {
lab=#net3}
N 2380 -1530 2400 -1530 {
lab=#net4}
N 2620 -1530 2640 -1530 {
lab=#net4}
N 2620 -1550 2640 -1550 {
lab=#net3}
N 2620 -1570 2640 -1570 {
lab=rowon_n[1]}
N 2620 -1590 2640 -1590 {
lab=row_n[1]}
N 2440 -1450 2440 -1440 {
lab=VSS}
N 2440 -1680 2440 -1670 {
lab=VDD}
N 2780 -1450 2790 -1460 {
lab=col_n[8]}
N 2790 -1660 2790 -1460 {
lab=col_n[8]}
N 2780 -1670 2790 -1660 {
lab=col_n[8]}
N 2780 -1450 2780 -1430 {
lab=col_n[8]}
N 2780 -1690 2780 -1670 {
lab=col_n[8]}
N 2660 -1590 2670 -1600 {
lab=row_n[1]}
N 2670 -1600 2870 -1600 {
lab=row_n[1]}
N 2870 -1600 2880 -1590 {
lab=row_n[1]}
N 2660 -1570 2670 -1580 {
lab=rowon_n[1]}
N 2670 -1580 2870 -1580 {
lab=rowon_n[1]}
N 2870 -1580 2880 -1570 {
lab=rowon_n[1]}
N 2660 -1550 2670 -1560 {
lab=#net3}
N 2670 -1560 2870 -1560 {
lab=#net3}
N 2870 -1560 2880 -1550 {
lab=#net3}
N 2660 -1530 2670 -1540 {
lab=#net4}
N 2670 -1540 2870 -1540 {
lab=#net4}
N 2870 -1540 2880 -1530 {
lab=#net4}
N 2720 -1690 2720 -1670 {
lab=vcm}
N 2760 -1690 2760 -1670 {
lab=ctop}
N 2640 -1590 2660 -1590 {
lab=row_n[1]}
N 2640 -1570 2660 -1570 {
lab=rowon_n[1]}
N 2640 -1550 2660 -1550 {
lab=#net3}
N 2640 -1530 2660 -1530 {
lab=#net4}
N 2880 -1530 2900 -1530 {
lab=#net4}
N 2880 -1550 2900 -1550 {
lab=#net3}
N 2880 -1570 2900 -1570 {
lab=rowon_n[1]}
N 2880 -1590 2900 -1590 {
lab=row_n[1]}
N 2700 -1450 2700 -1440 {
lab=VSS}
N 2700 -1680 2700 -1670 {
lab=VDD}
N 3040 -1450 3050 -1460 {
lab=col_n[9]}
N 3050 -1660 3050 -1460 {
lab=col_n[9]}
N 3040 -1670 3050 -1660 {
lab=col_n[9]}
N 3040 -1450 3040 -1430 {
lab=col_n[9]}
N 3040 -1690 3040 -1670 {
lab=col_n[9]}
N 2920 -1590 2930 -1600 {
lab=row_n[1]}
N 2930 -1600 3130 -1600 {
lab=row_n[1]}
N 3130 -1600 3140 -1590 {
lab=row_n[1]}
N 2920 -1570 2930 -1580 {
lab=rowon_n[1]}
N 2930 -1580 3130 -1580 {
lab=rowon_n[1]}
N 3130 -1580 3140 -1570 {
lab=rowon_n[1]}
N 2920 -1550 2930 -1560 {
lab=#net3}
N 2930 -1560 3130 -1560 {
lab=#net3}
N 3130 -1560 3140 -1550 {
lab=#net3}
N 2920 -1530 2930 -1540 {
lab=#net4}
N 2930 -1540 3130 -1540 {
lab=#net4}
N 3130 -1540 3140 -1530 {
lab=#net4}
N 2980 -1690 2980 -1670 {
lab=vcm}
N 3020 -1690 3020 -1670 {
lab=ctop}
N 2900 -1590 2920 -1590 {
lab=row_n[1]}
N 2900 -1570 2920 -1570 {
lab=rowon_n[1]}
N 2900 -1550 2920 -1550 {
lab=#net3}
N 2900 -1530 2920 -1530 {
lab=#net4}
N 3140 -1530 3160 -1530 {
lab=#net4}
N 3140 -1550 3160 -1550 {
lab=#net3}
N 3140 -1570 3160 -1570 {
lab=rowon_n[1]}
N 3140 -1590 3160 -1590 {
lab=row_n[1]}
N 2960 -1450 2960 -1440 {
lab=VSS}
N 2960 -1680 2960 -1670 {
lab=VDD}
N 3300 -1450 3310 -1460 {
lab=col_n[10]}
N 3310 -1660 3310 -1460 {
lab=col_n[10]}
N 3300 -1670 3310 -1660 {
lab=col_n[10]}
N 3300 -1450 3300 -1430 {
lab=col_n[10]}
N 3300 -1690 3300 -1670 {
lab=col_n[10]}
N 3180 -1590 3190 -1600 {
lab=row_n[1]}
N 3190 -1600 3390 -1600 {
lab=row_n[1]}
N 3390 -1600 3400 -1590 {
lab=row_n[1]}
N 3180 -1570 3190 -1580 {
lab=rowon_n[1]}
N 3190 -1580 3390 -1580 {
lab=rowon_n[1]}
N 3390 -1580 3400 -1570 {
lab=rowon_n[1]}
N 3180 -1550 3190 -1560 {
lab=#net3}
N 3190 -1560 3390 -1560 {
lab=#net3}
N 3390 -1560 3400 -1550 {
lab=#net3}
N 3180 -1530 3190 -1540 {
lab=#net4}
N 3190 -1540 3390 -1540 {
lab=#net4}
N 3390 -1540 3400 -1530 {
lab=#net4}
N 3240 -1690 3240 -1670 {
lab=vcm}
N 3280 -1690 3280 -1670 {
lab=ctop}
N 3160 -1590 3180 -1590 {
lab=row_n[1]}
N 3160 -1570 3180 -1570 {
lab=rowon_n[1]}
N 3160 -1550 3180 -1550 {
lab=#net3}
N 3160 -1530 3180 -1530 {
lab=#net4}
N 3400 -1530 3420 -1530 {
lab=#net4}
N 3400 -1550 3420 -1550 {
lab=#net3}
N 3400 -1570 3420 -1570 {
lab=rowon_n[1]}
N 3400 -1590 3420 -1590 {
lab=row_n[1]}
N 3220 -1450 3220 -1440 {
lab=VSS}
N 3220 -1680 3220 -1670 {
lab=VDD}
N 3560 -1450 3570 -1460 {
lab=col_n[11]}
N 3570 -1660 3570 -1460 {
lab=col_n[11]}
N 3560 -1670 3570 -1660 {
lab=col_n[11]}
N 3560 -1450 3560 -1430 {
lab=col_n[11]}
N 3560 -1690 3560 -1670 {
lab=col_n[11]}
N 3440 -1590 3450 -1600 {
lab=row_n[1]}
N 3450 -1600 3650 -1600 {
lab=row_n[1]}
N 3650 -1600 3660 -1590 {
lab=row_n[1]}
N 3440 -1570 3450 -1580 {
lab=rowon_n[1]}
N 3450 -1580 3650 -1580 {
lab=rowon_n[1]}
N 3650 -1580 3660 -1570 {
lab=rowon_n[1]}
N 3440 -1550 3450 -1560 {
lab=#net3}
N 3450 -1560 3650 -1560 {
lab=#net3}
N 3650 -1560 3660 -1550 {
lab=#net3}
N 3440 -1530 3450 -1540 {
lab=#net4}
N 3450 -1540 3650 -1540 {
lab=#net4}
N 3650 -1540 3660 -1530 {
lab=#net4}
N 3500 -1690 3500 -1670 {
lab=vcm}
N 3540 -1690 3540 -1670 {
lab=ctop}
N 3420 -1590 3440 -1590 {
lab=row_n[1]}
N 3420 -1570 3440 -1570 {
lab=rowon_n[1]}
N 3420 -1550 3440 -1550 {
lab=#net3}
N 3420 -1530 3440 -1530 {
lab=#net4}
N 3660 -1530 3680 -1530 {
lab=#net4}
N 3660 -1550 3680 -1550 {
lab=#net3}
N 3660 -1570 3680 -1570 {
lab=rowon_n[1]}
N 3660 -1590 3680 -1590 {
lab=row_n[1]}
N 3480 -1450 3480 -1440 {
lab=VSS}
N 3480 -1680 3480 -1670 {
lab=VDD}
N 3820 -1450 3830 -1460 {
lab=col_n[12]}
N 3830 -1660 3830 -1460 {
lab=col_n[12]}
N 3820 -1670 3830 -1660 {
lab=col_n[12]}
N 3820 -1450 3820 -1430 {
lab=col_n[12]}
N 3820 -1690 3820 -1670 {
lab=col_n[12]}
N 3700 -1590 3710 -1600 {
lab=row_n[1]}
N 3710 -1600 3910 -1600 {
lab=row_n[1]}
N 3910 -1600 3920 -1590 {
lab=row_n[1]}
N 3700 -1570 3710 -1580 {
lab=rowon_n[1]}
N 3710 -1580 3910 -1580 {
lab=rowon_n[1]}
N 3910 -1580 3920 -1570 {
lab=rowon_n[1]}
N 3700 -1550 3710 -1560 {
lab=#net3}
N 3710 -1560 3910 -1560 {
lab=#net3}
N 3910 -1560 3920 -1550 {
lab=#net3}
N 3700 -1530 3710 -1540 {
lab=#net4}
N 3710 -1540 3910 -1540 {
lab=#net4}
N 3910 -1540 3920 -1530 {
lab=#net4}
N 3760 -1690 3760 -1670 {
lab=vcm}
N 3800 -1690 3800 -1670 {
lab=ctop}
N 3680 -1590 3700 -1590 {
lab=row_n[1]}
N 3680 -1570 3700 -1570 {
lab=rowon_n[1]}
N 3680 -1550 3700 -1550 {
lab=#net3}
N 3680 -1530 3700 -1530 {
lab=#net4}
N 3920 -1530 3940 -1530 {
lab=#net4}
N 3920 -1550 3940 -1550 {
lab=#net3}
N 3920 -1570 3940 -1570 {
lab=rowon_n[1]}
N 3920 -1590 3940 -1590 {
lab=row_n[1]}
N 3740 -1450 3740 -1440 {
lab=VSS}
N 3740 -1680 3740 -1670 {
lab=VDD}
N 4080 -1450 4090 -1460 {
lab=col_n[13]}
N 4090 -1660 4090 -1460 {
lab=col_n[13]}
N 4080 -1670 4090 -1660 {
lab=col_n[13]}
N 4080 -1450 4080 -1430 {
lab=col_n[13]}
N 4080 -1690 4080 -1670 {
lab=col_n[13]}
N 3960 -1590 3970 -1600 {
lab=row_n[1]}
N 3970 -1600 4170 -1600 {
lab=row_n[1]}
N 4170 -1600 4180 -1590 {
lab=row_n[1]}
N 3960 -1570 3970 -1580 {
lab=rowon_n[1]}
N 3970 -1580 4170 -1580 {
lab=rowon_n[1]}
N 4170 -1580 4180 -1570 {
lab=rowon_n[1]}
N 3960 -1550 3970 -1560 {
lab=#net3}
N 3970 -1560 4170 -1560 {
lab=#net3}
N 4170 -1560 4180 -1550 {
lab=#net3}
N 3960 -1530 3970 -1540 {
lab=#net4}
N 3970 -1540 4170 -1540 {
lab=#net4}
N 4170 -1540 4180 -1530 {
lab=#net4}
N 4020 -1690 4020 -1670 {
lab=vcm}
N 4060 -1690 4060 -1670 {
lab=ctop}
N 3940 -1590 3960 -1590 {
lab=row_n[1]}
N 3940 -1570 3960 -1570 {
lab=rowon_n[1]}
N 3940 -1550 3960 -1550 {
lab=#net3}
N 3940 -1530 3960 -1530 {
lab=#net4}
N 4180 -1530 4200 -1530 {
lab=#net4}
N 4180 -1550 4200 -1550 {
lab=#net3}
N 4180 -1570 4200 -1570 {
lab=rowon_n[1]}
N 4180 -1590 4200 -1590 {
lab=row_n[1]}
N 4000 -1450 4000 -1440 {
lab=VSS}
N 4000 -1680 4000 -1670 {
lab=VDD}
N 4340 -1450 4350 -1460 {
lab=col_n[14]}
N 4350 -1660 4350 -1460 {
lab=col_n[14]}
N 4340 -1670 4350 -1660 {
lab=col_n[14]}
N 4340 -1450 4340 -1430 {
lab=col_n[14]}
N 4340 -1690 4340 -1670 {
lab=col_n[14]}
N 4220 -1590 4230 -1600 {
lab=row_n[1]}
N 4230 -1600 4430 -1600 {
lab=row_n[1]}
N 4430 -1600 4440 -1590 {
lab=row_n[1]}
N 4220 -1570 4230 -1580 {
lab=rowon_n[1]}
N 4230 -1580 4430 -1580 {
lab=rowon_n[1]}
N 4430 -1580 4440 -1570 {
lab=rowon_n[1]}
N 4220 -1550 4230 -1560 {
lab=#net3}
N 4230 -1560 4430 -1560 {
lab=#net3}
N 4430 -1560 4440 -1550 {
lab=#net3}
N 4220 -1530 4230 -1540 {
lab=#net4}
N 4230 -1540 4430 -1540 {
lab=#net4}
N 4430 -1540 4440 -1530 {
lab=#net4}
N 4280 -1690 4280 -1670 {
lab=vcm}
N 4320 -1690 4320 -1670 {
lab=ctop}
N 4200 -1590 4220 -1590 {
lab=row_n[1]}
N 4200 -1570 4220 -1570 {
lab=rowon_n[1]}
N 4200 -1550 4220 -1550 {
lab=#net3}
N 4200 -1530 4220 -1530 {
lab=#net4}
N 4440 -1530 4460 -1530 {
lab=#net4}
N 4440 -1550 4460 -1550 {
lab=#net3}
N 4440 -1570 4460 -1570 {
lab=rowon_n[1]}
N 4440 -1590 4460 -1590 {
lab=row_n[1]}
N 4260 -1450 4260 -1440 {
lab=VSS}
N 4260 -1680 4260 -1670 {
lab=VDD}
N 4600 -1450 4610 -1460 {
lab=col_n[15]}
N 4610 -1660 4610 -1460 {
lab=col_n[15]}
N 4600 -1670 4610 -1660 {
lab=col_n[15]}
N 4600 -1450 4600 -1430 {
lab=col_n[15]}
N 4600 -1690 4600 -1670 {
lab=col_n[15]}
N 4480 -1590 4490 -1600 {
lab=row_n[1]}
N 4490 -1600 4690 -1600 {
lab=row_n[1]}
N 4690 -1600 4700 -1590 {
lab=row_n[1]}
N 4480 -1570 4490 -1580 {
lab=rowon_n[1]}
N 4490 -1580 4690 -1580 {
lab=rowon_n[1]}
N 4690 -1580 4700 -1570 {
lab=rowon_n[1]}
N 4480 -1550 4490 -1560 {
lab=#net3}
N 4490 -1560 4690 -1560 {
lab=#net3}
N 4690 -1560 4700 -1550 {
lab=#net3}
N 4480 -1530 4490 -1540 {
lab=#net4}
N 4490 -1540 4690 -1540 {
lab=#net4}
N 4690 -1540 4700 -1530 {
lab=#net4}
N 4540 -1690 4540 -1670 {
lab=vcm}
N 4580 -1690 4580 -1670 {
lab=ctop}
N 4460 -1590 4480 -1590 {
lab=row_n[1]}
N 4460 -1570 4480 -1570 {
lab=rowon_n[1]}
N 4460 -1550 4480 -1550 {
lab=#net3}
N 4460 -1530 4480 -1530 {
lab=#net4}
N 4700 -1530 4720 -1530 {
lab=#net4}
N 4700 -1550 4720 -1550 {
lab=#net3}
N 4700 -1570 4720 -1570 {
lab=rowon_n[1]}
N 4700 -1590 4720 -1590 {
lab=row_n[1]}
N 4520 -1450 4520 -1440 {
lab=VSS}
N 4520 -1680 4520 -1670 {
lab=VDD}
N 4860 -1450 4870 -1460 {
lab=col_n[16]}
N 4870 -1660 4870 -1460 {
lab=col_n[16]}
N 4860 -1670 4870 -1660 {
lab=col_n[16]}
N 4860 -1450 4860 -1430 {
lab=col_n[16]}
N 4860 -1690 4860 -1670 {
lab=col_n[16]}
N 4740 -1590 4750 -1600 {
lab=row_n[1]}
N 4750 -1600 4950 -1600 {
lab=row_n[1]}
N 4950 -1600 4960 -1590 {
lab=row_n[1]}
N 4740 -1570 4750 -1580 {
lab=rowon_n[1]}
N 4750 -1580 4950 -1580 {
lab=rowon_n[1]}
N 4950 -1580 4960 -1570 {
lab=rowon_n[1]}
N 4740 -1550 4750 -1560 {
lab=#net3}
N 4750 -1560 4950 -1560 {
lab=#net3}
N 4950 -1560 4960 -1550 {
lab=#net3}
N 4740 -1530 4750 -1540 {
lab=#net4}
N 4750 -1540 4950 -1540 {
lab=#net4}
N 4950 -1540 4960 -1530 {
lab=#net4}
N 4800 -1690 4800 -1670 {
lab=vcm}
N 4840 -1690 4840 -1670 {
lab=ctop}
N 4720 -1590 4740 -1590 {
lab=row_n[1]}
N 4720 -1570 4740 -1570 {
lab=rowon_n[1]}
N 4720 -1550 4740 -1550 {
lab=#net3}
N 4720 -1530 4740 -1530 {
lab=#net4}
N 4960 -1530 4980 -1530 {
lab=#net4}
N 4960 -1550 4980 -1550 {
lab=#net3}
N 4960 -1570 4980 -1570 {
lab=rowon_n[1]}
N 4960 -1590 4980 -1590 {
lab=row_n[1]}
N 4780 -1450 4780 -1440 {
lab=VSS}
N 4780 -1680 4780 -1670 {
lab=VDD}
N 5120 -1450 5130 -1460 {
lab=col_n[17]}
N 5130 -1660 5130 -1460 {
lab=col_n[17]}
N 5120 -1670 5130 -1660 {
lab=col_n[17]}
N 5120 -1450 5120 -1430 {
lab=col_n[17]}
N 5120 -1690 5120 -1670 {
lab=col_n[17]}
N 5000 -1590 5010 -1600 {
lab=row_n[1]}
N 5010 -1600 5210 -1600 {
lab=row_n[1]}
N 5210 -1600 5220 -1590 {
lab=row_n[1]}
N 5000 -1570 5010 -1580 {
lab=rowon_n[1]}
N 5010 -1580 5210 -1580 {
lab=rowon_n[1]}
N 5210 -1580 5220 -1570 {
lab=rowon_n[1]}
N 5000 -1550 5010 -1560 {
lab=#net3}
N 5010 -1560 5210 -1560 {
lab=#net3}
N 5210 -1560 5220 -1550 {
lab=#net3}
N 5000 -1530 5010 -1540 {
lab=#net4}
N 5010 -1540 5210 -1540 {
lab=#net4}
N 5210 -1540 5220 -1530 {
lab=#net4}
N 5060 -1690 5060 -1670 {
lab=vcm}
N 5100 -1690 5100 -1670 {
lab=ctop}
N 4980 -1590 5000 -1590 {
lab=row_n[1]}
N 4980 -1570 5000 -1570 {
lab=rowon_n[1]}
N 4980 -1550 5000 -1550 {
lab=#net3}
N 4980 -1530 5000 -1530 {
lab=#net4}
N 5220 -1530 5240 -1530 {
lab=#net4}
N 5220 -1550 5240 -1550 {
lab=#net3}
N 5220 -1570 5240 -1570 {
lab=rowon_n[1]}
N 5220 -1590 5240 -1590 {
lab=row_n[1]}
N 5040 -1450 5040 -1440 {
lab=VSS}
N 5040 -1680 5040 -1670 {
lab=VDD}
N 5380 -1450 5390 -1460 {
lab=col_n[18]}
N 5390 -1660 5390 -1460 {
lab=col_n[18]}
N 5380 -1670 5390 -1660 {
lab=col_n[18]}
N 5380 -1450 5380 -1430 {
lab=col_n[18]}
N 5380 -1690 5380 -1670 {
lab=col_n[18]}
N 5260 -1590 5270 -1600 {
lab=row_n[1]}
N 5270 -1600 5470 -1600 {
lab=row_n[1]}
N 5470 -1600 5480 -1590 {
lab=row_n[1]}
N 5260 -1570 5270 -1580 {
lab=rowon_n[1]}
N 5270 -1580 5470 -1580 {
lab=rowon_n[1]}
N 5470 -1580 5480 -1570 {
lab=rowon_n[1]}
N 5260 -1550 5270 -1560 {
lab=#net3}
N 5270 -1560 5470 -1560 {
lab=#net3}
N 5470 -1560 5480 -1550 {
lab=#net3}
N 5260 -1530 5270 -1540 {
lab=#net4}
N 5270 -1540 5470 -1540 {
lab=#net4}
N 5470 -1540 5480 -1530 {
lab=#net4}
N 5320 -1690 5320 -1670 {
lab=vcm}
N 5360 -1690 5360 -1670 {
lab=ctop}
N 5240 -1590 5260 -1590 {
lab=row_n[1]}
N 5240 -1570 5260 -1570 {
lab=rowon_n[1]}
N 5240 -1550 5260 -1550 {
lab=#net3}
N 5240 -1530 5260 -1530 {
lab=#net4}
N 5480 -1530 5500 -1530 {
lab=#net4}
N 5480 -1550 5500 -1550 {
lab=#net3}
N 5480 -1570 5500 -1570 {
lab=rowon_n[1]}
N 5480 -1590 5500 -1590 {
lab=row_n[1]}
N 5300 -1450 5300 -1440 {
lab=VSS}
N 5300 -1680 5300 -1670 {
lab=VDD}
N 5640 -1450 5650 -1460 {
lab=col_n[19]}
N 5650 -1660 5650 -1460 {
lab=col_n[19]}
N 5640 -1670 5650 -1660 {
lab=col_n[19]}
N 5640 -1450 5640 -1430 {
lab=col_n[19]}
N 5640 -1690 5640 -1670 {
lab=col_n[19]}
N 5520 -1590 5530 -1600 {
lab=row_n[1]}
N 5530 -1600 5730 -1600 {
lab=row_n[1]}
N 5730 -1600 5740 -1590 {
lab=row_n[1]}
N 5520 -1570 5530 -1580 {
lab=rowon_n[1]}
N 5530 -1580 5730 -1580 {
lab=rowon_n[1]}
N 5730 -1580 5740 -1570 {
lab=rowon_n[1]}
N 5520 -1550 5530 -1560 {
lab=#net3}
N 5530 -1560 5730 -1560 {
lab=#net3}
N 5730 -1560 5740 -1550 {
lab=#net3}
N 5520 -1530 5530 -1540 {
lab=#net4}
N 5530 -1540 5730 -1540 {
lab=#net4}
N 5730 -1540 5740 -1530 {
lab=#net4}
N 5580 -1690 5580 -1670 {
lab=vcm}
N 5620 -1690 5620 -1670 {
lab=ctop}
N 5500 -1590 5520 -1590 {
lab=row_n[1]}
N 5500 -1570 5520 -1570 {
lab=rowon_n[1]}
N 5500 -1550 5520 -1550 {
lab=#net3}
N 5500 -1530 5520 -1530 {
lab=#net4}
N 5740 -1530 5760 -1530 {
lab=#net4}
N 5740 -1550 5760 -1550 {
lab=#net3}
N 5740 -1570 5760 -1570 {
lab=rowon_n[1]}
N 5740 -1590 5760 -1590 {
lab=row_n[1]}
N 5560 -1450 5560 -1440 {
lab=VSS}
N 5560 -1680 5560 -1670 {
lab=VDD}
N 5900 -1450 5910 -1460 {
lab=col_n[20]}
N 5910 -1660 5910 -1460 {
lab=col_n[20]}
N 5900 -1670 5910 -1660 {
lab=col_n[20]}
N 5900 -1450 5900 -1430 {
lab=col_n[20]}
N 5900 -1690 5900 -1670 {
lab=col_n[20]}
N 5780 -1590 5790 -1600 {
lab=row_n[1]}
N 5790 -1600 5990 -1600 {
lab=row_n[1]}
N 5990 -1600 6000 -1590 {
lab=row_n[1]}
N 5780 -1570 5790 -1580 {
lab=rowon_n[1]}
N 5790 -1580 5990 -1580 {
lab=rowon_n[1]}
N 5990 -1580 6000 -1570 {
lab=rowon_n[1]}
N 5780 -1550 5790 -1560 {
lab=#net3}
N 5790 -1560 5990 -1560 {
lab=#net3}
N 5990 -1560 6000 -1550 {
lab=#net3}
N 5780 -1530 5790 -1540 {
lab=#net4}
N 5790 -1540 5990 -1540 {
lab=#net4}
N 5990 -1540 6000 -1530 {
lab=#net4}
N 5840 -1690 5840 -1670 {
lab=vcm}
N 5880 -1690 5880 -1670 {
lab=ctop}
N 5760 -1590 5780 -1590 {
lab=row_n[1]}
N 5760 -1570 5780 -1570 {
lab=rowon_n[1]}
N 5760 -1550 5780 -1550 {
lab=#net3}
N 5760 -1530 5780 -1530 {
lab=#net4}
N 6000 -1530 6020 -1530 {
lab=#net4}
N 6000 -1550 6020 -1550 {
lab=#net3}
N 6000 -1570 6020 -1570 {
lab=rowon_n[1]}
N 6000 -1590 6020 -1590 {
lab=row_n[1]}
N 5820 -1450 5820 -1440 {
lab=VSS}
N 5820 -1680 5820 -1670 {
lab=VDD}
N 6160 -1450 6170 -1460 {
lab=col_n[21]}
N 6170 -1660 6170 -1460 {
lab=col_n[21]}
N 6160 -1670 6170 -1660 {
lab=col_n[21]}
N 6160 -1450 6160 -1430 {
lab=col_n[21]}
N 6160 -1690 6160 -1670 {
lab=col_n[21]}
N 6040 -1590 6050 -1600 {
lab=row_n[1]}
N 6050 -1600 6250 -1600 {
lab=row_n[1]}
N 6250 -1600 6260 -1590 {
lab=row_n[1]}
N 6040 -1570 6050 -1580 {
lab=rowon_n[1]}
N 6050 -1580 6250 -1580 {
lab=rowon_n[1]}
N 6250 -1580 6260 -1570 {
lab=rowon_n[1]}
N 6040 -1550 6050 -1560 {
lab=#net3}
N 6050 -1560 6250 -1560 {
lab=#net3}
N 6250 -1560 6260 -1550 {
lab=#net3}
N 6040 -1530 6050 -1540 {
lab=#net4}
N 6050 -1540 6250 -1540 {
lab=#net4}
N 6250 -1540 6260 -1530 {
lab=#net4}
N 6100 -1690 6100 -1670 {
lab=vcm}
N 6140 -1690 6140 -1670 {
lab=ctop}
N 6020 -1590 6040 -1590 {
lab=row_n[1]}
N 6020 -1570 6040 -1570 {
lab=rowon_n[1]}
N 6020 -1550 6040 -1550 {
lab=#net3}
N 6020 -1530 6040 -1530 {
lab=#net4}
N 6260 -1530 6280 -1530 {
lab=#net4}
N 6260 -1550 6280 -1550 {
lab=#net3}
N 6260 -1570 6280 -1570 {
lab=rowon_n[1]}
N 6260 -1590 6280 -1590 {
lab=row_n[1]}
N 6080 -1450 6080 -1440 {
lab=VSS}
N 6080 -1680 6080 -1670 {
lab=VDD}
N 6420 -1450 6430 -1460 {
lab=col_n[22]}
N 6430 -1660 6430 -1460 {
lab=col_n[22]}
N 6420 -1670 6430 -1660 {
lab=col_n[22]}
N 6420 -1450 6420 -1430 {
lab=col_n[22]}
N 6420 -1690 6420 -1670 {
lab=col_n[22]}
N 6300 -1590 6310 -1600 {
lab=row_n[1]}
N 6310 -1600 6510 -1600 {
lab=row_n[1]}
N 6510 -1600 6520 -1590 {
lab=row_n[1]}
N 6300 -1570 6310 -1580 {
lab=rowon_n[1]}
N 6310 -1580 6510 -1580 {
lab=rowon_n[1]}
N 6510 -1580 6520 -1570 {
lab=rowon_n[1]}
N 6300 -1550 6310 -1560 {
lab=#net3}
N 6310 -1560 6510 -1560 {
lab=#net3}
N 6510 -1560 6520 -1550 {
lab=#net3}
N 6300 -1530 6310 -1540 {
lab=#net4}
N 6310 -1540 6510 -1540 {
lab=#net4}
N 6510 -1540 6520 -1530 {
lab=#net4}
N 6360 -1690 6360 -1670 {
lab=vcm}
N 6400 -1690 6400 -1670 {
lab=ctop}
N 6280 -1590 6300 -1590 {
lab=row_n[1]}
N 6280 -1570 6300 -1570 {
lab=rowon_n[1]}
N 6280 -1550 6300 -1550 {
lab=#net3}
N 6280 -1530 6300 -1530 {
lab=#net4}
N 6520 -1530 6540 -1530 {
lab=#net4}
N 6520 -1550 6540 -1550 {
lab=#net3}
N 6520 -1570 6540 -1570 {
lab=rowon_n[1]}
N 6520 -1590 6540 -1590 {
lab=row_n[1]}
N 6340 -1450 6340 -1440 {
lab=VSS}
N 6340 -1680 6340 -1670 {
lab=VDD}
N 6680 -1450 6690 -1460 {
lab=col_n[23]}
N 6690 -1660 6690 -1460 {
lab=col_n[23]}
N 6680 -1670 6690 -1660 {
lab=col_n[23]}
N 6680 -1450 6680 -1430 {
lab=col_n[23]}
N 6680 -1690 6680 -1670 {
lab=col_n[23]}
N 6560 -1590 6570 -1600 {
lab=row_n[1]}
N 6570 -1600 6770 -1600 {
lab=row_n[1]}
N 6770 -1600 6780 -1590 {
lab=row_n[1]}
N 6560 -1570 6570 -1580 {
lab=rowon_n[1]}
N 6570 -1580 6770 -1580 {
lab=rowon_n[1]}
N 6770 -1580 6780 -1570 {
lab=rowon_n[1]}
N 6560 -1550 6570 -1560 {
lab=#net3}
N 6570 -1560 6770 -1560 {
lab=#net3}
N 6770 -1560 6780 -1550 {
lab=#net3}
N 6560 -1530 6570 -1540 {
lab=#net4}
N 6570 -1540 6770 -1540 {
lab=#net4}
N 6770 -1540 6780 -1530 {
lab=#net4}
N 6620 -1690 6620 -1670 {
lab=vcm}
N 6660 -1690 6660 -1670 {
lab=ctop}
N 6540 -1590 6560 -1590 {
lab=row_n[1]}
N 6540 -1570 6560 -1570 {
lab=rowon_n[1]}
N 6540 -1550 6560 -1550 {
lab=#net3}
N 6540 -1530 6560 -1530 {
lab=#net4}
N 6780 -1530 6800 -1530 {
lab=#net4}
N 6780 -1550 6800 -1550 {
lab=#net3}
N 6780 -1570 6800 -1570 {
lab=rowon_n[1]}
N 6780 -1590 6800 -1590 {
lab=row_n[1]}
N 6600 -1450 6600 -1440 {
lab=VSS}
N 6600 -1680 6600 -1670 {
lab=VDD}
N 6940 -1450 6950 -1460 {
lab=col_n[24]}
N 6950 -1660 6950 -1460 {
lab=col_n[24]}
N 6940 -1670 6950 -1660 {
lab=col_n[24]}
N 6940 -1450 6940 -1430 {
lab=col_n[24]}
N 6940 -1690 6940 -1670 {
lab=col_n[24]}
N 6820 -1590 6830 -1600 {
lab=row_n[1]}
N 6830 -1600 7030 -1600 {
lab=row_n[1]}
N 7030 -1600 7040 -1590 {
lab=row_n[1]}
N 6820 -1570 6830 -1580 {
lab=rowon_n[1]}
N 6830 -1580 7030 -1580 {
lab=rowon_n[1]}
N 7030 -1580 7040 -1570 {
lab=rowon_n[1]}
N 6820 -1550 6830 -1560 {
lab=#net3}
N 6830 -1560 7030 -1560 {
lab=#net3}
N 7030 -1560 7040 -1550 {
lab=#net3}
N 6820 -1530 6830 -1540 {
lab=#net4}
N 6830 -1540 7030 -1540 {
lab=#net4}
N 7030 -1540 7040 -1530 {
lab=#net4}
N 6880 -1690 6880 -1670 {
lab=vcm}
N 6920 -1690 6920 -1670 {
lab=ctop}
N 6800 -1590 6820 -1590 {
lab=row_n[1]}
N 6800 -1570 6820 -1570 {
lab=rowon_n[1]}
N 6800 -1550 6820 -1550 {
lab=#net3}
N 6800 -1530 6820 -1530 {
lab=#net4}
N 7040 -1530 7060 -1530 {
lab=#net4}
N 7040 -1550 7060 -1550 {
lab=#net3}
N 7040 -1570 7060 -1570 {
lab=rowon_n[1]}
N 7040 -1590 7060 -1590 {
lab=row_n[1]}
N 6860 -1450 6860 -1440 {
lab=VSS}
N 6860 -1680 6860 -1670 {
lab=VDD}
N 7200 -1450 7210 -1460 {
lab=col_n[25]}
N 7210 -1660 7210 -1460 {
lab=col_n[25]}
N 7200 -1670 7210 -1660 {
lab=col_n[25]}
N 7200 -1450 7200 -1430 {
lab=col_n[25]}
N 7200 -1690 7200 -1670 {
lab=col_n[25]}
N 7080 -1590 7090 -1600 {
lab=row_n[1]}
N 7090 -1600 7290 -1600 {
lab=row_n[1]}
N 7290 -1600 7300 -1590 {
lab=row_n[1]}
N 7080 -1570 7090 -1580 {
lab=rowon_n[1]}
N 7090 -1580 7290 -1580 {
lab=rowon_n[1]}
N 7290 -1580 7300 -1570 {
lab=rowon_n[1]}
N 7080 -1550 7090 -1560 {
lab=#net3}
N 7090 -1560 7290 -1560 {
lab=#net3}
N 7290 -1560 7300 -1550 {
lab=#net3}
N 7080 -1530 7090 -1540 {
lab=#net4}
N 7090 -1540 7290 -1540 {
lab=#net4}
N 7290 -1540 7300 -1530 {
lab=#net4}
N 7140 -1690 7140 -1670 {
lab=vcm}
N 7180 -1690 7180 -1670 {
lab=ctop}
N 7060 -1590 7080 -1590 {
lab=row_n[1]}
N 7060 -1570 7080 -1570 {
lab=rowon_n[1]}
N 7060 -1550 7080 -1550 {
lab=#net3}
N 7060 -1530 7080 -1530 {
lab=#net4}
N 7300 -1530 7320 -1530 {
lab=#net4}
N 7300 -1550 7320 -1550 {
lab=#net3}
N 7300 -1570 7320 -1570 {
lab=rowon_n[1]}
N 7300 -1590 7320 -1590 {
lab=row_n[1]}
N 7120 -1450 7120 -1440 {
lab=VSS}
N 7120 -1680 7120 -1670 {
lab=VDD}
N 7460 -1450 7470 -1460 {
lab=col_n[26]}
N 7470 -1660 7470 -1460 {
lab=col_n[26]}
N 7460 -1670 7470 -1660 {
lab=col_n[26]}
N 7460 -1450 7460 -1430 {
lab=col_n[26]}
N 7460 -1690 7460 -1670 {
lab=col_n[26]}
N 7340 -1590 7350 -1600 {
lab=row_n[1]}
N 7350 -1600 7550 -1600 {
lab=row_n[1]}
N 7550 -1600 7560 -1590 {
lab=row_n[1]}
N 7340 -1570 7350 -1580 {
lab=rowon_n[1]}
N 7350 -1580 7550 -1580 {
lab=rowon_n[1]}
N 7550 -1580 7560 -1570 {
lab=rowon_n[1]}
N 7340 -1550 7350 -1560 {
lab=#net3}
N 7350 -1560 7550 -1560 {
lab=#net3}
N 7550 -1560 7560 -1550 {
lab=#net3}
N 7340 -1530 7350 -1540 {
lab=#net4}
N 7350 -1540 7550 -1540 {
lab=#net4}
N 7550 -1540 7560 -1530 {
lab=#net4}
N 7400 -1690 7400 -1670 {
lab=vcm}
N 7440 -1690 7440 -1670 {
lab=ctop}
N 7320 -1590 7340 -1590 {
lab=row_n[1]}
N 7320 -1570 7340 -1570 {
lab=rowon_n[1]}
N 7320 -1550 7340 -1550 {
lab=#net3}
N 7320 -1530 7340 -1530 {
lab=#net4}
N 7560 -1530 7580 -1530 {
lab=#net4}
N 7560 -1550 7580 -1550 {
lab=#net3}
N 7560 -1570 7580 -1570 {
lab=rowon_n[1]}
N 7560 -1590 7580 -1590 {
lab=row_n[1]}
N 7380 -1450 7380 -1440 {
lab=VSS}
N 7380 -1680 7380 -1670 {
lab=VDD}
N 7720 -1450 7730 -1460 {
lab=col_n[27]}
N 7730 -1660 7730 -1460 {
lab=col_n[27]}
N 7720 -1670 7730 -1660 {
lab=col_n[27]}
N 7720 -1450 7720 -1430 {
lab=col_n[27]}
N 7720 -1690 7720 -1670 {
lab=col_n[27]}
N 7600 -1590 7610 -1600 {
lab=row_n[1]}
N 7610 -1600 7810 -1600 {
lab=row_n[1]}
N 7810 -1600 7820 -1590 {
lab=row_n[1]}
N 7600 -1570 7610 -1580 {
lab=rowon_n[1]}
N 7610 -1580 7810 -1580 {
lab=rowon_n[1]}
N 7810 -1580 7820 -1570 {
lab=rowon_n[1]}
N 7600 -1550 7610 -1560 {
lab=#net3}
N 7610 -1560 7810 -1560 {
lab=#net3}
N 7810 -1560 7820 -1550 {
lab=#net3}
N 7600 -1530 7610 -1540 {
lab=#net4}
N 7610 -1540 7810 -1540 {
lab=#net4}
N 7810 -1540 7820 -1530 {
lab=#net4}
N 7660 -1690 7660 -1670 {
lab=vcm}
N 7700 -1690 7700 -1670 {
lab=ctop}
N 7580 -1590 7600 -1590 {
lab=row_n[1]}
N 7580 -1570 7600 -1570 {
lab=rowon_n[1]}
N 7580 -1550 7600 -1550 {
lab=#net3}
N 7580 -1530 7600 -1530 {
lab=#net4}
N 7820 -1530 7840 -1530 {
lab=#net4}
N 7820 -1550 7840 -1550 {
lab=#net3}
N 7820 -1570 7840 -1570 {
lab=rowon_n[1]}
N 7820 -1590 7840 -1590 {
lab=row_n[1]}
N 7640 -1450 7640 -1440 {
lab=VSS}
N 7640 -1680 7640 -1670 {
lab=VDD}
N 7980 -1450 7990 -1460 {
lab=col_n[28]}
N 7990 -1660 7990 -1460 {
lab=col_n[28]}
N 7980 -1670 7990 -1660 {
lab=col_n[28]}
N 7980 -1450 7980 -1430 {
lab=col_n[28]}
N 7980 -1690 7980 -1670 {
lab=col_n[28]}
N 7860 -1590 7870 -1600 {
lab=row_n[1]}
N 7870 -1600 8070 -1600 {
lab=row_n[1]}
N 8070 -1600 8080 -1590 {
lab=row_n[1]}
N 7860 -1570 7870 -1580 {
lab=rowon_n[1]}
N 7870 -1580 8070 -1580 {
lab=rowon_n[1]}
N 8070 -1580 8080 -1570 {
lab=rowon_n[1]}
N 7860 -1550 7870 -1560 {
lab=#net3}
N 7870 -1560 8070 -1560 {
lab=#net3}
N 8070 -1560 8080 -1550 {
lab=#net3}
N 7860 -1530 7870 -1540 {
lab=#net4}
N 7870 -1540 8070 -1540 {
lab=#net4}
N 8070 -1540 8080 -1530 {
lab=#net4}
N 7920 -1690 7920 -1670 {
lab=vcm}
N 7960 -1690 7960 -1670 {
lab=ctop}
N 7840 -1590 7860 -1590 {
lab=row_n[1]}
N 7840 -1570 7860 -1570 {
lab=rowon_n[1]}
N 7840 -1550 7860 -1550 {
lab=#net3}
N 7840 -1530 7860 -1530 {
lab=#net4}
N 8080 -1530 8100 -1530 {
lab=#net4}
N 8080 -1550 8100 -1550 {
lab=#net3}
N 8080 -1570 8100 -1570 {
lab=rowon_n[1]}
N 8080 -1590 8100 -1590 {
lab=row_n[1]}
N 7900 -1450 7900 -1440 {
lab=VSS}
N 7900 -1680 7900 -1670 {
lab=VDD}
N 8240 -1450 8250 -1460 {
lab=col_n[29]}
N 8250 -1660 8250 -1460 {
lab=col_n[29]}
N 8240 -1670 8250 -1660 {
lab=col_n[29]}
N 8240 -1450 8240 -1430 {
lab=col_n[29]}
N 8240 -1690 8240 -1670 {
lab=col_n[29]}
N 8120 -1590 8130 -1600 {
lab=row_n[1]}
N 8130 -1600 8330 -1600 {
lab=row_n[1]}
N 8330 -1600 8340 -1590 {
lab=row_n[1]}
N 8120 -1570 8130 -1580 {
lab=rowon_n[1]}
N 8130 -1580 8330 -1580 {
lab=rowon_n[1]}
N 8330 -1580 8340 -1570 {
lab=rowon_n[1]}
N 8120 -1550 8130 -1560 {
lab=#net3}
N 8130 -1560 8330 -1560 {
lab=#net3}
N 8330 -1560 8340 -1550 {
lab=#net3}
N 8120 -1530 8130 -1540 {
lab=#net4}
N 8130 -1540 8330 -1540 {
lab=#net4}
N 8330 -1540 8340 -1530 {
lab=#net4}
N 8180 -1690 8180 -1670 {
lab=vcm}
N 8220 -1690 8220 -1670 {
lab=ctop}
N 8100 -1590 8120 -1590 {
lab=row_n[1]}
N 8100 -1570 8120 -1570 {
lab=rowon_n[1]}
N 8100 -1550 8120 -1550 {
lab=#net3}
N 8100 -1530 8120 -1530 {
lab=#net4}
N 8340 -1530 8360 -1530 {
lab=#net4}
N 8340 -1550 8360 -1550 {
lab=#net3}
N 8340 -1570 8360 -1570 {
lab=rowon_n[1]}
N 8340 -1590 8360 -1590 {
lab=row_n[1]}
N 8160 -1450 8160 -1440 {
lab=VSS}
N 8160 -1680 8160 -1670 {
lab=VDD}
N 8500 -1450 8510 -1460 {
lab=col_n[30]}
N 8510 -1660 8510 -1460 {
lab=col_n[30]}
N 8500 -1670 8510 -1660 {
lab=col_n[30]}
N 8500 -1450 8500 -1430 {
lab=col_n[30]}
N 8500 -1690 8500 -1670 {
lab=col_n[30]}
N 8380 -1590 8390 -1600 {
lab=row_n[1]}
N 8390 -1600 8590 -1600 {
lab=row_n[1]}
N 8590 -1600 8600 -1590 {
lab=row_n[1]}
N 8380 -1570 8390 -1580 {
lab=rowon_n[1]}
N 8390 -1580 8590 -1580 {
lab=rowon_n[1]}
N 8590 -1580 8600 -1570 {
lab=rowon_n[1]}
N 8380 -1550 8390 -1560 {
lab=#net3}
N 8390 -1560 8590 -1560 {
lab=#net3}
N 8590 -1560 8600 -1550 {
lab=#net3}
N 8380 -1530 8390 -1540 {
lab=#net4}
N 8390 -1540 8590 -1540 {
lab=#net4}
N 8590 -1540 8600 -1530 {
lab=#net4}
N 8440 -1690 8440 -1670 {
lab=vcm}
N 8480 -1690 8480 -1670 {
lab=ctop}
N 8360 -1590 8380 -1590 {
lab=row_n[1]}
N 8360 -1570 8380 -1570 {
lab=rowon_n[1]}
N 8360 -1550 8380 -1550 {
lab=#net3}
N 8360 -1530 8380 -1530 {
lab=#net4}
N 8600 -1530 8620 -1530 {
lab=#net4}
N 8600 -1550 8620 -1550 {
lab=#net3}
N 8600 -1570 8620 -1570 {
lab=rowon_n[1]}
N 8600 -1590 8620 -1590 {
lab=row_n[1]}
N 8420 -1450 8420 -1440 {
lab=VSS}
N 8420 -1680 8420 -1670 {
lab=VDD}
N 8760 -1450 8770 -1460 {
lab=col_n[31]}
N 8770 -1660 8770 -1460 {
lab=col_n[31]}
N 8760 -1670 8770 -1660 {
lab=col_n[31]}
N 8760 -1450 8760 -1430 {
lab=col_n[31]}
N 8760 -1690 8760 -1670 {
lab=col_n[31]}
N 8640 -1590 8650 -1600 {
lab=row_n[1]}
N 8650 -1600 8850 -1600 {
lab=row_n[1]}
N 8850 -1600 8860 -1590 {
lab=row_n[1]}
N 8640 -1570 8650 -1580 {
lab=rowon_n[1]}
N 8650 -1580 8850 -1580 {
lab=rowon_n[1]}
N 8850 -1580 8860 -1570 {
lab=rowon_n[1]}
N 8640 -1550 8650 -1560 {
lab=#net3}
N 8650 -1560 8850 -1560 {
lab=#net3}
N 8850 -1560 8860 -1550 {
lab=#net3}
N 8640 -1530 8650 -1540 {
lab=#net4}
N 8650 -1540 8850 -1540 {
lab=#net4}
N 8850 -1540 8860 -1530 {
lab=#net4}
N 8700 -1690 8700 -1670 {
lab=vcm}
N 8740 -1690 8740 -1670 {
lab=ctop}
N 8620 -1590 8640 -1590 {
lab=row_n[1]}
N 8620 -1570 8640 -1570 {
lab=rowon_n[1]}
N 8620 -1550 8640 -1550 {
lab=#net3}
N 8620 -1530 8640 -1530 {
lab=#net4}
N 8860 -1530 8880 -1530 {
lab=#net4}
N 8860 -1550 8880 -1550 {
lab=#net3}
N 8860 -1570 8880 -1570 {
lab=rowon_n[1]}
N 8860 -1590 8880 -1590 {
lab=row_n[1]}
N 8680 -1450 8680 -1440 {
lab=VSS}
N 8680 -1680 8680 -1670 {
lab=VDD}
N 700 -1710 710 -1720 {
lab=col_n[0]}
N 710 -1920 710 -1720 {
lab=col_n[0]}
N 700 -1930 710 -1920 {
lab=col_n[0]}
N 700 -1710 700 -1690 {
lab=col_n[0]}
N 700 -1950 700 -1930 {
lab=col_n[0]}
N 580 -1850 590 -1860 {
lab=row_n[2]}
N 590 -1860 790 -1860 {
lab=row_n[2]}
N 790 -1860 800 -1850 {
lab=row_n[2]}
N 580 -1830 590 -1840 {
lab=rowon_n[2]}
N 590 -1840 790 -1840 {
lab=rowon_n[2]}
N 790 -1840 800 -1830 {
lab=rowon_n[2]}
N 580 -1810 590 -1820 {
lab=#net5}
N 590 -1820 790 -1820 {
lab=#net5}
N 790 -1820 800 -1810 {
lab=#net5}
N 580 -1790 590 -1800 {
lab=#net6}
N 590 -1800 790 -1800 {
lab=#net6}
N 790 -1800 800 -1790 {
lab=#net6}
N 640 -1950 640 -1930 {
lab=vcm}
N 680 -1950 680 -1930 {
lab=ctop}
N 560 -1850 580 -1850 {
lab=row_n[2]}
N 560 -1830 580 -1830 {
lab=rowon_n[2]}
N 560 -1810 580 -1810 {
lab=#net5}
N 560 -1790 580 -1790 {
lab=#net6}
N 800 -1790 820 -1790 {
lab=#net6}
N 800 -1810 820 -1810 {
lab=#net5}
N 800 -1830 820 -1830 {
lab=rowon_n[2]}
N 800 -1850 820 -1850 {
lab=row_n[2]}
N 620 -1710 620 -1700 {
lab=VSS}
N 620 -1940 620 -1930 {
lab=VDD}
N 960 -1710 970 -1720 {
lab=col_n[1]}
N 970 -1920 970 -1720 {
lab=col_n[1]}
N 960 -1930 970 -1920 {
lab=col_n[1]}
N 960 -1710 960 -1690 {
lab=col_n[1]}
N 960 -1950 960 -1930 {
lab=col_n[1]}
N 840 -1850 850 -1860 {
lab=row_n[2]}
N 850 -1860 1050 -1860 {
lab=row_n[2]}
N 1050 -1860 1060 -1850 {
lab=row_n[2]}
N 840 -1830 850 -1840 {
lab=rowon_n[2]}
N 850 -1840 1050 -1840 {
lab=rowon_n[2]}
N 1050 -1840 1060 -1830 {
lab=rowon_n[2]}
N 840 -1810 850 -1820 {
lab=#net5}
N 850 -1820 1050 -1820 {
lab=#net5}
N 1050 -1820 1060 -1810 {
lab=#net5}
N 840 -1790 850 -1800 {
lab=#net6}
N 850 -1800 1050 -1800 {
lab=#net6}
N 1050 -1800 1060 -1790 {
lab=#net6}
N 900 -1950 900 -1930 {
lab=vcm}
N 940 -1950 940 -1930 {
lab=ctop}
N 820 -1850 840 -1850 {
lab=row_n[2]}
N 820 -1830 840 -1830 {
lab=rowon_n[2]}
N 820 -1810 840 -1810 {
lab=#net5}
N 820 -1790 840 -1790 {
lab=#net6}
N 1060 -1790 1080 -1790 {
lab=#net6}
N 1060 -1810 1080 -1810 {
lab=#net5}
N 1060 -1830 1080 -1830 {
lab=rowon_n[2]}
N 1060 -1850 1080 -1850 {
lab=row_n[2]}
N 880 -1710 880 -1700 {
lab=VSS}
N 880 -1940 880 -1930 {
lab=VDD}
N 1220 -1710 1230 -1720 {
lab=col_n[2]}
N 1230 -1920 1230 -1720 {
lab=col_n[2]}
N 1220 -1930 1230 -1920 {
lab=col_n[2]}
N 1220 -1710 1220 -1690 {
lab=col_n[2]}
N 1220 -1950 1220 -1930 {
lab=col_n[2]}
N 1100 -1850 1110 -1860 {
lab=row_n[2]}
N 1110 -1860 1310 -1860 {
lab=row_n[2]}
N 1310 -1860 1320 -1850 {
lab=row_n[2]}
N 1100 -1830 1110 -1840 {
lab=rowon_n[2]}
N 1110 -1840 1310 -1840 {
lab=rowon_n[2]}
N 1310 -1840 1320 -1830 {
lab=rowon_n[2]}
N 1100 -1810 1110 -1820 {
lab=#net5}
N 1110 -1820 1310 -1820 {
lab=#net5}
N 1310 -1820 1320 -1810 {
lab=#net5}
N 1100 -1790 1110 -1800 {
lab=#net6}
N 1110 -1800 1310 -1800 {
lab=#net6}
N 1310 -1800 1320 -1790 {
lab=#net6}
N 1160 -1950 1160 -1930 {
lab=vcm}
N 1200 -1950 1200 -1930 {
lab=ctop}
N 1080 -1850 1100 -1850 {
lab=row_n[2]}
N 1080 -1830 1100 -1830 {
lab=rowon_n[2]}
N 1080 -1810 1100 -1810 {
lab=#net5}
N 1080 -1790 1100 -1790 {
lab=#net6}
N 1320 -1790 1340 -1790 {
lab=#net6}
N 1320 -1810 1340 -1810 {
lab=#net5}
N 1320 -1830 1340 -1830 {
lab=rowon_n[2]}
N 1320 -1850 1340 -1850 {
lab=row_n[2]}
N 1140 -1710 1140 -1700 {
lab=VSS}
N 1140 -1940 1140 -1930 {
lab=VDD}
N 1480 -1710 1490 -1720 {
lab=col_n[3]}
N 1490 -1920 1490 -1720 {
lab=col_n[3]}
N 1480 -1930 1490 -1920 {
lab=col_n[3]}
N 1480 -1710 1480 -1690 {
lab=col_n[3]}
N 1480 -1950 1480 -1930 {
lab=col_n[3]}
N 1360 -1850 1370 -1860 {
lab=row_n[2]}
N 1370 -1860 1570 -1860 {
lab=row_n[2]}
N 1570 -1860 1580 -1850 {
lab=row_n[2]}
N 1360 -1830 1370 -1840 {
lab=rowon_n[2]}
N 1370 -1840 1570 -1840 {
lab=rowon_n[2]}
N 1570 -1840 1580 -1830 {
lab=rowon_n[2]}
N 1360 -1810 1370 -1820 {
lab=#net5}
N 1370 -1820 1570 -1820 {
lab=#net5}
N 1570 -1820 1580 -1810 {
lab=#net5}
N 1360 -1790 1370 -1800 {
lab=#net6}
N 1370 -1800 1570 -1800 {
lab=#net6}
N 1570 -1800 1580 -1790 {
lab=#net6}
N 1420 -1950 1420 -1930 {
lab=vcm}
N 1460 -1950 1460 -1930 {
lab=ctop}
N 1340 -1850 1360 -1850 {
lab=row_n[2]}
N 1340 -1830 1360 -1830 {
lab=rowon_n[2]}
N 1340 -1810 1360 -1810 {
lab=#net5}
N 1340 -1790 1360 -1790 {
lab=#net6}
N 1580 -1790 1600 -1790 {
lab=#net6}
N 1580 -1810 1600 -1810 {
lab=#net5}
N 1580 -1830 1600 -1830 {
lab=rowon_n[2]}
N 1580 -1850 1600 -1850 {
lab=row_n[2]}
N 1400 -1710 1400 -1700 {
lab=VSS}
N 1400 -1940 1400 -1930 {
lab=VDD}
N 1740 -1710 1750 -1720 {
lab=col_n[4]}
N 1750 -1920 1750 -1720 {
lab=col_n[4]}
N 1740 -1930 1750 -1920 {
lab=col_n[4]}
N 1740 -1710 1740 -1690 {
lab=col_n[4]}
N 1740 -1950 1740 -1930 {
lab=col_n[4]}
N 1620 -1850 1630 -1860 {
lab=row_n[2]}
N 1630 -1860 1830 -1860 {
lab=row_n[2]}
N 1830 -1860 1840 -1850 {
lab=row_n[2]}
N 1620 -1830 1630 -1840 {
lab=rowon_n[2]}
N 1630 -1840 1830 -1840 {
lab=rowon_n[2]}
N 1830 -1840 1840 -1830 {
lab=rowon_n[2]}
N 1620 -1810 1630 -1820 {
lab=#net5}
N 1630 -1820 1830 -1820 {
lab=#net5}
N 1830 -1820 1840 -1810 {
lab=#net5}
N 1620 -1790 1630 -1800 {
lab=#net6}
N 1630 -1800 1830 -1800 {
lab=#net6}
N 1830 -1800 1840 -1790 {
lab=#net6}
N 1680 -1950 1680 -1930 {
lab=vcm}
N 1720 -1950 1720 -1930 {
lab=ctop}
N 1600 -1850 1620 -1850 {
lab=row_n[2]}
N 1600 -1830 1620 -1830 {
lab=rowon_n[2]}
N 1600 -1810 1620 -1810 {
lab=#net5}
N 1600 -1790 1620 -1790 {
lab=#net6}
N 1840 -1790 1860 -1790 {
lab=#net6}
N 1840 -1810 1860 -1810 {
lab=#net5}
N 1840 -1830 1860 -1830 {
lab=rowon_n[2]}
N 1840 -1850 1860 -1850 {
lab=row_n[2]}
N 1660 -1710 1660 -1700 {
lab=VSS}
N 1660 -1940 1660 -1930 {
lab=VDD}
N 2000 -1710 2010 -1720 {
lab=col_n[5]}
N 2010 -1920 2010 -1720 {
lab=col_n[5]}
N 2000 -1930 2010 -1920 {
lab=col_n[5]}
N 2000 -1710 2000 -1690 {
lab=col_n[5]}
N 2000 -1950 2000 -1930 {
lab=col_n[5]}
N 1880 -1850 1890 -1860 {
lab=row_n[2]}
N 1890 -1860 2090 -1860 {
lab=row_n[2]}
N 2090 -1860 2100 -1850 {
lab=row_n[2]}
N 1880 -1830 1890 -1840 {
lab=rowon_n[2]}
N 1890 -1840 2090 -1840 {
lab=rowon_n[2]}
N 2090 -1840 2100 -1830 {
lab=rowon_n[2]}
N 1880 -1810 1890 -1820 {
lab=#net5}
N 1890 -1820 2090 -1820 {
lab=#net5}
N 2090 -1820 2100 -1810 {
lab=#net5}
N 1880 -1790 1890 -1800 {
lab=#net6}
N 1890 -1800 2090 -1800 {
lab=#net6}
N 2090 -1800 2100 -1790 {
lab=#net6}
N 1940 -1950 1940 -1930 {
lab=vcm}
N 1980 -1950 1980 -1930 {
lab=ctop}
N 1860 -1850 1880 -1850 {
lab=row_n[2]}
N 1860 -1830 1880 -1830 {
lab=rowon_n[2]}
N 1860 -1810 1880 -1810 {
lab=#net5}
N 1860 -1790 1880 -1790 {
lab=#net6}
N 2100 -1790 2120 -1790 {
lab=#net6}
N 2100 -1810 2120 -1810 {
lab=#net5}
N 2100 -1830 2120 -1830 {
lab=rowon_n[2]}
N 2100 -1850 2120 -1850 {
lab=row_n[2]}
N 1920 -1710 1920 -1700 {
lab=VSS}
N 1920 -1940 1920 -1930 {
lab=VDD}
N 2260 -1710 2270 -1720 {
lab=col_n[6]}
N 2270 -1920 2270 -1720 {
lab=col_n[6]}
N 2260 -1930 2270 -1920 {
lab=col_n[6]}
N 2260 -1710 2260 -1690 {
lab=col_n[6]}
N 2260 -1950 2260 -1930 {
lab=col_n[6]}
N 2140 -1850 2150 -1860 {
lab=row_n[2]}
N 2150 -1860 2350 -1860 {
lab=row_n[2]}
N 2350 -1860 2360 -1850 {
lab=row_n[2]}
N 2140 -1830 2150 -1840 {
lab=rowon_n[2]}
N 2150 -1840 2350 -1840 {
lab=rowon_n[2]}
N 2350 -1840 2360 -1830 {
lab=rowon_n[2]}
N 2140 -1810 2150 -1820 {
lab=#net5}
N 2150 -1820 2350 -1820 {
lab=#net5}
N 2350 -1820 2360 -1810 {
lab=#net5}
N 2140 -1790 2150 -1800 {
lab=#net6}
N 2150 -1800 2350 -1800 {
lab=#net6}
N 2350 -1800 2360 -1790 {
lab=#net6}
N 2200 -1950 2200 -1930 {
lab=vcm}
N 2240 -1950 2240 -1930 {
lab=ctop}
N 2120 -1850 2140 -1850 {
lab=row_n[2]}
N 2120 -1830 2140 -1830 {
lab=rowon_n[2]}
N 2120 -1810 2140 -1810 {
lab=#net5}
N 2120 -1790 2140 -1790 {
lab=#net6}
N 2360 -1790 2380 -1790 {
lab=#net6}
N 2360 -1810 2380 -1810 {
lab=#net5}
N 2360 -1830 2380 -1830 {
lab=rowon_n[2]}
N 2360 -1850 2380 -1850 {
lab=row_n[2]}
N 2180 -1710 2180 -1700 {
lab=VSS}
N 2180 -1940 2180 -1930 {
lab=VDD}
N 2520 -1710 2530 -1720 {
lab=col_n[7]}
N 2530 -1920 2530 -1720 {
lab=col_n[7]}
N 2520 -1930 2530 -1920 {
lab=col_n[7]}
N 2520 -1710 2520 -1690 {
lab=col_n[7]}
N 2520 -1950 2520 -1930 {
lab=col_n[7]}
N 2400 -1850 2410 -1860 {
lab=row_n[2]}
N 2410 -1860 2610 -1860 {
lab=row_n[2]}
N 2610 -1860 2620 -1850 {
lab=row_n[2]}
N 2400 -1830 2410 -1840 {
lab=rowon_n[2]}
N 2410 -1840 2610 -1840 {
lab=rowon_n[2]}
N 2610 -1840 2620 -1830 {
lab=rowon_n[2]}
N 2400 -1810 2410 -1820 {
lab=#net5}
N 2410 -1820 2610 -1820 {
lab=#net5}
N 2610 -1820 2620 -1810 {
lab=#net5}
N 2400 -1790 2410 -1800 {
lab=#net6}
N 2410 -1800 2610 -1800 {
lab=#net6}
N 2610 -1800 2620 -1790 {
lab=#net6}
N 2460 -1950 2460 -1930 {
lab=vcm}
N 2500 -1950 2500 -1930 {
lab=ctop}
N 2380 -1850 2400 -1850 {
lab=row_n[2]}
N 2380 -1830 2400 -1830 {
lab=rowon_n[2]}
N 2380 -1810 2400 -1810 {
lab=#net5}
N 2380 -1790 2400 -1790 {
lab=#net6}
N 2620 -1790 2640 -1790 {
lab=#net6}
N 2620 -1810 2640 -1810 {
lab=#net5}
N 2620 -1830 2640 -1830 {
lab=rowon_n[2]}
N 2620 -1850 2640 -1850 {
lab=row_n[2]}
N 2440 -1710 2440 -1700 {
lab=VSS}
N 2440 -1940 2440 -1930 {
lab=VDD}
N 2780 -1710 2790 -1720 {
lab=col_n[8]}
N 2790 -1920 2790 -1720 {
lab=col_n[8]}
N 2780 -1930 2790 -1920 {
lab=col_n[8]}
N 2780 -1710 2780 -1690 {
lab=col_n[8]}
N 2780 -1950 2780 -1930 {
lab=col_n[8]}
N 2660 -1850 2670 -1860 {
lab=row_n[2]}
N 2670 -1860 2870 -1860 {
lab=row_n[2]}
N 2870 -1860 2880 -1850 {
lab=row_n[2]}
N 2660 -1830 2670 -1840 {
lab=rowon_n[2]}
N 2670 -1840 2870 -1840 {
lab=rowon_n[2]}
N 2870 -1840 2880 -1830 {
lab=rowon_n[2]}
N 2660 -1810 2670 -1820 {
lab=#net5}
N 2670 -1820 2870 -1820 {
lab=#net5}
N 2870 -1820 2880 -1810 {
lab=#net5}
N 2660 -1790 2670 -1800 {
lab=#net6}
N 2670 -1800 2870 -1800 {
lab=#net6}
N 2870 -1800 2880 -1790 {
lab=#net6}
N 2720 -1950 2720 -1930 {
lab=vcm}
N 2760 -1950 2760 -1930 {
lab=ctop}
N 2640 -1850 2660 -1850 {
lab=row_n[2]}
N 2640 -1830 2660 -1830 {
lab=rowon_n[2]}
N 2640 -1810 2660 -1810 {
lab=#net5}
N 2640 -1790 2660 -1790 {
lab=#net6}
N 2880 -1790 2900 -1790 {
lab=#net6}
N 2880 -1810 2900 -1810 {
lab=#net5}
N 2880 -1830 2900 -1830 {
lab=rowon_n[2]}
N 2880 -1850 2900 -1850 {
lab=row_n[2]}
N 2700 -1710 2700 -1700 {
lab=VSS}
N 2700 -1940 2700 -1930 {
lab=VDD}
N 3040 -1710 3050 -1720 {
lab=col_n[9]}
N 3050 -1920 3050 -1720 {
lab=col_n[9]}
N 3040 -1930 3050 -1920 {
lab=col_n[9]}
N 3040 -1710 3040 -1690 {
lab=col_n[9]}
N 3040 -1950 3040 -1930 {
lab=col_n[9]}
N 2920 -1850 2930 -1860 {
lab=row_n[2]}
N 2930 -1860 3130 -1860 {
lab=row_n[2]}
N 3130 -1860 3140 -1850 {
lab=row_n[2]}
N 2920 -1830 2930 -1840 {
lab=rowon_n[2]}
N 2930 -1840 3130 -1840 {
lab=rowon_n[2]}
N 3130 -1840 3140 -1830 {
lab=rowon_n[2]}
N 2920 -1810 2930 -1820 {
lab=#net5}
N 2930 -1820 3130 -1820 {
lab=#net5}
N 3130 -1820 3140 -1810 {
lab=#net5}
N 2920 -1790 2930 -1800 {
lab=#net6}
N 2930 -1800 3130 -1800 {
lab=#net6}
N 3130 -1800 3140 -1790 {
lab=#net6}
N 2980 -1950 2980 -1930 {
lab=vcm}
N 3020 -1950 3020 -1930 {
lab=ctop}
N 2900 -1850 2920 -1850 {
lab=row_n[2]}
N 2900 -1830 2920 -1830 {
lab=rowon_n[2]}
N 2900 -1810 2920 -1810 {
lab=#net5}
N 2900 -1790 2920 -1790 {
lab=#net6}
N 3140 -1790 3160 -1790 {
lab=#net6}
N 3140 -1810 3160 -1810 {
lab=#net5}
N 3140 -1830 3160 -1830 {
lab=rowon_n[2]}
N 3140 -1850 3160 -1850 {
lab=row_n[2]}
N 2960 -1710 2960 -1700 {
lab=VSS}
N 2960 -1940 2960 -1930 {
lab=VDD}
N 3300 -1710 3310 -1720 {
lab=col_n[10]}
N 3310 -1920 3310 -1720 {
lab=col_n[10]}
N 3300 -1930 3310 -1920 {
lab=col_n[10]}
N 3300 -1710 3300 -1690 {
lab=col_n[10]}
N 3300 -1950 3300 -1930 {
lab=col_n[10]}
N 3180 -1850 3190 -1860 {
lab=row_n[2]}
N 3190 -1860 3390 -1860 {
lab=row_n[2]}
N 3390 -1860 3400 -1850 {
lab=row_n[2]}
N 3180 -1830 3190 -1840 {
lab=rowon_n[2]}
N 3190 -1840 3390 -1840 {
lab=rowon_n[2]}
N 3390 -1840 3400 -1830 {
lab=rowon_n[2]}
N 3180 -1810 3190 -1820 {
lab=#net5}
N 3190 -1820 3390 -1820 {
lab=#net5}
N 3390 -1820 3400 -1810 {
lab=#net5}
N 3180 -1790 3190 -1800 {
lab=#net6}
N 3190 -1800 3390 -1800 {
lab=#net6}
N 3390 -1800 3400 -1790 {
lab=#net6}
N 3240 -1950 3240 -1930 {
lab=vcm}
N 3280 -1950 3280 -1930 {
lab=ctop}
N 3160 -1850 3180 -1850 {
lab=row_n[2]}
N 3160 -1830 3180 -1830 {
lab=rowon_n[2]}
N 3160 -1810 3180 -1810 {
lab=#net5}
N 3160 -1790 3180 -1790 {
lab=#net6}
N 3400 -1790 3420 -1790 {
lab=#net6}
N 3400 -1810 3420 -1810 {
lab=#net5}
N 3400 -1830 3420 -1830 {
lab=rowon_n[2]}
N 3400 -1850 3420 -1850 {
lab=row_n[2]}
N 3220 -1710 3220 -1700 {
lab=VSS}
N 3220 -1940 3220 -1930 {
lab=VDD}
N 3560 -1710 3570 -1720 {
lab=col_n[11]}
N 3570 -1920 3570 -1720 {
lab=col_n[11]}
N 3560 -1930 3570 -1920 {
lab=col_n[11]}
N 3560 -1710 3560 -1690 {
lab=col_n[11]}
N 3560 -1950 3560 -1930 {
lab=col_n[11]}
N 3440 -1850 3450 -1860 {
lab=row_n[2]}
N 3450 -1860 3650 -1860 {
lab=row_n[2]}
N 3650 -1860 3660 -1850 {
lab=row_n[2]}
N 3440 -1830 3450 -1840 {
lab=rowon_n[2]}
N 3450 -1840 3650 -1840 {
lab=rowon_n[2]}
N 3650 -1840 3660 -1830 {
lab=rowon_n[2]}
N 3440 -1810 3450 -1820 {
lab=#net5}
N 3450 -1820 3650 -1820 {
lab=#net5}
N 3650 -1820 3660 -1810 {
lab=#net5}
N 3440 -1790 3450 -1800 {
lab=#net6}
N 3450 -1800 3650 -1800 {
lab=#net6}
N 3650 -1800 3660 -1790 {
lab=#net6}
N 3500 -1950 3500 -1930 {
lab=vcm}
N 3540 -1950 3540 -1930 {
lab=ctop}
N 3420 -1850 3440 -1850 {
lab=row_n[2]}
N 3420 -1830 3440 -1830 {
lab=rowon_n[2]}
N 3420 -1810 3440 -1810 {
lab=#net5}
N 3420 -1790 3440 -1790 {
lab=#net6}
N 3660 -1790 3680 -1790 {
lab=#net6}
N 3660 -1810 3680 -1810 {
lab=#net5}
N 3660 -1830 3680 -1830 {
lab=rowon_n[2]}
N 3660 -1850 3680 -1850 {
lab=row_n[2]}
N 3480 -1710 3480 -1700 {
lab=VSS}
N 3480 -1940 3480 -1930 {
lab=VDD}
N 3820 -1710 3830 -1720 {
lab=col_n[12]}
N 3830 -1920 3830 -1720 {
lab=col_n[12]}
N 3820 -1930 3830 -1920 {
lab=col_n[12]}
N 3820 -1710 3820 -1690 {
lab=col_n[12]}
N 3820 -1950 3820 -1930 {
lab=col_n[12]}
N 3700 -1850 3710 -1860 {
lab=row_n[2]}
N 3710 -1860 3910 -1860 {
lab=row_n[2]}
N 3910 -1860 3920 -1850 {
lab=row_n[2]}
N 3700 -1830 3710 -1840 {
lab=rowon_n[2]}
N 3710 -1840 3910 -1840 {
lab=rowon_n[2]}
N 3910 -1840 3920 -1830 {
lab=rowon_n[2]}
N 3700 -1810 3710 -1820 {
lab=#net5}
N 3710 -1820 3910 -1820 {
lab=#net5}
N 3910 -1820 3920 -1810 {
lab=#net5}
N 3700 -1790 3710 -1800 {
lab=#net6}
N 3710 -1800 3910 -1800 {
lab=#net6}
N 3910 -1800 3920 -1790 {
lab=#net6}
N 3760 -1950 3760 -1930 {
lab=vcm}
N 3800 -1950 3800 -1930 {
lab=ctop}
N 3680 -1850 3700 -1850 {
lab=row_n[2]}
N 3680 -1830 3700 -1830 {
lab=rowon_n[2]}
N 3680 -1810 3700 -1810 {
lab=#net5}
N 3680 -1790 3700 -1790 {
lab=#net6}
N 3920 -1790 3940 -1790 {
lab=#net6}
N 3920 -1810 3940 -1810 {
lab=#net5}
N 3920 -1830 3940 -1830 {
lab=rowon_n[2]}
N 3920 -1850 3940 -1850 {
lab=row_n[2]}
N 3740 -1710 3740 -1700 {
lab=VSS}
N 3740 -1940 3740 -1930 {
lab=VDD}
N 4080 -1710 4090 -1720 {
lab=col_n[13]}
N 4090 -1920 4090 -1720 {
lab=col_n[13]}
N 4080 -1930 4090 -1920 {
lab=col_n[13]}
N 4080 -1710 4080 -1690 {
lab=col_n[13]}
N 4080 -1950 4080 -1930 {
lab=col_n[13]}
N 3960 -1850 3970 -1860 {
lab=row_n[2]}
N 3970 -1860 4170 -1860 {
lab=row_n[2]}
N 4170 -1860 4180 -1850 {
lab=row_n[2]}
N 3960 -1830 3970 -1840 {
lab=rowon_n[2]}
N 3970 -1840 4170 -1840 {
lab=rowon_n[2]}
N 4170 -1840 4180 -1830 {
lab=rowon_n[2]}
N 3960 -1810 3970 -1820 {
lab=#net5}
N 3970 -1820 4170 -1820 {
lab=#net5}
N 4170 -1820 4180 -1810 {
lab=#net5}
N 3960 -1790 3970 -1800 {
lab=#net6}
N 3970 -1800 4170 -1800 {
lab=#net6}
N 4170 -1800 4180 -1790 {
lab=#net6}
N 4020 -1950 4020 -1930 {
lab=vcm}
N 4060 -1950 4060 -1930 {
lab=ctop}
N 3940 -1850 3960 -1850 {
lab=row_n[2]}
N 3940 -1830 3960 -1830 {
lab=rowon_n[2]}
N 3940 -1810 3960 -1810 {
lab=#net5}
N 3940 -1790 3960 -1790 {
lab=#net6}
N 4180 -1790 4200 -1790 {
lab=#net6}
N 4180 -1810 4200 -1810 {
lab=#net5}
N 4180 -1830 4200 -1830 {
lab=rowon_n[2]}
N 4180 -1850 4200 -1850 {
lab=row_n[2]}
N 4000 -1710 4000 -1700 {
lab=VSS}
N 4000 -1940 4000 -1930 {
lab=VDD}
N 4340 -1710 4350 -1720 {
lab=col_n[14]}
N 4350 -1920 4350 -1720 {
lab=col_n[14]}
N 4340 -1930 4350 -1920 {
lab=col_n[14]}
N 4340 -1710 4340 -1690 {
lab=col_n[14]}
N 4340 -1950 4340 -1930 {
lab=col_n[14]}
N 4220 -1850 4230 -1860 {
lab=row_n[2]}
N 4230 -1860 4430 -1860 {
lab=row_n[2]}
N 4430 -1860 4440 -1850 {
lab=row_n[2]}
N 4220 -1830 4230 -1840 {
lab=rowon_n[2]}
N 4230 -1840 4430 -1840 {
lab=rowon_n[2]}
N 4430 -1840 4440 -1830 {
lab=rowon_n[2]}
N 4220 -1810 4230 -1820 {
lab=#net5}
N 4230 -1820 4430 -1820 {
lab=#net5}
N 4430 -1820 4440 -1810 {
lab=#net5}
N 4220 -1790 4230 -1800 {
lab=#net6}
N 4230 -1800 4430 -1800 {
lab=#net6}
N 4430 -1800 4440 -1790 {
lab=#net6}
N 4280 -1950 4280 -1930 {
lab=vcm}
N 4320 -1950 4320 -1930 {
lab=ctop}
N 4200 -1850 4220 -1850 {
lab=row_n[2]}
N 4200 -1830 4220 -1830 {
lab=rowon_n[2]}
N 4200 -1810 4220 -1810 {
lab=#net5}
N 4200 -1790 4220 -1790 {
lab=#net6}
N 4440 -1790 4460 -1790 {
lab=#net6}
N 4440 -1810 4460 -1810 {
lab=#net5}
N 4440 -1830 4460 -1830 {
lab=rowon_n[2]}
N 4440 -1850 4460 -1850 {
lab=row_n[2]}
N 4260 -1710 4260 -1700 {
lab=VSS}
N 4260 -1940 4260 -1930 {
lab=VDD}
N 4600 -1710 4610 -1720 {
lab=col_n[15]}
N 4610 -1920 4610 -1720 {
lab=col_n[15]}
N 4600 -1930 4610 -1920 {
lab=col_n[15]}
N 4600 -1710 4600 -1690 {
lab=col_n[15]}
N 4600 -1950 4600 -1930 {
lab=col_n[15]}
N 4480 -1850 4490 -1860 {
lab=row_n[2]}
N 4490 -1860 4690 -1860 {
lab=row_n[2]}
N 4690 -1860 4700 -1850 {
lab=row_n[2]}
N 4480 -1830 4490 -1840 {
lab=rowon_n[2]}
N 4490 -1840 4690 -1840 {
lab=rowon_n[2]}
N 4690 -1840 4700 -1830 {
lab=rowon_n[2]}
N 4480 -1810 4490 -1820 {
lab=#net5}
N 4490 -1820 4690 -1820 {
lab=#net5}
N 4690 -1820 4700 -1810 {
lab=#net5}
N 4480 -1790 4490 -1800 {
lab=#net6}
N 4490 -1800 4690 -1800 {
lab=#net6}
N 4690 -1800 4700 -1790 {
lab=#net6}
N 4540 -1950 4540 -1930 {
lab=vcm}
N 4580 -1950 4580 -1930 {
lab=ctop}
N 4460 -1850 4480 -1850 {
lab=row_n[2]}
N 4460 -1830 4480 -1830 {
lab=rowon_n[2]}
N 4460 -1810 4480 -1810 {
lab=#net5}
N 4460 -1790 4480 -1790 {
lab=#net6}
N 4700 -1790 4720 -1790 {
lab=#net6}
N 4700 -1810 4720 -1810 {
lab=#net5}
N 4700 -1830 4720 -1830 {
lab=rowon_n[2]}
N 4700 -1850 4720 -1850 {
lab=row_n[2]}
N 4520 -1710 4520 -1700 {
lab=VSS}
N 4520 -1940 4520 -1930 {
lab=VDD}
N 4860 -1710 4870 -1720 {
lab=col_n[16]}
N 4870 -1920 4870 -1720 {
lab=col_n[16]}
N 4860 -1930 4870 -1920 {
lab=col_n[16]}
N 4860 -1710 4860 -1690 {
lab=col_n[16]}
N 4860 -1950 4860 -1930 {
lab=col_n[16]}
N 4740 -1850 4750 -1860 {
lab=row_n[2]}
N 4750 -1860 4950 -1860 {
lab=row_n[2]}
N 4950 -1860 4960 -1850 {
lab=row_n[2]}
N 4740 -1830 4750 -1840 {
lab=rowon_n[2]}
N 4750 -1840 4950 -1840 {
lab=rowon_n[2]}
N 4950 -1840 4960 -1830 {
lab=rowon_n[2]}
N 4740 -1810 4750 -1820 {
lab=#net5}
N 4750 -1820 4950 -1820 {
lab=#net5}
N 4950 -1820 4960 -1810 {
lab=#net5}
N 4740 -1790 4750 -1800 {
lab=#net6}
N 4750 -1800 4950 -1800 {
lab=#net6}
N 4950 -1800 4960 -1790 {
lab=#net6}
N 4800 -1950 4800 -1930 {
lab=vcm}
N 4840 -1950 4840 -1930 {
lab=ctop}
N 4720 -1850 4740 -1850 {
lab=row_n[2]}
N 4720 -1830 4740 -1830 {
lab=rowon_n[2]}
N 4720 -1810 4740 -1810 {
lab=#net5}
N 4720 -1790 4740 -1790 {
lab=#net6}
N 4960 -1790 4980 -1790 {
lab=#net6}
N 4960 -1810 4980 -1810 {
lab=#net5}
N 4960 -1830 4980 -1830 {
lab=rowon_n[2]}
N 4960 -1850 4980 -1850 {
lab=row_n[2]}
N 4780 -1710 4780 -1700 {
lab=VSS}
N 4780 -1940 4780 -1930 {
lab=VDD}
N 5120 -1710 5130 -1720 {
lab=col_n[17]}
N 5130 -1920 5130 -1720 {
lab=col_n[17]}
N 5120 -1930 5130 -1920 {
lab=col_n[17]}
N 5120 -1710 5120 -1690 {
lab=col_n[17]}
N 5120 -1950 5120 -1930 {
lab=col_n[17]}
N 5000 -1850 5010 -1860 {
lab=row_n[2]}
N 5010 -1860 5210 -1860 {
lab=row_n[2]}
N 5210 -1860 5220 -1850 {
lab=row_n[2]}
N 5000 -1830 5010 -1840 {
lab=rowon_n[2]}
N 5010 -1840 5210 -1840 {
lab=rowon_n[2]}
N 5210 -1840 5220 -1830 {
lab=rowon_n[2]}
N 5000 -1810 5010 -1820 {
lab=#net5}
N 5010 -1820 5210 -1820 {
lab=#net5}
N 5210 -1820 5220 -1810 {
lab=#net5}
N 5000 -1790 5010 -1800 {
lab=#net6}
N 5010 -1800 5210 -1800 {
lab=#net6}
N 5210 -1800 5220 -1790 {
lab=#net6}
N 5060 -1950 5060 -1930 {
lab=vcm}
N 5100 -1950 5100 -1930 {
lab=ctop}
N 4980 -1850 5000 -1850 {
lab=row_n[2]}
N 4980 -1830 5000 -1830 {
lab=rowon_n[2]}
N 4980 -1810 5000 -1810 {
lab=#net5}
N 4980 -1790 5000 -1790 {
lab=#net6}
N 5220 -1790 5240 -1790 {
lab=#net6}
N 5220 -1810 5240 -1810 {
lab=#net5}
N 5220 -1830 5240 -1830 {
lab=rowon_n[2]}
N 5220 -1850 5240 -1850 {
lab=row_n[2]}
N 5040 -1710 5040 -1700 {
lab=VSS}
N 5040 -1940 5040 -1930 {
lab=VDD}
N 5380 -1710 5390 -1720 {
lab=col_n[18]}
N 5390 -1920 5390 -1720 {
lab=col_n[18]}
N 5380 -1930 5390 -1920 {
lab=col_n[18]}
N 5380 -1710 5380 -1690 {
lab=col_n[18]}
N 5380 -1950 5380 -1930 {
lab=col_n[18]}
N 5260 -1850 5270 -1860 {
lab=row_n[2]}
N 5270 -1860 5470 -1860 {
lab=row_n[2]}
N 5470 -1860 5480 -1850 {
lab=row_n[2]}
N 5260 -1830 5270 -1840 {
lab=rowon_n[2]}
N 5270 -1840 5470 -1840 {
lab=rowon_n[2]}
N 5470 -1840 5480 -1830 {
lab=rowon_n[2]}
N 5260 -1810 5270 -1820 {
lab=#net5}
N 5270 -1820 5470 -1820 {
lab=#net5}
N 5470 -1820 5480 -1810 {
lab=#net5}
N 5260 -1790 5270 -1800 {
lab=#net6}
N 5270 -1800 5470 -1800 {
lab=#net6}
N 5470 -1800 5480 -1790 {
lab=#net6}
N 5320 -1950 5320 -1930 {
lab=vcm}
N 5360 -1950 5360 -1930 {
lab=ctop}
N 5240 -1850 5260 -1850 {
lab=row_n[2]}
N 5240 -1830 5260 -1830 {
lab=rowon_n[2]}
N 5240 -1810 5260 -1810 {
lab=#net5}
N 5240 -1790 5260 -1790 {
lab=#net6}
N 5480 -1790 5500 -1790 {
lab=#net6}
N 5480 -1810 5500 -1810 {
lab=#net5}
N 5480 -1830 5500 -1830 {
lab=rowon_n[2]}
N 5480 -1850 5500 -1850 {
lab=row_n[2]}
N 5300 -1710 5300 -1700 {
lab=VSS}
N 5300 -1940 5300 -1930 {
lab=VDD}
N 5640 -1710 5650 -1720 {
lab=col_n[19]}
N 5650 -1920 5650 -1720 {
lab=col_n[19]}
N 5640 -1930 5650 -1920 {
lab=col_n[19]}
N 5640 -1710 5640 -1690 {
lab=col_n[19]}
N 5640 -1950 5640 -1930 {
lab=col_n[19]}
N 5520 -1850 5530 -1860 {
lab=row_n[2]}
N 5530 -1860 5730 -1860 {
lab=row_n[2]}
N 5730 -1860 5740 -1850 {
lab=row_n[2]}
N 5520 -1830 5530 -1840 {
lab=rowon_n[2]}
N 5530 -1840 5730 -1840 {
lab=rowon_n[2]}
N 5730 -1840 5740 -1830 {
lab=rowon_n[2]}
N 5520 -1810 5530 -1820 {
lab=#net5}
N 5530 -1820 5730 -1820 {
lab=#net5}
N 5730 -1820 5740 -1810 {
lab=#net5}
N 5520 -1790 5530 -1800 {
lab=#net6}
N 5530 -1800 5730 -1800 {
lab=#net6}
N 5730 -1800 5740 -1790 {
lab=#net6}
N 5580 -1950 5580 -1930 {
lab=vcm}
N 5620 -1950 5620 -1930 {
lab=ctop}
N 5500 -1850 5520 -1850 {
lab=row_n[2]}
N 5500 -1830 5520 -1830 {
lab=rowon_n[2]}
N 5500 -1810 5520 -1810 {
lab=#net5}
N 5500 -1790 5520 -1790 {
lab=#net6}
N 5740 -1790 5760 -1790 {
lab=#net6}
N 5740 -1810 5760 -1810 {
lab=#net5}
N 5740 -1830 5760 -1830 {
lab=rowon_n[2]}
N 5740 -1850 5760 -1850 {
lab=row_n[2]}
N 5560 -1710 5560 -1700 {
lab=VSS}
N 5560 -1940 5560 -1930 {
lab=VDD}
N 5900 -1710 5910 -1720 {
lab=col_n[20]}
N 5910 -1920 5910 -1720 {
lab=col_n[20]}
N 5900 -1930 5910 -1920 {
lab=col_n[20]}
N 5900 -1710 5900 -1690 {
lab=col_n[20]}
N 5900 -1950 5900 -1930 {
lab=col_n[20]}
N 5780 -1850 5790 -1860 {
lab=row_n[2]}
N 5790 -1860 5990 -1860 {
lab=row_n[2]}
N 5990 -1860 6000 -1850 {
lab=row_n[2]}
N 5780 -1830 5790 -1840 {
lab=rowon_n[2]}
N 5790 -1840 5990 -1840 {
lab=rowon_n[2]}
N 5990 -1840 6000 -1830 {
lab=rowon_n[2]}
N 5780 -1810 5790 -1820 {
lab=#net5}
N 5790 -1820 5990 -1820 {
lab=#net5}
N 5990 -1820 6000 -1810 {
lab=#net5}
N 5780 -1790 5790 -1800 {
lab=#net6}
N 5790 -1800 5990 -1800 {
lab=#net6}
N 5990 -1800 6000 -1790 {
lab=#net6}
N 5840 -1950 5840 -1930 {
lab=vcm}
N 5880 -1950 5880 -1930 {
lab=ctop}
N 5760 -1850 5780 -1850 {
lab=row_n[2]}
N 5760 -1830 5780 -1830 {
lab=rowon_n[2]}
N 5760 -1810 5780 -1810 {
lab=#net5}
N 5760 -1790 5780 -1790 {
lab=#net6}
N 6000 -1790 6020 -1790 {
lab=#net6}
N 6000 -1810 6020 -1810 {
lab=#net5}
N 6000 -1830 6020 -1830 {
lab=rowon_n[2]}
N 6000 -1850 6020 -1850 {
lab=row_n[2]}
N 5820 -1710 5820 -1700 {
lab=VSS}
N 5820 -1940 5820 -1930 {
lab=VDD}
N 6160 -1710 6170 -1720 {
lab=col_n[21]}
N 6170 -1920 6170 -1720 {
lab=col_n[21]}
N 6160 -1930 6170 -1920 {
lab=col_n[21]}
N 6160 -1710 6160 -1690 {
lab=col_n[21]}
N 6160 -1950 6160 -1930 {
lab=col_n[21]}
N 6040 -1850 6050 -1860 {
lab=row_n[2]}
N 6050 -1860 6250 -1860 {
lab=row_n[2]}
N 6250 -1860 6260 -1850 {
lab=row_n[2]}
N 6040 -1830 6050 -1840 {
lab=rowon_n[2]}
N 6050 -1840 6250 -1840 {
lab=rowon_n[2]}
N 6250 -1840 6260 -1830 {
lab=rowon_n[2]}
N 6040 -1810 6050 -1820 {
lab=#net5}
N 6050 -1820 6250 -1820 {
lab=#net5}
N 6250 -1820 6260 -1810 {
lab=#net5}
N 6040 -1790 6050 -1800 {
lab=#net6}
N 6050 -1800 6250 -1800 {
lab=#net6}
N 6250 -1800 6260 -1790 {
lab=#net6}
N 6100 -1950 6100 -1930 {
lab=vcm}
N 6140 -1950 6140 -1930 {
lab=ctop}
N 6020 -1850 6040 -1850 {
lab=row_n[2]}
N 6020 -1830 6040 -1830 {
lab=rowon_n[2]}
N 6020 -1810 6040 -1810 {
lab=#net5}
N 6020 -1790 6040 -1790 {
lab=#net6}
N 6260 -1790 6280 -1790 {
lab=#net6}
N 6260 -1810 6280 -1810 {
lab=#net5}
N 6260 -1830 6280 -1830 {
lab=rowon_n[2]}
N 6260 -1850 6280 -1850 {
lab=row_n[2]}
N 6080 -1710 6080 -1700 {
lab=VSS}
N 6080 -1940 6080 -1930 {
lab=VDD}
N 6420 -1710 6430 -1720 {
lab=col_n[22]}
N 6430 -1920 6430 -1720 {
lab=col_n[22]}
N 6420 -1930 6430 -1920 {
lab=col_n[22]}
N 6420 -1710 6420 -1690 {
lab=col_n[22]}
N 6420 -1950 6420 -1930 {
lab=col_n[22]}
N 6300 -1850 6310 -1860 {
lab=row_n[2]}
N 6310 -1860 6510 -1860 {
lab=row_n[2]}
N 6510 -1860 6520 -1850 {
lab=row_n[2]}
N 6300 -1830 6310 -1840 {
lab=rowon_n[2]}
N 6310 -1840 6510 -1840 {
lab=rowon_n[2]}
N 6510 -1840 6520 -1830 {
lab=rowon_n[2]}
N 6300 -1810 6310 -1820 {
lab=#net5}
N 6310 -1820 6510 -1820 {
lab=#net5}
N 6510 -1820 6520 -1810 {
lab=#net5}
N 6300 -1790 6310 -1800 {
lab=#net6}
N 6310 -1800 6510 -1800 {
lab=#net6}
N 6510 -1800 6520 -1790 {
lab=#net6}
N 6360 -1950 6360 -1930 {
lab=vcm}
N 6400 -1950 6400 -1930 {
lab=ctop}
N 6280 -1850 6300 -1850 {
lab=row_n[2]}
N 6280 -1830 6300 -1830 {
lab=rowon_n[2]}
N 6280 -1810 6300 -1810 {
lab=#net5}
N 6280 -1790 6300 -1790 {
lab=#net6}
N 6520 -1790 6540 -1790 {
lab=#net6}
N 6520 -1810 6540 -1810 {
lab=#net5}
N 6520 -1830 6540 -1830 {
lab=rowon_n[2]}
N 6520 -1850 6540 -1850 {
lab=row_n[2]}
N 6340 -1710 6340 -1700 {
lab=VSS}
N 6340 -1940 6340 -1930 {
lab=VDD}
N 6680 -1710 6690 -1720 {
lab=col_n[23]}
N 6690 -1920 6690 -1720 {
lab=col_n[23]}
N 6680 -1930 6690 -1920 {
lab=col_n[23]}
N 6680 -1710 6680 -1690 {
lab=col_n[23]}
N 6680 -1950 6680 -1930 {
lab=col_n[23]}
N 6560 -1850 6570 -1860 {
lab=row_n[2]}
N 6570 -1860 6770 -1860 {
lab=row_n[2]}
N 6770 -1860 6780 -1850 {
lab=row_n[2]}
N 6560 -1830 6570 -1840 {
lab=rowon_n[2]}
N 6570 -1840 6770 -1840 {
lab=rowon_n[2]}
N 6770 -1840 6780 -1830 {
lab=rowon_n[2]}
N 6560 -1810 6570 -1820 {
lab=#net5}
N 6570 -1820 6770 -1820 {
lab=#net5}
N 6770 -1820 6780 -1810 {
lab=#net5}
N 6560 -1790 6570 -1800 {
lab=#net6}
N 6570 -1800 6770 -1800 {
lab=#net6}
N 6770 -1800 6780 -1790 {
lab=#net6}
N 6620 -1950 6620 -1930 {
lab=vcm}
N 6660 -1950 6660 -1930 {
lab=ctop}
N 6540 -1850 6560 -1850 {
lab=row_n[2]}
N 6540 -1830 6560 -1830 {
lab=rowon_n[2]}
N 6540 -1810 6560 -1810 {
lab=#net5}
N 6540 -1790 6560 -1790 {
lab=#net6}
N 6780 -1790 6800 -1790 {
lab=#net6}
N 6780 -1810 6800 -1810 {
lab=#net5}
N 6780 -1830 6800 -1830 {
lab=rowon_n[2]}
N 6780 -1850 6800 -1850 {
lab=row_n[2]}
N 6600 -1710 6600 -1700 {
lab=VSS}
N 6600 -1940 6600 -1930 {
lab=VDD}
N 6940 -1710 6950 -1720 {
lab=col_n[24]}
N 6950 -1920 6950 -1720 {
lab=col_n[24]}
N 6940 -1930 6950 -1920 {
lab=col_n[24]}
N 6940 -1710 6940 -1690 {
lab=col_n[24]}
N 6940 -1950 6940 -1930 {
lab=col_n[24]}
N 6820 -1850 6830 -1860 {
lab=row_n[2]}
N 6830 -1860 7030 -1860 {
lab=row_n[2]}
N 7030 -1860 7040 -1850 {
lab=row_n[2]}
N 6820 -1830 6830 -1840 {
lab=rowon_n[2]}
N 6830 -1840 7030 -1840 {
lab=rowon_n[2]}
N 7030 -1840 7040 -1830 {
lab=rowon_n[2]}
N 6820 -1810 6830 -1820 {
lab=#net5}
N 6830 -1820 7030 -1820 {
lab=#net5}
N 7030 -1820 7040 -1810 {
lab=#net5}
N 6820 -1790 6830 -1800 {
lab=#net6}
N 6830 -1800 7030 -1800 {
lab=#net6}
N 7030 -1800 7040 -1790 {
lab=#net6}
N 6880 -1950 6880 -1930 {
lab=vcm}
N 6920 -1950 6920 -1930 {
lab=ctop}
N 6800 -1850 6820 -1850 {
lab=row_n[2]}
N 6800 -1830 6820 -1830 {
lab=rowon_n[2]}
N 6800 -1810 6820 -1810 {
lab=#net5}
N 6800 -1790 6820 -1790 {
lab=#net6}
N 7040 -1790 7060 -1790 {
lab=#net6}
N 7040 -1810 7060 -1810 {
lab=#net5}
N 7040 -1830 7060 -1830 {
lab=rowon_n[2]}
N 7040 -1850 7060 -1850 {
lab=row_n[2]}
N 6860 -1710 6860 -1700 {
lab=VSS}
N 6860 -1940 6860 -1930 {
lab=VDD}
N 7200 -1710 7210 -1720 {
lab=col_n[25]}
N 7210 -1920 7210 -1720 {
lab=col_n[25]}
N 7200 -1930 7210 -1920 {
lab=col_n[25]}
N 7200 -1710 7200 -1690 {
lab=col_n[25]}
N 7200 -1950 7200 -1930 {
lab=col_n[25]}
N 7080 -1850 7090 -1860 {
lab=row_n[2]}
N 7090 -1860 7290 -1860 {
lab=row_n[2]}
N 7290 -1860 7300 -1850 {
lab=row_n[2]}
N 7080 -1830 7090 -1840 {
lab=rowon_n[2]}
N 7090 -1840 7290 -1840 {
lab=rowon_n[2]}
N 7290 -1840 7300 -1830 {
lab=rowon_n[2]}
N 7080 -1810 7090 -1820 {
lab=#net5}
N 7090 -1820 7290 -1820 {
lab=#net5}
N 7290 -1820 7300 -1810 {
lab=#net5}
N 7080 -1790 7090 -1800 {
lab=#net6}
N 7090 -1800 7290 -1800 {
lab=#net6}
N 7290 -1800 7300 -1790 {
lab=#net6}
N 7140 -1950 7140 -1930 {
lab=vcm}
N 7180 -1950 7180 -1930 {
lab=ctop}
N 7060 -1850 7080 -1850 {
lab=row_n[2]}
N 7060 -1830 7080 -1830 {
lab=rowon_n[2]}
N 7060 -1810 7080 -1810 {
lab=#net5}
N 7060 -1790 7080 -1790 {
lab=#net6}
N 7300 -1790 7320 -1790 {
lab=#net6}
N 7300 -1810 7320 -1810 {
lab=#net5}
N 7300 -1830 7320 -1830 {
lab=rowon_n[2]}
N 7300 -1850 7320 -1850 {
lab=row_n[2]}
N 7120 -1710 7120 -1700 {
lab=VSS}
N 7120 -1940 7120 -1930 {
lab=VDD}
N 7460 -1710 7470 -1720 {
lab=col_n[26]}
N 7470 -1920 7470 -1720 {
lab=col_n[26]}
N 7460 -1930 7470 -1920 {
lab=col_n[26]}
N 7460 -1710 7460 -1690 {
lab=col_n[26]}
N 7460 -1950 7460 -1930 {
lab=col_n[26]}
N 7340 -1850 7350 -1860 {
lab=row_n[2]}
N 7350 -1860 7550 -1860 {
lab=row_n[2]}
N 7550 -1860 7560 -1850 {
lab=row_n[2]}
N 7340 -1830 7350 -1840 {
lab=rowon_n[2]}
N 7350 -1840 7550 -1840 {
lab=rowon_n[2]}
N 7550 -1840 7560 -1830 {
lab=rowon_n[2]}
N 7340 -1810 7350 -1820 {
lab=#net5}
N 7350 -1820 7550 -1820 {
lab=#net5}
N 7550 -1820 7560 -1810 {
lab=#net5}
N 7340 -1790 7350 -1800 {
lab=#net6}
N 7350 -1800 7550 -1800 {
lab=#net6}
N 7550 -1800 7560 -1790 {
lab=#net6}
N 7400 -1950 7400 -1930 {
lab=vcm}
N 7440 -1950 7440 -1930 {
lab=ctop}
N 7320 -1850 7340 -1850 {
lab=row_n[2]}
N 7320 -1830 7340 -1830 {
lab=rowon_n[2]}
N 7320 -1810 7340 -1810 {
lab=#net5}
N 7320 -1790 7340 -1790 {
lab=#net6}
N 7560 -1790 7580 -1790 {
lab=#net6}
N 7560 -1810 7580 -1810 {
lab=#net5}
N 7560 -1830 7580 -1830 {
lab=rowon_n[2]}
N 7560 -1850 7580 -1850 {
lab=row_n[2]}
N 7380 -1710 7380 -1700 {
lab=VSS}
N 7380 -1940 7380 -1930 {
lab=VDD}
N 7720 -1710 7730 -1720 {
lab=col_n[27]}
N 7730 -1920 7730 -1720 {
lab=col_n[27]}
N 7720 -1930 7730 -1920 {
lab=col_n[27]}
N 7720 -1710 7720 -1690 {
lab=col_n[27]}
N 7720 -1950 7720 -1930 {
lab=col_n[27]}
N 7600 -1850 7610 -1860 {
lab=row_n[2]}
N 7610 -1860 7810 -1860 {
lab=row_n[2]}
N 7810 -1860 7820 -1850 {
lab=row_n[2]}
N 7600 -1830 7610 -1840 {
lab=rowon_n[2]}
N 7610 -1840 7810 -1840 {
lab=rowon_n[2]}
N 7810 -1840 7820 -1830 {
lab=rowon_n[2]}
N 7600 -1810 7610 -1820 {
lab=#net5}
N 7610 -1820 7810 -1820 {
lab=#net5}
N 7810 -1820 7820 -1810 {
lab=#net5}
N 7600 -1790 7610 -1800 {
lab=#net6}
N 7610 -1800 7810 -1800 {
lab=#net6}
N 7810 -1800 7820 -1790 {
lab=#net6}
N 7660 -1950 7660 -1930 {
lab=vcm}
N 7700 -1950 7700 -1930 {
lab=ctop}
N 7580 -1850 7600 -1850 {
lab=row_n[2]}
N 7580 -1830 7600 -1830 {
lab=rowon_n[2]}
N 7580 -1810 7600 -1810 {
lab=#net5}
N 7580 -1790 7600 -1790 {
lab=#net6}
N 7820 -1790 7840 -1790 {
lab=#net6}
N 7820 -1810 7840 -1810 {
lab=#net5}
N 7820 -1830 7840 -1830 {
lab=rowon_n[2]}
N 7820 -1850 7840 -1850 {
lab=row_n[2]}
N 7640 -1710 7640 -1700 {
lab=VSS}
N 7640 -1940 7640 -1930 {
lab=VDD}
N 7980 -1710 7990 -1720 {
lab=col_n[28]}
N 7990 -1920 7990 -1720 {
lab=col_n[28]}
N 7980 -1930 7990 -1920 {
lab=col_n[28]}
N 7980 -1710 7980 -1690 {
lab=col_n[28]}
N 7980 -1950 7980 -1930 {
lab=col_n[28]}
N 7860 -1850 7870 -1860 {
lab=row_n[2]}
N 7870 -1860 8070 -1860 {
lab=row_n[2]}
N 8070 -1860 8080 -1850 {
lab=row_n[2]}
N 7860 -1830 7870 -1840 {
lab=rowon_n[2]}
N 7870 -1840 8070 -1840 {
lab=rowon_n[2]}
N 8070 -1840 8080 -1830 {
lab=rowon_n[2]}
N 7860 -1810 7870 -1820 {
lab=#net5}
N 7870 -1820 8070 -1820 {
lab=#net5}
N 8070 -1820 8080 -1810 {
lab=#net5}
N 7860 -1790 7870 -1800 {
lab=#net6}
N 7870 -1800 8070 -1800 {
lab=#net6}
N 8070 -1800 8080 -1790 {
lab=#net6}
N 7920 -1950 7920 -1930 {
lab=vcm}
N 7960 -1950 7960 -1930 {
lab=ctop}
N 7840 -1850 7860 -1850 {
lab=row_n[2]}
N 7840 -1830 7860 -1830 {
lab=rowon_n[2]}
N 7840 -1810 7860 -1810 {
lab=#net5}
N 7840 -1790 7860 -1790 {
lab=#net6}
N 8080 -1790 8100 -1790 {
lab=#net6}
N 8080 -1810 8100 -1810 {
lab=#net5}
N 8080 -1830 8100 -1830 {
lab=rowon_n[2]}
N 8080 -1850 8100 -1850 {
lab=row_n[2]}
N 7900 -1710 7900 -1700 {
lab=VSS}
N 7900 -1940 7900 -1930 {
lab=VDD}
N 8240 -1710 8250 -1720 {
lab=col_n[29]}
N 8250 -1920 8250 -1720 {
lab=col_n[29]}
N 8240 -1930 8250 -1920 {
lab=col_n[29]}
N 8240 -1710 8240 -1690 {
lab=col_n[29]}
N 8240 -1950 8240 -1930 {
lab=col_n[29]}
N 8120 -1850 8130 -1860 {
lab=row_n[2]}
N 8130 -1860 8330 -1860 {
lab=row_n[2]}
N 8330 -1860 8340 -1850 {
lab=row_n[2]}
N 8120 -1830 8130 -1840 {
lab=rowon_n[2]}
N 8130 -1840 8330 -1840 {
lab=rowon_n[2]}
N 8330 -1840 8340 -1830 {
lab=rowon_n[2]}
N 8120 -1810 8130 -1820 {
lab=#net5}
N 8130 -1820 8330 -1820 {
lab=#net5}
N 8330 -1820 8340 -1810 {
lab=#net5}
N 8120 -1790 8130 -1800 {
lab=#net6}
N 8130 -1800 8330 -1800 {
lab=#net6}
N 8330 -1800 8340 -1790 {
lab=#net6}
N 8180 -1950 8180 -1930 {
lab=vcm}
N 8220 -1950 8220 -1930 {
lab=ctop}
N 8100 -1850 8120 -1850 {
lab=row_n[2]}
N 8100 -1830 8120 -1830 {
lab=rowon_n[2]}
N 8100 -1810 8120 -1810 {
lab=#net5}
N 8100 -1790 8120 -1790 {
lab=#net6}
N 8340 -1790 8360 -1790 {
lab=#net6}
N 8340 -1810 8360 -1810 {
lab=#net5}
N 8340 -1830 8360 -1830 {
lab=rowon_n[2]}
N 8340 -1850 8360 -1850 {
lab=row_n[2]}
N 8160 -1710 8160 -1700 {
lab=VSS}
N 8160 -1940 8160 -1930 {
lab=VDD}
N 8500 -1710 8510 -1720 {
lab=col_n[30]}
N 8510 -1920 8510 -1720 {
lab=col_n[30]}
N 8500 -1930 8510 -1920 {
lab=col_n[30]}
N 8500 -1710 8500 -1690 {
lab=col_n[30]}
N 8500 -1950 8500 -1930 {
lab=col_n[30]}
N 8380 -1850 8390 -1860 {
lab=row_n[2]}
N 8390 -1860 8590 -1860 {
lab=row_n[2]}
N 8590 -1860 8600 -1850 {
lab=row_n[2]}
N 8380 -1830 8390 -1840 {
lab=rowon_n[2]}
N 8390 -1840 8590 -1840 {
lab=rowon_n[2]}
N 8590 -1840 8600 -1830 {
lab=rowon_n[2]}
N 8380 -1810 8390 -1820 {
lab=#net5}
N 8390 -1820 8590 -1820 {
lab=#net5}
N 8590 -1820 8600 -1810 {
lab=#net5}
N 8380 -1790 8390 -1800 {
lab=#net6}
N 8390 -1800 8590 -1800 {
lab=#net6}
N 8590 -1800 8600 -1790 {
lab=#net6}
N 8440 -1950 8440 -1930 {
lab=vcm}
N 8480 -1950 8480 -1930 {
lab=ctop}
N 8360 -1850 8380 -1850 {
lab=row_n[2]}
N 8360 -1830 8380 -1830 {
lab=rowon_n[2]}
N 8360 -1810 8380 -1810 {
lab=#net5}
N 8360 -1790 8380 -1790 {
lab=#net6}
N 8600 -1790 8620 -1790 {
lab=#net6}
N 8600 -1810 8620 -1810 {
lab=#net5}
N 8600 -1830 8620 -1830 {
lab=rowon_n[2]}
N 8600 -1850 8620 -1850 {
lab=row_n[2]}
N 8420 -1710 8420 -1700 {
lab=VSS}
N 8420 -1940 8420 -1930 {
lab=VDD}
N 8760 -1710 8770 -1720 {
lab=col_n[31]}
N 8770 -1920 8770 -1720 {
lab=col_n[31]}
N 8760 -1930 8770 -1920 {
lab=col_n[31]}
N 8760 -1710 8760 -1690 {
lab=col_n[31]}
N 8760 -1950 8760 -1930 {
lab=col_n[31]}
N 8640 -1850 8650 -1860 {
lab=row_n[2]}
N 8650 -1860 8850 -1860 {
lab=row_n[2]}
N 8850 -1860 8860 -1850 {
lab=row_n[2]}
N 8640 -1830 8650 -1840 {
lab=rowon_n[2]}
N 8650 -1840 8850 -1840 {
lab=rowon_n[2]}
N 8850 -1840 8860 -1830 {
lab=rowon_n[2]}
N 8640 -1810 8650 -1820 {
lab=#net5}
N 8650 -1820 8850 -1820 {
lab=#net5}
N 8850 -1820 8860 -1810 {
lab=#net5}
N 8640 -1790 8650 -1800 {
lab=#net6}
N 8650 -1800 8850 -1800 {
lab=#net6}
N 8850 -1800 8860 -1790 {
lab=#net6}
N 8700 -1950 8700 -1930 {
lab=vcm}
N 8740 -1950 8740 -1930 {
lab=ctop}
N 8620 -1850 8640 -1850 {
lab=row_n[2]}
N 8620 -1830 8640 -1830 {
lab=rowon_n[2]}
N 8620 -1810 8640 -1810 {
lab=#net5}
N 8620 -1790 8640 -1790 {
lab=#net6}
N 8860 -1790 8880 -1790 {
lab=#net6}
N 8860 -1810 8880 -1810 {
lab=#net5}
N 8860 -1830 8880 -1830 {
lab=rowon_n[2]}
N 8860 -1850 8880 -1850 {
lab=row_n[2]}
N 8680 -1710 8680 -1700 {
lab=VSS}
N 8680 -1940 8680 -1930 {
lab=VDD}
N 700 -1970 710 -1980 {
lab=col_n[0]}
N 710 -2180 710 -1980 {
lab=col_n[0]}
N 700 -2190 710 -2180 {
lab=col_n[0]}
N 700 -1970 700 -1950 {
lab=col_n[0]}
N 700 -2210 700 -2190 {
lab=col_n[0]}
N 580 -2110 590 -2120 {
lab=row_n[3]}
N 590 -2120 790 -2120 {
lab=row_n[3]}
N 790 -2120 800 -2110 {
lab=row_n[3]}
N 580 -2090 590 -2100 {
lab=rowon_n[3]}
N 590 -2100 790 -2100 {
lab=rowon_n[3]}
N 790 -2100 800 -2090 {
lab=rowon_n[3]}
N 580 -2070 590 -2080 {
lab=#net7}
N 590 -2080 790 -2080 {
lab=#net7}
N 790 -2080 800 -2070 {
lab=#net7}
N 580 -2050 590 -2060 {
lab=#net8}
N 590 -2060 790 -2060 {
lab=#net8}
N 790 -2060 800 -2050 {
lab=#net8}
N 640 -2210 640 -2190 {
lab=vcm}
N 680 -2210 680 -2190 {
lab=ctop}
N 560 -2110 580 -2110 {
lab=row_n[3]}
N 560 -2090 580 -2090 {
lab=rowon_n[3]}
N 560 -2070 580 -2070 {
lab=#net7}
N 560 -2050 580 -2050 {
lab=#net8}
N 800 -2050 820 -2050 {
lab=#net8}
N 800 -2070 820 -2070 {
lab=#net7}
N 800 -2090 820 -2090 {
lab=rowon_n[3]}
N 800 -2110 820 -2110 {
lab=row_n[3]}
N 620 -1970 620 -1960 {
lab=VSS}
N 620 -2200 620 -2190 {
lab=VDD}
N 960 -1970 970 -1980 {
lab=col_n[1]}
N 970 -2180 970 -1980 {
lab=col_n[1]}
N 960 -2190 970 -2180 {
lab=col_n[1]}
N 960 -1970 960 -1950 {
lab=col_n[1]}
N 960 -2210 960 -2190 {
lab=col_n[1]}
N 840 -2110 850 -2120 {
lab=row_n[3]}
N 850 -2120 1050 -2120 {
lab=row_n[3]}
N 1050 -2120 1060 -2110 {
lab=row_n[3]}
N 840 -2090 850 -2100 {
lab=rowon_n[3]}
N 850 -2100 1050 -2100 {
lab=rowon_n[3]}
N 1050 -2100 1060 -2090 {
lab=rowon_n[3]}
N 840 -2070 850 -2080 {
lab=#net7}
N 850 -2080 1050 -2080 {
lab=#net7}
N 1050 -2080 1060 -2070 {
lab=#net7}
N 840 -2050 850 -2060 {
lab=#net8}
N 850 -2060 1050 -2060 {
lab=#net8}
N 1050 -2060 1060 -2050 {
lab=#net8}
N 900 -2210 900 -2190 {
lab=vcm}
N 940 -2210 940 -2190 {
lab=ctop}
N 820 -2110 840 -2110 {
lab=row_n[3]}
N 820 -2090 840 -2090 {
lab=rowon_n[3]}
N 820 -2070 840 -2070 {
lab=#net7}
N 820 -2050 840 -2050 {
lab=#net8}
N 1060 -2050 1080 -2050 {
lab=#net8}
N 1060 -2070 1080 -2070 {
lab=#net7}
N 1060 -2090 1080 -2090 {
lab=rowon_n[3]}
N 1060 -2110 1080 -2110 {
lab=row_n[3]}
N 880 -1970 880 -1960 {
lab=VSS}
N 880 -2200 880 -2190 {
lab=VDD}
N 1220 -1970 1230 -1980 {
lab=col_n[2]}
N 1230 -2180 1230 -1980 {
lab=col_n[2]}
N 1220 -2190 1230 -2180 {
lab=col_n[2]}
N 1220 -1970 1220 -1950 {
lab=col_n[2]}
N 1220 -2210 1220 -2190 {
lab=col_n[2]}
N 1100 -2110 1110 -2120 {
lab=row_n[3]}
N 1110 -2120 1310 -2120 {
lab=row_n[3]}
N 1310 -2120 1320 -2110 {
lab=row_n[3]}
N 1100 -2090 1110 -2100 {
lab=rowon_n[3]}
N 1110 -2100 1310 -2100 {
lab=rowon_n[3]}
N 1310 -2100 1320 -2090 {
lab=rowon_n[3]}
N 1100 -2070 1110 -2080 {
lab=#net7}
N 1110 -2080 1310 -2080 {
lab=#net7}
N 1310 -2080 1320 -2070 {
lab=#net7}
N 1100 -2050 1110 -2060 {
lab=#net8}
N 1110 -2060 1310 -2060 {
lab=#net8}
N 1310 -2060 1320 -2050 {
lab=#net8}
N 1160 -2210 1160 -2190 {
lab=vcm}
N 1200 -2210 1200 -2190 {
lab=ctop}
N 1080 -2110 1100 -2110 {
lab=row_n[3]}
N 1080 -2090 1100 -2090 {
lab=rowon_n[3]}
N 1080 -2070 1100 -2070 {
lab=#net7}
N 1080 -2050 1100 -2050 {
lab=#net8}
N 1320 -2050 1340 -2050 {
lab=#net8}
N 1320 -2070 1340 -2070 {
lab=#net7}
N 1320 -2090 1340 -2090 {
lab=rowon_n[3]}
N 1320 -2110 1340 -2110 {
lab=row_n[3]}
N 1140 -1970 1140 -1960 {
lab=VSS}
N 1140 -2200 1140 -2190 {
lab=VDD}
N 1480 -1970 1490 -1980 {
lab=col_n[3]}
N 1490 -2180 1490 -1980 {
lab=col_n[3]}
N 1480 -2190 1490 -2180 {
lab=col_n[3]}
N 1480 -1970 1480 -1950 {
lab=col_n[3]}
N 1480 -2210 1480 -2190 {
lab=col_n[3]}
N 1360 -2110 1370 -2120 {
lab=row_n[3]}
N 1370 -2120 1570 -2120 {
lab=row_n[3]}
N 1570 -2120 1580 -2110 {
lab=row_n[3]}
N 1360 -2090 1370 -2100 {
lab=rowon_n[3]}
N 1370 -2100 1570 -2100 {
lab=rowon_n[3]}
N 1570 -2100 1580 -2090 {
lab=rowon_n[3]}
N 1360 -2070 1370 -2080 {
lab=#net7}
N 1370 -2080 1570 -2080 {
lab=#net7}
N 1570 -2080 1580 -2070 {
lab=#net7}
N 1360 -2050 1370 -2060 {
lab=#net8}
N 1370 -2060 1570 -2060 {
lab=#net8}
N 1570 -2060 1580 -2050 {
lab=#net8}
N 1420 -2210 1420 -2190 {
lab=vcm}
N 1460 -2210 1460 -2190 {
lab=ctop}
N 1340 -2110 1360 -2110 {
lab=row_n[3]}
N 1340 -2090 1360 -2090 {
lab=rowon_n[3]}
N 1340 -2070 1360 -2070 {
lab=#net7}
N 1340 -2050 1360 -2050 {
lab=#net8}
N 1580 -2050 1600 -2050 {
lab=#net8}
N 1580 -2070 1600 -2070 {
lab=#net7}
N 1580 -2090 1600 -2090 {
lab=rowon_n[3]}
N 1580 -2110 1600 -2110 {
lab=row_n[3]}
N 1400 -1970 1400 -1960 {
lab=VSS}
N 1400 -2200 1400 -2190 {
lab=VDD}
N 1740 -1970 1750 -1980 {
lab=col_n[4]}
N 1750 -2180 1750 -1980 {
lab=col_n[4]}
N 1740 -2190 1750 -2180 {
lab=col_n[4]}
N 1740 -1970 1740 -1950 {
lab=col_n[4]}
N 1740 -2210 1740 -2190 {
lab=col_n[4]}
N 1620 -2110 1630 -2120 {
lab=row_n[3]}
N 1630 -2120 1830 -2120 {
lab=row_n[3]}
N 1830 -2120 1840 -2110 {
lab=row_n[3]}
N 1620 -2090 1630 -2100 {
lab=rowon_n[3]}
N 1630 -2100 1830 -2100 {
lab=rowon_n[3]}
N 1830 -2100 1840 -2090 {
lab=rowon_n[3]}
N 1620 -2070 1630 -2080 {
lab=#net7}
N 1630 -2080 1830 -2080 {
lab=#net7}
N 1830 -2080 1840 -2070 {
lab=#net7}
N 1620 -2050 1630 -2060 {
lab=#net8}
N 1630 -2060 1830 -2060 {
lab=#net8}
N 1830 -2060 1840 -2050 {
lab=#net8}
N 1680 -2210 1680 -2190 {
lab=vcm}
N 1720 -2210 1720 -2190 {
lab=ctop}
N 1600 -2110 1620 -2110 {
lab=row_n[3]}
N 1600 -2090 1620 -2090 {
lab=rowon_n[3]}
N 1600 -2070 1620 -2070 {
lab=#net7}
N 1600 -2050 1620 -2050 {
lab=#net8}
N 1840 -2050 1860 -2050 {
lab=#net8}
N 1840 -2070 1860 -2070 {
lab=#net7}
N 1840 -2090 1860 -2090 {
lab=rowon_n[3]}
N 1840 -2110 1860 -2110 {
lab=row_n[3]}
N 1660 -1970 1660 -1960 {
lab=VSS}
N 1660 -2200 1660 -2190 {
lab=VDD}
N 2000 -1970 2010 -1980 {
lab=col_n[5]}
N 2010 -2180 2010 -1980 {
lab=col_n[5]}
N 2000 -2190 2010 -2180 {
lab=col_n[5]}
N 2000 -1970 2000 -1950 {
lab=col_n[5]}
N 2000 -2210 2000 -2190 {
lab=col_n[5]}
N 1880 -2110 1890 -2120 {
lab=row_n[3]}
N 1890 -2120 2090 -2120 {
lab=row_n[3]}
N 2090 -2120 2100 -2110 {
lab=row_n[3]}
N 1880 -2090 1890 -2100 {
lab=rowon_n[3]}
N 1890 -2100 2090 -2100 {
lab=rowon_n[3]}
N 2090 -2100 2100 -2090 {
lab=rowon_n[3]}
N 1880 -2070 1890 -2080 {
lab=#net7}
N 1890 -2080 2090 -2080 {
lab=#net7}
N 2090 -2080 2100 -2070 {
lab=#net7}
N 1880 -2050 1890 -2060 {
lab=#net8}
N 1890 -2060 2090 -2060 {
lab=#net8}
N 2090 -2060 2100 -2050 {
lab=#net8}
N 1940 -2210 1940 -2190 {
lab=vcm}
N 1980 -2210 1980 -2190 {
lab=ctop}
N 1860 -2110 1880 -2110 {
lab=row_n[3]}
N 1860 -2090 1880 -2090 {
lab=rowon_n[3]}
N 1860 -2070 1880 -2070 {
lab=#net7}
N 1860 -2050 1880 -2050 {
lab=#net8}
N 2100 -2050 2120 -2050 {
lab=#net8}
N 2100 -2070 2120 -2070 {
lab=#net7}
N 2100 -2090 2120 -2090 {
lab=rowon_n[3]}
N 2100 -2110 2120 -2110 {
lab=row_n[3]}
N 1920 -1970 1920 -1960 {
lab=VSS}
N 1920 -2200 1920 -2190 {
lab=VDD}
N 2260 -1970 2270 -1980 {
lab=col_n[6]}
N 2270 -2180 2270 -1980 {
lab=col_n[6]}
N 2260 -2190 2270 -2180 {
lab=col_n[6]}
N 2260 -1970 2260 -1950 {
lab=col_n[6]}
N 2260 -2210 2260 -2190 {
lab=col_n[6]}
N 2140 -2110 2150 -2120 {
lab=row_n[3]}
N 2150 -2120 2350 -2120 {
lab=row_n[3]}
N 2350 -2120 2360 -2110 {
lab=row_n[3]}
N 2140 -2090 2150 -2100 {
lab=rowon_n[3]}
N 2150 -2100 2350 -2100 {
lab=rowon_n[3]}
N 2350 -2100 2360 -2090 {
lab=rowon_n[3]}
N 2140 -2070 2150 -2080 {
lab=#net7}
N 2150 -2080 2350 -2080 {
lab=#net7}
N 2350 -2080 2360 -2070 {
lab=#net7}
N 2140 -2050 2150 -2060 {
lab=#net8}
N 2150 -2060 2350 -2060 {
lab=#net8}
N 2350 -2060 2360 -2050 {
lab=#net8}
N 2200 -2210 2200 -2190 {
lab=vcm}
N 2240 -2210 2240 -2190 {
lab=ctop}
N 2120 -2110 2140 -2110 {
lab=row_n[3]}
N 2120 -2090 2140 -2090 {
lab=rowon_n[3]}
N 2120 -2070 2140 -2070 {
lab=#net7}
N 2120 -2050 2140 -2050 {
lab=#net8}
N 2360 -2050 2380 -2050 {
lab=#net8}
N 2360 -2070 2380 -2070 {
lab=#net7}
N 2360 -2090 2380 -2090 {
lab=rowon_n[3]}
N 2360 -2110 2380 -2110 {
lab=row_n[3]}
N 2180 -1970 2180 -1960 {
lab=VSS}
N 2180 -2200 2180 -2190 {
lab=VDD}
N 2520 -1970 2530 -1980 {
lab=col_n[7]}
N 2530 -2180 2530 -1980 {
lab=col_n[7]}
N 2520 -2190 2530 -2180 {
lab=col_n[7]}
N 2520 -1970 2520 -1950 {
lab=col_n[7]}
N 2520 -2210 2520 -2190 {
lab=col_n[7]}
N 2400 -2110 2410 -2120 {
lab=row_n[3]}
N 2410 -2120 2610 -2120 {
lab=row_n[3]}
N 2610 -2120 2620 -2110 {
lab=row_n[3]}
N 2400 -2090 2410 -2100 {
lab=rowon_n[3]}
N 2410 -2100 2610 -2100 {
lab=rowon_n[3]}
N 2610 -2100 2620 -2090 {
lab=rowon_n[3]}
N 2400 -2070 2410 -2080 {
lab=#net7}
N 2410 -2080 2610 -2080 {
lab=#net7}
N 2610 -2080 2620 -2070 {
lab=#net7}
N 2400 -2050 2410 -2060 {
lab=#net8}
N 2410 -2060 2610 -2060 {
lab=#net8}
N 2610 -2060 2620 -2050 {
lab=#net8}
N 2460 -2210 2460 -2190 {
lab=vcm}
N 2500 -2210 2500 -2190 {
lab=ctop}
N 2380 -2110 2400 -2110 {
lab=row_n[3]}
N 2380 -2090 2400 -2090 {
lab=rowon_n[3]}
N 2380 -2070 2400 -2070 {
lab=#net7}
N 2380 -2050 2400 -2050 {
lab=#net8}
N 2620 -2050 2640 -2050 {
lab=#net8}
N 2620 -2070 2640 -2070 {
lab=#net7}
N 2620 -2090 2640 -2090 {
lab=rowon_n[3]}
N 2620 -2110 2640 -2110 {
lab=row_n[3]}
N 2440 -1970 2440 -1960 {
lab=VSS}
N 2440 -2200 2440 -2190 {
lab=VDD}
N 2780 -1970 2790 -1980 {
lab=col_n[8]}
N 2790 -2180 2790 -1980 {
lab=col_n[8]}
N 2780 -2190 2790 -2180 {
lab=col_n[8]}
N 2780 -1970 2780 -1950 {
lab=col_n[8]}
N 2780 -2210 2780 -2190 {
lab=col_n[8]}
N 2660 -2110 2670 -2120 {
lab=row_n[3]}
N 2670 -2120 2870 -2120 {
lab=row_n[3]}
N 2870 -2120 2880 -2110 {
lab=row_n[3]}
N 2660 -2090 2670 -2100 {
lab=rowon_n[3]}
N 2670 -2100 2870 -2100 {
lab=rowon_n[3]}
N 2870 -2100 2880 -2090 {
lab=rowon_n[3]}
N 2660 -2070 2670 -2080 {
lab=#net7}
N 2670 -2080 2870 -2080 {
lab=#net7}
N 2870 -2080 2880 -2070 {
lab=#net7}
N 2660 -2050 2670 -2060 {
lab=#net8}
N 2670 -2060 2870 -2060 {
lab=#net8}
N 2870 -2060 2880 -2050 {
lab=#net8}
N 2720 -2210 2720 -2190 {
lab=vcm}
N 2760 -2210 2760 -2190 {
lab=ctop}
N 2640 -2110 2660 -2110 {
lab=row_n[3]}
N 2640 -2090 2660 -2090 {
lab=rowon_n[3]}
N 2640 -2070 2660 -2070 {
lab=#net7}
N 2640 -2050 2660 -2050 {
lab=#net8}
N 2880 -2050 2900 -2050 {
lab=#net8}
N 2880 -2070 2900 -2070 {
lab=#net7}
N 2880 -2090 2900 -2090 {
lab=rowon_n[3]}
N 2880 -2110 2900 -2110 {
lab=row_n[3]}
N 2700 -1970 2700 -1960 {
lab=VSS}
N 2700 -2200 2700 -2190 {
lab=VDD}
N 3040 -1970 3050 -1980 {
lab=col_n[9]}
N 3050 -2180 3050 -1980 {
lab=col_n[9]}
N 3040 -2190 3050 -2180 {
lab=col_n[9]}
N 3040 -1970 3040 -1950 {
lab=col_n[9]}
N 3040 -2210 3040 -2190 {
lab=col_n[9]}
N 2920 -2110 2930 -2120 {
lab=row_n[3]}
N 2930 -2120 3130 -2120 {
lab=row_n[3]}
N 3130 -2120 3140 -2110 {
lab=row_n[3]}
N 2920 -2090 2930 -2100 {
lab=rowon_n[3]}
N 2930 -2100 3130 -2100 {
lab=rowon_n[3]}
N 3130 -2100 3140 -2090 {
lab=rowon_n[3]}
N 2920 -2070 2930 -2080 {
lab=#net7}
N 2930 -2080 3130 -2080 {
lab=#net7}
N 3130 -2080 3140 -2070 {
lab=#net7}
N 2920 -2050 2930 -2060 {
lab=#net8}
N 2930 -2060 3130 -2060 {
lab=#net8}
N 3130 -2060 3140 -2050 {
lab=#net8}
N 2980 -2210 2980 -2190 {
lab=vcm}
N 3020 -2210 3020 -2190 {
lab=ctop}
N 2900 -2110 2920 -2110 {
lab=row_n[3]}
N 2900 -2090 2920 -2090 {
lab=rowon_n[3]}
N 2900 -2070 2920 -2070 {
lab=#net7}
N 2900 -2050 2920 -2050 {
lab=#net8}
N 3140 -2050 3160 -2050 {
lab=#net8}
N 3140 -2070 3160 -2070 {
lab=#net7}
N 3140 -2090 3160 -2090 {
lab=rowon_n[3]}
N 3140 -2110 3160 -2110 {
lab=row_n[3]}
N 2960 -1970 2960 -1960 {
lab=VSS}
N 2960 -2200 2960 -2190 {
lab=VDD}
N 3300 -1970 3310 -1980 {
lab=col_n[10]}
N 3310 -2180 3310 -1980 {
lab=col_n[10]}
N 3300 -2190 3310 -2180 {
lab=col_n[10]}
N 3300 -1970 3300 -1950 {
lab=col_n[10]}
N 3300 -2210 3300 -2190 {
lab=col_n[10]}
N 3180 -2110 3190 -2120 {
lab=row_n[3]}
N 3190 -2120 3390 -2120 {
lab=row_n[3]}
N 3390 -2120 3400 -2110 {
lab=row_n[3]}
N 3180 -2090 3190 -2100 {
lab=rowon_n[3]}
N 3190 -2100 3390 -2100 {
lab=rowon_n[3]}
N 3390 -2100 3400 -2090 {
lab=rowon_n[3]}
N 3180 -2070 3190 -2080 {
lab=#net7}
N 3190 -2080 3390 -2080 {
lab=#net7}
N 3390 -2080 3400 -2070 {
lab=#net7}
N 3180 -2050 3190 -2060 {
lab=#net8}
N 3190 -2060 3390 -2060 {
lab=#net8}
N 3390 -2060 3400 -2050 {
lab=#net8}
N 3240 -2210 3240 -2190 {
lab=vcm}
N 3280 -2210 3280 -2190 {
lab=ctop}
N 3160 -2110 3180 -2110 {
lab=row_n[3]}
N 3160 -2090 3180 -2090 {
lab=rowon_n[3]}
N 3160 -2070 3180 -2070 {
lab=#net7}
N 3160 -2050 3180 -2050 {
lab=#net8}
N 3400 -2050 3420 -2050 {
lab=#net8}
N 3400 -2070 3420 -2070 {
lab=#net7}
N 3400 -2090 3420 -2090 {
lab=rowon_n[3]}
N 3400 -2110 3420 -2110 {
lab=row_n[3]}
N 3220 -1970 3220 -1960 {
lab=VSS}
N 3220 -2200 3220 -2190 {
lab=VDD}
N 3560 -1970 3570 -1980 {
lab=col_n[11]}
N 3570 -2180 3570 -1980 {
lab=col_n[11]}
N 3560 -2190 3570 -2180 {
lab=col_n[11]}
N 3560 -1970 3560 -1950 {
lab=col_n[11]}
N 3560 -2210 3560 -2190 {
lab=col_n[11]}
N 3440 -2110 3450 -2120 {
lab=row_n[3]}
N 3450 -2120 3650 -2120 {
lab=row_n[3]}
N 3650 -2120 3660 -2110 {
lab=row_n[3]}
N 3440 -2090 3450 -2100 {
lab=rowon_n[3]}
N 3450 -2100 3650 -2100 {
lab=rowon_n[3]}
N 3650 -2100 3660 -2090 {
lab=rowon_n[3]}
N 3440 -2070 3450 -2080 {
lab=#net7}
N 3450 -2080 3650 -2080 {
lab=#net7}
N 3650 -2080 3660 -2070 {
lab=#net7}
N 3440 -2050 3450 -2060 {
lab=#net8}
N 3450 -2060 3650 -2060 {
lab=#net8}
N 3650 -2060 3660 -2050 {
lab=#net8}
N 3500 -2210 3500 -2190 {
lab=vcm}
N 3540 -2210 3540 -2190 {
lab=ctop}
N 3420 -2110 3440 -2110 {
lab=row_n[3]}
N 3420 -2090 3440 -2090 {
lab=rowon_n[3]}
N 3420 -2070 3440 -2070 {
lab=#net7}
N 3420 -2050 3440 -2050 {
lab=#net8}
N 3660 -2050 3680 -2050 {
lab=#net8}
N 3660 -2070 3680 -2070 {
lab=#net7}
N 3660 -2090 3680 -2090 {
lab=rowon_n[3]}
N 3660 -2110 3680 -2110 {
lab=row_n[3]}
N 3480 -1970 3480 -1960 {
lab=VSS}
N 3480 -2200 3480 -2190 {
lab=VDD}
N 3820 -1970 3830 -1980 {
lab=col_n[12]}
N 3830 -2180 3830 -1980 {
lab=col_n[12]}
N 3820 -2190 3830 -2180 {
lab=col_n[12]}
N 3820 -1970 3820 -1950 {
lab=col_n[12]}
N 3820 -2210 3820 -2190 {
lab=col_n[12]}
N 3700 -2110 3710 -2120 {
lab=row_n[3]}
N 3710 -2120 3910 -2120 {
lab=row_n[3]}
N 3910 -2120 3920 -2110 {
lab=row_n[3]}
N 3700 -2090 3710 -2100 {
lab=rowon_n[3]}
N 3710 -2100 3910 -2100 {
lab=rowon_n[3]}
N 3910 -2100 3920 -2090 {
lab=rowon_n[3]}
N 3700 -2070 3710 -2080 {
lab=#net7}
N 3710 -2080 3910 -2080 {
lab=#net7}
N 3910 -2080 3920 -2070 {
lab=#net7}
N 3700 -2050 3710 -2060 {
lab=#net8}
N 3710 -2060 3910 -2060 {
lab=#net8}
N 3910 -2060 3920 -2050 {
lab=#net8}
N 3760 -2210 3760 -2190 {
lab=vcm}
N 3800 -2210 3800 -2190 {
lab=ctop}
N 3680 -2110 3700 -2110 {
lab=row_n[3]}
N 3680 -2090 3700 -2090 {
lab=rowon_n[3]}
N 3680 -2070 3700 -2070 {
lab=#net7}
N 3680 -2050 3700 -2050 {
lab=#net8}
N 3920 -2050 3940 -2050 {
lab=#net8}
N 3920 -2070 3940 -2070 {
lab=#net7}
N 3920 -2090 3940 -2090 {
lab=rowon_n[3]}
N 3920 -2110 3940 -2110 {
lab=row_n[3]}
N 3740 -1970 3740 -1960 {
lab=VSS}
N 3740 -2200 3740 -2190 {
lab=VDD}
N 4080 -1970 4090 -1980 {
lab=col_n[13]}
N 4090 -2180 4090 -1980 {
lab=col_n[13]}
N 4080 -2190 4090 -2180 {
lab=col_n[13]}
N 4080 -1970 4080 -1950 {
lab=col_n[13]}
N 4080 -2210 4080 -2190 {
lab=col_n[13]}
N 3960 -2110 3970 -2120 {
lab=row_n[3]}
N 3970 -2120 4170 -2120 {
lab=row_n[3]}
N 4170 -2120 4180 -2110 {
lab=row_n[3]}
N 3960 -2090 3970 -2100 {
lab=rowon_n[3]}
N 3970 -2100 4170 -2100 {
lab=rowon_n[3]}
N 4170 -2100 4180 -2090 {
lab=rowon_n[3]}
N 3960 -2070 3970 -2080 {
lab=#net7}
N 3970 -2080 4170 -2080 {
lab=#net7}
N 4170 -2080 4180 -2070 {
lab=#net7}
N 3960 -2050 3970 -2060 {
lab=#net8}
N 3970 -2060 4170 -2060 {
lab=#net8}
N 4170 -2060 4180 -2050 {
lab=#net8}
N 4020 -2210 4020 -2190 {
lab=vcm}
N 4060 -2210 4060 -2190 {
lab=ctop}
N 3940 -2110 3960 -2110 {
lab=row_n[3]}
N 3940 -2090 3960 -2090 {
lab=rowon_n[3]}
N 3940 -2070 3960 -2070 {
lab=#net7}
N 3940 -2050 3960 -2050 {
lab=#net8}
N 4180 -2050 4200 -2050 {
lab=#net8}
N 4180 -2070 4200 -2070 {
lab=#net7}
N 4180 -2090 4200 -2090 {
lab=rowon_n[3]}
N 4180 -2110 4200 -2110 {
lab=row_n[3]}
N 4000 -1970 4000 -1960 {
lab=VSS}
N 4000 -2200 4000 -2190 {
lab=VDD}
N 4340 -1970 4350 -1980 {
lab=col_n[14]}
N 4350 -2180 4350 -1980 {
lab=col_n[14]}
N 4340 -2190 4350 -2180 {
lab=col_n[14]}
N 4340 -1970 4340 -1950 {
lab=col_n[14]}
N 4340 -2210 4340 -2190 {
lab=col_n[14]}
N 4220 -2110 4230 -2120 {
lab=row_n[3]}
N 4230 -2120 4430 -2120 {
lab=row_n[3]}
N 4430 -2120 4440 -2110 {
lab=row_n[3]}
N 4220 -2090 4230 -2100 {
lab=rowon_n[3]}
N 4230 -2100 4430 -2100 {
lab=rowon_n[3]}
N 4430 -2100 4440 -2090 {
lab=rowon_n[3]}
N 4220 -2070 4230 -2080 {
lab=#net7}
N 4230 -2080 4430 -2080 {
lab=#net7}
N 4430 -2080 4440 -2070 {
lab=#net7}
N 4220 -2050 4230 -2060 {
lab=#net8}
N 4230 -2060 4430 -2060 {
lab=#net8}
N 4430 -2060 4440 -2050 {
lab=#net8}
N 4280 -2210 4280 -2190 {
lab=vcm}
N 4320 -2210 4320 -2190 {
lab=ctop}
N 4200 -2110 4220 -2110 {
lab=row_n[3]}
N 4200 -2090 4220 -2090 {
lab=rowon_n[3]}
N 4200 -2070 4220 -2070 {
lab=#net7}
N 4200 -2050 4220 -2050 {
lab=#net8}
N 4440 -2050 4460 -2050 {
lab=#net8}
N 4440 -2070 4460 -2070 {
lab=#net7}
N 4440 -2090 4460 -2090 {
lab=rowon_n[3]}
N 4440 -2110 4460 -2110 {
lab=row_n[3]}
N 4260 -1970 4260 -1960 {
lab=VSS}
N 4260 -2200 4260 -2190 {
lab=VDD}
N 4600 -1970 4610 -1980 {
lab=col_n[15]}
N 4610 -2180 4610 -1980 {
lab=col_n[15]}
N 4600 -2190 4610 -2180 {
lab=col_n[15]}
N 4600 -1970 4600 -1950 {
lab=col_n[15]}
N 4600 -2210 4600 -2190 {
lab=col_n[15]}
N 4480 -2110 4490 -2120 {
lab=row_n[3]}
N 4490 -2120 4690 -2120 {
lab=row_n[3]}
N 4690 -2120 4700 -2110 {
lab=row_n[3]}
N 4480 -2090 4490 -2100 {
lab=rowon_n[3]}
N 4490 -2100 4690 -2100 {
lab=rowon_n[3]}
N 4690 -2100 4700 -2090 {
lab=rowon_n[3]}
N 4480 -2070 4490 -2080 {
lab=#net7}
N 4490 -2080 4690 -2080 {
lab=#net7}
N 4690 -2080 4700 -2070 {
lab=#net7}
N 4480 -2050 4490 -2060 {
lab=#net8}
N 4490 -2060 4690 -2060 {
lab=#net8}
N 4690 -2060 4700 -2050 {
lab=#net8}
N 4540 -2210 4540 -2190 {
lab=vcm}
N 4580 -2210 4580 -2190 {
lab=ctop}
N 4460 -2110 4480 -2110 {
lab=row_n[3]}
N 4460 -2090 4480 -2090 {
lab=rowon_n[3]}
N 4460 -2070 4480 -2070 {
lab=#net7}
N 4460 -2050 4480 -2050 {
lab=#net8}
N 4700 -2050 4720 -2050 {
lab=#net8}
N 4700 -2070 4720 -2070 {
lab=#net7}
N 4700 -2090 4720 -2090 {
lab=rowon_n[3]}
N 4700 -2110 4720 -2110 {
lab=row_n[3]}
N 4520 -1970 4520 -1960 {
lab=VSS}
N 4520 -2200 4520 -2190 {
lab=VDD}
N 4860 -1970 4870 -1980 {
lab=col_n[16]}
N 4870 -2180 4870 -1980 {
lab=col_n[16]}
N 4860 -2190 4870 -2180 {
lab=col_n[16]}
N 4860 -1970 4860 -1950 {
lab=col_n[16]}
N 4860 -2210 4860 -2190 {
lab=col_n[16]}
N 4740 -2110 4750 -2120 {
lab=row_n[3]}
N 4750 -2120 4950 -2120 {
lab=row_n[3]}
N 4950 -2120 4960 -2110 {
lab=row_n[3]}
N 4740 -2090 4750 -2100 {
lab=rowon_n[3]}
N 4750 -2100 4950 -2100 {
lab=rowon_n[3]}
N 4950 -2100 4960 -2090 {
lab=rowon_n[3]}
N 4740 -2070 4750 -2080 {
lab=#net7}
N 4750 -2080 4950 -2080 {
lab=#net7}
N 4950 -2080 4960 -2070 {
lab=#net7}
N 4740 -2050 4750 -2060 {
lab=#net8}
N 4750 -2060 4950 -2060 {
lab=#net8}
N 4950 -2060 4960 -2050 {
lab=#net8}
N 4800 -2210 4800 -2190 {
lab=vcm}
N 4840 -2210 4840 -2190 {
lab=ctop}
N 4720 -2110 4740 -2110 {
lab=row_n[3]}
N 4720 -2090 4740 -2090 {
lab=rowon_n[3]}
N 4720 -2070 4740 -2070 {
lab=#net7}
N 4720 -2050 4740 -2050 {
lab=#net8}
N 4960 -2050 4980 -2050 {
lab=#net8}
N 4960 -2070 4980 -2070 {
lab=#net7}
N 4960 -2090 4980 -2090 {
lab=rowon_n[3]}
N 4960 -2110 4980 -2110 {
lab=row_n[3]}
N 4780 -1970 4780 -1960 {
lab=VSS}
N 4780 -2200 4780 -2190 {
lab=VDD}
N 5120 -1970 5130 -1980 {
lab=col_n[17]}
N 5130 -2180 5130 -1980 {
lab=col_n[17]}
N 5120 -2190 5130 -2180 {
lab=col_n[17]}
N 5120 -1970 5120 -1950 {
lab=col_n[17]}
N 5120 -2210 5120 -2190 {
lab=col_n[17]}
N 5000 -2110 5010 -2120 {
lab=row_n[3]}
N 5010 -2120 5210 -2120 {
lab=row_n[3]}
N 5210 -2120 5220 -2110 {
lab=row_n[3]}
N 5000 -2090 5010 -2100 {
lab=rowon_n[3]}
N 5010 -2100 5210 -2100 {
lab=rowon_n[3]}
N 5210 -2100 5220 -2090 {
lab=rowon_n[3]}
N 5000 -2070 5010 -2080 {
lab=#net7}
N 5010 -2080 5210 -2080 {
lab=#net7}
N 5210 -2080 5220 -2070 {
lab=#net7}
N 5000 -2050 5010 -2060 {
lab=#net8}
N 5010 -2060 5210 -2060 {
lab=#net8}
N 5210 -2060 5220 -2050 {
lab=#net8}
N 5060 -2210 5060 -2190 {
lab=vcm}
N 5100 -2210 5100 -2190 {
lab=ctop}
N 4980 -2110 5000 -2110 {
lab=row_n[3]}
N 4980 -2090 5000 -2090 {
lab=rowon_n[3]}
N 4980 -2070 5000 -2070 {
lab=#net7}
N 4980 -2050 5000 -2050 {
lab=#net8}
N 5220 -2050 5240 -2050 {
lab=#net8}
N 5220 -2070 5240 -2070 {
lab=#net7}
N 5220 -2090 5240 -2090 {
lab=rowon_n[3]}
N 5220 -2110 5240 -2110 {
lab=row_n[3]}
N 5040 -1970 5040 -1960 {
lab=VSS}
N 5040 -2200 5040 -2190 {
lab=VDD}
N 5380 -1970 5390 -1980 {
lab=col_n[18]}
N 5390 -2180 5390 -1980 {
lab=col_n[18]}
N 5380 -2190 5390 -2180 {
lab=col_n[18]}
N 5380 -1970 5380 -1950 {
lab=col_n[18]}
N 5380 -2210 5380 -2190 {
lab=col_n[18]}
N 5260 -2110 5270 -2120 {
lab=row_n[3]}
N 5270 -2120 5470 -2120 {
lab=row_n[3]}
N 5470 -2120 5480 -2110 {
lab=row_n[3]}
N 5260 -2090 5270 -2100 {
lab=rowon_n[3]}
N 5270 -2100 5470 -2100 {
lab=rowon_n[3]}
N 5470 -2100 5480 -2090 {
lab=rowon_n[3]}
N 5260 -2070 5270 -2080 {
lab=#net7}
N 5270 -2080 5470 -2080 {
lab=#net7}
N 5470 -2080 5480 -2070 {
lab=#net7}
N 5260 -2050 5270 -2060 {
lab=#net8}
N 5270 -2060 5470 -2060 {
lab=#net8}
N 5470 -2060 5480 -2050 {
lab=#net8}
N 5320 -2210 5320 -2190 {
lab=vcm}
N 5360 -2210 5360 -2190 {
lab=ctop}
N 5240 -2110 5260 -2110 {
lab=row_n[3]}
N 5240 -2090 5260 -2090 {
lab=rowon_n[3]}
N 5240 -2070 5260 -2070 {
lab=#net7}
N 5240 -2050 5260 -2050 {
lab=#net8}
N 5480 -2050 5500 -2050 {
lab=#net8}
N 5480 -2070 5500 -2070 {
lab=#net7}
N 5480 -2090 5500 -2090 {
lab=rowon_n[3]}
N 5480 -2110 5500 -2110 {
lab=row_n[3]}
N 5300 -1970 5300 -1960 {
lab=VSS}
N 5300 -2200 5300 -2190 {
lab=VDD}
N 5640 -1970 5650 -1980 {
lab=col_n[19]}
N 5650 -2180 5650 -1980 {
lab=col_n[19]}
N 5640 -2190 5650 -2180 {
lab=col_n[19]}
N 5640 -1970 5640 -1950 {
lab=col_n[19]}
N 5640 -2210 5640 -2190 {
lab=col_n[19]}
N 5520 -2110 5530 -2120 {
lab=row_n[3]}
N 5530 -2120 5730 -2120 {
lab=row_n[3]}
N 5730 -2120 5740 -2110 {
lab=row_n[3]}
N 5520 -2090 5530 -2100 {
lab=rowon_n[3]}
N 5530 -2100 5730 -2100 {
lab=rowon_n[3]}
N 5730 -2100 5740 -2090 {
lab=rowon_n[3]}
N 5520 -2070 5530 -2080 {
lab=#net7}
N 5530 -2080 5730 -2080 {
lab=#net7}
N 5730 -2080 5740 -2070 {
lab=#net7}
N 5520 -2050 5530 -2060 {
lab=#net8}
N 5530 -2060 5730 -2060 {
lab=#net8}
N 5730 -2060 5740 -2050 {
lab=#net8}
N 5580 -2210 5580 -2190 {
lab=vcm}
N 5620 -2210 5620 -2190 {
lab=ctop}
N 5500 -2110 5520 -2110 {
lab=row_n[3]}
N 5500 -2090 5520 -2090 {
lab=rowon_n[3]}
N 5500 -2070 5520 -2070 {
lab=#net7}
N 5500 -2050 5520 -2050 {
lab=#net8}
N 5740 -2050 5760 -2050 {
lab=#net8}
N 5740 -2070 5760 -2070 {
lab=#net7}
N 5740 -2090 5760 -2090 {
lab=rowon_n[3]}
N 5740 -2110 5760 -2110 {
lab=row_n[3]}
N 5560 -1970 5560 -1960 {
lab=VSS}
N 5560 -2200 5560 -2190 {
lab=VDD}
N 5900 -1970 5910 -1980 {
lab=col_n[20]}
N 5910 -2180 5910 -1980 {
lab=col_n[20]}
N 5900 -2190 5910 -2180 {
lab=col_n[20]}
N 5900 -1970 5900 -1950 {
lab=col_n[20]}
N 5900 -2210 5900 -2190 {
lab=col_n[20]}
N 5780 -2110 5790 -2120 {
lab=row_n[3]}
N 5790 -2120 5990 -2120 {
lab=row_n[3]}
N 5990 -2120 6000 -2110 {
lab=row_n[3]}
N 5780 -2090 5790 -2100 {
lab=rowon_n[3]}
N 5790 -2100 5990 -2100 {
lab=rowon_n[3]}
N 5990 -2100 6000 -2090 {
lab=rowon_n[3]}
N 5780 -2070 5790 -2080 {
lab=#net7}
N 5790 -2080 5990 -2080 {
lab=#net7}
N 5990 -2080 6000 -2070 {
lab=#net7}
N 5780 -2050 5790 -2060 {
lab=#net8}
N 5790 -2060 5990 -2060 {
lab=#net8}
N 5990 -2060 6000 -2050 {
lab=#net8}
N 5840 -2210 5840 -2190 {
lab=vcm}
N 5880 -2210 5880 -2190 {
lab=ctop}
N 5760 -2110 5780 -2110 {
lab=row_n[3]}
N 5760 -2090 5780 -2090 {
lab=rowon_n[3]}
N 5760 -2070 5780 -2070 {
lab=#net7}
N 5760 -2050 5780 -2050 {
lab=#net8}
N 6000 -2050 6020 -2050 {
lab=#net8}
N 6000 -2070 6020 -2070 {
lab=#net7}
N 6000 -2090 6020 -2090 {
lab=rowon_n[3]}
N 6000 -2110 6020 -2110 {
lab=row_n[3]}
N 5820 -1970 5820 -1960 {
lab=VSS}
N 5820 -2200 5820 -2190 {
lab=VDD}
N 6160 -1970 6170 -1980 {
lab=col_n[21]}
N 6170 -2180 6170 -1980 {
lab=col_n[21]}
N 6160 -2190 6170 -2180 {
lab=col_n[21]}
N 6160 -1970 6160 -1950 {
lab=col_n[21]}
N 6160 -2210 6160 -2190 {
lab=col_n[21]}
N 6040 -2110 6050 -2120 {
lab=row_n[3]}
N 6050 -2120 6250 -2120 {
lab=row_n[3]}
N 6250 -2120 6260 -2110 {
lab=row_n[3]}
N 6040 -2090 6050 -2100 {
lab=rowon_n[3]}
N 6050 -2100 6250 -2100 {
lab=rowon_n[3]}
N 6250 -2100 6260 -2090 {
lab=rowon_n[3]}
N 6040 -2070 6050 -2080 {
lab=#net7}
N 6050 -2080 6250 -2080 {
lab=#net7}
N 6250 -2080 6260 -2070 {
lab=#net7}
N 6040 -2050 6050 -2060 {
lab=#net8}
N 6050 -2060 6250 -2060 {
lab=#net8}
N 6250 -2060 6260 -2050 {
lab=#net8}
N 6100 -2210 6100 -2190 {
lab=vcm}
N 6140 -2210 6140 -2190 {
lab=ctop}
N 6020 -2110 6040 -2110 {
lab=row_n[3]}
N 6020 -2090 6040 -2090 {
lab=rowon_n[3]}
N 6020 -2070 6040 -2070 {
lab=#net7}
N 6020 -2050 6040 -2050 {
lab=#net8}
N 6260 -2050 6280 -2050 {
lab=#net8}
N 6260 -2070 6280 -2070 {
lab=#net7}
N 6260 -2090 6280 -2090 {
lab=rowon_n[3]}
N 6260 -2110 6280 -2110 {
lab=row_n[3]}
N 6080 -1970 6080 -1960 {
lab=VSS}
N 6080 -2200 6080 -2190 {
lab=VDD}
N 6420 -1970 6430 -1980 {
lab=col_n[22]}
N 6430 -2180 6430 -1980 {
lab=col_n[22]}
N 6420 -2190 6430 -2180 {
lab=col_n[22]}
N 6420 -1970 6420 -1950 {
lab=col_n[22]}
N 6420 -2210 6420 -2190 {
lab=col_n[22]}
N 6300 -2110 6310 -2120 {
lab=row_n[3]}
N 6310 -2120 6510 -2120 {
lab=row_n[3]}
N 6510 -2120 6520 -2110 {
lab=row_n[3]}
N 6300 -2090 6310 -2100 {
lab=rowon_n[3]}
N 6310 -2100 6510 -2100 {
lab=rowon_n[3]}
N 6510 -2100 6520 -2090 {
lab=rowon_n[3]}
N 6300 -2070 6310 -2080 {
lab=#net7}
N 6310 -2080 6510 -2080 {
lab=#net7}
N 6510 -2080 6520 -2070 {
lab=#net7}
N 6300 -2050 6310 -2060 {
lab=#net8}
N 6310 -2060 6510 -2060 {
lab=#net8}
N 6510 -2060 6520 -2050 {
lab=#net8}
N 6360 -2210 6360 -2190 {
lab=vcm}
N 6400 -2210 6400 -2190 {
lab=ctop}
N 6280 -2110 6300 -2110 {
lab=row_n[3]}
N 6280 -2090 6300 -2090 {
lab=rowon_n[3]}
N 6280 -2070 6300 -2070 {
lab=#net7}
N 6280 -2050 6300 -2050 {
lab=#net8}
N 6520 -2050 6540 -2050 {
lab=#net8}
N 6520 -2070 6540 -2070 {
lab=#net7}
N 6520 -2090 6540 -2090 {
lab=rowon_n[3]}
N 6520 -2110 6540 -2110 {
lab=row_n[3]}
N 6340 -1970 6340 -1960 {
lab=VSS}
N 6340 -2200 6340 -2190 {
lab=VDD}
N 6680 -1970 6690 -1980 {
lab=col_n[23]}
N 6690 -2180 6690 -1980 {
lab=col_n[23]}
N 6680 -2190 6690 -2180 {
lab=col_n[23]}
N 6680 -1970 6680 -1950 {
lab=col_n[23]}
N 6680 -2210 6680 -2190 {
lab=col_n[23]}
N 6560 -2110 6570 -2120 {
lab=row_n[3]}
N 6570 -2120 6770 -2120 {
lab=row_n[3]}
N 6770 -2120 6780 -2110 {
lab=row_n[3]}
N 6560 -2090 6570 -2100 {
lab=rowon_n[3]}
N 6570 -2100 6770 -2100 {
lab=rowon_n[3]}
N 6770 -2100 6780 -2090 {
lab=rowon_n[3]}
N 6560 -2070 6570 -2080 {
lab=#net7}
N 6570 -2080 6770 -2080 {
lab=#net7}
N 6770 -2080 6780 -2070 {
lab=#net7}
N 6560 -2050 6570 -2060 {
lab=#net8}
N 6570 -2060 6770 -2060 {
lab=#net8}
N 6770 -2060 6780 -2050 {
lab=#net8}
N 6620 -2210 6620 -2190 {
lab=vcm}
N 6660 -2210 6660 -2190 {
lab=ctop}
N 6540 -2110 6560 -2110 {
lab=row_n[3]}
N 6540 -2090 6560 -2090 {
lab=rowon_n[3]}
N 6540 -2070 6560 -2070 {
lab=#net7}
N 6540 -2050 6560 -2050 {
lab=#net8}
N 6780 -2050 6800 -2050 {
lab=#net8}
N 6780 -2070 6800 -2070 {
lab=#net7}
N 6780 -2090 6800 -2090 {
lab=rowon_n[3]}
N 6780 -2110 6800 -2110 {
lab=row_n[3]}
N 6600 -1970 6600 -1960 {
lab=VSS}
N 6600 -2200 6600 -2190 {
lab=VDD}
N 6940 -1970 6950 -1980 {
lab=col_n[24]}
N 6950 -2180 6950 -1980 {
lab=col_n[24]}
N 6940 -2190 6950 -2180 {
lab=col_n[24]}
N 6940 -1970 6940 -1950 {
lab=col_n[24]}
N 6940 -2210 6940 -2190 {
lab=col_n[24]}
N 6820 -2110 6830 -2120 {
lab=row_n[3]}
N 6830 -2120 7030 -2120 {
lab=row_n[3]}
N 7030 -2120 7040 -2110 {
lab=row_n[3]}
N 6820 -2090 6830 -2100 {
lab=rowon_n[3]}
N 6830 -2100 7030 -2100 {
lab=rowon_n[3]}
N 7030 -2100 7040 -2090 {
lab=rowon_n[3]}
N 6820 -2070 6830 -2080 {
lab=#net7}
N 6830 -2080 7030 -2080 {
lab=#net7}
N 7030 -2080 7040 -2070 {
lab=#net7}
N 6820 -2050 6830 -2060 {
lab=#net8}
N 6830 -2060 7030 -2060 {
lab=#net8}
N 7030 -2060 7040 -2050 {
lab=#net8}
N 6880 -2210 6880 -2190 {
lab=vcm}
N 6920 -2210 6920 -2190 {
lab=ctop}
N 6800 -2110 6820 -2110 {
lab=row_n[3]}
N 6800 -2090 6820 -2090 {
lab=rowon_n[3]}
N 6800 -2070 6820 -2070 {
lab=#net7}
N 6800 -2050 6820 -2050 {
lab=#net8}
N 7040 -2050 7060 -2050 {
lab=#net8}
N 7040 -2070 7060 -2070 {
lab=#net7}
N 7040 -2090 7060 -2090 {
lab=rowon_n[3]}
N 7040 -2110 7060 -2110 {
lab=row_n[3]}
N 6860 -1970 6860 -1960 {
lab=VSS}
N 6860 -2200 6860 -2190 {
lab=VDD}
N 7200 -1970 7210 -1980 {
lab=col_n[25]}
N 7210 -2180 7210 -1980 {
lab=col_n[25]}
N 7200 -2190 7210 -2180 {
lab=col_n[25]}
N 7200 -1970 7200 -1950 {
lab=col_n[25]}
N 7200 -2210 7200 -2190 {
lab=col_n[25]}
N 7080 -2110 7090 -2120 {
lab=row_n[3]}
N 7090 -2120 7290 -2120 {
lab=row_n[3]}
N 7290 -2120 7300 -2110 {
lab=row_n[3]}
N 7080 -2090 7090 -2100 {
lab=rowon_n[3]}
N 7090 -2100 7290 -2100 {
lab=rowon_n[3]}
N 7290 -2100 7300 -2090 {
lab=rowon_n[3]}
N 7080 -2070 7090 -2080 {
lab=#net7}
N 7090 -2080 7290 -2080 {
lab=#net7}
N 7290 -2080 7300 -2070 {
lab=#net7}
N 7080 -2050 7090 -2060 {
lab=#net8}
N 7090 -2060 7290 -2060 {
lab=#net8}
N 7290 -2060 7300 -2050 {
lab=#net8}
N 7140 -2210 7140 -2190 {
lab=vcm}
N 7180 -2210 7180 -2190 {
lab=ctop}
N 7060 -2110 7080 -2110 {
lab=row_n[3]}
N 7060 -2090 7080 -2090 {
lab=rowon_n[3]}
N 7060 -2070 7080 -2070 {
lab=#net7}
N 7060 -2050 7080 -2050 {
lab=#net8}
N 7300 -2050 7320 -2050 {
lab=#net8}
N 7300 -2070 7320 -2070 {
lab=#net7}
N 7300 -2090 7320 -2090 {
lab=rowon_n[3]}
N 7300 -2110 7320 -2110 {
lab=row_n[3]}
N 7120 -1970 7120 -1960 {
lab=VSS}
N 7120 -2200 7120 -2190 {
lab=VDD}
N 7460 -1970 7470 -1980 {
lab=col_n[26]}
N 7470 -2180 7470 -1980 {
lab=col_n[26]}
N 7460 -2190 7470 -2180 {
lab=col_n[26]}
N 7460 -1970 7460 -1950 {
lab=col_n[26]}
N 7460 -2210 7460 -2190 {
lab=col_n[26]}
N 7340 -2110 7350 -2120 {
lab=row_n[3]}
N 7350 -2120 7550 -2120 {
lab=row_n[3]}
N 7550 -2120 7560 -2110 {
lab=row_n[3]}
N 7340 -2090 7350 -2100 {
lab=rowon_n[3]}
N 7350 -2100 7550 -2100 {
lab=rowon_n[3]}
N 7550 -2100 7560 -2090 {
lab=rowon_n[3]}
N 7340 -2070 7350 -2080 {
lab=#net7}
N 7350 -2080 7550 -2080 {
lab=#net7}
N 7550 -2080 7560 -2070 {
lab=#net7}
N 7340 -2050 7350 -2060 {
lab=#net8}
N 7350 -2060 7550 -2060 {
lab=#net8}
N 7550 -2060 7560 -2050 {
lab=#net8}
N 7400 -2210 7400 -2190 {
lab=vcm}
N 7440 -2210 7440 -2190 {
lab=ctop}
N 7320 -2110 7340 -2110 {
lab=row_n[3]}
N 7320 -2090 7340 -2090 {
lab=rowon_n[3]}
N 7320 -2070 7340 -2070 {
lab=#net7}
N 7320 -2050 7340 -2050 {
lab=#net8}
N 7560 -2050 7580 -2050 {
lab=#net8}
N 7560 -2070 7580 -2070 {
lab=#net7}
N 7560 -2090 7580 -2090 {
lab=rowon_n[3]}
N 7560 -2110 7580 -2110 {
lab=row_n[3]}
N 7380 -1970 7380 -1960 {
lab=VSS}
N 7380 -2200 7380 -2190 {
lab=VDD}
N 7720 -1970 7730 -1980 {
lab=col_n[27]}
N 7730 -2180 7730 -1980 {
lab=col_n[27]}
N 7720 -2190 7730 -2180 {
lab=col_n[27]}
N 7720 -1970 7720 -1950 {
lab=col_n[27]}
N 7720 -2210 7720 -2190 {
lab=col_n[27]}
N 7600 -2110 7610 -2120 {
lab=row_n[3]}
N 7610 -2120 7810 -2120 {
lab=row_n[3]}
N 7810 -2120 7820 -2110 {
lab=row_n[3]}
N 7600 -2090 7610 -2100 {
lab=rowon_n[3]}
N 7610 -2100 7810 -2100 {
lab=rowon_n[3]}
N 7810 -2100 7820 -2090 {
lab=rowon_n[3]}
N 7600 -2070 7610 -2080 {
lab=#net7}
N 7610 -2080 7810 -2080 {
lab=#net7}
N 7810 -2080 7820 -2070 {
lab=#net7}
N 7600 -2050 7610 -2060 {
lab=#net8}
N 7610 -2060 7810 -2060 {
lab=#net8}
N 7810 -2060 7820 -2050 {
lab=#net8}
N 7660 -2210 7660 -2190 {
lab=vcm}
N 7700 -2210 7700 -2190 {
lab=ctop}
N 7580 -2110 7600 -2110 {
lab=row_n[3]}
N 7580 -2090 7600 -2090 {
lab=rowon_n[3]}
N 7580 -2070 7600 -2070 {
lab=#net7}
N 7580 -2050 7600 -2050 {
lab=#net8}
N 7820 -2050 7840 -2050 {
lab=#net8}
N 7820 -2070 7840 -2070 {
lab=#net7}
N 7820 -2090 7840 -2090 {
lab=rowon_n[3]}
N 7820 -2110 7840 -2110 {
lab=row_n[3]}
N 7640 -1970 7640 -1960 {
lab=VSS}
N 7640 -2200 7640 -2190 {
lab=VDD}
N 7980 -1970 7990 -1980 {
lab=col_n[28]}
N 7990 -2180 7990 -1980 {
lab=col_n[28]}
N 7980 -2190 7990 -2180 {
lab=col_n[28]}
N 7980 -1970 7980 -1950 {
lab=col_n[28]}
N 7980 -2210 7980 -2190 {
lab=col_n[28]}
N 7860 -2110 7870 -2120 {
lab=row_n[3]}
N 7870 -2120 8070 -2120 {
lab=row_n[3]}
N 8070 -2120 8080 -2110 {
lab=row_n[3]}
N 7860 -2090 7870 -2100 {
lab=rowon_n[3]}
N 7870 -2100 8070 -2100 {
lab=rowon_n[3]}
N 8070 -2100 8080 -2090 {
lab=rowon_n[3]}
N 7860 -2070 7870 -2080 {
lab=#net7}
N 7870 -2080 8070 -2080 {
lab=#net7}
N 8070 -2080 8080 -2070 {
lab=#net7}
N 7860 -2050 7870 -2060 {
lab=#net8}
N 7870 -2060 8070 -2060 {
lab=#net8}
N 8070 -2060 8080 -2050 {
lab=#net8}
N 7920 -2210 7920 -2190 {
lab=vcm}
N 7960 -2210 7960 -2190 {
lab=ctop}
N 7840 -2110 7860 -2110 {
lab=row_n[3]}
N 7840 -2090 7860 -2090 {
lab=rowon_n[3]}
N 7840 -2070 7860 -2070 {
lab=#net7}
N 7840 -2050 7860 -2050 {
lab=#net8}
N 8080 -2050 8100 -2050 {
lab=#net8}
N 8080 -2070 8100 -2070 {
lab=#net7}
N 8080 -2090 8100 -2090 {
lab=rowon_n[3]}
N 8080 -2110 8100 -2110 {
lab=row_n[3]}
N 7900 -1970 7900 -1960 {
lab=VSS}
N 7900 -2200 7900 -2190 {
lab=VDD}
N 8240 -1970 8250 -1980 {
lab=col_n[29]}
N 8250 -2180 8250 -1980 {
lab=col_n[29]}
N 8240 -2190 8250 -2180 {
lab=col_n[29]}
N 8240 -1970 8240 -1950 {
lab=col_n[29]}
N 8240 -2210 8240 -2190 {
lab=col_n[29]}
N 8120 -2110 8130 -2120 {
lab=row_n[3]}
N 8130 -2120 8330 -2120 {
lab=row_n[3]}
N 8330 -2120 8340 -2110 {
lab=row_n[3]}
N 8120 -2090 8130 -2100 {
lab=rowon_n[3]}
N 8130 -2100 8330 -2100 {
lab=rowon_n[3]}
N 8330 -2100 8340 -2090 {
lab=rowon_n[3]}
N 8120 -2070 8130 -2080 {
lab=#net7}
N 8130 -2080 8330 -2080 {
lab=#net7}
N 8330 -2080 8340 -2070 {
lab=#net7}
N 8120 -2050 8130 -2060 {
lab=#net8}
N 8130 -2060 8330 -2060 {
lab=#net8}
N 8330 -2060 8340 -2050 {
lab=#net8}
N 8180 -2210 8180 -2190 {
lab=vcm}
N 8220 -2210 8220 -2190 {
lab=ctop}
N 8100 -2110 8120 -2110 {
lab=row_n[3]}
N 8100 -2090 8120 -2090 {
lab=rowon_n[3]}
N 8100 -2070 8120 -2070 {
lab=#net7}
N 8100 -2050 8120 -2050 {
lab=#net8}
N 8340 -2050 8360 -2050 {
lab=#net8}
N 8340 -2070 8360 -2070 {
lab=#net7}
N 8340 -2090 8360 -2090 {
lab=rowon_n[3]}
N 8340 -2110 8360 -2110 {
lab=row_n[3]}
N 8160 -1970 8160 -1960 {
lab=VSS}
N 8160 -2200 8160 -2190 {
lab=VDD}
N 8500 -1970 8510 -1980 {
lab=col_n[30]}
N 8510 -2180 8510 -1980 {
lab=col_n[30]}
N 8500 -2190 8510 -2180 {
lab=col_n[30]}
N 8500 -1970 8500 -1950 {
lab=col_n[30]}
N 8500 -2210 8500 -2190 {
lab=col_n[30]}
N 8380 -2110 8390 -2120 {
lab=row_n[3]}
N 8390 -2120 8590 -2120 {
lab=row_n[3]}
N 8590 -2120 8600 -2110 {
lab=row_n[3]}
N 8380 -2090 8390 -2100 {
lab=rowon_n[3]}
N 8390 -2100 8590 -2100 {
lab=rowon_n[3]}
N 8590 -2100 8600 -2090 {
lab=rowon_n[3]}
N 8380 -2070 8390 -2080 {
lab=#net7}
N 8390 -2080 8590 -2080 {
lab=#net7}
N 8590 -2080 8600 -2070 {
lab=#net7}
N 8380 -2050 8390 -2060 {
lab=#net8}
N 8390 -2060 8590 -2060 {
lab=#net8}
N 8590 -2060 8600 -2050 {
lab=#net8}
N 8440 -2210 8440 -2190 {
lab=vcm}
N 8480 -2210 8480 -2190 {
lab=ctop}
N 8360 -2110 8380 -2110 {
lab=row_n[3]}
N 8360 -2090 8380 -2090 {
lab=rowon_n[3]}
N 8360 -2070 8380 -2070 {
lab=#net7}
N 8360 -2050 8380 -2050 {
lab=#net8}
N 8600 -2050 8620 -2050 {
lab=#net8}
N 8600 -2070 8620 -2070 {
lab=#net7}
N 8600 -2090 8620 -2090 {
lab=rowon_n[3]}
N 8600 -2110 8620 -2110 {
lab=row_n[3]}
N 8420 -1970 8420 -1960 {
lab=VSS}
N 8420 -2200 8420 -2190 {
lab=VDD}
N 8760 -1970 8770 -1980 {
lab=col_n[31]}
N 8770 -2180 8770 -1980 {
lab=col_n[31]}
N 8760 -2190 8770 -2180 {
lab=col_n[31]}
N 8760 -1970 8760 -1950 {
lab=col_n[31]}
N 8760 -2210 8760 -2190 {
lab=col_n[31]}
N 8640 -2110 8650 -2120 {
lab=row_n[3]}
N 8650 -2120 8850 -2120 {
lab=row_n[3]}
N 8850 -2120 8860 -2110 {
lab=row_n[3]}
N 8640 -2090 8650 -2100 {
lab=rowon_n[3]}
N 8650 -2100 8850 -2100 {
lab=rowon_n[3]}
N 8850 -2100 8860 -2090 {
lab=rowon_n[3]}
N 8640 -2070 8650 -2080 {
lab=#net7}
N 8650 -2080 8850 -2080 {
lab=#net7}
N 8850 -2080 8860 -2070 {
lab=#net7}
N 8640 -2050 8650 -2060 {
lab=#net8}
N 8650 -2060 8850 -2060 {
lab=#net8}
N 8850 -2060 8860 -2050 {
lab=#net8}
N 8700 -2210 8700 -2190 {
lab=vcm}
N 8740 -2210 8740 -2190 {
lab=ctop}
N 8620 -2110 8640 -2110 {
lab=row_n[3]}
N 8620 -2090 8640 -2090 {
lab=rowon_n[3]}
N 8620 -2070 8640 -2070 {
lab=#net7}
N 8620 -2050 8640 -2050 {
lab=#net8}
N 8860 -2050 8880 -2050 {
lab=#net8}
N 8860 -2070 8880 -2070 {
lab=#net7}
N 8860 -2090 8880 -2090 {
lab=rowon_n[3]}
N 8860 -2110 8880 -2110 {
lab=row_n[3]}
N 8680 -1970 8680 -1960 {
lab=VSS}
N 8680 -2200 8680 -2190 {
lab=VDD}
N 700 -2230 710 -2240 {
lab=col_n[0]}
N 710 -2440 710 -2240 {
lab=col_n[0]}
N 700 -2450 710 -2440 {
lab=col_n[0]}
N 700 -2230 700 -2210 {
lab=col_n[0]}
N 700 -2470 700 -2450 {
lab=col_n[0]}
N 580 -2370 590 -2380 {
lab=row_n[4]}
N 590 -2380 790 -2380 {
lab=row_n[4]}
N 790 -2380 800 -2370 {
lab=row_n[4]}
N 580 -2350 590 -2360 {
lab=rowon_n[4]}
N 590 -2360 790 -2360 {
lab=rowon_n[4]}
N 790 -2360 800 -2350 {
lab=rowon_n[4]}
N 580 -2330 590 -2340 {
lab=#net9}
N 590 -2340 790 -2340 {
lab=#net9}
N 790 -2340 800 -2330 {
lab=#net9}
N 580 -2310 590 -2320 {
lab=#net10}
N 590 -2320 790 -2320 {
lab=#net10}
N 790 -2320 800 -2310 {
lab=#net10}
N 640 -2470 640 -2450 {
lab=vcm}
N 680 -2470 680 -2450 {
lab=ctop}
N 560 -2370 580 -2370 {
lab=row_n[4]}
N 560 -2350 580 -2350 {
lab=rowon_n[4]}
N 560 -2330 580 -2330 {
lab=#net9}
N 560 -2310 580 -2310 {
lab=#net10}
N 800 -2310 820 -2310 {
lab=#net10}
N 800 -2330 820 -2330 {
lab=#net9}
N 800 -2350 820 -2350 {
lab=rowon_n[4]}
N 800 -2370 820 -2370 {
lab=row_n[4]}
N 620 -2230 620 -2220 {
lab=VSS}
N 620 -2460 620 -2450 {
lab=VDD}
N 960 -2230 970 -2240 {
lab=col_n[1]}
N 970 -2440 970 -2240 {
lab=col_n[1]}
N 960 -2450 970 -2440 {
lab=col_n[1]}
N 960 -2230 960 -2210 {
lab=col_n[1]}
N 960 -2470 960 -2450 {
lab=col_n[1]}
N 840 -2370 850 -2380 {
lab=row_n[4]}
N 850 -2380 1050 -2380 {
lab=row_n[4]}
N 1050 -2380 1060 -2370 {
lab=row_n[4]}
N 840 -2350 850 -2360 {
lab=rowon_n[4]}
N 850 -2360 1050 -2360 {
lab=rowon_n[4]}
N 1050 -2360 1060 -2350 {
lab=rowon_n[4]}
N 840 -2330 850 -2340 {
lab=#net9}
N 850 -2340 1050 -2340 {
lab=#net9}
N 1050 -2340 1060 -2330 {
lab=#net9}
N 840 -2310 850 -2320 {
lab=#net10}
N 850 -2320 1050 -2320 {
lab=#net10}
N 1050 -2320 1060 -2310 {
lab=#net10}
N 900 -2470 900 -2450 {
lab=vcm}
N 940 -2470 940 -2450 {
lab=ctop}
N 820 -2370 840 -2370 {
lab=row_n[4]}
N 820 -2350 840 -2350 {
lab=rowon_n[4]}
N 820 -2330 840 -2330 {
lab=#net9}
N 820 -2310 840 -2310 {
lab=#net10}
N 1060 -2310 1080 -2310 {
lab=#net10}
N 1060 -2330 1080 -2330 {
lab=#net9}
N 1060 -2350 1080 -2350 {
lab=rowon_n[4]}
N 1060 -2370 1080 -2370 {
lab=row_n[4]}
N 880 -2230 880 -2220 {
lab=VSS}
N 880 -2460 880 -2450 {
lab=VDD}
N 1220 -2230 1230 -2240 {
lab=col_n[2]}
N 1230 -2440 1230 -2240 {
lab=col_n[2]}
N 1220 -2450 1230 -2440 {
lab=col_n[2]}
N 1220 -2230 1220 -2210 {
lab=col_n[2]}
N 1220 -2470 1220 -2450 {
lab=col_n[2]}
N 1100 -2370 1110 -2380 {
lab=row_n[4]}
N 1110 -2380 1310 -2380 {
lab=row_n[4]}
N 1310 -2380 1320 -2370 {
lab=row_n[4]}
N 1100 -2350 1110 -2360 {
lab=rowon_n[4]}
N 1110 -2360 1310 -2360 {
lab=rowon_n[4]}
N 1310 -2360 1320 -2350 {
lab=rowon_n[4]}
N 1100 -2330 1110 -2340 {
lab=#net9}
N 1110 -2340 1310 -2340 {
lab=#net9}
N 1310 -2340 1320 -2330 {
lab=#net9}
N 1100 -2310 1110 -2320 {
lab=#net10}
N 1110 -2320 1310 -2320 {
lab=#net10}
N 1310 -2320 1320 -2310 {
lab=#net10}
N 1160 -2470 1160 -2450 {
lab=vcm}
N 1200 -2470 1200 -2450 {
lab=ctop}
N 1080 -2370 1100 -2370 {
lab=row_n[4]}
N 1080 -2350 1100 -2350 {
lab=rowon_n[4]}
N 1080 -2330 1100 -2330 {
lab=#net9}
N 1080 -2310 1100 -2310 {
lab=#net10}
N 1320 -2310 1340 -2310 {
lab=#net10}
N 1320 -2330 1340 -2330 {
lab=#net9}
N 1320 -2350 1340 -2350 {
lab=rowon_n[4]}
N 1320 -2370 1340 -2370 {
lab=row_n[4]}
N 1140 -2230 1140 -2220 {
lab=VSS}
N 1140 -2460 1140 -2450 {
lab=VDD}
N 1480 -2230 1490 -2240 {
lab=col_n[3]}
N 1490 -2440 1490 -2240 {
lab=col_n[3]}
N 1480 -2450 1490 -2440 {
lab=col_n[3]}
N 1480 -2230 1480 -2210 {
lab=col_n[3]}
N 1480 -2470 1480 -2450 {
lab=col_n[3]}
N 1360 -2370 1370 -2380 {
lab=row_n[4]}
N 1370 -2380 1570 -2380 {
lab=row_n[4]}
N 1570 -2380 1580 -2370 {
lab=row_n[4]}
N 1360 -2350 1370 -2360 {
lab=rowon_n[4]}
N 1370 -2360 1570 -2360 {
lab=rowon_n[4]}
N 1570 -2360 1580 -2350 {
lab=rowon_n[4]}
N 1360 -2330 1370 -2340 {
lab=#net9}
N 1370 -2340 1570 -2340 {
lab=#net9}
N 1570 -2340 1580 -2330 {
lab=#net9}
N 1360 -2310 1370 -2320 {
lab=#net10}
N 1370 -2320 1570 -2320 {
lab=#net10}
N 1570 -2320 1580 -2310 {
lab=#net10}
N 1420 -2470 1420 -2450 {
lab=vcm}
N 1460 -2470 1460 -2450 {
lab=ctop}
N 1340 -2370 1360 -2370 {
lab=row_n[4]}
N 1340 -2350 1360 -2350 {
lab=rowon_n[4]}
N 1340 -2330 1360 -2330 {
lab=#net9}
N 1340 -2310 1360 -2310 {
lab=#net10}
N 1580 -2310 1600 -2310 {
lab=#net10}
N 1580 -2330 1600 -2330 {
lab=#net9}
N 1580 -2350 1600 -2350 {
lab=rowon_n[4]}
N 1580 -2370 1600 -2370 {
lab=row_n[4]}
N 1400 -2230 1400 -2220 {
lab=VSS}
N 1400 -2460 1400 -2450 {
lab=VDD}
N 1740 -2230 1750 -2240 {
lab=col_n[4]}
N 1750 -2440 1750 -2240 {
lab=col_n[4]}
N 1740 -2450 1750 -2440 {
lab=col_n[4]}
N 1740 -2230 1740 -2210 {
lab=col_n[4]}
N 1740 -2470 1740 -2450 {
lab=col_n[4]}
N 1620 -2370 1630 -2380 {
lab=row_n[4]}
N 1630 -2380 1830 -2380 {
lab=row_n[4]}
N 1830 -2380 1840 -2370 {
lab=row_n[4]}
N 1620 -2350 1630 -2360 {
lab=rowon_n[4]}
N 1630 -2360 1830 -2360 {
lab=rowon_n[4]}
N 1830 -2360 1840 -2350 {
lab=rowon_n[4]}
N 1620 -2330 1630 -2340 {
lab=#net9}
N 1630 -2340 1830 -2340 {
lab=#net9}
N 1830 -2340 1840 -2330 {
lab=#net9}
N 1620 -2310 1630 -2320 {
lab=#net10}
N 1630 -2320 1830 -2320 {
lab=#net10}
N 1830 -2320 1840 -2310 {
lab=#net10}
N 1680 -2470 1680 -2450 {
lab=vcm}
N 1720 -2470 1720 -2450 {
lab=ctop}
N 1600 -2370 1620 -2370 {
lab=row_n[4]}
N 1600 -2350 1620 -2350 {
lab=rowon_n[4]}
N 1600 -2330 1620 -2330 {
lab=#net9}
N 1600 -2310 1620 -2310 {
lab=#net10}
N 1840 -2310 1860 -2310 {
lab=#net10}
N 1840 -2330 1860 -2330 {
lab=#net9}
N 1840 -2350 1860 -2350 {
lab=rowon_n[4]}
N 1840 -2370 1860 -2370 {
lab=row_n[4]}
N 1660 -2230 1660 -2220 {
lab=VSS}
N 1660 -2460 1660 -2450 {
lab=VDD}
N 2000 -2230 2010 -2240 {
lab=col_n[5]}
N 2010 -2440 2010 -2240 {
lab=col_n[5]}
N 2000 -2450 2010 -2440 {
lab=col_n[5]}
N 2000 -2230 2000 -2210 {
lab=col_n[5]}
N 2000 -2470 2000 -2450 {
lab=col_n[5]}
N 1880 -2370 1890 -2380 {
lab=row_n[4]}
N 1890 -2380 2090 -2380 {
lab=row_n[4]}
N 2090 -2380 2100 -2370 {
lab=row_n[4]}
N 1880 -2350 1890 -2360 {
lab=rowon_n[4]}
N 1890 -2360 2090 -2360 {
lab=rowon_n[4]}
N 2090 -2360 2100 -2350 {
lab=rowon_n[4]}
N 1880 -2330 1890 -2340 {
lab=#net9}
N 1890 -2340 2090 -2340 {
lab=#net9}
N 2090 -2340 2100 -2330 {
lab=#net9}
N 1880 -2310 1890 -2320 {
lab=#net10}
N 1890 -2320 2090 -2320 {
lab=#net10}
N 2090 -2320 2100 -2310 {
lab=#net10}
N 1940 -2470 1940 -2450 {
lab=vcm}
N 1980 -2470 1980 -2450 {
lab=ctop}
N 1860 -2370 1880 -2370 {
lab=row_n[4]}
N 1860 -2350 1880 -2350 {
lab=rowon_n[4]}
N 1860 -2330 1880 -2330 {
lab=#net9}
N 1860 -2310 1880 -2310 {
lab=#net10}
N 2100 -2310 2120 -2310 {
lab=#net10}
N 2100 -2330 2120 -2330 {
lab=#net9}
N 2100 -2350 2120 -2350 {
lab=rowon_n[4]}
N 2100 -2370 2120 -2370 {
lab=row_n[4]}
N 1920 -2230 1920 -2220 {
lab=VSS}
N 1920 -2460 1920 -2450 {
lab=VDD}
N 2260 -2230 2270 -2240 {
lab=col_n[6]}
N 2270 -2440 2270 -2240 {
lab=col_n[6]}
N 2260 -2450 2270 -2440 {
lab=col_n[6]}
N 2260 -2230 2260 -2210 {
lab=col_n[6]}
N 2260 -2470 2260 -2450 {
lab=col_n[6]}
N 2140 -2370 2150 -2380 {
lab=row_n[4]}
N 2150 -2380 2350 -2380 {
lab=row_n[4]}
N 2350 -2380 2360 -2370 {
lab=row_n[4]}
N 2140 -2350 2150 -2360 {
lab=rowon_n[4]}
N 2150 -2360 2350 -2360 {
lab=rowon_n[4]}
N 2350 -2360 2360 -2350 {
lab=rowon_n[4]}
N 2140 -2330 2150 -2340 {
lab=#net9}
N 2150 -2340 2350 -2340 {
lab=#net9}
N 2350 -2340 2360 -2330 {
lab=#net9}
N 2140 -2310 2150 -2320 {
lab=#net10}
N 2150 -2320 2350 -2320 {
lab=#net10}
N 2350 -2320 2360 -2310 {
lab=#net10}
N 2200 -2470 2200 -2450 {
lab=vcm}
N 2240 -2470 2240 -2450 {
lab=ctop}
N 2120 -2370 2140 -2370 {
lab=row_n[4]}
N 2120 -2350 2140 -2350 {
lab=rowon_n[4]}
N 2120 -2330 2140 -2330 {
lab=#net9}
N 2120 -2310 2140 -2310 {
lab=#net10}
N 2360 -2310 2380 -2310 {
lab=#net10}
N 2360 -2330 2380 -2330 {
lab=#net9}
N 2360 -2350 2380 -2350 {
lab=rowon_n[4]}
N 2360 -2370 2380 -2370 {
lab=row_n[4]}
N 2180 -2230 2180 -2220 {
lab=VSS}
N 2180 -2460 2180 -2450 {
lab=VDD}
N 2520 -2230 2530 -2240 {
lab=col_n[7]}
N 2530 -2440 2530 -2240 {
lab=col_n[7]}
N 2520 -2450 2530 -2440 {
lab=col_n[7]}
N 2520 -2230 2520 -2210 {
lab=col_n[7]}
N 2520 -2470 2520 -2450 {
lab=col_n[7]}
N 2400 -2370 2410 -2380 {
lab=row_n[4]}
N 2410 -2380 2610 -2380 {
lab=row_n[4]}
N 2610 -2380 2620 -2370 {
lab=row_n[4]}
N 2400 -2350 2410 -2360 {
lab=rowon_n[4]}
N 2410 -2360 2610 -2360 {
lab=rowon_n[4]}
N 2610 -2360 2620 -2350 {
lab=rowon_n[4]}
N 2400 -2330 2410 -2340 {
lab=#net9}
N 2410 -2340 2610 -2340 {
lab=#net9}
N 2610 -2340 2620 -2330 {
lab=#net9}
N 2400 -2310 2410 -2320 {
lab=#net10}
N 2410 -2320 2610 -2320 {
lab=#net10}
N 2610 -2320 2620 -2310 {
lab=#net10}
N 2460 -2470 2460 -2450 {
lab=vcm}
N 2500 -2470 2500 -2450 {
lab=ctop}
N 2380 -2370 2400 -2370 {
lab=row_n[4]}
N 2380 -2350 2400 -2350 {
lab=rowon_n[4]}
N 2380 -2330 2400 -2330 {
lab=#net9}
N 2380 -2310 2400 -2310 {
lab=#net10}
N 2620 -2310 2640 -2310 {
lab=#net10}
N 2620 -2330 2640 -2330 {
lab=#net9}
N 2620 -2350 2640 -2350 {
lab=rowon_n[4]}
N 2620 -2370 2640 -2370 {
lab=row_n[4]}
N 2440 -2230 2440 -2220 {
lab=VSS}
N 2440 -2460 2440 -2450 {
lab=VDD}
N 2780 -2230 2790 -2240 {
lab=col_n[8]}
N 2790 -2440 2790 -2240 {
lab=col_n[8]}
N 2780 -2450 2790 -2440 {
lab=col_n[8]}
N 2780 -2230 2780 -2210 {
lab=col_n[8]}
N 2780 -2470 2780 -2450 {
lab=col_n[8]}
N 2660 -2370 2670 -2380 {
lab=row_n[4]}
N 2670 -2380 2870 -2380 {
lab=row_n[4]}
N 2870 -2380 2880 -2370 {
lab=row_n[4]}
N 2660 -2350 2670 -2360 {
lab=rowon_n[4]}
N 2670 -2360 2870 -2360 {
lab=rowon_n[4]}
N 2870 -2360 2880 -2350 {
lab=rowon_n[4]}
N 2660 -2330 2670 -2340 {
lab=#net9}
N 2670 -2340 2870 -2340 {
lab=#net9}
N 2870 -2340 2880 -2330 {
lab=#net9}
N 2660 -2310 2670 -2320 {
lab=#net10}
N 2670 -2320 2870 -2320 {
lab=#net10}
N 2870 -2320 2880 -2310 {
lab=#net10}
N 2720 -2470 2720 -2450 {
lab=vcm}
N 2760 -2470 2760 -2450 {
lab=ctop}
N 2640 -2370 2660 -2370 {
lab=row_n[4]}
N 2640 -2350 2660 -2350 {
lab=rowon_n[4]}
N 2640 -2330 2660 -2330 {
lab=#net9}
N 2640 -2310 2660 -2310 {
lab=#net10}
N 2880 -2310 2900 -2310 {
lab=#net10}
N 2880 -2330 2900 -2330 {
lab=#net9}
N 2880 -2350 2900 -2350 {
lab=rowon_n[4]}
N 2880 -2370 2900 -2370 {
lab=row_n[4]}
N 2700 -2230 2700 -2220 {
lab=VSS}
N 2700 -2460 2700 -2450 {
lab=VDD}
N 3040 -2230 3050 -2240 {
lab=col_n[9]}
N 3050 -2440 3050 -2240 {
lab=col_n[9]}
N 3040 -2450 3050 -2440 {
lab=col_n[9]}
N 3040 -2230 3040 -2210 {
lab=col_n[9]}
N 3040 -2470 3040 -2450 {
lab=col_n[9]}
N 2920 -2370 2930 -2380 {
lab=row_n[4]}
N 2930 -2380 3130 -2380 {
lab=row_n[4]}
N 3130 -2380 3140 -2370 {
lab=row_n[4]}
N 2920 -2350 2930 -2360 {
lab=rowon_n[4]}
N 2930 -2360 3130 -2360 {
lab=rowon_n[4]}
N 3130 -2360 3140 -2350 {
lab=rowon_n[4]}
N 2920 -2330 2930 -2340 {
lab=#net9}
N 2930 -2340 3130 -2340 {
lab=#net9}
N 3130 -2340 3140 -2330 {
lab=#net9}
N 2920 -2310 2930 -2320 {
lab=#net10}
N 2930 -2320 3130 -2320 {
lab=#net10}
N 3130 -2320 3140 -2310 {
lab=#net10}
N 2980 -2470 2980 -2450 {
lab=vcm}
N 3020 -2470 3020 -2450 {
lab=ctop}
N 2900 -2370 2920 -2370 {
lab=row_n[4]}
N 2900 -2350 2920 -2350 {
lab=rowon_n[4]}
N 2900 -2330 2920 -2330 {
lab=#net9}
N 2900 -2310 2920 -2310 {
lab=#net10}
N 3140 -2310 3160 -2310 {
lab=#net10}
N 3140 -2330 3160 -2330 {
lab=#net9}
N 3140 -2350 3160 -2350 {
lab=rowon_n[4]}
N 3140 -2370 3160 -2370 {
lab=row_n[4]}
N 2960 -2230 2960 -2220 {
lab=VSS}
N 2960 -2460 2960 -2450 {
lab=VDD}
N 3300 -2230 3310 -2240 {
lab=col_n[10]}
N 3310 -2440 3310 -2240 {
lab=col_n[10]}
N 3300 -2450 3310 -2440 {
lab=col_n[10]}
N 3300 -2230 3300 -2210 {
lab=col_n[10]}
N 3300 -2470 3300 -2450 {
lab=col_n[10]}
N 3180 -2370 3190 -2380 {
lab=row_n[4]}
N 3190 -2380 3390 -2380 {
lab=row_n[4]}
N 3390 -2380 3400 -2370 {
lab=row_n[4]}
N 3180 -2350 3190 -2360 {
lab=rowon_n[4]}
N 3190 -2360 3390 -2360 {
lab=rowon_n[4]}
N 3390 -2360 3400 -2350 {
lab=rowon_n[4]}
N 3180 -2330 3190 -2340 {
lab=#net9}
N 3190 -2340 3390 -2340 {
lab=#net9}
N 3390 -2340 3400 -2330 {
lab=#net9}
N 3180 -2310 3190 -2320 {
lab=#net10}
N 3190 -2320 3390 -2320 {
lab=#net10}
N 3390 -2320 3400 -2310 {
lab=#net10}
N 3240 -2470 3240 -2450 {
lab=vcm}
N 3280 -2470 3280 -2450 {
lab=ctop}
N 3160 -2370 3180 -2370 {
lab=row_n[4]}
N 3160 -2350 3180 -2350 {
lab=rowon_n[4]}
N 3160 -2330 3180 -2330 {
lab=#net9}
N 3160 -2310 3180 -2310 {
lab=#net10}
N 3400 -2310 3420 -2310 {
lab=#net10}
N 3400 -2330 3420 -2330 {
lab=#net9}
N 3400 -2350 3420 -2350 {
lab=rowon_n[4]}
N 3400 -2370 3420 -2370 {
lab=row_n[4]}
N 3220 -2230 3220 -2220 {
lab=VSS}
N 3220 -2460 3220 -2450 {
lab=VDD}
N 3560 -2230 3570 -2240 {
lab=col_n[11]}
N 3570 -2440 3570 -2240 {
lab=col_n[11]}
N 3560 -2450 3570 -2440 {
lab=col_n[11]}
N 3560 -2230 3560 -2210 {
lab=col_n[11]}
N 3560 -2470 3560 -2450 {
lab=col_n[11]}
N 3440 -2370 3450 -2380 {
lab=row_n[4]}
N 3450 -2380 3650 -2380 {
lab=row_n[4]}
N 3650 -2380 3660 -2370 {
lab=row_n[4]}
N 3440 -2350 3450 -2360 {
lab=rowon_n[4]}
N 3450 -2360 3650 -2360 {
lab=rowon_n[4]}
N 3650 -2360 3660 -2350 {
lab=rowon_n[4]}
N 3440 -2330 3450 -2340 {
lab=#net9}
N 3450 -2340 3650 -2340 {
lab=#net9}
N 3650 -2340 3660 -2330 {
lab=#net9}
N 3440 -2310 3450 -2320 {
lab=#net10}
N 3450 -2320 3650 -2320 {
lab=#net10}
N 3650 -2320 3660 -2310 {
lab=#net10}
N 3500 -2470 3500 -2450 {
lab=vcm}
N 3540 -2470 3540 -2450 {
lab=ctop}
N 3420 -2370 3440 -2370 {
lab=row_n[4]}
N 3420 -2350 3440 -2350 {
lab=rowon_n[4]}
N 3420 -2330 3440 -2330 {
lab=#net9}
N 3420 -2310 3440 -2310 {
lab=#net10}
N 3660 -2310 3680 -2310 {
lab=#net10}
N 3660 -2330 3680 -2330 {
lab=#net9}
N 3660 -2350 3680 -2350 {
lab=rowon_n[4]}
N 3660 -2370 3680 -2370 {
lab=row_n[4]}
N 3480 -2230 3480 -2220 {
lab=VSS}
N 3480 -2460 3480 -2450 {
lab=VDD}
N 3820 -2230 3830 -2240 {
lab=col_n[12]}
N 3830 -2440 3830 -2240 {
lab=col_n[12]}
N 3820 -2450 3830 -2440 {
lab=col_n[12]}
N 3820 -2230 3820 -2210 {
lab=col_n[12]}
N 3820 -2470 3820 -2450 {
lab=col_n[12]}
N 3700 -2370 3710 -2380 {
lab=row_n[4]}
N 3710 -2380 3910 -2380 {
lab=row_n[4]}
N 3910 -2380 3920 -2370 {
lab=row_n[4]}
N 3700 -2350 3710 -2360 {
lab=rowon_n[4]}
N 3710 -2360 3910 -2360 {
lab=rowon_n[4]}
N 3910 -2360 3920 -2350 {
lab=rowon_n[4]}
N 3700 -2330 3710 -2340 {
lab=#net9}
N 3710 -2340 3910 -2340 {
lab=#net9}
N 3910 -2340 3920 -2330 {
lab=#net9}
N 3700 -2310 3710 -2320 {
lab=#net10}
N 3710 -2320 3910 -2320 {
lab=#net10}
N 3910 -2320 3920 -2310 {
lab=#net10}
N 3760 -2470 3760 -2450 {
lab=vcm}
N 3800 -2470 3800 -2450 {
lab=ctop}
N 3680 -2370 3700 -2370 {
lab=row_n[4]}
N 3680 -2350 3700 -2350 {
lab=rowon_n[4]}
N 3680 -2330 3700 -2330 {
lab=#net9}
N 3680 -2310 3700 -2310 {
lab=#net10}
N 3920 -2310 3940 -2310 {
lab=#net10}
N 3920 -2330 3940 -2330 {
lab=#net9}
N 3920 -2350 3940 -2350 {
lab=rowon_n[4]}
N 3920 -2370 3940 -2370 {
lab=row_n[4]}
N 3740 -2230 3740 -2220 {
lab=VSS}
N 3740 -2460 3740 -2450 {
lab=VDD}
N 4080 -2230 4090 -2240 {
lab=col_n[13]}
N 4090 -2440 4090 -2240 {
lab=col_n[13]}
N 4080 -2450 4090 -2440 {
lab=col_n[13]}
N 4080 -2230 4080 -2210 {
lab=col_n[13]}
N 4080 -2470 4080 -2450 {
lab=col_n[13]}
N 3960 -2370 3970 -2380 {
lab=row_n[4]}
N 3970 -2380 4170 -2380 {
lab=row_n[4]}
N 4170 -2380 4180 -2370 {
lab=row_n[4]}
N 3960 -2350 3970 -2360 {
lab=rowon_n[4]}
N 3970 -2360 4170 -2360 {
lab=rowon_n[4]}
N 4170 -2360 4180 -2350 {
lab=rowon_n[4]}
N 3960 -2330 3970 -2340 {
lab=#net9}
N 3970 -2340 4170 -2340 {
lab=#net9}
N 4170 -2340 4180 -2330 {
lab=#net9}
N 3960 -2310 3970 -2320 {
lab=#net10}
N 3970 -2320 4170 -2320 {
lab=#net10}
N 4170 -2320 4180 -2310 {
lab=#net10}
N 4020 -2470 4020 -2450 {
lab=vcm}
N 4060 -2470 4060 -2450 {
lab=ctop}
N 3940 -2370 3960 -2370 {
lab=row_n[4]}
N 3940 -2350 3960 -2350 {
lab=rowon_n[4]}
N 3940 -2330 3960 -2330 {
lab=#net9}
N 3940 -2310 3960 -2310 {
lab=#net10}
N 4180 -2310 4200 -2310 {
lab=#net10}
N 4180 -2330 4200 -2330 {
lab=#net9}
N 4180 -2350 4200 -2350 {
lab=rowon_n[4]}
N 4180 -2370 4200 -2370 {
lab=row_n[4]}
N 4000 -2230 4000 -2220 {
lab=VSS}
N 4000 -2460 4000 -2450 {
lab=VDD}
N 4340 -2230 4350 -2240 {
lab=col_n[14]}
N 4350 -2440 4350 -2240 {
lab=col_n[14]}
N 4340 -2450 4350 -2440 {
lab=col_n[14]}
N 4340 -2230 4340 -2210 {
lab=col_n[14]}
N 4340 -2470 4340 -2450 {
lab=col_n[14]}
N 4220 -2370 4230 -2380 {
lab=row_n[4]}
N 4230 -2380 4430 -2380 {
lab=row_n[4]}
N 4430 -2380 4440 -2370 {
lab=row_n[4]}
N 4220 -2350 4230 -2360 {
lab=rowon_n[4]}
N 4230 -2360 4430 -2360 {
lab=rowon_n[4]}
N 4430 -2360 4440 -2350 {
lab=rowon_n[4]}
N 4220 -2330 4230 -2340 {
lab=#net9}
N 4230 -2340 4430 -2340 {
lab=#net9}
N 4430 -2340 4440 -2330 {
lab=#net9}
N 4220 -2310 4230 -2320 {
lab=#net10}
N 4230 -2320 4430 -2320 {
lab=#net10}
N 4430 -2320 4440 -2310 {
lab=#net10}
N 4280 -2470 4280 -2450 {
lab=vcm}
N 4320 -2470 4320 -2450 {
lab=ctop}
N 4200 -2370 4220 -2370 {
lab=row_n[4]}
N 4200 -2350 4220 -2350 {
lab=rowon_n[4]}
N 4200 -2330 4220 -2330 {
lab=#net9}
N 4200 -2310 4220 -2310 {
lab=#net10}
N 4440 -2310 4460 -2310 {
lab=#net10}
N 4440 -2330 4460 -2330 {
lab=#net9}
N 4440 -2350 4460 -2350 {
lab=rowon_n[4]}
N 4440 -2370 4460 -2370 {
lab=row_n[4]}
N 4260 -2230 4260 -2220 {
lab=VSS}
N 4260 -2460 4260 -2450 {
lab=VDD}
N 4600 -2230 4610 -2240 {
lab=col_n[15]}
N 4610 -2440 4610 -2240 {
lab=col_n[15]}
N 4600 -2450 4610 -2440 {
lab=col_n[15]}
N 4600 -2230 4600 -2210 {
lab=col_n[15]}
N 4600 -2470 4600 -2450 {
lab=col_n[15]}
N 4480 -2370 4490 -2380 {
lab=row_n[4]}
N 4490 -2380 4690 -2380 {
lab=row_n[4]}
N 4690 -2380 4700 -2370 {
lab=row_n[4]}
N 4480 -2350 4490 -2360 {
lab=rowon_n[4]}
N 4490 -2360 4690 -2360 {
lab=rowon_n[4]}
N 4690 -2360 4700 -2350 {
lab=rowon_n[4]}
N 4480 -2330 4490 -2340 {
lab=#net9}
N 4490 -2340 4690 -2340 {
lab=#net9}
N 4690 -2340 4700 -2330 {
lab=#net9}
N 4480 -2310 4490 -2320 {
lab=#net10}
N 4490 -2320 4690 -2320 {
lab=#net10}
N 4690 -2320 4700 -2310 {
lab=#net10}
N 4540 -2470 4540 -2450 {
lab=vcm}
N 4580 -2470 4580 -2450 {
lab=ctop}
N 4460 -2370 4480 -2370 {
lab=row_n[4]}
N 4460 -2350 4480 -2350 {
lab=rowon_n[4]}
N 4460 -2330 4480 -2330 {
lab=#net9}
N 4460 -2310 4480 -2310 {
lab=#net10}
N 4700 -2310 4720 -2310 {
lab=#net10}
N 4700 -2330 4720 -2330 {
lab=#net9}
N 4700 -2350 4720 -2350 {
lab=rowon_n[4]}
N 4700 -2370 4720 -2370 {
lab=row_n[4]}
N 4520 -2230 4520 -2220 {
lab=VSS}
N 4520 -2460 4520 -2450 {
lab=VDD}
N 4860 -2230 4870 -2240 {
lab=col_n[16]}
N 4870 -2440 4870 -2240 {
lab=col_n[16]}
N 4860 -2450 4870 -2440 {
lab=col_n[16]}
N 4860 -2230 4860 -2210 {
lab=col_n[16]}
N 4860 -2470 4860 -2450 {
lab=col_n[16]}
N 4740 -2370 4750 -2380 {
lab=row_n[4]}
N 4750 -2380 4950 -2380 {
lab=row_n[4]}
N 4950 -2380 4960 -2370 {
lab=row_n[4]}
N 4740 -2350 4750 -2360 {
lab=rowon_n[4]}
N 4750 -2360 4950 -2360 {
lab=rowon_n[4]}
N 4950 -2360 4960 -2350 {
lab=rowon_n[4]}
N 4740 -2330 4750 -2340 {
lab=#net9}
N 4750 -2340 4950 -2340 {
lab=#net9}
N 4950 -2340 4960 -2330 {
lab=#net9}
N 4740 -2310 4750 -2320 {
lab=#net10}
N 4750 -2320 4950 -2320 {
lab=#net10}
N 4950 -2320 4960 -2310 {
lab=#net10}
N 4800 -2470 4800 -2450 {
lab=vcm}
N 4840 -2470 4840 -2450 {
lab=ctop}
N 4720 -2370 4740 -2370 {
lab=row_n[4]}
N 4720 -2350 4740 -2350 {
lab=rowon_n[4]}
N 4720 -2330 4740 -2330 {
lab=#net9}
N 4720 -2310 4740 -2310 {
lab=#net10}
N 4960 -2310 4980 -2310 {
lab=#net10}
N 4960 -2330 4980 -2330 {
lab=#net9}
N 4960 -2350 4980 -2350 {
lab=rowon_n[4]}
N 4960 -2370 4980 -2370 {
lab=row_n[4]}
N 4780 -2230 4780 -2220 {
lab=VSS}
N 4780 -2460 4780 -2450 {
lab=VDD}
N 5120 -2230 5130 -2240 {
lab=col_n[17]}
N 5130 -2440 5130 -2240 {
lab=col_n[17]}
N 5120 -2450 5130 -2440 {
lab=col_n[17]}
N 5120 -2230 5120 -2210 {
lab=col_n[17]}
N 5120 -2470 5120 -2450 {
lab=col_n[17]}
N 5000 -2370 5010 -2380 {
lab=row_n[4]}
N 5010 -2380 5210 -2380 {
lab=row_n[4]}
N 5210 -2380 5220 -2370 {
lab=row_n[4]}
N 5000 -2350 5010 -2360 {
lab=rowon_n[4]}
N 5010 -2360 5210 -2360 {
lab=rowon_n[4]}
N 5210 -2360 5220 -2350 {
lab=rowon_n[4]}
N 5000 -2330 5010 -2340 {
lab=#net9}
N 5010 -2340 5210 -2340 {
lab=#net9}
N 5210 -2340 5220 -2330 {
lab=#net9}
N 5000 -2310 5010 -2320 {
lab=#net10}
N 5010 -2320 5210 -2320 {
lab=#net10}
N 5210 -2320 5220 -2310 {
lab=#net10}
N 5060 -2470 5060 -2450 {
lab=vcm}
N 5100 -2470 5100 -2450 {
lab=ctop}
N 4980 -2370 5000 -2370 {
lab=row_n[4]}
N 4980 -2350 5000 -2350 {
lab=rowon_n[4]}
N 4980 -2330 5000 -2330 {
lab=#net9}
N 4980 -2310 5000 -2310 {
lab=#net10}
N 5220 -2310 5240 -2310 {
lab=#net10}
N 5220 -2330 5240 -2330 {
lab=#net9}
N 5220 -2350 5240 -2350 {
lab=rowon_n[4]}
N 5220 -2370 5240 -2370 {
lab=row_n[4]}
N 5040 -2230 5040 -2220 {
lab=VSS}
N 5040 -2460 5040 -2450 {
lab=VDD}
N 5380 -2230 5390 -2240 {
lab=col_n[18]}
N 5390 -2440 5390 -2240 {
lab=col_n[18]}
N 5380 -2450 5390 -2440 {
lab=col_n[18]}
N 5380 -2230 5380 -2210 {
lab=col_n[18]}
N 5380 -2470 5380 -2450 {
lab=col_n[18]}
N 5260 -2370 5270 -2380 {
lab=row_n[4]}
N 5270 -2380 5470 -2380 {
lab=row_n[4]}
N 5470 -2380 5480 -2370 {
lab=row_n[4]}
N 5260 -2350 5270 -2360 {
lab=rowon_n[4]}
N 5270 -2360 5470 -2360 {
lab=rowon_n[4]}
N 5470 -2360 5480 -2350 {
lab=rowon_n[4]}
N 5260 -2330 5270 -2340 {
lab=#net9}
N 5270 -2340 5470 -2340 {
lab=#net9}
N 5470 -2340 5480 -2330 {
lab=#net9}
N 5260 -2310 5270 -2320 {
lab=#net10}
N 5270 -2320 5470 -2320 {
lab=#net10}
N 5470 -2320 5480 -2310 {
lab=#net10}
N 5320 -2470 5320 -2450 {
lab=vcm}
N 5360 -2470 5360 -2450 {
lab=ctop}
N 5240 -2370 5260 -2370 {
lab=row_n[4]}
N 5240 -2350 5260 -2350 {
lab=rowon_n[4]}
N 5240 -2330 5260 -2330 {
lab=#net9}
N 5240 -2310 5260 -2310 {
lab=#net10}
N 5480 -2310 5500 -2310 {
lab=#net10}
N 5480 -2330 5500 -2330 {
lab=#net9}
N 5480 -2350 5500 -2350 {
lab=rowon_n[4]}
N 5480 -2370 5500 -2370 {
lab=row_n[4]}
N 5300 -2230 5300 -2220 {
lab=VSS}
N 5300 -2460 5300 -2450 {
lab=VDD}
N 5640 -2230 5650 -2240 {
lab=col_n[19]}
N 5650 -2440 5650 -2240 {
lab=col_n[19]}
N 5640 -2450 5650 -2440 {
lab=col_n[19]}
N 5640 -2230 5640 -2210 {
lab=col_n[19]}
N 5640 -2470 5640 -2450 {
lab=col_n[19]}
N 5520 -2370 5530 -2380 {
lab=row_n[4]}
N 5530 -2380 5730 -2380 {
lab=row_n[4]}
N 5730 -2380 5740 -2370 {
lab=row_n[4]}
N 5520 -2350 5530 -2360 {
lab=rowon_n[4]}
N 5530 -2360 5730 -2360 {
lab=rowon_n[4]}
N 5730 -2360 5740 -2350 {
lab=rowon_n[4]}
N 5520 -2330 5530 -2340 {
lab=#net9}
N 5530 -2340 5730 -2340 {
lab=#net9}
N 5730 -2340 5740 -2330 {
lab=#net9}
N 5520 -2310 5530 -2320 {
lab=#net10}
N 5530 -2320 5730 -2320 {
lab=#net10}
N 5730 -2320 5740 -2310 {
lab=#net10}
N 5580 -2470 5580 -2450 {
lab=vcm}
N 5620 -2470 5620 -2450 {
lab=ctop}
N 5500 -2370 5520 -2370 {
lab=row_n[4]}
N 5500 -2350 5520 -2350 {
lab=rowon_n[4]}
N 5500 -2330 5520 -2330 {
lab=#net9}
N 5500 -2310 5520 -2310 {
lab=#net10}
N 5740 -2310 5760 -2310 {
lab=#net10}
N 5740 -2330 5760 -2330 {
lab=#net9}
N 5740 -2350 5760 -2350 {
lab=rowon_n[4]}
N 5740 -2370 5760 -2370 {
lab=row_n[4]}
N 5560 -2230 5560 -2220 {
lab=VSS}
N 5560 -2460 5560 -2450 {
lab=VDD}
N 5900 -2230 5910 -2240 {
lab=col_n[20]}
N 5910 -2440 5910 -2240 {
lab=col_n[20]}
N 5900 -2450 5910 -2440 {
lab=col_n[20]}
N 5900 -2230 5900 -2210 {
lab=col_n[20]}
N 5900 -2470 5900 -2450 {
lab=col_n[20]}
N 5780 -2370 5790 -2380 {
lab=row_n[4]}
N 5790 -2380 5990 -2380 {
lab=row_n[4]}
N 5990 -2380 6000 -2370 {
lab=row_n[4]}
N 5780 -2350 5790 -2360 {
lab=rowon_n[4]}
N 5790 -2360 5990 -2360 {
lab=rowon_n[4]}
N 5990 -2360 6000 -2350 {
lab=rowon_n[4]}
N 5780 -2330 5790 -2340 {
lab=#net9}
N 5790 -2340 5990 -2340 {
lab=#net9}
N 5990 -2340 6000 -2330 {
lab=#net9}
N 5780 -2310 5790 -2320 {
lab=#net10}
N 5790 -2320 5990 -2320 {
lab=#net10}
N 5990 -2320 6000 -2310 {
lab=#net10}
N 5840 -2470 5840 -2450 {
lab=vcm}
N 5880 -2470 5880 -2450 {
lab=ctop}
N 5760 -2370 5780 -2370 {
lab=row_n[4]}
N 5760 -2350 5780 -2350 {
lab=rowon_n[4]}
N 5760 -2330 5780 -2330 {
lab=#net9}
N 5760 -2310 5780 -2310 {
lab=#net10}
N 6000 -2310 6020 -2310 {
lab=#net10}
N 6000 -2330 6020 -2330 {
lab=#net9}
N 6000 -2350 6020 -2350 {
lab=rowon_n[4]}
N 6000 -2370 6020 -2370 {
lab=row_n[4]}
N 5820 -2230 5820 -2220 {
lab=VSS}
N 5820 -2460 5820 -2450 {
lab=VDD}
N 6160 -2230 6170 -2240 {
lab=col_n[21]}
N 6170 -2440 6170 -2240 {
lab=col_n[21]}
N 6160 -2450 6170 -2440 {
lab=col_n[21]}
N 6160 -2230 6160 -2210 {
lab=col_n[21]}
N 6160 -2470 6160 -2450 {
lab=col_n[21]}
N 6040 -2370 6050 -2380 {
lab=row_n[4]}
N 6050 -2380 6250 -2380 {
lab=row_n[4]}
N 6250 -2380 6260 -2370 {
lab=row_n[4]}
N 6040 -2350 6050 -2360 {
lab=rowon_n[4]}
N 6050 -2360 6250 -2360 {
lab=rowon_n[4]}
N 6250 -2360 6260 -2350 {
lab=rowon_n[4]}
N 6040 -2330 6050 -2340 {
lab=#net9}
N 6050 -2340 6250 -2340 {
lab=#net9}
N 6250 -2340 6260 -2330 {
lab=#net9}
N 6040 -2310 6050 -2320 {
lab=#net10}
N 6050 -2320 6250 -2320 {
lab=#net10}
N 6250 -2320 6260 -2310 {
lab=#net10}
N 6100 -2470 6100 -2450 {
lab=vcm}
N 6140 -2470 6140 -2450 {
lab=ctop}
N 6020 -2370 6040 -2370 {
lab=row_n[4]}
N 6020 -2350 6040 -2350 {
lab=rowon_n[4]}
N 6020 -2330 6040 -2330 {
lab=#net9}
N 6020 -2310 6040 -2310 {
lab=#net10}
N 6260 -2310 6280 -2310 {
lab=#net10}
N 6260 -2330 6280 -2330 {
lab=#net9}
N 6260 -2350 6280 -2350 {
lab=rowon_n[4]}
N 6260 -2370 6280 -2370 {
lab=row_n[4]}
N 6080 -2230 6080 -2220 {
lab=VSS}
N 6080 -2460 6080 -2450 {
lab=VDD}
N 6420 -2230 6430 -2240 {
lab=col_n[22]}
N 6430 -2440 6430 -2240 {
lab=col_n[22]}
N 6420 -2450 6430 -2440 {
lab=col_n[22]}
N 6420 -2230 6420 -2210 {
lab=col_n[22]}
N 6420 -2470 6420 -2450 {
lab=col_n[22]}
N 6300 -2370 6310 -2380 {
lab=row_n[4]}
N 6310 -2380 6510 -2380 {
lab=row_n[4]}
N 6510 -2380 6520 -2370 {
lab=row_n[4]}
N 6300 -2350 6310 -2360 {
lab=rowon_n[4]}
N 6310 -2360 6510 -2360 {
lab=rowon_n[4]}
N 6510 -2360 6520 -2350 {
lab=rowon_n[4]}
N 6300 -2330 6310 -2340 {
lab=#net9}
N 6310 -2340 6510 -2340 {
lab=#net9}
N 6510 -2340 6520 -2330 {
lab=#net9}
N 6300 -2310 6310 -2320 {
lab=#net10}
N 6310 -2320 6510 -2320 {
lab=#net10}
N 6510 -2320 6520 -2310 {
lab=#net10}
N 6360 -2470 6360 -2450 {
lab=vcm}
N 6400 -2470 6400 -2450 {
lab=ctop}
N 6280 -2370 6300 -2370 {
lab=row_n[4]}
N 6280 -2350 6300 -2350 {
lab=rowon_n[4]}
N 6280 -2330 6300 -2330 {
lab=#net9}
N 6280 -2310 6300 -2310 {
lab=#net10}
N 6520 -2310 6540 -2310 {
lab=#net10}
N 6520 -2330 6540 -2330 {
lab=#net9}
N 6520 -2350 6540 -2350 {
lab=rowon_n[4]}
N 6520 -2370 6540 -2370 {
lab=row_n[4]}
N 6340 -2230 6340 -2220 {
lab=VSS}
N 6340 -2460 6340 -2450 {
lab=VDD}
N 6680 -2230 6690 -2240 {
lab=col_n[23]}
N 6690 -2440 6690 -2240 {
lab=col_n[23]}
N 6680 -2450 6690 -2440 {
lab=col_n[23]}
N 6680 -2230 6680 -2210 {
lab=col_n[23]}
N 6680 -2470 6680 -2450 {
lab=col_n[23]}
N 6560 -2370 6570 -2380 {
lab=row_n[4]}
N 6570 -2380 6770 -2380 {
lab=row_n[4]}
N 6770 -2380 6780 -2370 {
lab=row_n[4]}
N 6560 -2350 6570 -2360 {
lab=rowon_n[4]}
N 6570 -2360 6770 -2360 {
lab=rowon_n[4]}
N 6770 -2360 6780 -2350 {
lab=rowon_n[4]}
N 6560 -2330 6570 -2340 {
lab=#net9}
N 6570 -2340 6770 -2340 {
lab=#net9}
N 6770 -2340 6780 -2330 {
lab=#net9}
N 6560 -2310 6570 -2320 {
lab=#net10}
N 6570 -2320 6770 -2320 {
lab=#net10}
N 6770 -2320 6780 -2310 {
lab=#net10}
N 6620 -2470 6620 -2450 {
lab=vcm}
N 6660 -2470 6660 -2450 {
lab=ctop}
N 6540 -2370 6560 -2370 {
lab=row_n[4]}
N 6540 -2350 6560 -2350 {
lab=rowon_n[4]}
N 6540 -2330 6560 -2330 {
lab=#net9}
N 6540 -2310 6560 -2310 {
lab=#net10}
N 6780 -2310 6800 -2310 {
lab=#net10}
N 6780 -2330 6800 -2330 {
lab=#net9}
N 6780 -2350 6800 -2350 {
lab=rowon_n[4]}
N 6780 -2370 6800 -2370 {
lab=row_n[4]}
N 6600 -2230 6600 -2220 {
lab=VSS}
N 6600 -2460 6600 -2450 {
lab=VDD}
N 6940 -2230 6950 -2240 {
lab=col_n[24]}
N 6950 -2440 6950 -2240 {
lab=col_n[24]}
N 6940 -2450 6950 -2440 {
lab=col_n[24]}
N 6940 -2230 6940 -2210 {
lab=col_n[24]}
N 6940 -2470 6940 -2450 {
lab=col_n[24]}
N 6820 -2370 6830 -2380 {
lab=row_n[4]}
N 6830 -2380 7030 -2380 {
lab=row_n[4]}
N 7030 -2380 7040 -2370 {
lab=row_n[4]}
N 6820 -2350 6830 -2360 {
lab=rowon_n[4]}
N 6830 -2360 7030 -2360 {
lab=rowon_n[4]}
N 7030 -2360 7040 -2350 {
lab=rowon_n[4]}
N 6820 -2330 6830 -2340 {
lab=#net9}
N 6830 -2340 7030 -2340 {
lab=#net9}
N 7030 -2340 7040 -2330 {
lab=#net9}
N 6820 -2310 6830 -2320 {
lab=#net10}
N 6830 -2320 7030 -2320 {
lab=#net10}
N 7030 -2320 7040 -2310 {
lab=#net10}
N 6880 -2470 6880 -2450 {
lab=vcm}
N 6920 -2470 6920 -2450 {
lab=ctop}
N 6800 -2370 6820 -2370 {
lab=row_n[4]}
N 6800 -2350 6820 -2350 {
lab=rowon_n[4]}
N 6800 -2330 6820 -2330 {
lab=#net9}
N 6800 -2310 6820 -2310 {
lab=#net10}
N 7040 -2310 7060 -2310 {
lab=#net10}
N 7040 -2330 7060 -2330 {
lab=#net9}
N 7040 -2350 7060 -2350 {
lab=rowon_n[4]}
N 7040 -2370 7060 -2370 {
lab=row_n[4]}
N 6860 -2230 6860 -2220 {
lab=VSS}
N 6860 -2460 6860 -2450 {
lab=VDD}
N 7200 -2230 7210 -2240 {
lab=col_n[25]}
N 7210 -2440 7210 -2240 {
lab=col_n[25]}
N 7200 -2450 7210 -2440 {
lab=col_n[25]}
N 7200 -2230 7200 -2210 {
lab=col_n[25]}
N 7200 -2470 7200 -2450 {
lab=col_n[25]}
N 7080 -2370 7090 -2380 {
lab=row_n[4]}
N 7090 -2380 7290 -2380 {
lab=row_n[4]}
N 7290 -2380 7300 -2370 {
lab=row_n[4]}
N 7080 -2350 7090 -2360 {
lab=rowon_n[4]}
N 7090 -2360 7290 -2360 {
lab=rowon_n[4]}
N 7290 -2360 7300 -2350 {
lab=rowon_n[4]}
N 7080 -2330 7090 -2340 {
lab=#net9}
N 7090 -2340 7290 -2340 {
lab=#net9}
N 7290 -2340 7300 -2330 {
lab=#net9}
N 7080 -2310 7090 -2320 {
lab=#net10}
N 7090 -2320 7290 -2320 {
lab=#net10}
N 7290 -2320 7300 -2310 {
lab=#net10}
N 7140 -2470 7140 -2450 {
lab=vcm}
N 7180 -2470 7180 -2450 {
lab=ctop}
N 7060 -2370 7080 -2370 {
lab=row_n[4]}
N 7060 -2350 7080 -2350 {
lab=rowon_n[4]}
N 7060 -2330 7080 -2330 {
lab=#net9}
N 7060 -2310 7080 -2310 {
lab=#net10}
N 7300 -2310 7320 -2310 {
lab=#net10}
N 7300 -2330 7320 -2330 {
lab=#net9}
N 7300 -2350 7320 -2350 {
lab=rowon_n[4]}
N 7300 -2370 7320 -2370 {
lab=row_n[4]}
N 7120 -2230 7120 -2220 {
lab=VSS}
N 7120 -2460 7120 -2450 {
lab=VDD}
N 7460 -2230 7470 -2240 {
lab=col_n[26]}
N 7470 -2440 7470 -2240 {
lab=col_n[26]}
N 7460 -2450 7470 -2440 {
lab=col_n[26]}
N 7460 -2230 7460 -2210 {
lab=col_n[26]}
N 7460 -2470 7460 -2450 {
lab=col_n[26]}
N 7340 -2370 7350 -2380 {
lab=row_n[4]}
N 7350 -2380 7550 -2380 {
lab=row_n[4]}
N 7550 -2380 7560 -2370 {
lab=row_n[4]}
N 7340 -2350 7350 -2360 {
lab=rowon_n[4]}
N 7350 -2360 7550 -2360 {
lab=rowon_n[4]}
N 7550 -2360 7560 -2350 {
lab=rowon_n[4]}
N 7340 -2330 7350 -2340 {
lab=#net9}
N 7350 -2340 7550 -2340 {
lab=#net9}
N 7550 -2340 7560 -2330 {
lab=#net9}
N 7340 -2310 7350 -2320 {
lab=#net10}
N 7350 -2320 7550 -2320 {
lab=#net10}
N 7550 -2320 7560 -2310 {
lab=#net10}
N 7400 -2470 7400 -2450 {
lab=vcm}
N 7440 -2470 7440 -2450 {
lab=ctop}
N 7320 -2370 7340 -2370 {
lab=row_n[4]}
N 7320 -2350 7340 -2350 {
lab=rowon_n[4]}
N 7320 -2330 7340 -2330 {
lab=#net9}
N 7320 -2310 7340 -2310 {
lab=#net10}
N 7560 -2310 7580 -2310 {
lab=#net10}
N 7560 -2330 7580 -2330 {
lab=#net9}
N 7560 -2350 7580 -2350 {
lab=rowon_n[4]}
N 7560 -2370 7580 -2370 {
lab=row_n[4]}
N 7380 -2230 7380 -2220 {
lab=VSS}
N 7380 -2460 7380 -2450 {
lab=VDD}
N 7720 -2230 7730 -2240 {
lab=col_n[27]}
N 7730 -2440 7730 -2240 {
lab=col_n[27]}
N 7720 -2450 7730 -2440 {
lab=col_n[27]}
N 7720 -2230 7720 -2210 {
lab=col_n[27]}
N 7720 -2470 7720 -2450 {
lab=col_n[27]}
N 7600 -2370 7610 -2380 {
lab=row_n[4]}
N 7610 -2380 7810 -2380 {
lab=row_n[4]}
N 7810 -2380 7820 -2370 {
lab=row_n[4]}
N 7600 -2350 7610 -2360 {
lab=rowon_n[4]}
N 7610 -2360 7810 -2360 {
lab=rowon_n[4]}
N 7810 -2360 7820 -2350 {
lab=rowon_n[4]}
N 7600 -2330 7610 -2340 {
lab=#net9}
N 7610 -2340 7810 -2340 {
lab=#net9}
N 7810 -2340 7820 -2330 {
lab=#net9}
N 7600 -2310 7610 -2320 {
lab=#net10}
N 7610 -2320 7810 -2320 {
lab=#net10}
N 7810 -2320 7820 -2310 {
lab=#net10}
N 7660 -2470 7660 -2450 {
lab=vcm}
N 7700 -2470 7700 -2450 {
lab=ctop}
N 7580 -2370 7600 -2370 {
lab=row_n[4]}
N 7580 -2350 7600 -2350 {
lab=rowon_n[4]}
N 7580 -2330 7600 -2330 {
lab=#net9}
N 7580 -2310 7600 -2310 {
lab=#net10}
N 7820 -2310 7840 -2310 {
lab=#net10}
N 7820 -2330 7840 -2330 {
lab=#net9}
N 7820 -2350 7840 -2350 {
lab=rowon_n[4]}
N 7820 -2370 7840 -2370 {
lab=row_n[4]}
N 7640 -2230 7640 -2220 {
lab=VSS}
N 7640 -2460 7640 -2450 {
lab=VDD}
N 7980 -2230 7990 -2240 {
lab=col_n[28]}
N 7990 -2440 7990 -2240 {
lab=col_n[28]}
N 7980 -2450 7990 -2440 {
lab=col_n[28]}
N 7980 -2230 7980 -2210 {
lab=col_n[28]}
N 7980 -2470 7980 -2450 {
lab=col_n[28]}
N 7860 -2370 7870 -2380 {
lab=row_n[4]}
N 7870 -2380 8070 -2380 {
lab=row_n[4]}
N 8070 -2380 8080 -2370 {
lab=row_n[4]}
N 7860 -2350 7870 -2360 {
lab=rowon_n[4]}
N 7870 -2360 8070 -2360 {
lab=rowon_n[4]}
N 8070 -2360 8080 -2350 {
lab=rowon_n[4]}
N 7860 -2330 7870 -2340 {
lab=#net9}
N 7870 -2340 8070 -2340 {
lab=#net9}
N 8070 -2340 8080 -2330 {
lab=#net9}
N 7860 -2310 7870 -2320 {
lab=#net10}
N 7870 -2320 8070 -2320 {
lab=#net10}
N 8070 -2320 8080 -2310 {
lab=#net10}
N 7920 -2470 7920 -2450 {
lab=vcm}
N 7960 -2470 7960 -2450 {
lab=ctop}
N 7840 -2370 7860 -2370 {
lab=row_n[4]}
N 7840 -2350 7860 -2350 {
lab=rowon_n[4]}
N 7840 -2330 7860 -2330 {
lab=#net9}
N 7840 -2310 7860 -2310 {
lab=#net10}
N 8080 -2310 8100 -2310 {
lab=#net10}
N 8080 -2330 8100 -2330 {
lab=#net9}
N 8080 -2350 8100 -2350 {
lab=rowon_n[4]}
N 8080 -2370 8100 -2370 {
lab=row_n[4]}
N 7900 -2230 7900 -2220 {
lab=VSS}
N 7900 -2460 7900 -2450 {
lab=VDD}
N 8240 -2230 8250 -2240 {
lab=col_n[29]}
N 8250 -2440 8250 -2240 {
lab=col_n[29]}
N 8240 -2450 8250 -2440 {
lab=col_n[29]}
N 8240 -2230 8240 -2210 {
lab=col_n[29]}
N 8240 -2470 8240 -2450 {
lab=col_n[29]}
N 8120 -2370 8130 -2380 {
lab=row_n[4]}
N 8130 -2380 8330 -2380 {
lab=row_n[4]}
N 8330 -2380 8340 -2370 {
lab=row_n[4]}
N 8120 -2350 8130 -2360 {
lab=rowon_n[4]}
N 8130 -2360 8330 -2360 {
lab=rowon_n[4]}
N 8330 -2360 8340 -2350 {
lab=rowon_n[4]}
N 8120 -2330 8130 -2340 {
lab=#net9}
N 8130 -2340 8330 -2340 {
lab=#net9}
N 8330 -2340 8340 -2330 {
lab=#net9}
N 8120 -2310 8130 -2320 {
lab=#net10}
N 8130 -2320 8330 -2320 {
lab=#net10}
N 8330 -2320 8340 -2310 {
lab=#net10}
N 8180 -2470 8180 -2450 {
lab=vcm}
N 8220 -2470 8220 -2450 {
lab=ctop}
N 8100 -2370 8120 -2370 {
lab=row_n[4]}
N 8100 -2350 8120 -2350 {
lab=rowon_n[4]}
N 8100 -2330 8120 -2330 {
lab=#net9}
N 8100 -2310 8120 -2310 {
lab=#net10}
N 8340 -2310 8360 -2310 {
lab=#net10}
N 8340 -2330 8360 -2330 {
lab=#net9}
N 8340 -2350 8360 -2350 {
lab=rowon_n[4]}
N 8340 -2370 8360 -2370 {
lab=row_n[4]}
N 8160 -2230 8160 -2220 {
lab=VSS}
N 8160 -2460 8160 -2450 {
lab=VDD}
N 8500 -2230 8510 -2240 {
lab=col_n[30]}
N 8510 -2440 8510 -2240 {
lab=col_n[30]}
N 8500 -2450 8510 -2440 {
lab=col_n[30]}
N 8500 -2230 8500 -2210 {
lab=col_n[30]}
N 8500 -2470 8500 -2450 {
lab=col_n[30]}
N 8380 -2370 8390 -2380 {
lab=row_n[4]}
N 8390 -2380 8590 -2380 {
lab=row_n[4]}
N 8590 -2380 8600 -2370 {
lab=row_n[4]}
N 8380 -2350 8390 -2360 {
lab=rowon_n[4]}
N 8390 -2360 8590 -2360 {
lab=rowon_n[4]}
N 8590 -2360 8600 -2350 {
lab=rowon_n[4]}
N 8380 -2330 8390 -2340 {
lab=#net9}
N 8390 -2340 8590 -2340 {
lab=#net9}
N 8590 -2340 8600 -2330 {
lab=#net9}
N 8380 -2310 8390 -2320 {
lab=#net10}
N 8390 -2320 8590 -2320 {
lab=#net10}
N 8590 -2320 8600 -2310 {
lab=#net10}
N 8440 -2470 8440 -2450 {
lab=vcm}
N 8480 -2470 8480 -2450 {
lab=ctop}
N 8360 -2370 8380 -2370 {
lab=row_n[4]}
N 8360 -2350 8380 -2350 {
lab=rowon_n[4]}
N 8360 -2330 8380 -2330 {
lab=#net9}
N 8360 -2310 8380 -2310 {
lab=#net10}
N 8600 -2310 8620 -2310 {
lab=#net10}
N 8600 -2330 8620 -2330 {
lab=#net9}
N 8600 -2350 8620 -2350 {
lab=rowon_n[4]}
N 8600 -2370 8620 -2370 {
lab=row_n[4]}
N 8420 -2230 8420 -2220 {
lab=VSS}
N 8420 -2460 8420 -2450 {
lab=VDD}
N 8760 -2230 8770 -2240 {
lab=col_n[31]}
N 8770 -2440 8770 -2240 {
lab=col_n[31]}
N 8760 -2450 8770 -2440 {
lab=col_n[31]}
N 8760 -2230 8760 -2210 {
lab=col_n[31]}
N 8760 -2470 8760 -2450 {
lab=col_n[31]}
N 8640 -2370 8650 -2380 {
lab=row_n[4]}
N 8650 -2380 8850 -2380 {
lab=row_n[4]}
N 8850 -2380 8860 -2370 {
lab=row_n[4]}
N 8640 -2350 8650 -2360 {
lab=rowon_n[4]}
N 8650 -2360 8850 -2360 {
lab=rowon_n[4]}
N 8850 -2360 8860 -2350 {
lab=rowon_n[4]}
N 8640 -2330 8650 -2340 {
lab=#net9}
N 8650 -2340 8850 -2340 {
lab=#net9}
N 8850 -2340 8860 -2330 {
lab=#net9}
N 8640 -2310 8650 -2320 {
lab=#net10}
N 8650 -2320 8850 -2320 {
lab=#net10}
N 8850 -2320 8860 -2310 {
lab=#net10}
N 8700 -2470 8700 -2450 {
lab=vcm}
N 8740 -2470 8740 -2450 {
lab=ctop}
N 8620 -2370 8640 -2370 {
lab=row_n[4]}
N 8620 -2350 8640 -2350 {
lab=rowon_n[4]}
N 8620 -2330 8640 -2330 {
lab=#net9}
N 8620 -2310 8640 -2310 {
lab=#net10}
N 8860 -2310 8880 -2310 {
lab=#net10}
N 8860 -2330 8880 -2330 {
lab=#net9}
N 8860 -2350 8880 -2350 {
lab=rowon_n[4]}
N 8860 -2370 8880 -2370 {
lab=row_n[4]}
N 8680 -2230 8680 -2220 {
lab=VSS}
N 8680 -2460 8680 -2450 {
lab=VDD}
N 700 -2490 710 -2500 {
lab=col_n[0]}
N 710 -2700 710 -2500 {
lab=col_n[0]}
N 700 -2710 710 -2700 {
lab=col_n[0]}
N 700 -2490 700 -2470 {
lab=col_n[0]}
N 700 -2730 700 -2710 {
lab=col_n[0]}
N 580 -2630 590 -2640 {
lab=row_n[5]}
N 590 -2640 790 -2640 {
lab=row_n[5]}
N 790 -2640 800 -2630 {
lab=row_n[5]}
N 580 -2610 590 -2620 {
lab=rowon_n[5]}
N 590 -2620 790 -2620 {
lab=rowon_n[5]}
N 790 -2620 800 -2610 {
lab=rowon_n[5]}
N 580 -2590 590 -2600 {
lab=#net11}
N 590 -2600 790 -2600 {
lab=#net11}
N 790 -2600 800 -2590 {
lab=#net11}
N 580 -2570 590 -2580 {
lab=#net12}
N 590 -2580 790 -2580 {
lab=#net12}
N 790 -2580 800 -2570 {
lab=#net12}
N 640 -2730 640 -2710 {
lab=vcm}
N 680 -2730 680 -2710 {
lab=ctop}
N 560 -2630 580 -2630 {
lab=row_n[5]}
N 560 -2610 580 -2610 {
lab=rowon_n[5]}
N 560 -2590 580 -2590 {
lab=#net11}
N 560 -2570 580 -2570 {
lab=#net12}
N 800 -2570 820 -2570 {
lab=#net12}
N 800 -2590 820 -2590 {
lab=#net11}
N 800 -2610 820 -2610 {
lab=rowon_n[5]}
N 800 -2630 820 -2630 {
lab=row_n[5]}
N 620 -2490 620 -2480 {
lab=VSS}
N 620 -2720 620 -2710 {
lab=VDD}
N 960 -2490 970 -2500 {
lab=col_n[1]}
N 970 -2700 970 -2500 {
lab=col_n[1]}
N 960 -2710 970 -2700 {
lab=col_n[1]}
N 960 -2490 960 -2470 {
lab=col_n[1]}
N 960 -2730 960 -2710 {
lab=col_n[1]}
N 840 -2630 850 -2640 {
lab=row_n[5]}
N 850 -2640 1050 -2640 {
lab=row_n[5]}
N 1050 -2640 1060 -2630 {
lab=row_n[5]}
N 840 -2610 850 -2620 {
lab=rowon_n[5]}
N 850 -2620 1050 -2620 {
lab=rowon_n[5]}
N 1050 -2620 1060 -2610 {
lab=rowon_n[5]}
N 840 -2590 850 -2600 {
lab=#net11}
N 850 -2600 1050 -2600 {
lab=#net11}
N 1050 -2600 1060 -2590 {
lab=#net11}
N 840 -2570 850 -2580 {
lab=#net12}
N 850 -2580 1050 -2580 {
lab=#net12}
N 1050 -2580 1060 -2570 {
lab=#net12}
N 900 -2730 900 -2710 {
lab=vcm}
N 940 -2730 940 -2710 {
lab=ctop}
N 820 -2630 840 -2630 {
lab=row_n[5]}
N 820 -2610 840 -2610 {
lab=rowon_n[5]}
N 820 -2590 840 -2590 {
lab=#net11}
N 820 -2570 840 -2570 {
lab=#net12}
N 1060 -2570 1080 -2570 {
lab=#net12}
N 1060 -2590 1080 -2590 {
lab=#net11}
N 1060 -2610 1080 -2610 {
lab=rowon_n[5]}
N 1060 -2630 1080 -2630 {
lab=row_n[5]}
N 880 -2490 880 -2480 {
lab=VSS}
N 880 -2720 880 -2710 {
lab=VDD}
N 1220 -2490 1230 -2500 {
lab=col_n[2]}
N 1230 -2700 1230 -2500 {
lab=col_n[2]}
N 1220 -2710 1230 -2700 {
lab=col_n[2]}
N 1220 -2490 1220 -2470 {
lab=col_n[2]}
N 1220 -2730 1220 -2710 {
lab=col_n[2]}
N 1100 -2630 1110 -2640 {
lab=row_n[5]}
N 1110 -2640 1310 -2640 {
lab=row_n[5]}
N 1310 -2640 1320 -2630 {
lab=row_n[5]}
N 1100 -2610 1110 -2620 {
lab=rowon_n[5]}
N 1110 -2620 1310 -2620 {
lab=rowon_n[5]}
N 1310 -2620 1320 -2610 {
lab=rowon_n[5]}
N 1100 -2590 1110 -2600 {
lab=#net11}
N 1110 -2600 1310 -2600 {
lab=#net11}
N 1310 -2600 1320 -2590 {
lab=#net11}
N 1100 -2570 1110 -2580 {
lab=#net12}
N 1110 -2580 1310 -2580 {
lab=#net12}
N 1310 -2580 1320 -2570 {
lab=#net12}
N 1160 -2730 1160 -2710 {
lab=vcm}
N 1200 -2730 1200 -2710 {
lab=ctop}
N 1080 -2630 1100 -2630 {
lab=row_n[5]}
N 1080 -2610 1100 -2610 {
lab=rowon_n[5]}
N 1080 -2590 1100 -2590 {
lab=#net11}
N 1080 -2570 1100 -2570 {
lab=#net12}
N 1320 -2570 1340 -2570 {
lab=#net12}
N 1320 -2590 1340 -2590 {
lab=#net11}
N 1320 -2610 1340 -2610 {
lab=rowon_n[5]}
N 1320 -2630 1340 -2630 {
lab=row_n[5]}
N 1140 -2490 1140 -2480 {
lab=VSS}
N 1140 -2720 1140 -2710 {
lab=VDD}
N 1480 -2490 1490 -2500 {
lab=col_n[3]}
N 1490 -2700 1490 -2500 {
lab=col_n[3]}
N 1480 -2710 1490 -2700 {
lab=col_n[3]}
N 1480 -2490 1480 -2470 {
lab=col_n[3]}
N 1480 -2730 1480 -2710 {
lab=col_n[3]}
N 1360 -2630 1370 -2640 {
lab=row_n[5]}
N 1370 -2640 1570 -2640 {
lab=row_n[5]}
N 1570 -2640 1580 -2630 {
lab=row_n[5]}
N 1360 -2610 1370 -2620 {
lab=rowon_n[5]}
N 1370 -2620 1570 -2620 {
lab=rowon_n[5]}
N 1570 -2620 1580 -2610 {
lab=rowon_n[5]}
N 1360 -2590 1370 -2600 {
lab=#net11}
N 1370 -2600 1570 -2600 {
lab=#net11}
N 1570 -2600 1580 -2590 {
lab=#net11}
N 1360 -2570 1370 -2580 {
lab=#net12}
N 1370 -2580 1570 -2580 {
lab=#net12}
N 1570 -2580 1580 -2570 {
lab=#net12}
N 1420 -2730 1420 -2710 {
lab=vcm}
N 1460 -2730 1460 -2710 {
lab=ctop}
N 1340 -2630 1360 -2630 {
lab=row_n[5]}
N 1340 -2610 1360 -2610 {
lab=rowon_n[5]}
N 1340 -2590 1360 -2590 {
lab=#net11}
N 1340 -2570 1360 -2570 {
lab=#net12}
N 1580 -2570 1600 -2570 {
lab=#net12}
N 1580 -2590 1600 -2590 {
lab=#net11}
N 1580 -2610 1600 -2610 {
lab=rowon_n[5]}
N 1580 -2630 1600 -2630 {
lab=row_n[5]}
N 1400 -2490 1400 -2480 {
lab=VSS}
N 1400 -2720 1400 -2710 {
lab=VDD}
N 1740 -2490 1750 -2500 {
lab=col_n[4]}
N 1750 -2700 1750 -2500 {
lab=col_n[4]}
N 1740 -2710 1750 -2700 {
lab=col_n[4]}
N 1740 -2490 1740 -2470 {
lab=col_n[4]}
N 1740 -2730 1740 -2710 {
lab=col_n[4]}
N 1620 -2630 1630 -2640 {
lab=row_n[5]}
N 1630 -2640 1830 -2640 {
lab=row_n[5]}
N 1830 -2640 1840 -2630 {
lab=row_n[5]}
N 1620 -2610 1630 -2620 {
lab=rowon_n[5]}
N 1630 -2620 1830 -2620 {
lab=rowon_n[5]}
N 1830 -2620 1840 -2610 {
lab=rowon_n[5]}
N 1620 -2590 1630 -2600 {
lab=#net11}
N 1630 -2600 1830 -2600 {
lab=#net11}
N 1830 -2600 1840 -2590 {
lab=#net11}
N 1620 -2570 1630 -2580 {
lab=#net12}
N 1630 -2580 1830 -2580 {
lab=#net12}
N 1830 -2580 1840 -2570 {
lab=#net12}
N 1680 -2730 1680 -2710 {
lab=vcm}
N 1720 -2730 1720 -2710 {
lab=ctop}
N 1600 -2630 1620 -2630 {
lab=row_n[5]}
N 1600 -2610 1620 -2610 {
lab=rowon_n[5]}
N 1600 -2590 1620 -2590 {
lab=#net11}
N 1600 -2570 1620 -2570 {
lab=#net12}
N 1840 -2570 1860 -2570 {
lab=#net12}
N 1840 -2590 1860 -2590 {
lab=#net11}
N 1840 -2610 1860 -2610 {
lab=rowon_n[5]}
N 1840 -2630 1860 -2630 {
lab=row_n[5]}
N 1660 -2490 1660 -2480 {
lab=VSS}
N 1660 -2720 1660 -2710 {
lab=VDD}
N 2000 -2490 2010 -2500 {
lab=col_n[5]}
N 2010 -2700 2010 -2500 {
lab=col_n[5]}
N 2000 -2710 2010 -2700 {
lab=col_n[5]}
N 2000 -2490 2000 -2470 {
lab=col_n[5]}
N 2000 -2730 2000 -2710 {
lab=col_n[5]}
N 1880 -2630 1890 -2640 {
lab=row_n[5]}
N 1890 -2640 2090 -2640 {
lab=row_n[5]}
N 2090 -2640 2100 -2630 {
lab=row_n[5]}
N 1880 -2610 1890 -2620 {
lab=rowon_n[5]}
N 1890 -2620 2090 -2620 {
lab=rowon_n[5]}
N 2090 -2620 2100 -2610 {
lab=rowon_n[5]}
N 1880 -2590 1890 -2600 {
lab=#net11}
N 1890 -2600 2090 -2600 {
lab=#net11}
N 2090 -2600 2100 -2590 {
lab=#net11}
N 1880 -2570 1890 -2580 {
lab=#net12}
N 1890 -2580 2090 -2580 {
lab=#net12}
N 2090 -2580 2100 -2570 {
lab=#net12}
N 1940 -2730 1940 -2710 {
lab=vcm}
N 1980 -2730 1980 -2710 {
lab=ctop}
N 1860 -2630 1880 -2630 {
lab=row_n[5]}
N 1860 -2610 1880 -2610 {
lab=rowon_n[5]}
N 1860 -2590 1880 -2590 {
lab=#net11}
N 1860 -2570 1880 -2570 {
lab=#net12}
N 2100 -2570 2120 -2570 {
lab=#net12}
N 2100 -2590 2120 -2590 {
lab=#net11}
N 2100 -2610 2120 -2610 {
lab=rowon_n[5]}
N 2100 -2630 2120 -2630 {
lab=row_n[5]}
N 1920 -2490 1920 -2480 {
lab=VSS}
N 1920 -2720 1920 -2710 {
lab=VDD}
N 2260 -2490 2270 -2500 {
lab=col_n[6]}
N 2270 -2700 2270 -2500 {
lab=col_n[6]}
N 2260 -2710 2270 -2700 {
lab=col_n[6]}
N 2260 -2490 2260 -2470 {
lab=col_n[6]}
N 2260 -2730 2260 -2710 {
lab=col_n[6]}
N 2140 -2630 2150 -2640 {
lab=row_n[5]}
N 2150 -2640 2350 -2640 {
lab=row_n[5]}
N 2350 -2640 2360 -2630 {
lab=row_n[5]}
N 2140 -2610 2150 -2620 {
lab=rowon_n[5]}
N 2150 -2620 2350 -2620 {
lab=rowon_n[5]}
N 2350 -2620 2360 -2610 {
lab=rowon_n[5]}
N 2140 -2590 2150 -2600 {
lab=#net11}
N 2150 -2600 2350 -2600 {
lab=#net11}
N 2350 -2600 2360 -2590 {
lab=#net11}
N 2140 -2570 2150 -2580 {
lab=#net12}
N 2150 -2580 2350 -2580 {
lab=#net12}
N 2350 -2580 2360 -2570 {
lab=#net12}
N 2200 -2730 2200 -2710 {
lab=vcm}
N 2240 -2730 2240 -2710 {
lab=ctop}
N 2120 -2630 2140 -2630 {
lab=row_n[5]}
N 2120 -2610 2140 -2610 {
lab=rowon_n[5]}
N 2120 -2590 2140 -2590 {
lab=#net11}
N 2120 -2570 2140 -2570 {
lab=#net12}
N 2360 -2570 2380 -2570 {
lab=#net12}
N 2360 -2590 2380 -2590 {
lab=#net11}
N 2360 -2610 2380 -2610 {
lab=rowon_n[5]}
N 2360 -2630 2380 -2630 {
lab=row_n[5]}
N 2180 -2490 2180 -2480 {
lab=VSS}
N 2180 -2720 2180 -2710 {
lab=VDD}
N 2520 -2490 2530 -2500 {
lab=col_n[7]}
N 2530 -2700 2530 -2500 {
lab=col_n[7]}
N 2520 -2710 2530 -2700 {
lab=col_n[7]}
N 2520 -2490 2520 -2470 {
lab=col_n[7]}
N 2520 -2730 2520 -2710 {
lab=col_n[7]}
N 2400 -2630 2410 -2640 {
lab=row_n[5]}
N 2410 -2640 2610 -2640 {
lab=row_n[5]}
N 2610 -2640 2620 -2630 {
lab=row_n[5]}
N 2400 -2610 2410 -2620 {
lab=rowon_n[5]}
N 2410 -2620 2610 -2620 {
lab=rowon_n[5]}
N 2610 -2620 2620 -2610 {
lab=rowon_n[5]}
N 2400 -2590 2410 -2600 {
lab=#net11}
N 2410 -2600 2610 -2600 {
lab=#net11}
N 2610 -2600 2620 -2590 {
lab=#net11}
N 2400 -2570 2410 -2580 {
lab=#net12}
N 2410 -2580 2610 -2580 {
lab=#net12}
N 2610 -2580 2620 -2570 {
lab=#net12}
N 2460 -2730 2460 -2710 {
lab=vcm}
N 2500 -2730 2500 -2710 {
lab=ctop}
N 2380 -2630 2400 -2630 {
lab=row_n[5]}
N 2380 -2610 2400 -2610 {
lab=rowon_n[5]}
N 2380 -2590 2400 -2590 {
lab=#net11}
N 2380 -2570 2400 -2570 {
lab=#net12}
N 2620 -2570 2640 -2570 {
lab=#net12}
N 2620 -2590 2640 -2590 {
lab=#net11}
N 2620 -2610 2640 -2610 {
lab=rowon_n[5]}
N 2620 -2630 2640 -2630 {
lab=row_n[5]}
N 2440 -2490 2440 -2480 {
lab=VSS}
N 2440 -2720 2440 -2710 {
lab=VDD}
N 2780 -2490 2790 -2500 {
lab=col_n[8]}
N 2790 -2700 2790 -2500 {
lab=col_n[8]}
N 2780 -2710 2790 -2700 {
lab=col_n[8]}
N 2780 -2490 2780 -2470 {
lab=col_n[8]}
N 2780 -2730 2780 -2710 {
lab=col_n[8]}
N 2660 -2630 2670 -2640 {
lab=row_n[5]}
N 2670 -2640 2870 -2640 {
lab=row_n[5]}
N 2870 -2640 2880 -2630 {
lab=row_n[5]}
N 2660 -2610 2670 -2620 {
lab=rowon_n[5]}
N 2670 -2620 2870 -2620 {
lab=rowon_n[5]}
N 2870 -2620 2880 -2610 {
lab=rowon_n[5]}
N 2660 -2590 2670 -2600 {
lab=#net11}
N 2670 -2600 2870 -2600 {
lab=#net11}
N 2870 -2600 2880 -2590 {
lab=#net11}
N 2660 -2570 2670 -2580 {
lab=#net12}
N 2670 -2580 2870 -2580 {
lab=#net12}
N 2870 -2580 2880 -2570 {
lab=#net12}
N 2720 -2730 2720 -2710 {
lab=vcm}
N 2760 -2730 2760 -2710 {
lab=ctop}
N 2640 -2630 2660 -2630 {
lab=row_n[5]}
N 2640 -2610 2660 -2610 {
lab=rowon_n[5]}
N 2640 -2590 2660 -2590 {
lab=#net11}
N 2640 -2570 2660 -2570 {
lab=#net12}
N 2880 -2570 2900 -2570 {
lab=#net12}
N 2880 -2590 2900 -2590 {
lab=#net11}
N 2880 -2610 2900 -2610 {
lab=rowon_n[5]}
N 2880 -2630 2900 -2630 {
lab=row_n[5]}
N 2700 -2490 2700 -2480 {
lab=VSS}
N 2700 -2720 2700 -2710 {
lab=VDD}
N 3040 -2490 3050 -2500 {
lab=col_n[9]}
N 3050 -2700 3050 -2500 {
lab=col_n[9]}
N 3040 -2710 3050 -2700 {
lab=col_n[9]}
N 3040 -2490 3040 -2470 {
lab=col_n[9]}
N 3040 -2730 3040 -2710 {
lab=col_n[9]}
N 2920 -2630 2930 -2640 {
lab=row_n[5]}
N 2930 -2640 3130 -2640 {
lab=row_n[5]}
N 3130 -2640 3140 -2630 {
lab=row_n[5]}
N 2920 -2610 2930 -2620 {
lab=rowon_n[5]}
N 2930 -2620 3130 -2620 {
lab=rowon_n[5]}
N 3130 -2620 3140 -2610 {
lab=rowon_n[5]}
N 2920 -2590 2930 -2600 {
lab=#net11}
N 2930 -2600 3130 -2600 {
lab=#net11}
N 3130 -2600 3140 -2590 {
lab=#net11}
N 2920 -2570 2930 -2580 {
lab=#net12}
N 2930 -2580 3130 -2580 {
lab=#net12}
N 3130 -2580 3140 -2570 {
lab=#net12}
N 2980 -2730 2980 -2710 {
lab=vcm}
N 3020 -2730 3020 -2710 {
lab=ctop}
N 2900 -2630 2920 -2630 {
lab=row_n[5]}
N 2900 -2610 2920 -2610 {
lab=rowon_n[5]}
N 2900 -2590 2920 -2590 {
lab=#net11}
N 2900 -2570 2920 -2570 {
lab=#net12}
N 3140 -2570 3160 -2570 {
lab=#net12}
N 3140 -2590 3160 -2590 {
lab=#net11}
N 3140 -2610 3160 -2610 {
lab=rowon_n[5]}
N 3140 -2630 3160 -2630 {
lab=row_n[5]}
N 2960 -2490 2960 -2480 {
lab=VSS}
N 2960 -2720 2960 -2710 {
lab=VDD}
N 3300 -2490 3310 -2500 {
lab=col_n[10]}
N 3310 -2700 3310 -2500 {
lab=col_n[10]}
N 3300 -2710 3310 -2700 {
lab=col_n[10]}
N 3300 -2490 3300 -2470 {
lab=col_n[10]}
N 3300 -2730 3300 -2710 {
lab=col_n[10]}
N 3180 -2630 3190 -2640 {
lab=row_n[5]}
N 3190 -2640 3390 -2640 {
lab=row_n[5]}
N 3390 -2640 3400 -2630 {
lab=row_n[5]}
N 3180 -2610 3190 -2620 {
lab=rowon_n[5]}
N 3190 -2620 3390 -2620 {
lab=rowon_n[5]}
N 3390 -2620 3400 -2610 {
lab=rowon_n[5]}
N 3180 -2590 3190 -2600 {
lab=#net11}
N 3190 -2600 3390 -2600 {
lab=#net11}
N 3390 -2600 3400 -2590 {
lab=#net11}
N 3180 -2570 3190 -2580 {
lab=#net12}
N 3190 -2580 3390 -2580 {
lab=#net12}
N 3390 -2580 3400 -2570 {
lab=#net12}
N 3240 -2730 3240 -2710 {
lab=vcm}
N 3280 -2730 3280 -2710 {
lab=ctop}
N 3160 -2630 3180 -2630 {
lab=row_n[5]}
N 3160 -2610 3180 -2610 {
lab=rowon_n[5]}
N 3160 -2590 3180 -2590 {
lab=#net11}
N 3160 -2570 3180 -2570 {
lab=#net12}
N 3400 -2570 3420 -2570 {
lab=#net12}
N 3400 -2590 3420 -2590 {
lab=#net11}
N 3400 -2610 3420 -2610 {
lab=rowon_n[5]}
N 3400 -2630 3420 -2630 {
lab=row_n[5]}
N 3220 -2490 3220 -2480 {
lab=VSS}
N 3220 -2720 3220 -2710 {
lab=VDD}
N 3560 -2490 3570 -2500 {
lab=col_n[11]}
N 3570 -2700 3570 -2500 {
lab=col_n[11]}
N 3560 -2710 3570 -2700 {
lab=col_n[11]}
N 3560 -2490 3560 -2470 {
lab=col_n[11]}
N 3560 -2730 3560 -2710 {
lab=col_n[11]}
N 3440 -2630 3450 -2640 {
lab=row_n[5]}
N 3450 -2640 3650 -2640 {
lab=row_n[5]}
N 3650 -2640 3660 -2630 {
lab=row_n[5]}
N 3440 -2610 3450 -2620 {
lab=rowon_n[5]}
N 3450 -2620 3650 -2620 {
lab=rowon_n[5]}
N 3650 -2620 3660 -2610 {
lab=rowon_n[5]}
N 3440 -2590 3450 -2600 {
lab=#net11}
N 3450 -2600 3650 -2600 {
lab=#net11}
N 3650 -2600 3660 -2590 {
lab=#net11}
N 3440 -2570 3450 -2580 {
lab=#net12}
N 3450 -2580 3650 -2580 {
lab=#net12}
N 3650 -2580 3660 -2570 {
lab=#net12}
N 3500 -2730 3500 -2710 {
lab=vcm}
N 3540 -2730 3540 -2710 {
lab=ctop}
N 3420 -2630 3440 -2630 {
lab=row_n[5]}
N 3420 -2610 3440 -2610 {
lab=rowon_n[5]}
N 3420 -2590 3440 -2590 {
lab=#net11}
N 3420 -2570 3440 -2570 {
lab=#net12}
N 3660 -2570 3680 -2570 {
lab=#net12}
N 3660 -2590 3680 -2590 {
lab=#net11}
N 3660 -2610 3680 -2610 {
lab=rowon_n[5]}
N 3660 -2630 3680 -2630 {
lab=row_n[5]}
N 3480 -2490 3480 -2480 {
lab=VSS}
N 3480 -2720 3480 -2710 {
lab=VDD}
N 3820 -2490 3830 -2500 {
lab=col_n[12]}
N 3830 -2700 3830 -2500 {
lab=col_n[12]}
N 3820 -2710 3830 -2700 {
lab=col_n[12]}
N 3820 -2490 3820 -2470 {
lab=col_n[12]}
N 3820 -2730 3820 -2710 {
lab=col_n[12]}
N 3700 -2630 3710 -2640 {
lab=row_n[5]}
N 3710 -2640 3910 -2640 {
lab=row_n[5]}
N 3910 -2640 3920 -2630 {
lab=row_n[5]}
N 3700 -2610 3710 -2620 {
lab=rowon_n[5]}
N 3710 -2620 3910 -2620 {
lab=rowon_n[5]}
N 3910 -2620 3920 -2610 {
lab=rowon_n[5]}
N 3700 -2590 3710 -2600 {
lab=#net11}
N 3710 -2600 3910 -2600 {
lab=#net11}
N 3910 -2600 3920 -2590 {
lab=#net11}
N 3700 -2570 3710 -2580 {
lab=#net12}
N 3710 -2580 3910 -2580 {
lab=#net12}
N 3910 -2580 3920 -2570 {
lab=#net12}
N 3760 -2730 3760 -2710 {
lab=vcm}
N 3800 -2730 3800 -2710 {
lab=ctop}
N 3680 -2630 3700 -2630 {
lab=row_n[5]}
N 3680 -2610 3700 -2610 {
lab=rowon_n[5]}
N 3680 -2590 3700 -2590 {
lab=#net11}
N 3680 -2570 3700 -2570 {
lab=#net12}
N 3920 -2570 3940 -2570 {
lab=#net12}
N 3920 -2590 3940 -2590 {
lab=#net11}
N 3920 -2610 3940 -2610 {
lab=rowon_n[5]}
N 3920 -2630 3940 -2630 {
lab=row_n[5]}
N 3740 -2490 3740 -2480 {
lab=VSS}
N 3740 -2720 3740 -2710 {
lab=VDD}
N 4080 -2490 4090 -2500 {
lab=col_n[13]}
N 4090 -2700 4090 -2500 {
lab=col_n[13]}
N 4080 -2710 4090 -2700 {
lab=col_n[13]}
N 4080 -2490 4080 -2470 {
lab=col_n[13]}
N 4080 -2730 4080 -2710 {
lab=col_n[13]}
N 3960 -2630 3970 -2640 {
lab=row_n[5]}
N 3970 -2640 4170 -2640 {
lab=row_n[5]}
N 4170 -2640 4180 -2630 {
lab=row_n[5]}
N 3960 -2610 3970 -2620 {
lab=rowon_n[5]}
N 3970 -2620 4170 -2620 {
lab=rowon_n[5]}
N 4170 -2620 4180 -2610 {
lab=rowon_n[5]}
N 3960 -2590 3970 -2600 {
lab=#net11}
N 3970 -2600 4170 -2600 {
lab=#net11}
N 4170 -2600 4180 -2590 {
lab=#net11}
N 3960 -2570 3970 -2580 {
lab=#net12}
N 3970 -2580 4170 -2580 {
lab=#net12}
N 4170 -2580 4180 -2570 {
lab=#net12}
N 4020 -2730 4020 -2710 {
lab=vcm}
N 4060 -2730 4060 -2710 {
lab=ctop}
N 3940 -2630 3960 -2630 {
lab=row_n[5]}
N 3940 -2610 3960 -2610 {
lab=rowon_n[5]}
N 3940 -2590 3960 -2590 {
lab=#net11}
N 3940 -2570 3960 -2570 {
lab=#net12}
N 4180 -2570 4200 -2570 {
lab=#net12}
N 4180 -2590 4200 -2590 {
lab=#net11}
N 4180 -2610 4200 -2610 {
lab=rowon_n[5]}
N 4180 -2630 4200 -2630 {
lab=row_n[5]}
N 4000 -2490 4000 -2480 {
lab=VSS}
N 4000 -2720 4000 -2710 {
lab=VDD}
N 4340 -2490 4350 -2500 {
lab=col_n[14]}
N 4350 -2700 4350 -2500 {
lab=col_n[14]}
N 4340 -2710 4350 -2700 {
lab=col_n[14]}
N 4340 -2490 4340 -2470 {
lab=col_n[14]}
N 4340 -2730 4340 -2710 {
lab=col_n[14]}
N 4220 -2630 4230 -2640 {
lab=row_n[5]}
N 4230 -2640 4430 -2640 {
lab=row_n[5]}
N 4430 -2640 4440 -2630 {
lab=row_n[5]}
N 4220 -2610 4230 -2620 {
lab=rowon_n[5]}
N 4230 -2620 4430 -2620 {
lab=rowon_n[5]}
N 4430 -2620 4440 -2610 {
lab=rowon_n[5]}
N 4220 -2590 4230 -2600 {
lab=#net11}
N 4230 -2600 4430 -2600 {
lab=#net11}
N 4430 -2600 4440 -2590 {
lab=#net11}
N 4220 -2570 4230 -2580 {
lab=#net12}
N 4230 -2580 4430 -2580 {
lab=#net12}
N 4430 -2580 4440 -2570 {
lab=#net12}
N 4280 -2730 4280 -2710 {
lab=vcm}
N 4320 -2730 4320 -2710 {
lab=ctop}
N 4200 -2630 4220 -2630 {
lab=row_n[5]}
N 4200 -2610 4220 -2610 {
lab=rowon_n[5]}
N 4200 -2590 4220 -2590 {
lab=#net11}
N 4200 -2570 4220 -2570 {
lab=#net12}
N 4440 -2570 4460 -2570 {
lab=#net12}
N 4440 -2590 4460 -2590 {
lab=#net11}
N 4440 -2610 4460 -2610 {
lab=rowon_n[5]}
N 4440 -2630 4460 -2630 {
lab=row_n[5]}
N 4260 -2490 4260 -2480 {
lab=VSS}
N 4260 -2720 4260 -2710 {
lab=VDD}
N 4600 -2490 4610 -2500 {
lab=col_n[15]}
N 4610 -2700 4610 -2500 {
lab=col_n[15]}
N 4600 -2710 4610 -2700 {
lab=col_n[15]}
N 4600 -2490 4600 -2470 {
lab=col_n[15]}
N 4600 -2730 4600 -2710 {
lab=col_n[15]}
N 4480 -2630 4490 -2640 {
lab=row_n[5]}
N 4490 -2640 4690 -2640 {
lab=row_n[5]}
N 4690 -2640 4700 -2630 {
lab=row_n[5]}
N 4480 -2610 4490 -2620 {
lab=rowon_n[5]}
N 4490 -2620 4690 -2620 {
lab=rowon_n[5]}
N 4690 -2620 4700 -2610 {
lab=rowon_n[5]}
N 4480 -2590 4490 -2600 {
lab=#net11}
N 4490 -2600 4690 -2600 {
lab=#net11}
N 4690 -2600 4700 -2590 {
lab=#net11}
N 4480 -2570 4490 -2580 {
lab=#net12}
N 4490 -2580 4690 -2580 {
lab=#net12}
N 4690 -2580 4700 -2570 {
lab=#net12}
N 4540 -2730 4540 -2710 {
lab=vcm}
N 4580 -2730 4580 -2710 {
lab=ctop}
N 4460 -2630 4480 -2630 {
lab=row_n[5]}
N 4460 -2610 4480 -2610 {
lab=rowon_n[5]}
N 4460 -2590 4480 -2590 {
lab=#net11}
N 4460 -2570 4480 -2570 {
lab=#net12}
N 4700 -2570 4720 -2570 {
lab=#net12}
N 4700 -2590 4720 -2590 {
lab=#net11}
N 4700 -2610 4720 -2610 {
lab=rowon_n[5]}
N 4700 -2630 4720 -2630 {
lab=row_n[5]}
N 4520 -2490 4520 -2480 {
lab=VSS}
N 4520 -2720 4520 -2710 {
lab=VDD}
N 4860 -2490 4870 -2500 {
lab=col_n[16]}
N 4870 -2700 4870 -2500 {
lab=col_n[16]}
N 4860 -2710 4870 -2700 {
lab=col_n[16]}
N 4860 -2490 4860 -2470 {
lab=col_n[16]}
N 4860 -2730 4860 -2710 {
lab=col_n[16]}
N 4740 -2630 4750 -2640 {
lab=row_n[5]}
N 4750 -2640 4950 -2640 {
lab=row_n[5]}
N 4950 -2640 4960 -2630 {
lab=row_n[5]}
N 4740 -2610 4750 -2620 {
lab=rowon_n[5]}
N 4750 -2620 4950 -2620 {
lab=rowon_n[5]}
N 4950 -2620 4960 -2610 {
lab=rowon_n[5]}
N 4740 -2590 4750 -2600 {
lab=#net11}
N 4750 -2600 4950 -2600 {
lab=#net11}
N 4950 -2600 4960 -2590 {
lab=#net11}
N 4740 -2570 4750 -2580 {
lab=#net12}
N 4750 -2580 4950 -2580 {
lab=#net12}
N 4950 -2580 4960 -2570 {
lab=#net12}
N 4800 -2730 4800 -2710 {
lab=vcm}
N 4840 -2730 4840 -2710 {
lab=ctop}
N 4720 -2630 4740 -2630 {
lab=row_n[5]}
N 4720 -2610 4740 -2610 {
lab=rowon_n[5]}
N 4720 -2590 4740 -2590 {
lab=#net11}
N 4720 -2570 4740 -2570 {
lab=#net12}
N 4960 -2570 4980 -2570 {
lab=#net12}
N 4960 -2590 4980 -2590 {
lab=#net11}
N 4960 -2610 4980 -2610 {
lab=rowon_n[5]}
N 4960 -2630 4980 -2630 {
lab=row_n[5]}
N 4780 -2490 4780 -2480 {
lab=VSS}
N 4780 -2720 4780 -2710 {
lab=VDD}
N 5120 -2490 5130 -2500 {
lab=col_n[17]}
N 5130 -2700 5130 -2500 {
lab=col_n[17]}
N 5120 -2710 5130 -2700 {
lab=col_n[17]}
N 5120 -2490 5120 -2470 {
lab=col_n[17]}
N 5120 -2730 5120 -2710 {
lab=col_n[17]}
N 5000 -2630 5010 -2640 {
lab=row_n[5]}
N 5010 -2640 5210 -2640 {
lab=row_n[5]}
N 5210 -2640 5220 -2630 {
lab=row_n[5]}
N 5000 -2610 5010 -2620 {
lab=rowon_n[5]}
N 5010 -2620 5210 -2620 {
lab=rowon_n[5]}
N 5210 -2620 5220 -2610 {
lab=rowon_n[5]}
N 5000 -2590 5010 -2600 {
lab=#net11}
N 5010 -2600 5210 -2600 {
lab=#net11}
N 5210 -2600 5220 -2590 {
lab=#net11}
N 5000 -2570 5010 -2580 {
lab=#net12}
N 5010 -2580 5210 -2580 {
lab=#net12}
N 5210 -2580 5220 -2570 {
lab=#net12}
N 5060 -2730 5060 -2710 {
lab=vcm}
N 5100 -2730 5100 -2710 {
lab=ctop}
N 4980 -2630 5000 -2630 {
lab=row_n[5]}
N 4980 -2610 5000 -2610 {
lab=rowon_n[5]}
N 4980 -2590 5000 -2590 {
lab=#net11}
N 4980 -2570 5000 -2570 {
lab=#net12}
N 5220 -2570 5240 -2570 {
lab=#net12}
N 5220 -2590 5240 -2590 {
lab=#net11}
N 5220 -2610 5240 -2610 {
lab=rowon_n[5]}
N 5220 -2630 5240 -2630 {
lab=row_n[5]}
N 5040 -2490 5040 -2480 {
lab=VSS}
N 5040 -2720 5040 -2710 {
lab=VDD}
N 5380 -2490 5390 -2500 {
lab=col_n[18]}
N 5390 -2700 5390 -2500 {
lab=col_n[18]}
N 5380 -2710 5390 -2700 {
lab=col_n[18]}
N 5380 -2490 5380 -2470 {
lab=col_n[18]}
N 5380 -2730 5380 -2710 {
lab=col_n[18]}
N 5260 -2630 5270 -2640 {
lab=row_n[5]}
N 5270 -2640 5470 -2640 {
lab=row_n[5]}
N 5470 -2640 5480 -2630 {
lab=row_n[5]}
N 5260 -2610 5270 -2620 {
lab=rowon_n[5]}
N 5270 -2620 5470 -2620 {
lab=rowon_n[5]}
N 5470 -2620 5480 -2610 {
lab=rowon_n[5]}
N 5260 -2590 5270 -2600 {
lab=#net11}
N 5270 -2600 5470 -2600 {
lab=#net11}
N 5470 -2600 5480 -2590 {
lab=#net11}
N 5260 -2570 5270 -2580 {
lab=#net12}
N 5270 -2580 5470 -2580 {
lab=#net12}
N 5470 -2580 5480 -2570 {
lab=#net12}
N 5320 -2730 5320 -2710 {
lab=vcm}
N 5360 -2730 5360 -2710 {
lab=ctop}
N 5240 -2630 5260 -2630 {
lab=row_n[5]}
N 5240 -2610 5260 -2610 {
lab=rowon_n[5]}
N 5240 -2590 5260 -2590 {
lab=#net11}
N 5240 -2570 5260 -2570 {
lab=#net12}
N 5480 -2570 5500 -2570 {
lab=#net12}
N 5480 -2590 5500 -2590 {
lab=#net11}
N 5480 -2610 5500 -2610 {
lab=rowon_n[5]}
N 5480 -2630 5500 -2630 {
lab=row_n[5]}
N 5300 -2490 5300 -2480 {
lab=VSS}
N 5300 -2720 5300 -2710 {
lab=VDD}
N 5640 -2490 5650 -2500 {
lab=col_n[19]}
N 5650 -2700 5650 -2500 {
lab=col_n[19]}
N 5640 -2710 5650 -2700 {
lab=col_n[19]}
N 5640 -2490 5640 -2470 {
lab=col_n[19]}
N 5640 -2730 5640 -2710 {
lab=col_n[19]}
N 5520 -2630 5530 -2640 {
lab=row_n[5]}
N 5530 -2640 5730 -2640 {
lab=row_n[5]}
N 5730 -2640 5740 -2630 {
lab=row_n[5]}
N 5520 -2610 5530 -2620 {
lab=rowon_n[5]}
N 5530 -2620 5730 -2620 {
lab=rowon_n[5]}
N 5730 -2620 5740 -2610 {
lab=rowon_n[5]}
N 5520 -2590 5530 -2600 {
lab=#net11}
N 5530 -2600 5730 -2600 {
lab=#net11}
N 5730 -2600 5740 -2590 {
lab=#net11}
N 5520 -2570 5530 -2580 {
lab=#net12}
N 5530 -2580 5730 -2580 {
lab=#net12}
N 5730 -2580 5740 -2570 {
lab=#net12}
N 5580 -2730 5580 -2710 {
lab=vcm}
N 5620 -2730 5620 -2710 {
lab=ctop}
N 5500 -2630 5520 -2630 {
lab=row_n[5]}
N 5500 -2610 5520 -2610 {
lab=rowon_n[5]}
N 5500 -2590 5520 -2590 {
lab=#net11}
N 5500 -2570 5520 -2570 {
lab=#net12}
N 5740 -2570 5760 -2570 {
lab=#net12}
N 5740 -2590 5760 -2590 {
lab=#net11}
N 5740 -2610 5760 -2610 {
lab=rowon_n[5]}
N 5740 -2630 5760 -2630 {
lab=row_n[5]}
N 5560 -2490 5560 -2480 {
lab=VSS}
N 5560 -2720 5560 -2710 {
lab=VDD}
N 5900 -2490 5910 -2500 {
lab=col_n[20]}
N 5910 -2700 5910 -2500 {
lab=col_n[20]}
N 5900 -2710 5910 -2700 {
lab=col_n[20]}
N 5900 -2490 5900 -2470 {
lab=col_n[20]}
N 5900 -2730 5900 -2710 {
lab=col_n[20]}
N 5780 -2630 5790 -2640 {
lab=row_n[5]}
N 5790 -2640 5990 -2640 {
lab=row_n[5]}
N 5990 -2640 6000 -2630 {
lab=row_n[5]}
N 5780 -2610 5790 -2620 {
lab=rowon_n[5]}
N 5790 -2620 5990 -2620 {
lab=rowon_n[5]}
N 5990 -2620 6000 -2610 {
lab=rowon_n[5]}
N 5780 -2590 5790 -2600 {
lab=#net11}
N 5790 -2600 5990 -2600 {
lab=#net11}
N 5990 -2600 6000 -2590 {
lab=#net11}
N 5780 -2570 5790 -2580 {
lab=#net12}
N 5790 -2580 5990 -2580 {
lab=#net12}
N 5990 -2580 6000 -2570 {
lab=#net12}
N 5840 -2730 5840 -2710 {
lab=vcm}
N 5880 -2730 5880 -2710 {
lab=ctop}
N 5760 -2630 5780 -2630 {
lab=row_n[5]}
N 5760 -2610 5780 -2610 {
lab=rowon_n[5]}
N 5760 -2590 5780 -2590 {
lab=#net11}
N 5760 -2570 5780 -2570 {
lab=#net12}
N 6000 -2570 6020 -2570 {
lab=#net12}
N 6000 -2590 6020 -2590 {
lab=#net11}
N 6000 -2610 6020 -2610 {
lab=rowon_n[5]}
N 6000 -2630 6020 -2630 {
lab=row_n[5]}
N 5820 -2490 5820 -2480 {
lab=VSS}
N 5820 -2720 5820 -2710 {
lab=VDD}
N 6160 -2490 6170 -2500 {
lab=col_n[21]}
N 6170 -2700 6170 -2500 {
lab=col_n[21]}
N 6160 -2710 6170 -2700 {
lab=col_n[21]}
N 6160 -2490 6160 -2470 {
lab=col_n[21]}
N 6160 -2730 6160 -2710 {
lab=col_n[21]}
N 6040 -2630 6050 -2640 {
lab=row_n[5]}
N 6050 -2640 6250 -2640 {
lab=row_n[5]}
N 6250 -2640 6260 -2630 {
lab=row_n[5]}
N 6040 -2610 6050 -2620 {
lab=rowon_n[5]}
N 6050 -2620 6250 -2620 {
lab=rowon_n[5]}
N 6250 -2620 6260 -2610 {
lab=rowon_n[5]}
N 6040 -2590 6050 -2600 {
lab=#net11}
N 6050 -2600 6250 -2600 {
lab=#net11}
N 6250 -2600 6260 -2590 {
lab=#net11}
N 6040 -2570 6050 -2580 {
lab=#net12}
N 6050 -2580 6250 -2580 {
lab=#net12}
N 6250 -2580 6260 -2570 {
lab=#net12}
N 6100 -2730 6100 -2710 {
lab=vcm}
N 6140 -2730 6140 -2710 {
lab=ctop}
N 6020 -2630 6040 -2630 {
lab=row_n[5]}
N 6020 -2610 6040 -2610 {
lab=rowon_n[5]}
N 6020 -2590 6040 -2590 {
lab=#net11}
N 6020 -2570 6040 -2570 {
lab=#net12}
N 6260 -2570 6280 -2570 {
lab=#net12}
N 6260 -2590 6280 -2590 {
lab=#net11}
N 6260 -2610 6280 -2610 {
lab=rowon_n[5]}
N 6260 -2630 6280 -2630 {
lab=row_n[5]}
N 6080 -2490 6080 -2480 {
lab=VSS}
N 6080 -2720 6080 -2710 {
lab=VDD}
N 6420 -2490 6430 -2500 {
lab=col_n[22]}
N 6430 -2700 6430 -2500 {
lab=col_n[22]}
N 6420 -2710 6430 -2700 {
lab=col_n[22]}
N 6420 -2490 6420 -2470 {
lab=col_n[22]}
N 6420 -2730 6420 -2710 {
lab=col_n[22]}
N 6300 -2630 6310 -2640 {
lab=row_n[5]}
N 6310 -2640 6510 -2640 {
lab=row_n[5]}
N 6510 -2640 6520 -2630 {
lab=row_n[5]}
N 6300 -2610 6310 -2620 {
lab=rowon_n[5]}
N 6310 -2620 6510 -2620 {
lab=rowon_n[5]}
N 6510 -2620 6520 -2610 {
lab=rowon_n[5]}
N 6300 -2590 6310 -2600 {
lab=#net11}
N 6310 -2600 6510 -2600 {
lab=#net11}
N 6510 -2600 6520 -2590 {
lab=#net11}
N 6300 -2570 6310 -2580 {
lab=#net12}
N 6310 -2580 6510 -2580 {
lab=#net12}
N 6510 -2580 6520 -2570 {
lab=#net12}
N 6360 -2730 6360 -2710 {
lab=vcm}
N 6400 -2730 6400 -2710 {
lab=ctop}
N 6280 -2630 6300 -2630 {
lab=row_n[5]}
N 6280 -2610 6300 -2610 {
lab=rowon_n[5]}
N 6280 -2590 6300 -2590 {
lab=#net11}
N 6280 -2570 6300 -2570 {
lab=#net12}
N 6520 -2570 6540 -2570 {
lab=#net12}
N 6520 -2590 6540 -2590 {
lab=#net11}
N 6520 -2610 6540 -2610 {
lab=rowon_n[5]}
N 6520 -2630 6540 -2630 {
lab=row_n[5]}
N 6340 -2490 6340 -2480 {
lab=VSS}
N 6340 -2720 6340 -2710 {
lab=VDD}
N 6680 -2490 6690 -2500 {
lab=col_n[23]}
N 6690 -2700 6690 -2500 {
lab=col_n[23]}
N 6680 -2710 6690 -2700 {
lab=col_n[23]}
N 6680 -2490 6680 -2470 {
lab=col_n[23]}
N 6680 -2730 6680 -2710 {
lab=col_n[23]}
N 6560 -2630 6570 -2640 {
lab=row_n[5]}
N 6570 -2640 6770 -2640 {
lab=row_n[5]}
N 6770 -2640 6780 -2630 {
lab=row_n[5]}
N 6560 -2610 6570 -2620 {
lab=rowon_n[5]}
N 6570 -2620 6770 -2620 {
lab=rowon_n[5]}
N 6770 -2620 6780 -2610 {
lab=rowon_n[5]}
N 6560 -2590 6570 -2600 {
lab=#net11}
N 6570 -2600 6770 -2600 {
lab=#net11}
N 6770 -2600 6780 -2590 {
lab=#net11}
N 6560 -2570 6570 -2580 {
lab=#net12}
N 6570 -2580 6770 -2580 {
lab=#net12}
N 6770 -2580 6780 -2570 {
lab=#net12}
N 6620 -2730 6620 -2710 {
lab=vcm}
N 6660 -2730 6660 -2710 {
lab=ctop}
N 6540 -2630 6560 -2630 {
lab=row_n[5]}
N 6540 -2610 6560 -2610 {
lab=rowon_n[5]}
N 6540 -2590 6560 -2590 {
lab=#net11}
N 6540 -2570 6560 -2570 {
lab=#net12}
N 6780 -2570 6800 -2570 {
lab=#net12}
N 6780 -2590 6800 -2590 {
lab=#net11}
N 6780 -2610 6800 -2610 {
lab=rowon_n[5]}
N 6780 -2630 6800 -2630 {
lab=row_n[5]}
N 6600 -2490 6600 -2480 {
lab=VSS}
N 6600 -2720 6600 -2710 {
lab=VDD}
N 6940 -2490 6950 -2500 {
lab=col_n[24]}
N 6950 -2700 6950 -2500 {
lab=col_n[24]}
N 6940 -2710 6950 -2700 {
lab=col_n[24]}
N 6940 -2490 6940 -2470 {
lab=col_n[24]}
N 6940 -2730 6940 -2710 {
lab=col_n[24]}
N 6820 -2630 6830 -2640 {
lab=row_n[5]}
N 6830 -2640 7030 -2640 {
lab=row_n[5]}
N 7030 -2640 7040 -2630 {
lab=row_n[5]}
N 6820 -2610 6830 -2620 {
lab=rowon_n[5]}
N 6830 -2620 7030 -2620 {
lab=rowon_n[5]}
N 7030 -2620 7040 -2610 {
lab=rowon_n[5]}
N 6820 -2590 6830 -2600 {
lab=#net11}
N 6830 -2600 7030 -2600 {
lab=#net11}
N 7030 -2600 7040 -2590 {
lab=#net11}
N 6820 -2570 6830 -2580 {
lab=#net12}
N 6830 -2580 7030 -2580 {
lab=#net12}
N 7030 -2580 7040 -2570 {
lab=#net12}
N 6880 -2730 6880 -2710 {
lab=vcm}
N 6920 -2730 6920 -2710 {
lab=ctop}
N 6800 -2630 6820 -2630 {
lab=row_n[5]}
N 6800 -2610 6820 -2610 {
lab=rowon_n[5]}
N 6800 -2590 6820 -2590 {
lab=#net11}
N 6800 -2570 6820 -2570 {
lab=#net12}
N 7040 -2570 7060 -2570 {
lab=#net12}
N 7040 -2590 7060 -2590 {
lab=#net11}
N 7040 -2610 7060 -2610 {
lab=rowon_n[5]}
N 7040 -2630 7060 -2630 {
lab=row_n[5]}
N 6860 -2490 6860 -2480 {
lab=VSS}
N 6860 -2720 6860 -2710 {
lab=VDD}
N 7200 -2490 7210 -2500 {
lab=col_n[25]}
N 7210 -2700 7210 -2500 {
lab=col_n[25]}
N 7200 -2710 7210 -2700 {
lab=col_n[25]}
N 7200 -2490 7200 -2470 {
lab=col_n[25]}
N 7200 -2730 7200 -2710 {
lab=col_n[25]}
N 7080 -2630 7090 -2640 {
lab=row_n[5]}
N 7090 -2640 7290 -2640 {
lab=row_n[5]}
N 7290 -2640 7300 -2630 {
lab=row_n[5]}
N 7080 -2610 7090 -2620 {
lab=rowon_n[5]}
N 7090 -2620 7290 -2620 {
lab=rowon_n[5]}
N 7290 -2620 7300 -2610 {
lab=rowon_n[5]}
N 7080 -2590 7090 -2600 {
lab=#net11}
N 7090 -2600 7290 -2600 {
lab=#net11}
N 7290 -2600 7300 -2590 {
lab=#net11}
N 7080 -2570 7090 -2580 {
lab=#net12}
N 7090 -2580 7290 -2580 {
lab=#net12}
N 7290 -2580 7300 -2570 {
lab=#net12}
N 7140 -2730 7140 -2710 {
lab=vcm}
N 7180 -2730 7180 -2710 {
lab=ctop}
N 7060 -2630 7080 -2630 {
lab=row_n[5]}
N 7060 -2610 7080 -2610 {
lab=rowon_n[5]}
N 7060 -2590 7080 -2590 {
lab=#net11}
N 7060 -2570 7080 -2570 {
lab=#net12}
N 7300 -2570 7320 -2570 {
lab=#net12}
N 7300 -2590 7320 -2590 {
lab=#net11}
N 7300 -2610 7320 -2610 {
lab=rowon_n[5]}
N 7300 -2630 7320 -2630 {
lab=row_n[5]}
N 7120 -2490 7120 -2480 {
lab=VSS}
N 7120 -2720 7120 -2710 {
lab=VDD}
N 7460 -2490 7470 -2500 {
lab=col_n[26]}
N 7470 -2700 7470 -2500 {
lab=col_n[26]}
N 7460 -2710 7470 -2700 {
lab=col_n[26]}
N 7460 -2490 7460 -2470 {
lab=col_n[26]}
N 7460 -2730 7460 -2710 {
lab=col_n[26]}
N 7340 -2630 7350 -2640 {
lab=row_n[5]}
N 7350 -2640 7550 -2640 {
lab=row_n[5]}
N 7550 -2640 7560 -2630 {
lab=row_n[5]}
N 7340 -2610 7350 -2620 {
lab=rowon_n[5]}
N 7350 -2620 7550 -2620 {
lab=rowon_n[5]}
N 7550 -2620 7560 -2610 {
lab=rowon_n[5]}
N 7340 -2590 7350 -2600 {
lab=#net11}
N 7350 -2600 7550 -2600 {
lab=#net11}
N 7550 -2600 7560 -2590 {
lab=#net11}
N 7340 -2570 7350 -2580 {
lab=#net12}
N 7350 -2580 7550 -2580 {
lab=#net12}
N 7550 -2580 7560 -2570 {
lab=#net12}
N 7400 -2730 7400 -2710 {
lab=vcm}
N 7440 -2730 7440 -2710 {
lab=ctop}
N 7320 -2630 7340 -2630 {
lab=row_n[5]}
N 7320 -2610 7340 -2610 {
lab=rowon_n[5]}
N 7320 -2590 7340 -2590 {
lab=#net11}
N 7320 -2570 7340 -2570 {
lab=#net12}
N 7560 -2570 7580 -2570 {
lab=#net12}
N 7560 -2590 7580 -2590 {
lab=#net11}
N 7560 -2610 7580 -2610 {
lab=rowon_n[5]}
N 7560 -2630 7580 -2630 {
lab=row_n[5]}
N 7380 -2490 7380 -2480 {
lab=VSS}
N 7380 -2720 7380 -2710 {
lab=VDD}
N 7720 -2490 7730 -2500 {
lab=col_n[27]}
N 7730 -2700 7730 -2500 {
lab=col_n[27]}
N 7720 -2710 7730 -2700 {
lab=col_n[27]}
N 7720 -2490 7720 -2470 {
lab=col_n[27]}
N 7720 -2730 7720 -2710 {
lab=col_n[27]}
N 7600 -2630 7610 -2640 {
lab=row_n[5]}
N 7610 -2640 7810 -2640 {
lab=row_n[5]}
N 7810 -2640 7820 -2630 {
lab=row_n[5]}
N 7600 -2610 7610 -2620 {
lab=rowon_n[5]}
N 7610 -2620 7810 -2620 {
lab=rowon_n[5]}
N 7810 -2620 7820 -2610 {
lab=rowon_n[5]}
N 7600 -2590 7610 -2600 {
lab=#net11}
N 7610 -2600 7810 -2600 {
lab=#net11}
N 7810 -2600 7820 -2590 {
lab=#net11}
N 7600 -2570 7610 -2580 {
lab=#net12}
N 7610 -2580 7810 -2580 {
lab=#net12}
N 7810 -2580 7820 -2570 {
lab=#net12}
N 7660 -2730 7660 -2710 {
lab=vcm}
N 7700 -2730 7700 -2710 {
lab=ctop}
N 7580 -2630 7600 -2630 {
lab=row_n[5]}
N 7580 -2610 7600 -2610 {
lab=rowon_n[5]}
N 7580 -2590 7600 -2590 {
lab=#net11}
N 7580 -2570 7600 -2570 {
lab=#net12}
N 7820 -2570 7840 -2570 {
lab=#net12}
N 7820 -2590 7840 -2590 {
lab=#net11}
N 7820 -2610 7840 -2610 {
lab=rowon_n[5]}
N 7820 -2630 7840 -2630 {
lab=row_n[5]}
N 7640 -2490 7640 -2480 {
lab=VSS}
N 7640 -2720 7640 -2710 {
lab=VDD}
N 7980 -2490 7990 -2500 {
lab=col_n[28]}
N 7990 -2700 7990 -2500 {
lab=col_n[28]}
N 7980 -2710 7990 -2700 {
lab=col_n[28]}
N 7980 -2490 7980 -2470 {
lab=col_n[28]}
N 7980 -2730 7980 -2710 {
lab=col_n[28]}
N 7860 -2630 7870 -2640 {
lab=row_n[5]}
N 7870 -2640 8070 -2640 {
lab=row_n[5]}
N 8070 -2640 8080 -2630 {
lab=row_n[5]}
N 7860 -2610 7870 -2620 {
lab=rowon_n[5]}
N 7870 -2620 8070 -2620 {
lab=rowon_n[5]}
N 8070 -2620 8080 -2610 {
lab=rowon_n[5]}
N 7860 -2590 7870 -2600 {
lab=#net11}
N 7870 -2600 8070 -2600 {
lab=#net11}
N 8070 -2600 8080 -2590 {
lab=#net11}
N 7860 -2570 7870 -2580 {
lab=#net12}
N 7870 -2580 8070 -2580 {
lab=#net12}
N 8070 -2580 8080 -2570 {
lab=#net12}
N 7920 -2730 7920 -2710 {
lab=vcm}
N 7960 -2730 7960 -2710 {
lab=ctop}
N 7840 -2630 7860 -2630 {
lab=row_n[5]}
N 7840 -2610 7860 -2610 {
lab=rowon_n[5]}
N 7840 -2590 7860 -2590 {
lab=#net11}
N 7840 -2570 7860 -2570 {
lab=#net12}
N 8080 -2570 8100 -2570 {
lab=#net12}
N 8080 -2590 8100 -2590 {
lab=#net11}
N 8080 -2610 8100 -2610 {
lab=rowon_n[5]}
N 8080 -2630 8100 -2630 {
lab=row_n[5]}
N 7900 -2490 7900 -2480 {
lab=VSS}
N 7900 -2720 7900 -2710 {
lab=VDD}
N 8240 -2490 8250 -2500 {
lab=col_n[29]}
N 8250 -2700 8250 -2500 {
lab=col_n[29]}
N 8240 -2710 8250 -2700 {
lab=col_n[29]}
N 8240 -2490 8240 -2470 {
lab=col_n[29]}
N 8240 -2730 8240 -2710 {
lab=col_n[29]}
N 8120 -2630 8130 -2640 {
lab=row_n[5]}
N 8130 -2640 8330 -2640 {
lab=row_n[5]}
N 8330 -2640 8340 -2630 {
lab=row_n[5]}
N 8120 -2610 8130 -2620 {
lab=rowon_n[5]}
N 8130 -2620 8330 -2620 {
lab=rowon_n[5]}
N 8330 -2620 8340 -2610 {
lab=rowon_n[5]}
N 8120 -2590 8130 -2600 {
lab=#net11}
N 8130 -2600 8330 -2600 {
lab=#net11}
N 8330 -2600 8340 -2590 {
lab=#net11}
N 8120 -2570 8130 -2580 {
lab=#net12}
N 8130 -2580 8330 -2580 {
lab=#net12}
N 8330 -2580 8340 -2570 {
lab=#net12}
N 8180 -2730 8180 -2710 {
lab=vcm}
N 8220 -2730 8220 -2710 {
lab=ctop}
N 8100 -2630 8120 -2630 {
lab=row_n[5]}
N 8100 -2610 8120 -2610 {
lab=rowon_n[5]}
N 8100 -2590 8120 -2590 {
lab=#net11}
N 8100 -2570 8120 -2570 {
lab=#net12}
N 8340 -2570 8360 -2570 {
lab=#net12}
N 8340 -2590 8360 -2590 {
lab=#net11}
N 8340 -2610 8360 -2610 {
lab=rowon_n[5]}
N 8340 -2630 8360 -2630 {
lab=row_n[5]}
N 8160 -2490 8160 -2480 {
lab=VSS}
N 8160 -2720 8160 -2710 {
lab=VDD}
N 8500 -2490 8510 -2500 {
lab=col_n[30]}
N 8510 -2700 8510 -2500 {
lab=col_n[30]}
N 8500 -2710 8510 -2700 {
lab=col_n[30]}
N 8500 -2490 8500 -2470 {
lab=col_n[30]}
N 8500 -2730 8500 -2710 {
lab=col_n[30]}
N 8380 -2630 8390 -2640 {
lab=row_n[5]}
N 8390 -2640 8590 -2640 {
lab=row_n[5]}
N 8590 -2640 8600 -2630 {
lab=row_n[5]}
N 8380 -2610 8390 -2620 {
lab=rowon_n[5]}
N 8390 -2620 8590 -2620 {
lab=rowon_n[5]}
N 8590 -2620 8600 -2610 {
lab=rowon_n[5]}
N 8380 -2590 8390 -2600 {
lab=#net11}
N 8390 -2600 8590 -2600 {
lab=#net11}
N 8590 -2600 8600 -2590 {
lab=#net11}
N 8380 -2570 8390 -2580 {
lab=#net12}
N 8390 -2580 8590 -2580 {
lab=#net12}
N 8590 -2580 8600 -2570 {
lab=#net12}
N 8440 -2730 8440 -2710 {
lab=vcm}
N 8480 -2730 8480 -2710 {
lab=ctop}
N 8360 -2630 8380 -2630 {
lab=row_n[5]}
N 8360 -2610 8380 -2610 {
lab=rowon_n[5]}
N 8360 -2590 8380 -2590 {
lab=#net11}
N 8360 -2570 8380 -2570 {
lab=#net12}
N 8600 -2570 8620 -2570 {
lab=#net12}
N 8600 -2590 8620 -2590 {
lab=#net11}
N 8600 -2610 8620 -2610 {
lab=rowon_n[5]}
N 8600 -2630 8620 -2630 {
lab=row_n[5]}
N 8420 -2490 8420 -2480 {
lab=VSS}
N 8420 -2720 8420 -2710 {
lab=VDD}
N 8760 -2490 8770 -2500 {
lab=col_n[31]}
N 8770 -2700 8770 -2500 {
lab=col_n[31]}
N 8760 -2710 8770 -2700 {
lab=col_n[31]}
N 8760 -2490 8760 -2470 {
lab=col_n[31]}
N 8760 -2730 8760 -2710 {
lab=col_n[31]}
N 8640 -2630 8650 -2640 {
lab=row_n[5]}
N 8650 -2640 8850 -2640 {
lab=row_n[5]}
N 8850 -2640 8860 -2630 {
lab=row_n[5]}
N 8640 -2610 8650 -2620 {
lab=rowon_n[5]}
N 8650 -2620 8850 -2620 {
lab=rowon_n[5]}
N 8850 -2620 8860 -2610 {
lab=rowon_n[5]}
N 8640 -2590 8650 -2600 {
lab=#net11}
N 8650 -2600 8850 -2600 {
lab=#net11}
N 8850 -2600 8860 -2590 {
lab=#net11}
N 8640 -2570 8650 -2580 {
lab=#net12}
N 8650 -2580 8850 -2580 {
lab=#net12}
N 8850 -2580 8860 -2570 {
lab=#net12}
N 8700 -2730 8700 -2710 {
lab=vcm}
N 8740 -2730 8740 -2710 {
lab=ctop}
N 8620 -2630 8640 -2630 {
lab=row_n[5]}
N 8620 -2610 8640 -2610 {
lab=rowon_n[5]}
N 8620 -2590 8640 -2590 {
lab=#net11}
N 8620 -2570 8640 -2570 {
lab=#net12}
N 8860 -2570 8880 -2570 {
lab=#net12}
N 8860 -2590 8880 -2590 {
lab=#net11}
N 8860 -2610 8880 -2610 {
lab=rowon_n[5]}
N 8860 -2630 8880 -2630 {
lab=row_n[5]}
N 8680 -2490 8680 -2480 {
lab=VSS}
N 8680 -2720 8680 -2710 {
lab=VDD}
N 700 -2750 710 -2760 {
lab=col_n[0]}
N 710 -2960 710 -2760 {
lab=col_n[0]}
N 700 -2970 710 -2960 {
lab=col_n[0]}
N 700 -2750 700 -2730 {
lab=col_n[0]}
N 700 -2990 700 -2970 {
lab=col_n[0]}
N 580 -2890 590 -2900 {
lab=row_n[6]}
N 590 -2900 790 -2900 {
lab=row_n[6]}
N 790 -2900 800 -2890 {
lab=row_n[6]}
N 580 -2870 590 -2880 {
lab=rowon_n[6]}
N 590 -2880 790 -2880 {
lab=rowon_n[6]}
N 790 -2880 800 -2870 {
lab=rowon_n[6]}
N 580 -2850 590 -2860 {
lab=#net13}
N 590 -2860 790 -2860 {
lab=#net13}
N 790 -2860 800 -2850 {
lab=#net13}
N 580 -2830 590 -2840 {
lab=#net14}
N 590 -2840 790 -2840 {
lab=#net14}
N 790 -2840 800 -2830 {
lab=#net14}
N 640 -2990 640 -2970 {
lab=vcm}
N 680 -2990 680 -2970 {
lab=ctop}
N 560 -2890 580 -2890 {
lab=row_n[6]}
N 560 -2870 580 -2870 {
lab=rowon_n[6]}
N 560 -2850 580 -2850 {
lab=#net13}
N 560 -2830 580 -2830 {
lab=#net14}
N 800 -2830 820 -2830 {
lab=#net14}
N 800 -2850 820 -2850 {
lab=#net13}
N 800 -2870 820 -2870 {
lab=rowon_n[6]}
N 800 -2890 820 -2890 {
lab=row_n[6]}
N 620 -2750 620 -2740 {
lab=VSS}
N 620 -2980 620 -2970 {
lab=VDD}
N 960 -2750 970 -2760 {
lab=col_n[1]}
N 970 -2960 970 -2760 {
lab=col_n[1]}
N 960 -2970 970 -2960 {
lab=col_n[1]}
N 960 -2750 960 -2730 {
lab=col_n[1]}
N 960 -2990 960 -2970 {
lab=col_n[1]}
N 840 -2890 850 -2900 {
lab=row_n[6]}
N 850 -2900 1050 -2900 {
lab=row_n[6]}
N 1050 -2900 1060 -2890 {
lab=row_n[6]}
N 840 -2870 850 -2880 {
lab=rowon_n[6]}
N 850 -2880 1050 -2880 {
lab=rowon_n[6]}
N 1050 -2880 1060 -2870 {
lab=rowon_n[6]}
N 840 -2850 850 -2860 {
lab=#net13}
N 850 -2860 1050 -2860 {
lab=#net13}
N 1050 -2860 1060 -2850 {
lab=#net13}
N 840 -2830 850 -2840 {
lab=#net14}
N 850 -2840 1050 -2840 {
lab=#net14}
N 1050 -2840 1060 -2830 {
lab=#net14}
N 900 -2990 900 -2970 {
lab=vcm}
N 940 -2990 940 -2970 {
lab=ctop}
N 820 -2890 840 -2890 {
lab=row_n[6]}
N 820 -2870 840 -2870 {
lab=rowon_n[6]}
N 820 -2850 840 -2850 {
lab=#net13}
N 820 -2830 840 -2830 {
lab=#net14}
N 1060 -2830 1080 -2830 {
lab=#net14}
N 1060 -2850 1080 -2850 {
lab=#net13}
N 1060 -2870 1080 -2870 {
lab=rowon_n[6]}
N 1060 -2890 1080 -2890 {
lab=row_n[6]}
N 880 -2750 880 -2740 {
lab=VSS}
N 880 -2980 880 -2970 {
lab=VDD}
N 1220 -2750 1230 -2760 {
lab=col_n[2]}
N 1230 -2960 1230 -2760 {
lab=col_n[2]}
N 1220 -2970 1230 -2960 {
lab=col_n[2]}
N 1220 -2750 1220 -2730 {
lab=col_n[2]}
N 1220 -2990 1220 -2970 {
lab=col_n[2]}
N 1100 -2890 1110 -2900 {
lab=row_n[6]}
N 1110 -2900 1310 -2900 {
lab=row_n[6]}
N 1310 -2900 1320 -2890 {
lab=row_n[6]}
N 1100 -2870 1110 -2880 {
lab=rowon_n[6]}
N 1110 -2880 1310 -2880 {
lab=rowon_n[6]}
N 1310 -2880 1320 -2870 {
lab=rowon_n[6]}
N 1100 -2850 1110 -2860 {
lab=#net13}
N 1110 -2860 1310 -2860 {
lab=#net13}
N 1310 -2860 1320 -2850 {
lab=#net13}
N 1100 -2830 1110 -2840 {
lab=#net14}
N 1110 -2840 1310 -2840 {
lab=#net14}
N 1310 -2840 1320 -2830 {
lab=#net14}
N 1160 -2990 1160 -2970 {
lab=vcm}
N 1200 -2990 1200 -2970 {
lab=ctop}
N 1080 -2890 1100 -2890 {
lab=row_n[6]}
N 1080 -2870 1100 -2870 {
lab=rowon_n[6]}
N 1080 -2850 1100 -2850 {
lab=#net13}
N 1080 -2830 1100 -2830 {
lab=#net14}
N 1320 -2830 1340 -2830 {
lab=#net14}
N 1320 -2850 1340 -2850 {
lab=#net13}
N 1320 -2870 1340 -2870 {
lab=rowon_n[6]}
N 1320 -2890 1340 -2890 {
lab=row_n[6]}
N 1140 -2750 1140 -2740 {
lab=VSS}
N 1140 -2980 1140 -2970 {
lab=VDD}
N 1480 -2750 1490 -2760 {
lab=col_n[3]}
N 1490 -2960 1490 -2760 {
lab=col_n[3]}
N 1480 -2970 1490 -2960 {
lab=col_n[3]}
N 1480 -2750 1480 -2730 {
lab=col_n[3]}
N 1480 -2990 1480 -2970 {
lab=col_n[3]}
N 1360 -2890 1370 -2900 {
lab=row_n[6]}
N 1370 -2900 1570 -2900 {
lab=row_n[6]}
N 1570 -2900 1580 -2890 {
lab=row_n[6]}
N 1360 -2870 1370 -2880 {
lab=rowon_n[6]}
N 1370 -2880 1570 -2880 {
lab=rowon_n[6]}
N 1570 -2880 1580 -2870 {
lab=rowon_n[6]}
N 1360 -2850 1370 -2860 {
lab=#net13}
N 1370 -2860 1570 -2860 {
lab=#net13}
N 1570 -2860 1580 -2850 {
lab=#net13}
N 1360 -2830 1370 -2840 {
lab=#net14}
N 1370 -2840 1570 -2840 {
lab=#net14}
N 1570 -2840 1580 -2830 {
lab=#net14}
N 1420 -2990 1420 -2970 {
lab=vcm}
N 1460 -2990 1460 -2970 {
lab=ctop}
N 1340 -2890 1360 -2890 {
lab=row_n[6]}
N 1340 -2870 1360 -2870 {
lab=rowon_n[6]}
N 1340 -2850 1360 -2850 {
lab=#net13}
N 1340 -2830 1360 -2830 {
lab=#net14}
N 1580 -2830 1600 -2830 {
lab=#net14}
N 1580 -2850 1600 -2850 {
lab=#net13}
N 1580 -2870 1600 -2870 {
lab=rowon_n[6]}
N 1580 -2890 1600 -2890 {
lab=row_n[6]}
N 1400 -2750 1400 -2740 {
lab=VSS}
N 1400 -2980 1400 -2970 {
lab=VDD}
N 1740 -2750 1750 -2760 {
lab=col_n[4]}
N 1750 -2960 1750 -2760 {
lab=col_n[4]}
N 1740 -2970 1750 -2960 {
lab=col_n[4]}
N 1740 -2750 1740 -2730 {
lab=col_n[4]}
N 1740 -2990 1740 -2970 {
lab=col_n[4]}
N 1620 -2890 1630 -2900 {
lab=row_n[6]}
N 1630 -2900 1830 -2900 {
lab=row_n[6]}
N 1830 -2900 1840 -2890 {
lab=row_n[6]}
N 1620 -2870 1630 -2880 {
lab=rowon_n[6]}
N 1630 -2880 1830 -2880 {
lab=rowon_n[6]}
N 1830 -2880 1840 -2870 {
lab=rowon_n[6]}
N 1620 -2850 1630 -2860 {
lab=#net13}
N 1630 -2860 1830 -2860 {
lab=#net13}
N 1830 -2860 1840 -2850 {
lab=#net13}
N 1620 -2830 1630 -2840 {
lab=#net14}
N 1630 -2840 1830 -2840 {
lab=#net14}
N 1830 -2840 1840 -2830 {
lab=#net14}
N 1680 -2990 1680 -2970 {
lab=vcm}
N 1720 -2990 1720 -2970 {
lab=ctop}
N 1600 -2890 1620 -2890 {
lab=row_n[6]}
N 1600 -2870 1620 -2870 {
lab=rowon_n[6]}
N 1600 -2850 1620 -2850 {
lab=#net13}
N 1600 -2830 1620 -2830 {
lab=#net14}
N 1840 -2830 1860 -2830 {
lab=#net14}
N 1840 -2850 1860 -2850 {
lab=#net13}
N 1840 -2870 1860 -2870 {
lab=rowon_n[6]}
N 1840 -2890 1860 -2890 {
lab=row_n[6]}
N 1660 -2750 1660 -2740 {
lab=VSS}
N 1660 -2980 1660 -2970 {
lab=VDD}
N 2000 -2750 2010 -2760 {
lab=col_n[5]}
N 2010 -2960 2010 -2760 {
lab=col_n[5]}
N 2000 -2970 2010 -2960 {
lab=col_n[5]}
N 2000 -2750 2000 -2730 {
lab=col_n[5]}
N 2000 -2990 2000 -2970 {
lab=col_n[5]}
N 1880 -2890 1890 -2900 {
lab=row_n[6]}
N 1890 -2900 2090 -2900 {
lab=row_n[6]}
N 2090 -2900 2100 -2890 {
lab=row_n[6]}
N 1880 -2870 1890 -2880 {
lab=rowon_n[6]}
N 1890 -2880 2090 -2880 {
lab=rowon_n[6]}
N 2090 -2880 2100 -2870 {
lab=rowon_n[6]}
N 1880 -2850 1890 -2860 {
lab=#net13}
N 1890 -2860 2090 -2860 {
lab=#net13}
N 2090 -2860 2100 -2850 {
lab=#net13}
N 1880 -2830 1890 -2840 {
lab=#net14}
N 1890 -2840 2090 -2840 {
lab=#net14}
N 2090 -2840 2100 -2830 {
lab=#net14}
N 1940 -2990 1940 -2970 {
lab=vcm}
N 1980 -2990 1980 -2970 {
lab=ctop}
N 1860 -2890 1880 -2890 {
lab=row_n[6]}
N 1860 -2870 1880 -2870 {
lab=rowon_n[6]}
N 1860 -2850 1880 -2850 {
lab=#net13}
N 1860 -2830 1880 -2830 {
lab=#net14}
N 2100 -2830 2120 -2830 {
lab=#net14}
N 2100 -2850 2120 -2850 {
lab=#net13}
N 2100 -2870 2120 -2870 {
lab=rowon_n[6]}
N 2100 -2890 2120 -2890 {
lab=row_n[6]}
N 1920 -2750 1920 -2740 {
lab=VSS}
N 1920 -2980 1920 -2970 {
lab=VDD}
N 2260 -2750 2270 -2760 {
lab=col_n[6]}
N 2270 -2960 2270 -2760 {
lab=col_n[6]}
N 2260 -2970 2270 -2960 {
lab=col_n[6]}
N 2260 -2750 2260 -2730 {
lab=col_n[6]}
N 2260 -2990 2260 -2970 {
lab=col_n[6]}
N 2140 -2890 2150 -2900 {
lab=row_n[6]}
N 2150 -2900 2350 -2900 {
lab=row_n[6]}
N 2350 -2900 2360 -2890 {
lab=row_n[6]}
N 2140 -2870 2150 -2880 {
lab=rowon_n[6]}
N 2150 -2880 2350 -2880 {
lab=rowon_n[6]}
N 2350 -2880 2360 -2870 {
lab=rowon_n[6]}
N 2140 -2850 2150 -2860 {
lab=#net13}
N 2150 -2860 2350 -2860 {
lab=#net13}
N 2350 -2860 2360 -2850 {
lab=#net13}
N 2140 -2830 2150 -2840 {
lab=#net14}
N 2150 -2840 2350 -2840 {
lab=#net14}
N 2350 -2840 2360 -2830 {
lab=#net14}
N 2200 -2990 2200 -2970 {
lab=vcm}
N 2240 -2990 2240 -2970 {
lab=ctop}
N 2120 -2890 2140 -2890 {
lab=row_n[6]}
N 2120 -2870 2140 -2870 {
lab=rowon_n[6]}
N 2120 -2850 2140 -2850 {
lab=#net13}
N 2120 -2830 2140 -2830 {
lab=#net14}
N 2360 -2830 2380 -2830 {
lab=#net14}
N 2360 -2850 2380 -2850 {
lab=#net13}
N 2360 -2870 2380 -2870 {
lab=rowon_n[6]}
N 2360 -2890 2380 -2890 {
lab=row_n[6]}
N 2180 -2750 2180 -2740 {
lab=VSS}
N 2180 -2980 2180 -2970 {
lab=VDD}
N 2520 -2750 2530 -2760 {
lab=col_n[7]}
N 2530 -2960 2530 -2760 {
lab=col_n[7]}
N 2520 -2970 2530 -2960 {
lab=col_n[7]}
N 2520 -2750 2520 -2730 {
lab=col_n[7]}
N 2520 -2990 2520 -2970 {
lab=col_n[7]}
N 2400 -2890 2410 -2900 {
lab=row_n[6]}
N 2410 -2900 2610 -2900 {
lab=row_n[6]}
N 2610 -2900 2620 -2890 {
lab=row_n[6]}
N 2400 -2870 2410 -2880 {
lab=rowon_n[6]}
N 2410 -2880 2610 -2880 {
lab=rowon_n[6]}
N 2610 -2880 2620 -2870 {
lab=rowon_n[6]}
N 2400 -2850 2410 -2860 {
lab=#net13}
N 2410 -2860 2610 -2860 {
lab=#net13}
N 2610 -2860 2620 -2850 {
lab=#net13}
N 2400 -2830 2410 -2840 {
lab=#net14}
N 2410 -2840 2610 -2840 {
lab=#net14}
N 2610 -2840 2620 -2830 {
lab=#net14}
N 2460 -2990 2460 -2970 {
lab=vcm}
N 2500 -2990 2500 -2970 {
lab=ctop}
N 2380 -2890 2400 -2890 {
lab=row_n[6]}
N 2380 -2870 2400 -2870 {
lab=rowon_n[6]}
N 2380 -2850 2400 -2850 {
lab=#net13}
N 2380 -2830 2400 -2830 {
lab=#net14}
N 2620 -2830 2640 -2830 {
lab=#net14}
N 2620 -2850 2640 -2850 {
lab=#net13}
N 2620 -2870 2640 -2870 {
lab=rowon_n[6]}
N 2620 -2890 2640 -2890 {
lab=row_n[6]}
N 2440 -2750 2440 -2740 {
lab=VSS}
N 2440 -2980 2440 -2970 {
lab=VDD}
N 2780 -2750 2790 -2760 {
lab=col_n[8]}
N 2790 -2960 2790 -2760 {
lab=col_n[8]}
N 2780 -2970 2790 -2960 {
lab=col_n[8]}
N 2780 -2750 2780 -2730 {
lab=col_n[8]}
N 2780 -2990 2780 -2970 {
lab=col_n[8]}
N 2660 -2890 2670 -2900 {
lab=row_n[6]}
N 2670 -2900 2870 -2900 {
lab=row_n[6]}
N 2870 -2900 2880 -2890 {
lab=row_n[6]}
N 2660 -2870 2670 -2880 {
lab=rowon_n[6]}
N 2670 -2880 2870 -2880 {
lab=rowon_n[6]}
N 2870 -2880 2880 -2870 {
lab=rowon_n[6]}
N 2660 -2850 2670 -2860 {
lab=#net13}
N 2670 -2860 2870 -2860 {
lab=#net13}
N 2870 -2860 2880 -2850 {
lab=#net13}
N 2660 -2830 2670 -2840 {
lab=#net14}
N 2670 -2840 2870 -2840 {
lab=#net14}
N 2870 -2840 2880 -2830 {
lab=#net14}
N 2720 -2990 2720 -2970 {
lab=vcm}
N 2760 -2990 2760 -2970 {
lab=ctop}
N 2640 -2890 2660 -2890 {
lab=row_n[6]}
N 2640 -2870 2660 -2870 {
lab=rowon_n[6]}
N 2640 -2850 2660 -2850 {
lab=#net13}
N 2640 -2830 2660 -2830 {
lab=#net14}
N 2880 -2830 2900 -2830 {
lab=#net14}
N 2880 -2850 2900 -2850 {
lab=#net13}
N 2880 -2870 2900 -2870 {
lab=rowon_n[6]}
N 2880 -2890 2900 -2890 {
lab=row_n[6]}
N 2700 -2750 2700 -2740 {
lab=VSS}
N 2700 -2980 2700 -2970 {
lab=VDD}
N 3040 -2750 3050 -2760 {
lab=col_n[9]}
N 3050 -2960 3050 -2760 {
lab=col_n[9]}
N 3040 -2970 3050 -2960 {
lab=col_n[9]}
N 3040 -2750 3040 -2730 {
lab=col_n[9]}
N 3040 -2990 3040 -2970 {
lab=col_n[9]}
N 2920 -2890 2930 -2900 {
lab=row_n[6]}
N 2930 -2900 3130 -2900 {
lab=row_n[6]}
N 3130 -2900 3140 -2890 {
lab=row_n[6]}
N 2920 -2870 2930 -2880 {
lab=rowon_n[6]}
N 2930 -2880 3130 -2880 {
lab=rowon_n[6]}
N 3130 -2880 3140 -2870 {
lab=rowon_n[6]}
N 2920 -2850 2930 -2860 {
lab=#net13}
N 2930 -2860 3130 -2860 {
lab=#net13}
N 3130 -2860 3140 -2850 {
lab=#net13}
N 2920 -2830 2930 -2840 {
lab=#net14}
N 2930 -2840 3130 -2840 {
lab=#net14}
N 3130 -2840 3140 -2830 {
lab=#net14}
N 2980 -2990 2980 -2970 {
lab=vcm}
N 3020 -2990 3020 -2970 {
lab=ctop}
N 2900 -2890 2920 -2890 {
lab=row_n[6]}
N 2900 -2870 2920 -2870 {
lab=rowon_n[6]}
N 2900 -2850 2920 -2850 {
lab=#net13}
N 2900 -2830 2920 -2830 {
lab=#net14}
N 3140 -2830 3160 -2830 {
lab=#net14}
N 3140 -2850 3160 -2850 {
lab=#net13}
N 3140 -2870 3160 -2870 {
lab=rowon_n[6]}
N 3140 -2890 3160 -2890 {
lab=row_n[6]}
N 2960 -2750 2960 -2740 {
lab=VSS}
N 2960 -2980 2960 -2970 {
lab=VDD}
N 3300 -2750 3310 -2760 {
lab=col_n[10]}
N 3310 -2960 3310 -2760 {
lab=col_n[10]}
N 3300 -2970 3310 -2960 {
lab=col_n[10]}
N 3300 -2750 3300 -2730 {
lab=col_n[10]}
N 3300 -2990 3300 -2970 {
lab=col_n[10]}
N 3180 -2890 3190 -2900 {
lab=row_n[6]}
N 3190 -2900 3390 -2900 {
lab=row_n[6]}
N 3390 -2900 3400 -2890 {
lab=row_n[6]}
N 3180 -2870 3190 -2880 {
lab=rowon_n[6]}
N 3190 -2880 3390 -2880 {
lab=rowon_n[6]}
N 3390 -2880 3400 -2870 {
lab=rowon_n[6]}
N 3180 -2850 3190 -2860 {
lab=#net13}
N 3190 -2860 3390 -2860 {
lab=#net13}
N 3390 -2860 3400 -2850 {
lab=#net13}
N 3180 -2830 3190 -2840 {
lab=#net14}
N 3190 -2840 3390 -2840 {
lab=#net14}
N 3390 -2840 3400 -2830 {
lab=#net14}
N 3240 -2990 3240 -2970 {
lab=vcm}
N 3280 -2990 3280 -2970 {
lab=ctop}
N 3160 -2890 3180 -2890 {
lab=row_n[6]}
N 3160 -2870 3180 -2870 {
lab=rowon_n[6]}
N 3160 -2850 3180 -2850 {
lab=#net13}
N 3160 -2830 3180 -2830 {
lab=#net14}
N 3400 -2830 3420 -2830 {
lab=#net14}
N 3400 -2850 3420 -2850 {
lab=#net13}
N 3400 -2870 3420 -2870 {
lab=rowon_n[6]}
N 3400 -2890 3420 -2890 {
lab=row_n[6]}
N 3220 -2750 3220 -2740 {
lab=VSS}
N 3220 -2980 3220 -2970 {
lab=VDD}
N 3560 -2750 3570 -2760 {
lab=col_n[11]}
N 3570 -2960 3570 -2760 {
lab=col_n[11]}
N 3560 -2970 3570 -2960 {
lab=col_n[11]}
N 3560 -2750 3560 -2730 {
lab=col_n[11]}
N 3560 -2990 3560 -2970 {
lab=col_n[11]}
N 3440 -2890 3450 -2900 {
lab=row_n[6]}
N 3450 -2900 3650 -2900 {
lab=row_n[6]}
N 3650 -2900 3660 -2890 {
lab=row_n[6]}
N 3440 -2870 3450 -2880 {
lab=rowon_n[6]}
N 3450 -2880 3650 -2880 {
lab=rowon_n[6]}
N 3650 -2880 3660 -2870 {
lab=rowon_n[6]}
N 3440 -2850 3450 -2860 {
lab=#net13}
N 3450 -2860 3650 -2860 {
lab=#net13}
N 3650 -2860 3660 -2850 {
lab=#net13}
N 3440 -2830 3450 -2840 {
lab=#net14}
N 3450 -2840 3650 -2840 {
lab=#net14}
N 3650 -2840 3660 -2830 {
lab=#net14}
N 3500 -2990 3500 -2970 {
lab=vcm}
N 3540 -2990 3540 -2970 {
lab=ctop}
N 3420 -2890 3440 -2890 {
lab=row_n[6]}
N 3420 -2870 3440 -2870 {
lab=rowon_n[6]}
N 3420 -2850 3440 -2850 {
lab=#net13}
N 3420 -2830 3440 -2830 {
lab=#net14}
N 3660 -2830 3680 -2830 {
lab=#net14}
N 3660 -2850 3680 -2850 {
lab=#net13}
N 3660 -2870 3680 -2870 {
lab=rowon_n[6]}
N 3660 -2890 3680 -2890 {
lab=row_n[6]}
N 3480 -2750 3480 -2740 {
lab=VSS}
N 3480 -2980 3480 -2970 {
lab=VDD}
N 3820 -2750 3830 -2760 {
lab=col_n[12]}
N 3830 -2960 3830 -2760 {
lab=col_n[12]}
N 3820 -2970 3830 -2960 {
lab=col_n[12]}
N 3820 -2750 3820 -2730 {
lab=col_n[12]}
N 3820 -2990 3820 -2970 {
lab=col_n[12]}
N 3700 -2890 3710 -2900 {
lab=row_n[6]}
N 3710 -2900 3910 -2900 {
lab=row_n[6]}
N 3910 -2900 3920 -2890 {
lab=row_n[6]}
N 3700 -2870 3710 -2880 {
lab=rowon_n[6]}
N 3710 -2880 3910 -2880 {
lab=rowon_n[6]}
N 3910 -2880 3920 -2870 {
lab=rowon_n[6]}
N 3700 -2850 3710 -2860 {
lab=#net13}
N 3710 -2860 3910 -2860 {
lab=#net13}
N 3910 -2860 3920 -2850 {
lab=#net13}
N 3700 -2830 3710 -2840 {
lab=#net14}
N 3710 -2840 3910 -2840 {
lab=#net14}
N 3910 -2840 3920 -2830 {
lab=#net14}
N 3760 -2990 3760 -2970 {
lab=vcm}
N 3800 -2990 3800 -2970 {
lab=ctop}
N 3680 -2890 3700 -2890 {
lab=row_n[6]}
N 3680 -2870 3700 -2870 {
lab=rowon_n[6]}
N 3680 -2850 3700 -2850 {
lab=#net13}
N 3680 -2830 3700 -2830 {
lab=#net14}
N 3920 -2830 3940 -2830 {
lab=#net14}
N 3920 -2850 3940 -2850 {
lab=#net13}
N 3920 -2870 3940 -2870 {
lab=rowon_n[6]}
N 3920 -2890 3940 -2890 {
lab=row_n[6]}
N 3740 -2750 3740 -2740 {
lab=VSS}
N 3740 -2980 3740 -2970 {
lab=VDD}
N 4080 -2750 4090 -2760 {
lab=col_n[13]}
N 4090 -2960 4090 -2760 {
lab=col_n[13]}
N 4080 -2970 4090 -2960 {
lab=col_n[13]}
N 4080 -2750 4080 -2730 {
lab=col_n[13]}
N 4080 -2990 4080 -2970 {
lab=col_n[13]}
N 3960 -2890 3970 -2900 {
lab=row_n[6]}
N 3970 -2900 4170 -2900 {
lab=row_n[6]}
N 4170 -2900 4180 -2890 {
lab=row_n[6]}
N 3960 -2870 3970 -2880 {
lab=rowon_n[6]}
N 3970 -2880 4170 -2880 {
lab=rowon_n[6]}
N 4170 -2880 4180 -2870 {
lab=rowon_n[6]}
N 3960 -2850 3970 -2860 {
lab=#net13}
N 3970 -2860 4170 -2860 {
lab=#net13}
N 4170 -2860 4180 -2850 {
lab=#net13}
N 3960 -2830 3970 -2840 {
lab=#net14}
N 3970 -2840 4170 -2840 {
lab=#net14}
N 4170 -2840 4180 -2830 {
lab=#net14}
N 4020 -2990 4020 -2970 {
lab=vcm}
N 4060 -2990 4060 -2970 {
lab=ctop}
N 3940 -2890 3960 -2890 {
lab=row_n[6]}
N 3940 -2870 3960 -2870 {
lab=rowon_n[6]}
N 3940 -2850 3960 -2850 {
lab=#net13}
N 3940 -2830 3960 -2830 {
lab=#net14}
N 4180 -2830 4200 -2830 {
lab=#net14}
N 4180 -2850 4200 -2850 {
lab=#net13}
N 4180 -2870 4200 -2870 {
lab=rowon_n[6]}
N 4180 -2890 4200 -2890 {
lab=row_n[6]}
N 4000 -2750 4000 -2740 {
lab=VSS}
N 4000 -2980 4000 -2970 {
lab=VDD}
N 4340 -2750 4350 -2760 {
lab=col_n[14]}
N 4350 -2960 4350 -2760 {
lab=col_n[14]}
N 4340 -2970 4350 -2960 {
lab=col_n[14]}
N 4340 -2750 4340 -2730 {
lab=col_n[14]}
N 4340 -2990 4340 -2970 {
lab=col_n[14]}
N 4220 -2890 4230 -2900 {
lab=row_n[6]}
N 4230 -2900 4430 -2900 {
lab=row_n[6]}
N 4430 -2900 4440 -2890 {
lab=row_n[6]}
N 4220 -2870 4230 -2880 {
lab=rowon_n[6]}
N 4230 -2880 4430 -2880 {
lab=rowon_n[6]}
N 4430 -2880 4440 -2870 {
lab=rowon_n[6]}
N 4220 -2850 4230 -2860 {
lab=#net13}
N 4230 -2860 4430 -2860 {
lab=#net13}
N 4430 -2860 4440 -2850 {
lab=#net13}
N 4220 -2830 4230 -2840 {
lab=#net14}
N 4230 -2840 4430 -2840 {
lab=#net14}
N 4430 -2840 4440 -2830 {
lab=#net14}
N 4280 -2990 4280 -2970 {
lab=vcm}
N 4320 -2990 4320 -2970 {
lab=ctop}
N 4200 -2890 4220 -2890 {
lab=row_n[6]}
N 4200 -2870 4220 -2870 {
lab=rowon_n[6]}
N 4200 -2850 4220 -2850 {
lab=#net13}
N 4200 -2830 4220 -2830 {
lab=#net14}
N 4440 -2830 4460 -2830 {
lab=#net14}
N 4440 -2850 4460 -2850 {
lab=#net13}
N 4440 -2870 4460 -2870 {
lab=rowon_n[6]}
N 4440 -2890 4460 -2890 {
lab=row_n[6]}
N 4260 -2750 4260 -2740 {
lab=VSS}
N 4260 -2980 4260 -2970 {
lab=VDD}
N 4600 -2750 4610 -2760 {
lab=col_n[15]}
N 4610 -2960 4610 -2760 {
lab=col_n[15]}
N 4600 -2970 4610 -2960 {
lab=col_n[15]}
N 4600 -2750 4600 -2730 {
lab=col_n[15]}
N 4600 -2990 4600 -2970 {
lab=col_n[15]}
N 4480 -2890 4490 -2900 {
lab=row_n[6]}
N 4490 -2900 4690 -2900 {
lab=row_n[6]}
N 4690 -2900 4700 -2890 {
lab=row_n[6]}
N 4480 -2870 4490 -2880 {
lab=rowon_n[6]}
N 4490 -2880 4690 -2880 {
lab=rowon_n[6]}
N 4690 -2880 4700 -2870 {
lab=rowon_n[6]}
N 4480 -2850 4490 -2860 {
lab=#net13}
N 4490 -2860 4690 -2860 {
lab=#net13}
N 4690 -2860 4700 -2850 {
lab=#net13}
N 4480 -2830 4490 -2840 {
lab=#net14}
N 4490 -2840 4690 -2840 {
lab=#net14}
N 4690 -2840 4700 -2830 {
lab=#net14}
N 4540 -2990 4540 -2970 {
lab=vcm}
N 4580 -2990 4580 -2970 {
lab=ctop}
N 4460 -2890 4480 -2890 {
lab=row_n[6]}
N 4460 -2870 4480 -2870 {
lab=rowon_n[6]}
N 4460 -2850 4480 -2850 {
lab=#net13}
N 4460 -2830 4480 -2830 {
lab=#net14}
N 4700 -2830 4720 -2830 {
lab=#net14}
N 4700 -2850 4720 -2850 {
lab=#net13}
N 4700 -2870 4720 -2870 {
lab=rowon_n[6]}
N 4700 -2890 4720 -2890 {
lab=row_n[6]}
N 4520 -2750 4520 -2740 {
lab=VSS}
N 4520 -2980 4520 -2970 {
lab=VDD}
N 4860 -2750 4870 -2760 {
lab=col_n[16]}
N 4870 -2960 4870 -2760 {
lab=col_n[16]}
N 4860 -2970 4870 -2960 {
lab=col_n[16]}
N 4860 -2750 4860 -2730 {
lab=col_n[16]}
N 4860 -2990 4860 -2970 {
lab=col_n[16]}
N 4740 -2890 4750 -2900 {
lab=row_n[6]}
N 4750 -2900 4950 -2900 {
lab=row_n[6]}
N 4950 -2900 4960 -2890 {
lab=row_n[6]}
N 4740 -2870 4750 -2880 {
lab=rowon_n[6]}
N 4750 -2880 4950 -2880 {
lab=rowon_n[6]}
N 4950 -2880 4960 -2870 {
lab=rowon_n[6]}
N 4740 -2850 4750 -2860 {
lab=#net13}
N 4750 -2860 4950 -2860 {
lab=#net13}
N 4950 -2860 4960 -2850 {
lab=#net13}
N 4740 -2830 4750 -2840 {
lab=#net14}
N 4750 -2840 4950 -2840 {
lab=#net14}
N 4950 -2840 4960 -2830 {
lab=#net14}
N 4800 -2990 4800 -2970 {
lab=vcm}
N 4840 -2990 4840 -2970 {
lab=ctop}
N 4720 -2890 4740 -2890 {
lab=row_n[6]}
N 4720 -2870 4740 -2870 {
lab=rowon_n[6]}
N 4720 -2850 4740 -2850 {
lab=#net13}
N 4720 -2830 4740 -2830 {
lab=#net14}
N 4960 -2830 4980 -2830 {
lab=#net14}
N 4960 -2850 4980 -2850 {
lab=#net13}
N 4960 -2870 4980 -2870 {
lab=rowon_n[6]}
N 4960 -2890 4980 -2890 {
lab=row_n[6]}
N 4780 -2750 4780 -2740 {
lab=VSS}
N 4780 -2980 4780 -2970 {
lab=VDD}
N 5120 -2750 5130 -2760 {
lab=col_n[17]}
N 5130 -2960 5130 -2760 {
lab=col_n[17]}
N 5120 -2970 5130 -2960 {
lab=col_n[17]}
N 5120 -2750 5120 -2730 {
lab=col_n[17]}
N 5120 -2990 5120 -2970 {
lab=col_n[17]}
N 5000 -2890 5010 -2900 {
lab=row_n[6]}
N 5010 -2900 5210 -2900 {
lab=row_n[6]}
N 5210 -2900 5220 -2890 {
lab=row_n[6]}
N 5000 -2870 5010 -2880 {
lab=rowon_n[6]}
N 5010 -2880 5210 -2880 {
lab=rowon_n[6]}
N 5210 -2880 5220 -2870 {
lab=rowon_n[6]}
N 5000 -2850 5010 -2860 {
lab=#net13}
N 5010 -2860 5210 -2860 {
lab=#net13}
N 5210 -2860 5220 -2850 {
lab=#net13}
N 5000 -2830 5010 -2840 {
lab=#net14}
N 5010 -2840 5210 -2840 {
lab=#net14}
N 5210 -2840 5220 -2830 {
lab=#net14}
N 5060 -2990 5060 -2970 {
lab=vcm}
N 5100 -2990 5100 -2970 {
lab=ctop}
N 4980 -2890 5000 -2890 {
lab=row_n[6]}
N 4980 -2870 5000 -2870 {
lab=rowon_n[6]}
N 4980 -2850 5000 -2850 {
lab=#net13}
N 4980 -2830 5000 -2830 {
lab=#net14}
N 5220 -2830 5240 -2830 {
lab=#net14}
N 5220 -2850 5240 -2850 {
lab=#net13}
N 5220 -2870 5240 -2870 {
lab=rowon_n[6]}
N 5220 -2890 5240 -2890 {
lab=row_n[6]}
N 5040 -2750 5040 -2740 {
lab=VSS}
N 5040 -2980 5040 -2970 {
lab=VDD}
N 5380 -2750 5390 -2760 {
lab=col_n[18]}
N 5390 -2960 5390 -2760 {
lab=col_n[18]}
N 5380 -2970 5390 -2960 {
lab=col_n[18]}
N 5380 -2750 5380 -2730 {
lab=col_n[18]}
N 5380 -2990 5380 -2970 {
lab=col_n[18]}
N 5260 -2890 5270 -2900 {
lab=row_n[6]}
N 5270 -2900 5470 -2900 {
lab=row_n[6]}
N 5470 -2900 5480 -2890 {
lab=row_n[6]}
N 5260 -2870 5270 -2880 {
lab=rowon_n[6]}
N 5270 -2880 5470 -2880 {
lab=rowon_n[6]}
N 5470 -2880 5480 -2870 {
lab=rowon_n[6]}
N 5260 -2850 5270 -2860 {
lab=#net13}
N 5270 -2860 5470 -2860 {
lab=#net13}
N 5470 -2860 5480 -2850 {
lab=#net13}
N 5260 -2830 5270 -2840 {
lab=#net14}
N 5270 -2840 5470 -2840 {
lab=#net14}
N 5470 -2840 5480 -2830 {
lab=#net14}
N 5320 -2990 5320 -2970 {
lab=vcm}
N 5360 -2990 5360 -2970 {
lab=ctop}
N 5240 -2890 5260 -2890 {
lab=row_n[6]}
N 5240 -2870 5260 -2870 {
lab=rowon_n[6]}
N 5240 -2850 5260 -2850 {
lab=#net13}
N 5240 -2830 5260 -2830 {
lab=#net14}
N 5480 -2830 5500 -2830 {
lab=#net14}
N 5480 -2850 5500 -2850 {
lab=#net13}
N 5480 -2870 5500 -2870 {
lab=rowon_n[6]}
N 5480 -2890 5500 -2890 {
lab=row_n[6]}
N 5300 -2750 5300 -2740 {
lab=VSS}
N 5300 -2980 5300 -2970 {
lab=VDD}
N 5640 -2750 5650 -2760 {
lab=col_n[19]}
N 5650 -2960 5650 -2760 {
lab=col_n[19]}
N 5640 -2970 5650 -2960 {
lab=col_n[19]}
N 5640 -2750 5640 -2730 {
lab=col_n[19]}
N 5640 -2990 5640 -2970 {
lab=col_n[19]}
N 5520 -2890 5530 -2900 {
lab=row_n[6]}
N 5530 -2900 5730 -2900 {
lab=row_n[6]}
N 5730 -2900 5740 -2890 {
lab=row_n[6]}
N 5520 -2870 5530 -2880 {
lab=rowon_n[6]}
N 5530 -2880 5730 -2880 {
lab=rowon_n[6]}
N 5730 -2880 5740 -2870 {
lab=rowon_n[6]}
N 5520 -2850 5530 -2860 {
lab=#net13}
N 5530 -2860 5730 -2860 {
lab=#net13}
N 5730 -2860 5740 -2850 {
lab=#net13}
N 5520 -2830 5530 -2840 {
lab=#net14}
N 5530 -2840 5730 -2840 {
lab=#net14}
N 5730 -2840 5740 -2830 {
lab=#net14}
N 5580 -2990 5580 -2970 {
lab=vcm}
N 5620 -2990 5620 -2970 {
lab=ctop}
N 5500 -2890 5520 -2890 {
lab=row_n[6]}
N 5500 -2870 5520 -2870 {
lab=rowon_n[6]}
N 5500 -2850 5520 -2850 {
lab=#net13}
N 5500 -2830 5520 -2830 {
lab=#net14}
N 5740 -2830 5760 -2830 {
lab=#net14}
N 5740 -2850 5760 -2850 {
lab=#net13}
N 5740 -2870 5760 -2870 {
lab=rowon_n[6]}
N 5740 -2890 5760 -2890 {
lab=row_n[6]}
N 5560 -2750 5560 -2740 {
lab=VSS}
N 5560 -2980 5560 -2970 {
lab=VDD}
N 5900 -2750 5910 -2760 {
lab=col_n[20]}
N 5910 -2960 5910 -2760 {
lab=col_n[20]}
N 5900 -2970 5910 -2960 {
lab=col_n[20]}
N 5900 -2750 5900 -2730 {
lab=col_n[20]}
N 5900 -2990 5900 -2970 {
lab=col_n[20]}
N 5780 -2890 5790 -2900 {
lab=row_n[6]}
N 5790 -2900 5990 -2900 {
lab=row_n[6]}
N 5990 -2900 6000 -2890 {
lab=row_n[6]}
N 5780 -2870 5790 -2880 {
lab=rowon_n[6]}
N 5790 -2880 5990 -2880 {
lab=rowon_n[6]}
N 5990 -2880 6000 -2870 {
lab=rowon_n[6]}
N 5780 -2850 5790 -2860 {
lab=#net13}
N 5790 -2860 5990 -2860 {
lab=#net13}
N 5990 -2860 6000 -2850 {
lab=#net13}
N 5780 -2830 5790 -2840 {
lab=#net14}
N 5790 -2840 5990 -2840 {
lab=#net14}
N 5990 -2840 6000 -2830 {
lab=#net14}
N 5840 -2990 5840 -2970 {
lab=vcm}
N 5880 -2990 5880 -2970 {
lab=ctop}
N 5760 -2890 5780 -2890 {
lab=row_n[6]}
N 5760 -2870 5780 -2870 {
lab=rowon_n[6]}
N 5760 -2850 5780 -2850 {
lab=#net13}
N 5760 -2830 5780 -2830 {
lab=#net14}
N 6000 -2830 6020 -2830 {
lab=#net14}
N 6000 -2850 6020 -2850 {
lab=#net13}
N 6000 -2870 6020 -2870 {
lab=rowon_n[6]}
N 6000 -2890 6020 -2890 {
lab=row_n[6]}
N 5820 -2750 5820 -2740 {
lab=VSS}
N 5820 -2980 5820 -2970 {
lab=VDD}
N 6160 -2750 6170 -2760 {
lab=col_n[21]}
N 6170 -2960 6170 -2760 {
lab=col_n[21]}
N 6160 -2970 6170 -2960 {
lab=col_n[21]}
N 6160 -2750 6160 -2730 {
lab=col_n[21]}
N 6160 -2990 6160 -2970 {
lab=col_n[21]}
N 6040 -2890 6050 -2900 {
lab=row_n[6]}
N 6050 -2900 6250 -2900 {
lab=row_n[6]}
N 6250 -2900 6260 -2890 {
lab=row_n[6]}
N 6040 -2870 6050 -2880 {
lab=rowon_n[6]}
N 6050 -2880 6250 -2880 {
lab=rowon_n[6]}
N 6250 -2880 6260 -2870 {
lab=rowon_n[6]}
N 6040 -2850 6050 -2860 {
lab=#net13}
N 6050 -2860 6250 -2860 {
lab=#net13}
N 6250 -2860 6260 -2850 {
lab=#net13}
N 6040 -2830 6050 -2840 {
lab=#net14}
N 6050 -2840 6250 -2840 {
lab=#net14}
N 6250 -2840 6260 -2830 {
lab=#net14}
N 6100 -2990 6100 -2970 {
lab=vcm}
N 6140 -2990 6140 -2970 {
lab=ctop}
N 6020 -2890 6040 -2890 {
lab=row_n[6]}
N 6020 -2870 6040 -2870 {
lab=rowon_n[6]}
N 6020 -2850 6040 -2850 {
lab=#net13}
N 6020 -2830 6040 -2830 {
lab=#net14}
N 6260 -2830 6280 -2830 {
lab=#net14}
N 6260 -2850 6280 -2850 {
lab=#net13}
N 6260 -2870 6280 -2870 {
lab=rowon_n[6]}
N 6260 -2890 6280 -2890 {
lab=row_n[6]}
N 6080 -2750 6080 -2740 {
lab=VSS}
N 6080 -2980 6080 -2970 {
lab=VDD}
N 6420 -2750 6430 -2760 {
lab=col_n[22]}
N 6430 -2960 6430 -2760 {
lab=col_n[22]}
N 6420 -2970 6430 -2960 {
lab=col_n[22]}
N 6420 -2750 6420 -2730 {
lab=col_n[22]}
N 6420 -2990 6420 -2970 {
lab=col_n[22]}
N 6300 -2890 6310 -2900 {
lab=row_n[6]}
N 6310 -2900 6510 -2900 {
lab=row_n[6]}
N 6510 -2900 6520 -2890 {
lab=row_n[6]}
N 6300 -2870 6310 -2880 {
lab=rowon_n[6]}
N 6310 -2880 6510 -2880 {
lab=rowon_n[6]}
N 6510 -2880 6520 -2870 {
lab=rowon_n[6]}
N 6300 -2850 6310 -2860 {
lab=#net13}
N 6310 -2860 6510 -2860 {
lab=#net13}
N 6510 -2860 6520 -2850 {
lab=#net13}
N 6300 -2830 6310 -2840 {
lab=#net14}
N 6310 -2840 6510 -2840 {
lab=#net14}
N 6510 -2840 6520 -2830 {
lab=#net14}
N 6360 -2990 6360 -2970 {
lab=vcm}
N 6400 -2990 6400 -2970 {
lab=ctop}
N 6280 -2890 6300 -2890 {
lab=row_n[6]}
N 6280 -2870 6300 -2870 {
lab=rowon_n[6]}
N 6280 -2850 6300 -2850 {
lab=#net13}
N 6280 -2830 6300 -2830 {
lab=#net14}
N 6520 -2830 6540 -2830 {
lab=#net14}
N 6520 -2850 6540 -2850 {
lab=#net13}
N 6520 -2870 6540 -2870 {
lab=rowon_n[6]}
N 6520 -2890 6540 -2890 {
lab=row_n[6]}
N 6340 -2750 6340 -2740 {
lab=VSS}
N 6340 -2980 6340 -2970 {
lab=VDD}
N 6680 -2750 6690 -2760 {
lab=col_n[23]}
N 6690 -2960 6690 -2760 {
lab=col_n[23]}
N 6680 -2970 6690 -2960 {
lab=col_n[23]}
N 6680 -2750 6680 -2730 {
lab=col_n[23]}
N 6680 -2990 6680 -2970 {
lab=col_n[23]}
N 6560 -2890 6570 -2900 {
lab=row_n[6]}
N 6570 -2900 6770 -2900 {
lab=row_n[6]}
N 6770 -2900 6780 -2890 {
lab=row_n[6]}
N 6560 -2870 6570 -2880 {
lab=rowon_n[6]}
N 6570 -2880 6770 -2880 {
lab=rowon_n[6]}
N 6770 -2880 6780 -2870 {
lab=rowon_n[6]}
N 6560 -2850 6570 -2860 {
lab=#net13}
N 6570 -2860 6770 -2860 {
lab=#net13}
N 6770 -2860 6780 -2850 {
lab=#net13}
N 6560 -2830 6570 -2840 {
lab=#net14}
N 6570 -2840 6770 -2840 {
lab=#net14}
N 6770 -2840 6780 -2830 {
lab=#net14}
N 6620 -2990 6620 -2970 {
lab=vcm}
N 6660 -2990 6660 -2970 {
lab=ctop}
N 6540 -2890 6560 -2890 {
lab=row_n[6]}
N 6540 -2870 6560 -2870 {
lab=rowon_n[6]}
N 6540 -2850 6560 -2850 {
lab=#net13}
N 6540 -2830 6560 -2830 {
lab=#net14}
N 6780 -2830 6800 -2830 {
lab=#net14}
N 6780 -2850 6800 -2850 {
lab=#net13}
N 6780 -2870 6800 -2870 {
lab=rowon_n[6]}
N 6780 -2890 6800 -2890 {
lab=row_n[6]}
N 6600 -2750 6600 -2740 {
lab=VSS}
N 6600 -2980 6600 -2970 {
lab=VDD}
N 6940 -2750 6950 -2760 {
lab=col_n[24]}
N 6950 -2960 6950 -2760 {
lab=col_n[24]}
N 6940 -2970 6950 -2960 {
lab=col_n[24]}
N 6940 -2750 6940 -2730 {
lab=col_n[24]}
N 6940 -2990 6940 -2970 {
lab=col_n[24]}
N 6820 -2890 6830 -2900 {
lab=row_n[6]}
N 6830 -2900 7030 -2900 {
lab=row_n[6]}
N 7030 -2900 7040 -2890 {
lab=row_n[6]}
N 6820 -2870 6830 -2880 {
lab=rowon_n[6]}
N 6830 -2880 7030 -2880 {
lab=rowon_n[6]}
N 7030 -2880 7040 -2870 {
lab=rowon_n[6]}
N 6820 -2850 6830 -2860 {
lab=#net13}
N 6830 -2860 7030 -2860 {
lab=#net13}
N 7030 -2860 7040 -2850 {
lab=#net13}
N 6820 -2830 6830 -2840 {
lab=#net14}
N 6830 -2840 7030 -2840 {
lab=#net14}
N 7030 -2840 7040 -2830 {
lab=#net14}
N 6880 -2990 6880 -2970 {
lab=vcm}
N 6920 -2990 6920 -2970 {
lab=ctop}
N 6800 -2890 6820 -2890 {
lab=row_n[6]}
N 6800 -2870 6820 -2870 {
lab=rowon_n[6]}
N 6800 -2850 6820 -2850 {
lab=#net13}
N 6800 -2830 6820 -2830 {
lab=#net14}
N 7040 -2830 7060 -2830 {
lab=#net14}
N 7040 -2850 7060 -2850 {
lab=#net13}
N 7040 -2870 7060 -2870 {
lab=rowon_n[6]}
N 7040 -2890 7060 -2890 {
lab=row_n[6]}
N 6860 -2750 6860 -2740 {
lab=VSS}
N 6860 -2980 6860 -2970 {
lab=VDD}
N 7200 -2750 7210 -2760 {
lab=col_n[25]}
N 7210 -2960 7210 -2760 {
lab=col_n[25]}
N 7200 -2970 7210 -2960 {
lab=col_n[25]}
N 7200 -2750 7200 -2730 {
lab=col_n[25]}
N 7200 -2990 7200 -2970 {
lab=col_n[25]}
N 7080 -2890 7090 -2900 {
lab=row_n[6]}
N 7090 -2900 7290 -2900 {
lab=row_n[6]}
N 7290 -2900 7300 -2890 {
lab=row_n[6]}
N 7080 -2870 7090 -2880 {
lab=rowon_n[6]}
N 7090 -2880 7290 -2880 {
lab=rowon_n[6]}
N 7290 -2880 7300 -2870 {
lab=rowon_n[6]}
N 7080 -2850 7090 -2860 {
lab=#net13}
N 7090 -2860 7290 -2860 {
lab=#net13}
N 7290 -2860 7300 -2850 {
lab=#net13}
N 7080 -2830 7090 -2840 {
lab=#net14}
N 7090 -2840 7290 -2840 {
lab=#net14}
N 7290 -2840 7300 -2830 {
lab=#net14}
N 7140 -2990 7140 -2970 {
lab=vcm}
N 7180 -2990 7180 -2970 {
lab=ctop}
N 7060 -2890 7080 -2890 {
lab=row_n[6]}
N 7060 -2870 7080 -2870 {
lab=rowon_n[6]}
N 7060 -2850 7080 -2850 {
lab=#net13}
N 7060 -2830 7080 -2830 {
lab=#net14}
N 7300 -2830 7320 -2830 {
lab=#net14}
N 7300 -2850 7320 -2850 {
lab=#net13}
N 7300 -2870 7320 -2870 {
lab=rowon_n[6]}
N 7300 -2890 7320 -2890 {
lab=row_n[6]}
N 7120 -2750 7120 -2740 {
lab=VSS}
N 7120 -2980 7120 -2970 {
lab=VDD}
N 7460 -2750 7470 -2760 {
lab=col_n[26]}
N 7470 -2960 7470 -2760 {
lab=col_n[26]}
N 7460 -2970 7470 -2960 {
lab=col_n[26]}
N 7460 -2750 7460 -2730 {
lab=col_n[26]}
N 7460 -2990 7460 -2970 {
lab=col_n[26]}
N 7340 -2890 7350 -2900 {
lab=row_n[6]}
N 7350 -2900 7550 -2900 {
lab=row_n[6]}
N 7550 -2900 7560 -2890 {
lab=row_n[6]}
N 7340 -2870 7350 -2880 {
lab=rowon_n[6]}
N 7350 -2880 7550 -2880 {
lab=rowon_n[6]}
N 7550 -2880 7560 -2870 {
lab=rowon_n[6]}
N 7340 -2850 7350 -2860 {
lab=#net13}
N 7350 -2860 7550 -2860 {
lab=#net13}
N 7550 -2860 7560 -2850 {
lab=#net13}
N 7340 -2830 7350 -2840 {
lab=#net14}
N 7350 -2840 7550 -2840 {
lab=#net14}
N 7550 -2840 7560 -2830 {
lab=#net14}
N 7400 -2990 7400 -2970 {
lab=vcm}
N 7440 -2990 7440 -2970 {
lab=ctop}
N 7320 -2890 7340 -2890 {
lab=row_n[6]}
N 7320 -2870 7340 -2870 {
lab=rowon_n[6]}
N 7320 -2850 7340 -2850 {
lab=#net13}
N 7320 -2830 7340 -2830 {
lab=#net14}
N 7560 -2830 7580 -2830 {
lab=#net14}
N 7560 -2850 7580 -2850 {
lab=#net13}
N 7560 -2870 7580 -2870 {
lab=rowon_n[6]}
N 7560 -2890 7580 -2890 {
lab=row_n[6]}
N 7380 -2750 7380 -2740 {
lab=VSS}
N 7380 -2980 7380 -2970 {
lab=VDD}
N 7720 -2750 7730 -2760 {
lab=col_n[27]}
N 7730 -2960 7730 -2760 {
lab=col_n[27]}
N 7720 -2970 7730 -2960 {
lab=col_n[27]}
N 7720 -2750 7720 -2730 {
lab=col_n[27]}
N 7720 -2990 7720 -2970 {
lab=col_n[27]}
N 7600 -2890 7610 -2900 {
lab=row_n[6]}
N 7610 -2900 7810 -2900 {
lab=row_n[6]}
N 7810 -2900 7820 -2890 {
lab=row_n[6]}
N 7600 -2870 7610 -2880 {
lab=rowon_n[6]}
N 7610 -2880 7810 -2880 {
lab=rowon_n[6]}
N 7810 -2880 7820 -2870 {
lab=rowon_n[6]}
N 7600 -2850 7610 -2860 {
lab=#net13}
N 7610 -2860 7810 -2860 {
lab=#net13}
N 7810 -2860 7820 -2850 {
lab=#net13}
N 7600 -2830 7610 -2840 {
lab=#net14}
N 7610 -2840 7810 -2840 {
lab=#net14}
N 7810 -2840 7820 -2830 {
lab=#net14}
N 7660 -2990 7660 -2970 {
lab=vcm}
N 7700 -2990 7700 -2970 {
lab=ctop}
N 7580 -2890 7600 -2890 {
lab=row_n[6]}
N 7580 -2870 7600 -2870 {
lab=rowon_n[6]}
N 7580 -2850 7600 -2850 {
lab=#net13}
N 7580 -2830 7600 -2830 {
lab=#net14}
N 7820 -2830 7840 -2830 {
lab=#net14}
N 7820 -2850 7840 -2850 {
lab=#net13}
N 7820 -2870 7840 -2870 {
lab=rowon_n[6]}
N 7820 -2890 7840 -2890 {
lab=row_n[6]}
N 7640 -2750 7640 -2740 {
lab=VSS}
N 7640 -2980 7640 -2970 {
lab=VDD}
N 7980 -2750 7990 -2760 {
lab=col_n[28]}
N 7990 -2960 7990 -2760 {
lab=col_n[28]}
N 7980 -2970 7990 -2960 {
lab=col_n[28]}
N 7980 -2750 7980 -2730 {
lab=col_n[28]}
N 7980 -2990 7980 -2970 {
lab=col_n[28]}
N 7860 -2890 7870 -2900 {
lab=row_n[6]}
N 7870 -2900 8070 -2900 {
lab=row_n[6]}
N 8070 -2900 8080 -2890 {
lab=row_n[6]}
N 7860 -2870 7870 -2880 {
lab=rowon_n[6]}
N 7870 -2880 8070 -2880 {
lab=rowon_n[6]}
N 8070 -2880 8080 -2870 {
lab=rowon_n[6]}
N 7860 -2850 7870 -2860 {
lab=#net13}
N 7870 -2860 8070 -2860 {
lab=#net13}
N 8070 -2860 8080 -2850 {
lab=#net13}
N 7860 -2830 7870 -2840 {
lab=#net14}
N 7870 -2840 8070 -2840 {
lab=#net14}
N 8070 -2840 8080 -2830 {
lab=#net14}
N 7920 -2990 7920 -2970 {
lab=vcm}
N 7960 -2990 7960 -2970 {
lab=ctop}
N 7840 -2890 7860 -2890 {
lab=row_n[6]}
N 7840 -2870 7860 -2870 {
lab=rowon_n[6]}
N 7840 -2850 7860 -2850 {
lab=#net13}
N 7840 -2830 7860 -2830 {
lab=#net14}
N 8080 -2830 8100 -2830 {
lab=#net14}
N 8080 -2850 8100 -2850 {
lab=#net13}
N 8080 -2870 8100 -2870 {
lab=rowon_n[6]}
N 8080 -2890 8100 -2890 {
lab=row_n[6]}
N 7900 -2750 7900 -2740 {
lab=VSS}
N 7900 -2980 7900 -2970 {
lab=VDD}
N 8240 -2750 8250 -2760 {
lab=col_n[29]}
N 8250 -2960 8250 -2760 {
lab=col_n[29]}
N 8240 -2970 8250 -2960 {
lab=col_n[29]}
N 8240 -2750 8240 -2730 {
lab=col_n[29]}
N 8240 -2990 8240 -2970 {
lab=col_n[29]}
N 8120 -2890 8130 -2900 {
lab=row_n[6]}
N 8130 -2900 8330 -2900 {
lab=row_n[6]}
N 8330 -2900 8340 -2890 {
lab=row_n[6]}
N 8120 -2870 8130 -2880 {
lab=rowon_n[6]}
N 8130 -2880 8330 -2880 {
lab=rowon_n[6]}
N 8330 -2880 8340 -2870 {
lab=rowon_n[6]}
N 8120 -2850 8130 -2860 {
lab=#net13}
N 8130 -2860 8330 -2860 {
lab=#net13}
N 8330 -2860 8340 -2850 {
lab=#net13}
N 8120 -2830 8130 -2840 {
lab=#net14}
N 8130 -2840 8330 -2840 {
lab=#net14}
N 8330 -2840 8340 -2830 {
lab=#net14}
N 8180 -2990 8180 -2970 {
lab=vcm}
N 8220 -2990 8220 -2970 {
lab=ctop}
N 8100 -2890 8120 -2890 {
lab=row_n[6]}
N 8100 -2870 8120 -2870 {
lab=rowon_n[6]}
N 8100 -2850 8120 -2850 {
lab=#net13}
N 8100 -2830 8120 -2830 {
lab=#net14}
N 8340 -2830 8360 -2830 {
lab=#net14}
N 8340 -2850 8360 -2850 {
lab=#net13}
N 8340 -2870 8360 -2870 {
lab=rowon_n[6]}
N 8340 -2890 8360 -2890 {
lab=row_n[6]}
N 8160 -2750 8160 -2740 {
lab=VSS}
N 8160 -2980 8160 -2970 {
lab=VDD}
N 8500 -2750 8510 -2760 {
lab=col_n[30]}
N 8510 -2960 8510 -2760 {
lab=col_n[30]}
N 8500 -2970 8510 -2960 {
lab=col_n[30]}
N 8500 -2750 8500 -2730 {
lab=col_n[30]}
N 8500 -2990 8500 -2970 {
lab=col_n[30]}
N 8380 -2890 8390 -2900 {
lab=row_n[6]}
N 8390 -2900 8590 -2900 {
lab=row_n[6]}
N 8590 -2900 8600 -2890 {
lab=row_n[6]}
N 8380 -2870 8390 -2880 {
lab=rowon_n[6]}
N 8390 -2880 8590 -2880 {
lab=rowon_n[6]}
N 8590 -2880 8600 -2870 {
lab=rowon_n[6]}
N 8380 -2850 8390 -2860 {
lab=#net13}
N 8390 -2860 8590 -2860 {
lab=#net13}
N 8590 -2860 8600 -2850 {
lab=#net13}
N 8380 -2830 8390 -2840 {
lab=#net14}
N 8390 -2840 8590 -2840 {
lab=#net14}
N 8590 -2840 8600 -2830 {
lab=#net14}
N 8440 -2990 8440 -2970 {
lab=vcm}
N 8480 -2990 8480 -2970 {
lab=ctop}
N 8360 -2890 8380 -2890 {
lab=row_n[6]}
N 8360 -2870 8380 -2870 {
lab=rowon_n[6]}
N 8360 -2850 8380 -2850 {
lab=#net13}
N 8360 -2830 8380 -2830 {
lab=#net14}
N 8600 -2830 8620 -2830 {
lab=#net14}
N 8600 -2850 8620 -2850 {
lab=#net13}
N 8600 -2870 8620 -2870 {
lab=rowon_n[6]}
N 8600 -2890 8620 -2890 {
lab=row_n[6]}
N 8420 -2750 8420 -2740 {
lab=VSS}
N 8420 -2980 8420 -2970 {
lab=VDD}
N 8760 -2750 8770 -2760 {
lab=col_n[31]}
N 8770 -2960 8770 -2760 {
lab=col_n[31]}
N 8760 -2970 8770 -2960 {
lab=col_n[31]}
N 8760 -2750 8760 -2730 {
lab=col_n[31]}
N 8760 -2990 8760 -2970 {
lab=col_n[31]}
N 8640 -2890 8650 -2900 {
lab=row_n[6]}
N 8650 -2900 8850 -2900 {
lab=row_n[6]}
N 8850 -2900 8860 -2890 {
lab=row_n[6]}
N 8640 -2870 8650 -2880 {
lab=rowon_n[6]}
N 8650 -2880 8850 -2880 {
lab=rowon_n[6]}
N 8850 -2880 8860 -2870 {
lab=rowon_n[6]}
N 8640 -2850 8650 -2860 {
lab=#net13}
N 8650 -2860 8850 -2860 {
lab=#net13}
N 8850 -2860 8860 -2850 {
lab=#net13}
N 8640 -2830 8650 -2840 {
lab=#net14}
N 8650 -2840 8850 -2840 {
lab=#net14}
N 8850 -2840 8860 -2830 {
lab=#net14}
N 8700 -2990 8700 -2970 {
lab=vcm}
N 8740 -2990 8740 -2970 {
lab=ctop}
N 8620 -2890 8640 -2890 {
lab=row_n[6]}
N 8620 -2870 8640 -2870 {
lab=rowon_n[6]}
N 8620 -2850 8640 -2850 {
lab=#net13}
N 8620 -2830 8640 -2830 {
lab=#net14}
N 8860 -2830 8880 -2830 {
lab=#net14}
N 8860 -2850 8880 -2850 {
lab=#net13}
N 8860 -2870 8880 -2870 {
lab=rowon_n[6]}
N 8860 -2890 8880 -2890 {
lab=row_n[6]}
N 8680 -2750 8680 -2740 {
lab=VSS}
N 8680 -2980 8680 -2970 {
lab=VDD}
N 700 -3010 710 -3020 {
lab=col_n[0]}
N 710 -3220 710 -3020 {
lab=col_n[0]}
N 700 -3230 710 -3220 {
lab=col_n[0]}
N 700 -3010 700 -2990 {
lab=col_n[0]}
N 700 -3250 700 -3230 {
lab=col_n[0]}
N 580 -3150 590 -3160 {
lab=row_n[7]}
N 590 -3160 790 -3160 {
lab=row_n[7]}
N 790 -3160 800 -3150 {
lab=row_n[7]}
N 580 -3130 590 -3140 {
lab=rowon_n[7]}
N 590 -3140 790 -3140 {
lab=rowon_n[7]}
N 790 -3140 800 -3130 {
lab=rowon_n[7]}
N 580 -3110 590 -3120 {
lab=#net15}
N 590 -3120 790 -3120 {
lab=#net15}
N 790 -3120 800 -3110 {
lab=#net15}
N 580 -3090 590 -3100 {
lab=#net16}
N 590 -3100 790 -3100 {
lab=#net16}
N 790 -3100 800 -3090 {
lab=#net16}
N 640 -3250 640 -3230 {
lab=vcm}
N 680 -3250 680 -3230 {
lab=ctop}
N 560 -3150 580 -3150 {
lab=row_n[7]}
N 560 -3130 580 -3130 {
lab=rowon_n[7]}
N 560 -3110 580 -3110 {
lab=#net15}
N 560 -3090 580 -3090 {
lab=#net16}
N 800 -3090 820 -3090 {
lab=#net16}
N 800 -3110 820 -3110 {
lab=#net15}
N 800 -3130 820 -3130 {
lab=rowon_n[7]}
N 800 -3150 820 -3150 {
lab=row_n[7]}
N 620 -3010 620 -3000 {
lab=VSS}
N 620 -3240 620 -3230 {
lab=VDD}
N 960 -3010 970 -3020 {
lab=col_n[1]}
N 970 -3220 970 -3020 {
lab=col_n[1]}
N 960 -3230 970 -3220 {
lab=col_n[1]}
N 960 -3010 960 -2990 {
lab=col_n[1]}
N 960 -3250 960 -3230 {
lab=col_n[1]}
N 840 -3150 850 -3160 {
lab=row_n[7]}
N 850 -3160 1050 -3160 {
lab=row_n[7]}
N 1050 -3160 1060 -3150 {
lab=row_n[7]}
N 840 -3130 850 -3140 {
lab=rowon_n[7]}
N 850 -3140 1050 -3140 {
lab=rowon_n[7]}
N 1050 -3140 1060 -3130 {
lab=rowon_n[7]}
N 840 -3110 850 -3120 {
lab=#net15}
N 850 -3120 1050 -3120 {
lab=#net15}
N 1050 -3120 1060 -3110 {
lab=#net15}
N 840 -3090 850 -3100 {
lab=#net16}
N 850 -3100 1050 -3100 {
lab=#net16}
N 1050 -3100 1060 -3090 {
lab=#net16}
N 900 -3250 900 -3230 {
lab=vcm}
N 940 -3250 940 -3230 {
lab=ctop}
N 820 -3150 840 -3150 {
lab=row_n[7]}
N 820 -3130 840 -3130 {
lab=rowon_n[7]}
N 820 -3110 840 -3110 {
lab=#net15}
N 820 -3090 840 -3090 {
lab=#net16}
N 1060 -3090 1080 -3090 {
lab=#net16}
N 1060 -3110 1080 -3110 {
lab=#net15}
N 1060 -3130 1080 -3130 {
lab=rowon_n[7]}
N 1060 -3150 1080 -3150 {
lab=row_n[7]}
N 880 -3010 880 -3000 {
lab=VSS}
N 880 -3240 880 -3230 {
lab=VDD}
N 1220 -3010 1230 -3020 {
lab=col_n[2]}
N 1230 -3220 1230 -3020 {
lab=col_n[2]}
N 1220 -3230 1230 -3220 {
lab=col_n[2]}
N 1220 -3010 1220 -2990 {
lab=col_n[2]}
N 1220 -3250 1220 -3230 {
lab=col_n[2]}
N 1100 -3150 1110 -3160 {
lab=row_n[7]}
N 1110 -3160 1310 -3160 {
lab=row_n[7]}
N 1310 -3160 1320 -3150 {
lab=row_n[7]}
N 1100 -3130 1110 -3140 {
lab=rowon_n[7]}
N 1110 -3140 1310 -3140 {
lab=rowon_n[7]}
N 1310 -3140 1320 -3130 {
lab=rowon_n[7]}
N 1100 -3110 1110 -3120 {
lab=#net15}
N 1110 -3120 1310 -3120 {
lab=#net15}
N 1310 -3120 1320 -3110 {
lab=#net15}
N 1100 -3090 1110 -3100 {
lab=#net16}
N 1110 -3100 1310 -3100 {
lab=#net16}
N 1310 -3100 1320 -3090 {
lab=#net16}
N 1160 -3250 1160 -3230 {
lab=vcm}
N 1200 -3250 1200 -3230 {
lab=ctop}
N 1080 -3150 1100 -3150 {
lab=row_n[7]}
N 1080 -3130 1100 -3130 {
lab=rowon_n[7]}
N 1080 -3110 1100 -3110 {
lab=#net15}
N 1080 -3090 1100 -3090 {
lab=#net16}
N 1320 -3090 1340 -3090 {
lab=#net16}
N 1320 -3110 1340 -3110 {
lab=#net15}
N 1320 -3130 1340 -3130 {
lab=rowon_n[7]}
N 1320 -3150 1340 -3150 {
lab=row_n[7]}
N 1140 -3010 1140 -3000 {
lab=VSS}
N 1140 -3240 1140 -3230 {
lab=VDD}
N 1480 -3010 1490 -3020 {
lab=col_n[3]}
N 1490 -3220 1490 -3020 {
lab=col_n[3]}
N 1480 -3230 1490 -3220 {
lab=col_n[3]}
N 1480 -3010 1480 -2990 {
lab=col_n[3]}
N 1480 -3250 1480 -3230 {
lab=col_n[3]}
N 1360 -3150 1370 -3160 {
lab=row_n[7]}
N 1370 -3160 1570 -3160 {
lab=row_n[7]}
N 1570 -3160 1580 -3150 {
lab=row_n[7]}
N 1360 -3130 1370 -3140 {
lab=rowon_n[7]}
N 1370 -3140 1570 -3140 {
lab=rowon_n[7]}
N 1570 -3140 1580 -3130 {
lab=rowon_n[7]}
N 1360 -3110 1370 -3120 {
lab=#net15}
N 1370 -3120 1570 -3120 {
lab=#net15}
N 1570 -3120 1580 -3110 {
lab=#net15}
N 1360 -3090 1370 -3100 {
lab=#net16}
N 1370 -3100 1570 -3100 {
lab=#net16}
N 1570 -3100 1580 -3090 {
lab=#net16}
N 1420 -3250 1420 -3230 {
lab=vcm}
N 1460 -3250 1460 -3230 {
lab=ctop}
N 1340 -3150 1360 -3150 {
lab=row_n[7]}
N 1340 -3130 1360 -3130 {
lab=rowon_n[7]}
N 1340 -3110 1360 -3110 {
lab=#net15}
N 1340 -3090 1360 -3090 {
lab=#net16}
N 1580 -3090 1600 -3090 {
lab=#net16}
N 1580 -3110 1600 -3110 {
lab=#net15}
N 1580 -3130 1600 -3130 {
lab=rowon_n[7]}
N 1580 -3150 1600 -3150 {
lab=row_n[7]}
N 1400 -3010 1400 -3000 {
lab=VSS}
N 1400 -3240 1400 -3230 {
lab=VDD}
N 1740 -3010 1750 -3020 {
lab=col_n[4]}
N 1750 -3220 1750 -3020 {
lab=col_n[4]}
N 1740 -3230 1750 -3220 {
lab=col_n[4]}
N 1740 -3010 1740 -2990 {
lab=col_n[4]}
N 1740 -3250 1740 -3230 {
lab=col_n[4]}
N 1620 -3150 1630 -3160 {
lab=row_n[7]}
N 1630 -3160 1830 -3160 {
lab=row_n[7]}
N 1830 -3160 1840 -3150 {
lab=row_n[7]}
N 1620 -3130 1630 -3140 {
lab=rowon_n[7]}
N 1630 -3140 1830 -3140 {
lab=rowon_n[7]}
N 1830 -3140 1840 -3130 {
lab=rowon_n[7]}
N 1620 -3110 1630 -3120 {
lab=#net15}
N 1630 -3120 1830 -3120 {
lab=#net15}
N 1830 -3120 1840 -3110 {
lab=#net15}
N 1620 -3090 1630 -3100 {
lab=#net16}
N 1630 -3100 1830 -3100 {
lab=#net16}
N 1830 -3100 1840 -3090 {
lab=#net16}
N 1680 -3250 1680 -3230 {
lab=vcm}
N 1720 -3250 1720 -3230 {
lab=ctop}
N 1600 -3150 1620 -3150 {
lab=row_n[7]}
N 1600 -3130 1620 -3130 {
lab=rowon_n[7]}
N 1600 -3110 1620 -3110 {
lab=#net15}
N 1600 -3090 1620 -3090 {
lab=#net16}
N 1840 -3090 1860 -3090 {
lab=#net16}
N 1840 -3110 1860 -3110 {
lab=#net15}
N 1840 -3130 1860 -3130 {
lab=rowon_n[7]}
N 1840 -3150 1860 -3150 {
lab=row_n[7]}
N 1660 -3010 1660 -3000 {
lab=VSS}
N 1660 -3240 1660 -3230 {
lab=VDD}
N 2000 -3010 2010 -3020 {
lab=col_n[5]}
N 2010 -3220 2010 -3020 {
lab=col_n[5]}
N 2000 -3230 2010 -3220 {
lab=col_n[5]}
N 2000 -3010 2000 -2990 {
lab=col_n[5]}
N 2000 -3250 2000 -3230 {
lab=col_n[5]}
N 1880 -3150 1890 -3160 {
lab=row_n[7]}
N 1890 -3160 2090 -3160 {
lab=row_n[7]}
N 2090 -3160 2100 -3150 {
lab=row_n[7]}
N 1880 -3130 1890 -3140 {
lab=rowon_n[7]}
N 1890 -3140 2090 -3140 {
lab=rowon_n[7]}
N 2090 -3140 2100 -3130 {
lab=rowon_n[7]}
N 1880 -3110 1890 -3120 {
lab=#net15}
N 1890 -3120 2090 -3120 {
lab=#net15}
N 2090 -3120 2100 -3110 {
lab=#net15}
N 1880 -3090 1890 -3100 {
lab=#net16}
N 1890 -3100 2090 -3100 {
lab=#net16}
N 2090 -3100 2100 -3090 {
lab=#net16}
N 1940 -3250 1940 -3230 {
lab=vcm}
N 1980 -3250 1980 -3230 {
lab=ctop}
N 1860 -3150 1880 -3150 {
lab=row_n[7]}
N 1860 -3130 1880 -3130 {
lab=rowon_n[7]}
N 1860 -3110 1880 -3110 {
lab=#net15}
N 1860 -3090 1880 -3090 {
lab=#net16}
N 2100 -3090 2120 -3090 {
lab=#net16}
N 2100 -3110 2120 -3110 {
lab=#net15}
N 2100 -3130 2120 -3130 {
lab=rowon_n[7]}
N 2100 -3150 2120 -3150 {
lab=row_n[7]}
N 1920 -3010 1920 -3000 {
lab=VSS}
N 1920 -3240 1920 -3230 {
lab=VDD}
N 2260 -3010 2270 -3020 {
lab=col_n[6]}
N 2270 -3220 2270 -3020 {
lab=col_n[6]}
N 2260 -3230 2270 -3220 {
lab=col_n[6]}
N 2260 -3010 2260 -2990 {
lab=col_n[6]}
N 2260 -3250 2260 -3230 {
lab=col_n[6]}
N 2140 -3150 2150 -3160 {
lab=row_n[7]}
N 2150 -3160 2350 -3160 {
lab=row_n[7]}
N 2350 -3160 2360 -3150 {
lab=row_n[7]}
N 2140 -3130 2150 -3140 {
lab=rowon_n[7]}
N 2150 -3140 2350 -3140 {
lab=rowon_n[7]}
N 2350 -3140 2360 -3130 {
lab=rowon_n[7]}
N 2140 -3110 2150 -3120 {
lab=#net15}
N 2150 -3120 2350 -3120 {
lab=#net15}
N 2350 -3120 2360 -3110 {
lab=#net15}
N 2140 -3090 2150 -3100 {
lab=#net16}
N 2150 -3100 2350 -3100 {
lab=#net16}
N 2350 -3100 2360 -3090 {
lab=#net16}
N 2200 -3250 2200 -3230 {
lab=vcm}
N 2240 -3250 2240 -3230 {
lab=ctop}
N 2120 -3150 2140 -3150 {
lab=row_n[7]}
N 2120 -3130 2140 -3130 {
lab=rowon_n[7]}
N 2120 -3110 2140 -3110 {
lab=#net15}
N 2120 -3090 2140 -3090 {
lab=#net16}
N 2360 -3090 2380 -3090 {
lab=#net16}
N 2360 -3110 2380 -3110 {
lab=#net15}
N 2360 -3130 2380 -3130 {
lab=rowon_n[7]}
N 2360 -3150 2380 -3150 {
lab=row_n[7]}
N 2180 -3010 2180 -3000 {
lab=VSS}
N 2180 -3240 2180 -3230 {
lab=VDD}
N 2520 -3010 2530 -3020 {
lab=col_n[7]}
N 2530 -3220 2530 -3020 {
lab=col_n[7]}
N 2520 -3230 2530 -3220 {
lab=col_n[7]}
N 2520 -3010 2520 -2990 {
lab=col_n[7]}
N 2520 -3250 2520 -3230 {
lab=col_n[7]}
N 2400 -3150 2410 -3160 {
lab=row_n[7]}
N 2410 -3160 2610 -3160 {
lab=row_n[7]}
N 2610 -3160 2620 -3150 {
lab=row_n[7]}
N 2400 -3130 2410 -3140 {
lab=rowon_n[7]}
N 2410 -3140 2610 -3140 {
lab=rowon_n[7]}
N 2610 -3140 2620 -3130 {
lab=rowon_n[7]}
N 2400 -3110 2410 -3120 {
lab=#net15}
N 2410 -3120 2610 -3120 {
lab=#net15}
N 2610 -3120 2620 -3110 {
lab=#net15}
N 2400 -3090 2410 -3100 {
lab=#net16}
N 2410 -3100 2610 -3100 {
lab=#net16}
N 2610 -3100 2620 -3090 {
lab=#net16}
N 2460 -3250 2460 -3230 {
lab=vcm}
N 2500 -3250 2500 -3230 {
lab=ctop}
N 2380 -3150 2400 -3150 {
lab=row_n[7]}
N 2380 -3130 2400 -3130 {
lab=rowon_n[7]}
N 2380 -3110 2400 -3110 {
lab=#net15}
N 2380 -3090 2400 -3090 {
lab=#net16}
N 2620 -3090 2640 -3090 {
lab=#net16}
N 2620 -3110 2640 -3110 {
lab=#net15}
N 2620 -3130 2640 -3130 {
lab=rowon_n[7]}
N 2620 -3150 2640 -3150 {
lab=row_n[7]}
N 2440 -3010 2440 -3000 {
lab=VSS}
N 2440 -3240 2440 -3230 {
lab=VDD}
N 2780 -3010 2790 -3020 {
lab=col_n[8]}
N 2790 -3220 2790 -3020 {
lab=col_n[8]}
N 2780 -3230 2790 -3220 {
lab=col_n[8]}
N 2780 -3010 2780 -2990 {
lab=col_n[8]}
N 2780 -3250 2780 -3230 {
lab=col_n[8]}
N 2660 -3150 2670 -3160 {
lab=row_n[7]}
N 2670 -3160 2870 -3160 {
lab=row_n[7]}
N 2870 -3160 2880 -3150 {
lab=row_n[7]}
N 2660 -3130 2670 -3140 {
lab=rowon_n[7]}
N 2670 -3140 2870 -3140 {
lab=rowon_n[7]}
N 2870 -3140 2880 -3130 {
lab=rowon_n[7]}
N 2660 -3110 2670 -3120 {
lab=#net15}
N 2670 -3120 2870 -3120 {
lab=#net15}
N 2870 -3120 2880 -3110 {
lab=#net15}
N 2660 -3090 2670 -3100 {
lab=#net16}
N 2670 -3100 2870 -3100 {
lab=#net16}
N 2870 -3100 2880 -3090 {
lab=#net16}
N 2720 -3250 2720 -3230 {
lab=vcm}
N 2760 -3250 2760 -3230 {
lab=ctop}
N 2640 -3150 2660 -3150 {
lab=row_n[7]}
N 2640 -3130 2660 -3130 {
lab=rowon_n[7]}
N 2640 -3110 2660 -3110 {
lab=#net15}
N 2640 -3090 2660 -3090 {
lab=#net16}
N 2880 -3090 2900 -3090 {
lab=#net16}
N 2880 -3110 2900 -3110 {
lab=#net15}
N 2880 -3130 2900 -3130 {
lab=rowon_n[7]}
N 2880 -3150 2900 -3150 {
lab=row_n[7]}
N 2700 -3010 2700 -3000 {
lab=VSS}
N 2700 -3240 2700 -3230 {
lab=VDD}
N 3040 -3010 3050 -3020 {
lab=col_n[9]}
N 3050 -3220 3050 -3020 {
lab=col_n[9]}
N 3040 -3230 3050 -3220 {
lab=col_n[9]}
N 3040 -3010 3040 -2990 {
lab=col_n[9]}
N 3040 -3250 3040 -3230 {
lab=col_n[9]}
N 2920 -3150 2930 -3160 {
lab=row_n[7]}
N 2930 -3160 3130 -3160 {
lab=row_n[7]}
N 3130 -3160 3140 -3150 {
lab=row_n[7]}
N 2920 -3130 2930 -3140 {
lab=rowon_n[7]}
N 2930 -3140 3130 -3140 {
lab=rowon_n[7]}
N 3130 -3140 3140 -3130 {
lab=rowon_n[7]}
N 2920 -3110 2930 -3120 {
lab=#net15}
N 2930 -3120 3130 -3120 {
lab=#net15}
N 3130 -3120 3140 -3110 {
lab=#net15}
N 2920 -3090 2930 -3100 {
lab=#net16}
N 2930 -3100 3130 -3100 {
lab=#net16}
N 3130 -3100 3140 -3090 {
lab=#net16}
N 2980 -3250 2980 -3230 {
lab=vcm}
N 3020 -3250 3020 -3230 {
lab=ctop}
N 2900 -3150 2920 -3150 {
lab=row_n[7]}
N 2900 -3130 2920 -3130 {
lab=rowon_n[7]}
N 2900 -3110 2920 -3110 {
lab=#net15}
N 2900 -3090 2920 -3090 {
lab=#net16}
N 3140 -3090 3160 -3090 {
lab=#net16}
N 3140 -3110 3160 -3110 {
lab=#net15}
N 3140 -3130 3160 -3130 {
lab=rowon_n[7]}
N 3140 -3150 3160 -3150 {
lab=row_n[7]}
N 2960 -3010 2960 -3000 {
lab=VSS}
N 2960 -3240 2960 -3230 {
lab=VDD}
N 3300 -3010 3310 -3020 {
lab=col_n[10]}
N 3310 -3220 3310 -3020 {
lab=col_n[10]}
N 3300 -3230 3310 -3220 {
lab=col_n[10]}
N 3300 -3010 3300 -2990 {
lab=col_n[10]}
N 3300 -3250 3300 -3230 {
lab=col_n[10]}
N 3180 -3150 3190 -3160 {
lab=row_n[7]}
N 3190 -3160 3390 -3160 {
lab=row_n[7]}
N 3390 -3160 3400 -3150 {
lab=row_n[7]}
N 3180 -3130 3190 -3140 {
lab=rowon_n[7]}
N 3190 -3140 3390 -3140 {
lab=rowon_n[7]}
N 3390 -3140 3400 -3130 {
lab=rowon_n[7]}
N 3180 -3110 3190 -3120 {
lab=#net15}
N 3190 -3120 3390 -3120 {
lab=#net15}
N 3390 -3120 3400 -3110 {
lab=#net15}
N 3180 -3090 3190 -3100 {
lab=#net16}
N 3190 -3100 3390 -3100 {
lab=#net16}
N 3390 -3100 3400 -3090 {
lab=#net16}
N 3240 -3250 3240 -3230 {
lab=vcm}
N 3280 -3250 3280 -3230 {
lab=ctop}
N 3160 -3150 3180 -3150 {
lab=row_n[7]}
N 3160 -3130 3180 -3130 {
lab=rowon_n[7]}
N 3160 -3110 3180 -3110 {
lab=#net15}
N 3160 -3090 3180 -3090 {
lab=#net16}
N 3400 -3090 3420 -3090 {
lab=#net16}
N 3400 -3110 3420 -3110 {
lab=#net15}
N 3400 -3130 3420 -3130 {
lab=rowon_n[7]}
N 3400 -3150 3420 -3150 {
lab=row_n[7]}
N 3220 -3010 3220 -3000 {
lab=VSS}
N 3220 -3240 3220 -3230 {
lab=VDD}
N 3560 -3010 3570 -3020 {
lab=col_n[11]}
N 3570 -3220 3570 -3020 {
lab=col_n[11]}
N 3560 -3230 3570 -3220 {
lab=col_n[11]}
N 3560 -3010 3560 -2990 {
lab=col_n[11]}
N 3560 -3250 3560 -3230 {
lab=col_n[11]}
N 3440 -3150 3450 -3160 {
lab=row_n[7]}
N 3450 -3160 3650 -3160 {
lab=row_n[7]}
N 3650 -3160 3660 -3150 {
lab=row_n[7]}
N 3440 -3130 3450 -3140 {
lab=rowon_n[7]}
N 3450 -3140 3650 -3140 {
lab=rowon_n[7]}
N 3650 -3140 3660 -3130 {
lab=rowon_n[7]}
N 3440 -3110 3450 -3120 {
lab=#net15}
N 3450 -3120 3650 -3120 {
lab=#net15}
N 3650 -3120 3660 -3110 {
lab=#net15}
N 3440 -3090 3450 -3100 {
lab=#net16}
N 3450 -3100 3650 -3100 {
lab=#net16}
N 3650 -3100 3660 -3090 {
lab=#net16}
N 3500 -3250 3500 -3230 {
lab=vcm}
N 3540 -3250 3540 -3230 {
lab=ctop}
N 3420 -3150 3440 -3150 {
lab=row_n[7]}
N 3420 -3130 3440 -3130 {
lab=rowon_n[7]}
N 3420 -3110 3440 -3110 {
lab=#net15}
N 3420 -3090 3440 -3090 {
lab=#net16}
N 3660 -3090 3680 -3090 {
lab=#net16}
N 3660 -3110 3680 -3110 {
lab=#net15}
N 3660 -3130 3680 -3130 {
lab=rowon_n[7]}
N 3660 -3150 3680 -3150 {
lab=row_n[7]}
N 3480 -3010 3480 -3000 {
lab=VSS}
N 3480 -3240 3480 -3230 {
lab=VDD}
N 3820 -3010 3830 -3020 {
lab=col_n[12]}
N 3830 -3220 3830 -3020 {
lab=col_n[12]}
N 3820 -3230 3830 -3220 {
lab=col_n[12]}
N 3820 -3010 3820 -2990 {
lab=col_n[12]}
N 3820 -3250 3820 -3230 {
lab=col_n[12]}
N 3700 -3150 3710 -3160 {
lab=row_n[7]}
N 3710 -3160 3910 -3160 {
lab=row_n[7]}
N 3910 -3160 3920 -3150 {
lab=row_n[7]}
N 3700 -3130 3710 -3140 {
lab=rowon_n[7]}
N 3710 -3140 3910 -3140 {
lab=rowon_n[7]}
N 3910 -3140 3920 -3130 {
lab=rowon_n[7]}
N 3700 -3110 3710 -3120 {
lab=#net15}
N 3710 -3120 3910 -3120 {
lab=#net15}
N 3910 -3120 3920 -3110 {
lab=#net15}
N 3700 -3090 3710 -3100 {
lab=#net16}
N 3710 -3100 3910 -3100 {
lab=#net16}
N 3910 -3100 3920 -3090 {
lab=#net16}
N 3760 -3250 3760 -3230 {
lab=vcm}
N 3800 -3250 3800 -3230 {
lab=ctop}
N 3680 -3150 3700 -3150 {
lab=row_n[7]}
N 3680 -3130 3700 -3130 {
lab=rowon_n[7]}
N 3680 -3110 3700 -3110 {
lab=#net15}
N 3680 -3090 3700 -3090 {
lab=#net16}
N 3920 -3090 3940 -3090 {
lab=#net16}
N 3920 -3110 3940 -3110 {
lab=#net15}
N 3920 -3130 3940 -3130 {
lab=rowon_n[7]}
N 3920 -3150 3940 -3150 {
lab=row_n[7]}
N 3740 -3010 3740 -3000 {
lab=VSS}
N 3740 -3240 3740 -3230 {
lab=VDD}
N 4080 -3010 4090 -3020 {
lab=col_n[13]}
N 4090 -3220 4090 -3020 {
lab=col_n[13]}
N 4080 -3230 4090 -3220 {
lab=col_n[13]}
N 4080 -3010 4080 -2990 {
lab=col_n[13]}
N 4080 -3250 4080 -3230 {
lab=col_n[13]}
N 3960 -3150 3970 -3160 {
lab=row_n[7]}
N 3970 -3160 4170 -3160 {
lab=row_n[7]}
N 4170 -3160 4180 -3150 {
lab=row_n[7]}
N 3960 -3130 3970 -3140 {
lab=rowon_n[7]}
N 3970 -3140 4170 -3140 {
lab=rowon_n[7]}
N 4170 -3140 4180 -3130 {
lab=rowon_n[7]}
N 3960 -3110 3970 -3120 {
lab=#net15}
N 3970 -3120 4170 -3120 {
lab=#net15}
N 4170 -3120 4180 -3110 {
lab=#net15}
N 3960 -3090 3970 -3100 {
lab=#net16}
N 3970 -3100 4170 -3100 {
lab=#net16}
N 4170 -3100 4180 -3090 {
lab=#net16}
N 4020 -3250 4020 -3230 {
lab=vcm}
N 4060 -3250 4060 -3230 {
lab=ctop}
N 3940 -3150 3960 -3150 {
lab=row_n[7]}
N 3940 -3130 3960 -3130 {
lab=rowon_n[7]}
N 3940 -3110 3960 -3110 {
lab=#net15}
N 3940 -3090 3960 -3090 {
lab=#net16}
N 4180 -3090 4200 -3090 {
lab=#net16}
N 4180 -3110 4200 -3110 {
lab=#net15}
N 4180 -3130 4200 -3130 {
lab=rowon_n[7]}
N 4180 -3150 4200 -3150 {
lab=row_n[7]}
N 4000 -3010 4000 -3000 {
lab=VSS}
N 4000 -3240 4000 -3230 {
lab=VDD}
N 4340 -3010 4350 -3020 {
lab=col_n[14]}
N 4350 -3220 4350 -3020 {
lab=col_n[14]}
N 4340 -3230 4350 -3220 {
lab=col_n[14]}
N 4340 -3010 4340 -2990 {
lab=col_n[14]}
N 4340 -3250 4340 -3230 {
lab=col_n[14]}
N 4220 -3150 4230 -3160 {
lab=row_n[7]}
N 4230 -3160 4430 -3160 {
lab=row_n[7]}
N 4430 -3160 4440 -3150 {
lab=row_n[7]}
N 4220 -3130 4230 -3140 {
lab=rowon_n[7]}
N 4230 -3140 4430 -3140 {
lab=rowon_n[7]}
N 4430 -3140 4440 -3130 {
lab=rowon_n[7]}
N 4220 -3110 4230 -3120 {
lab=#net15}
N 4230 -3120 4430 -3120 {
lab=#net15}
N 4430 -3120 4440 -3110 {
lab=#net15}
N 4220 -3090 4230 -3100 {
lab=#net16}
N 4230 -3100 4430 -3100 {
lab=#net16}
N 4430 -3100 4440 -3090 {
lab=#net16}
N 4280 -3250 4280 -3230 {
lab=vcm}
N 4320 -3250 4320 -3230 {
lab=ctop}
N 4200 -3150 4220 -3150 {
lab=row_n[7]}
N 4200 -3130 4220 -3130 {
lab=rowon_n[7]}
N 4200 -3110 4220 -3110 {
lab=#net15}
N 4200 -3090 4220 -3090 {
lab=#net16}
N 4440 -3090 4460 -3090 {
lab=#net16}
N 4440 -3110 4460 -3110 {
lab=#net15}
N 4440 -3130 4460 -3130 {
lab=rowon_n[7]}
N 4440 -3150 4460 -3150 {
lab=row_n[7]}
N 4260 -3010 4260 -3000 {
lab=VSS}
N 4260 -3240 4260 -3230 {
lab=VDD}
N 4600 -3010 4610 -3020 {
lab=col_n[15]}
N 4610 -3220 4610 -3020 {
lab=col_n[15]}
N 4600 -3230 4610 -3220 {
lab=col_n[15]}
N 4600 -3010 4600 -2990 {
lab=col_n[15]}
N 4600 -3250 4600 -3230 {
lab=col_n[15]}
N 4480 -3150 4490 -3160 {
lab=row_n[7]}
N 4490 -3160 4690 -3160 {
lab=row_n[7]}
N 4690 -3160 4700 -3150 {
lab=row_n[7]}
N 4480 -3130 4490 -3140 {
lab=rowon_n[7]}
N 4490 -3140 4690 -3140 {
lab=rowon_n[7]}
N 4690 -3140 4700 -3130 {
lab=rowon_n[7]}
N 4480 -3110 4490 -3120 {
lab=#net15}
N 4490 -3120 4690 -3120 {
lab=#net15}
N 4690 -3120 4700 -3110 {
lab=#net15}
N 4480 -3090 4490 -3100 {
lab=#net16}
N 4490 -3100 4690 -3100 {
lab=#net16}
N 4690 -3100 4700 -3090 {
lab=#net16}
N 4540 -3250 4540 -3230 {
lab=vcm}
N 4580 -3250 4580 -3230 {
lab=ctop}
N 4460 -3150 4480 -3150 {
lab=row_n[7]}
N 4460 -3130 4480 -3130 {
lab=rowon_n[7]}
N 4460 -3110 4480 -3110 {
lab=#net15}
N 4460 -3090 4480 -3090 {
lab=#net16}
N 4700 -3090 4720 -3090 {
lab=#net16}
N 4700 -3110 4720 -3110 {
lab=#net15}
N 4700 -3130 4720 -3130 {
lab=rowon_n[7]}
N 4700 -3150 4720 -3150 {
lab=row_n[7]}
N 4520 -3010 4520 -3000 {
lab=VSS}
N 4520 -3240 4520 -3230 {
lab=VDD}
N 4860 -3010 4870 -3020 {
lab=col_n[16]}
N 4870 -3220 4870 -3020 {
lab=col_n[16]}
N 4860 -3230 4870 -3220 {
lab=col_n[16]}
N 4860 -3010 4860 -2990 {
lab=col_n[16]}
N 4860 -3250 4860 -3230 {
lab=col_n[16]}
N 4740 -3150 4750 -3160 {
lab=row_n[7]}
N 4750 -3160 4950 -3160 {
lab=row_n[7]}
N 4950 -3160 4960 -3150 {
lab=row_n[7]}
N 4740 -3130 4750 -3140 {
lab=rowon_n[7]}
N 4750 -3140 4950 -3140 {
lab=rowon_n[7]}
N 4950 -3140 4960 -3130 {
lab=rowon_n[7]}
N 4740 -3110 4750 -3120 {
lab=#net15}
N 4750 -3120 4950 -3120 {
lab=#net15}
N 4950 -3120 4960 -3110 {
lab=#net15}
N 4740 -3090 4750 -3100 {
lab=#net16}
N 4750 -3100 4950 -3100 {
lab=#net16}
N 4950 -3100 4960 -3090 {
lab=#net16}
N 4800 -3250 4800 -3230 {
lab=vcm}
N 4840 -3250 4840 -3230 {
lab=ctop}
N 4720 -3150 4740 -3150 {
lab=row_n[7]}
N 4720 -3130 4740 -3130 {
lab=rowon_n[7]}
N 4720 -3110 4740 -3110 {
lab=#net15}
N 4720 -3090 4740 -3090 {
lab=#net16}
N 4960 -3090 4980 -3090 {
lab=#net16}
N 4960 -3110 4980 -3110 {
lab=#net15}
N 4960 -3130 4980 -3130 {
lab=rowon_n[7]}
N 4960 -3150 4980 -3150 {
lab=row_n[7]}
N 4780 -3010 4780 -3000 {
lab=VSS}
N 4780 -3240 4780 -3230 {
lab=VDD}
N 5120 -3010 5130 -3020 {
lab=col_n[17]}
N 5130 -3220 5130 -3020 {
lab=col_n[17]}
N 5120 -3230 5130 -3220 {
lab=col_n[17]}
N 5120 -3010 5120 -2990 {
lab=col_n[17]}
N 5120 -3250 5120 -3230 {
lab=col_n[17]}
N 5000 -3150 5010 -3160 {
lab=row_n[7]}
N 5010 -3160 5210 -3160 {
lab=row_n[7]}
N 5210 -3160 5220 -3150 {
lab=row_n[7]}
N 5000 -3130 5010 -3140 {
lab=rowon_n[7]}
N 5010 -3140 5210 -3140 {
lab=rowon_n[7]}
N 5210 -3140 5220 -3130 {
lab=rowon_n[7]}
N 5000 -3110 5010 -3120 {
lab=#net15}
N 5010 -3120 5210 -3120 {
lab=#net15}
N 5210 -3120 5220 -3110 {
lab=#net15}
N 5000 -3090 5010 -3100 {
lab=#net16}
N 5010 -3100 5210 -3100 {
lab=#net16}
N 5210 -3100 5220 -3090 {
lab=#net16}
N 5060 -3250 5060 -3230 {
lab=vcm}
N 5100 -3250 5100 -3230 {
lab=ctop}
N 4980 -3150 5000 -3150 {
lab=row_n[7]}
N 4980 -3130 5000 -3130 {
lab=rowon_n[7]}
N 4980 -3110 5000 -3110 {
lab=#net15}
N 4980 -3090 5000 -3090 {
lab=#net16}
N 5220 -3090 5240 -3090 {
lab=#net16}
N 5220 -3110 5240 -3110 {
lab=#net15}
N 5220 -3130 5240 -3130 {
lab=rowon_n[7]}
N 5220 -3150 5240 -3150 {
lab=row_n[7]}
N 5040 -3010 5040 -3000 {
lab=VSS}
N 5040 -3240 5040 -3230 {
lab=VDD}
N 5380 -3010 5390 -3020 {
lab=col_n[18]}
N 5390 -3220 5390 -3020 {
lab=col_n[18]}
N 5380 -3230 5390 -3220 {
lab=col_n[18]}
N 5380 -3010 5380 -2990 {
lab=col_n[18]}
N 5380 -3250 5380 -3230 {
lab=col_n[18]}
N 5260 -3150 5270 -3160 {
lab=row_n[7]}
N 5270 -3160 5470 -3160 {
lab=row_n[7]}
N 5470 -3160 5480 -3150 {
lab=row_n[7]}
N 5260 -3130 5270 -3140 {
lab=rowon_n[7]}
N 5270 -3140 5470 -3140 {
lab=rowon_n[7]}
N 5470 -3140 5480 -3130 {
lab=rowon_n[7]}
N 5260 -3110 5270 -3120 {
lab=#net15}
N 5270 -3120 5470 -3120 {
lab=#net15}
N 5470 -3120 5480 -3110 {
lab=#net15}
N 5260 -3090 5270 -3100 {
lab=#net16}
N 5270 -3100 5470 -3100 {
lab=#net16}
N 5470 -3100 5480 -3090 {
lab=#net16}
N 5320 -3250 5320 -3230 {
lab=vcm}
N 5360 -3250 5360 -3230 {
lab=ctop}
N 5240 -3150 5260 -3150 {
lab=row_n[7]}
N 5240 -3130 5260 -3130 {
lab=rowon_n[7]}
N 5240 -3110 5260 -3110 {
lab=#net15}
N 5240 -3090 5260 -3090 {
lab=#net16}
N 5480 -3090 5500 -3090 {
lab=#net16}
N 5480 -3110 5500 -3110 {
lab=#net15}
N 5480 -3130 5500 -3130 {
lab=rowon_n[7]}
N 5480 -3150 5500 -3150 {
lab=row_n[7]}
N 5300 -3010 5300 -3000 {
lab=VSS}
N 5300 -3240 5300 -3230 {
lab=VDD}
N 5640 -3010 5650 -3020 {
lab=col_n[19]}
N 5650 -3220 5650 -3020 {
lab=col_n[19]}
N 5640 -3230 5650 -3220 {
lab=col_n[19]}
N 5640 -3010 5640 -2990 {
lab=col_n[19]}
N 5640 -3250 5640 -3230 {
lab=col_n[19]}
N 5520 -3150 5530 -3160 {
lab=row_n[7]}
N 5530 -3160 5730 -3160 {
lab=row_n[7]}
N 5730 -3160 5740 -3150 {
lab=row_n[7]}
N 5520 -3130 5530 -3140 {
lab=rowon_n[7]}
N 5530 -3140 5730 -3140 {
lab=rowon_n[7]}
N 5730 -3140 5740 -3130 {
lab=rowon_n[7]}
N 5520 -3110 5530 -3120 {
lab=#net15}
N 5530 -3120 5730 -3120 {
lab=#net15}
N 5730 -3120 5740 -3110 {
lab=#net15}
N 5520 -3090 5530 -3100 {
lab=#net16}
N 5530 -3100 5730 -3100 {
lab=#net16}
N 5730 -3100 5740 -3090 {
lab=#net16}
N 5580 -3250 5580 -3230 {
lab=vcm}
N 5620 -3250 5620 -3230 {
lab=ctop}
N 5500 -3150 5520 -3150 {
lab=row_n[7]}
N 5500 -3130 5520 -3130 {
lab=rowon_n[7]}
N 5500 -3110 5520 -3110 {
lab=#net15}
N 5500 -3090 5520 -3090 {
lab=#net16}
N 5740 -3090 5760 -3090 {
lab=#net16}
N 5740 -3110 5760 -3110 {
lab=#net15}
N 5740 -3130 5760 -3130 {
lab=rowon_n[7]}
N 5740 -3150 5760 -3150 {
lab=row_n[7]}
N 5560 -3010 5560 -3000 {
lab=VSS}
N 5560 -3240 5560 -3230 {
lab=VDD}
N 5900 -3010 5910 -3020 {
lab=col_n[20]}
N 5910 -3220 5910 -3020 {
lab=col_n[20]}
N 5900 -3230 5910 -3220 {
lab=col_n[20]}
N 5900 -3010 5900 -2990 {
lab=col_n[20]}
N 5900 -3250 5900 -3230 {
lab=col_n[20]}
N 5780 -3150 5790 -3160 {
lab=row_n[7]}
N 5790 -3160 5990 -3160 {
lab=row_n[7]}
N 5990 -3160 6000 -3150 {
lab=row_n[7]}
N 5780 -3130 5790 -3140 {
lab=rowon_n[7]}
N 5790 -3140 5990 -3140 {
lab=rowon_n[7]}
N 5990 -3140 6000 -3130 {
lab=rowon_n[7]}
N 5780 -3110 5790 -3120 {
lab=#net15}
N 5790 -3120 5990 -3120 {
lab=#net15}
N 5990 -3120 6000 -3110 {
lab=#net15}
N 5780 -3090 5790 -3100 {
lab=#net16}
N 5790 -3100 5990 -3100 {
lab=#net16}
N 5990 -3100 6000 -3090 {
lab=#net16}
N 5840 -3250 5840 -3230 {
lab=vcm}
N 5880 -3250 5880 -3230 {
lab=ctop}
N 5760 -3150 5780 -3150 {
lab=row_n[7]}
N 5760 -3130 5780 -3130 {
lab=rowon_n[7]}
N 5760 -3110 5780 -3110 {
lab=#net15}
N 5760 -3090 5780 -3090 {
lab=#net16}
N 6000 -3090 6020 -3090 {
lab=#net16}
N 6000 -3110 6020 -3110 {
lab=#net15}
N 6000 -3130 6020 -3130 {
lab=rowon_n[7]}
N 6000 -3150 6020 -3150 {
lab=row_n[7]}
N 5820 -3010 5820 -3000 {
lab=VSS}
N 5820 -3240 5820 -3230 {
lab=VDD}
N 6160 -3010 6170 -3020 {
lab=col_n[21]}
N 6170 -3220 6170 -3020 {
lab=col_n[21]}
N 6160 -3230 6170 -3220 {
lab=col_n[21]}
N 6160 -3010 6160 -2990 {
lab=col_n[21]}
N 6160 -3250 6160 -3230 {
lab=col_n[21]}
N 6040 -3150 6050 -3160 {
lab=row_n[7]}
N 6050 -3160 6250 -3160 {
lab=row_n[7]}
N 6250 -3160 6260 -3150 {
lab=row_n[7]}
N 6040 -3130 6050 -3140 {
lab=rowon_n[7]}
N 6050 -3140 6250 -3140 {
lab=rowon_n[7]}
N 6250 -3140 6260 -3130 {
lab=rowon_n[7]}
N 6040 -3110 6050 -3120 {
lab=#net15}
N 6050 -3120 6250 -3120 {
lab=#net15}
N 6250 -3120 6260 -3110 {
lab=#net15}
N 6040 -3090 6050 -3100 {
lab=#net16}
N 6050 -3100 6250 -3100 {
lab=#net16}
N 6250 -3100 6260 -3090 {
lab=#net16}
N 6100 -3250 6100 -3230 {
lab=vcm}
N 6140 -3250 6140 -3230 {
lab=ctop}
N 6020 -3150 6040 -3150 {
lab=row_n[7]}
N 6020 -3130 6040 -3130 {
lab=rowon_n[7]}
N 6020 -3110 6040 -3110 {
lab=#net15}
N 6020 -3090 6040 -3090 {
lab=#net16}
N 6260 -3090 6280 -3090 {
lab=#net16}
N 6260 -3110 6280 -3110 {
lab=#net15}
N 6260 -3130 6280 -3130 {
lab=rowon_n[7]}
N 6260 -3150 6280 -3150 {
lab=row_n[7]}
N 6080 -3010 6080 -3000 {
lab=VSS}
N 6080 -3240 6080 -3230 {
lab=VDD}
N 6420 -3010 6430 -3020 {
lab=col_n[22]}
N 6430 -3220 6430 -3020 {
lab=col_n[22]}
N 6420 -3230 6430 -3220 {
lab=col_n[22]}
N 6420 -3010 6420 -2990 {
lab=col_n[22]}
N 6420 -3250 6420 -3230 {
lab=col_n[22]}
N 6300 -3150 6310 -3160 {
lab=row_n[7]}
N 6310 -3160 6510 -3160 {
lab=row_n[7]}
N 6510 -3160 6520 -3150 {
lab=row_n[7]}
N 6300 -3130 6310 -3140 {
lab=rowon_n[7]}
N 6310 -3140 6510 -3140 {
lab=rowon_n[7]}
N 6510 -3140 6520 -3130 {
lab=rowon_n[7]}
N 6300 -3110 6310 -3120 {
lab=#net15}
N 6310 -3120 6510 -3120 {
lab=#net15}
N 6510 -3120 6520 -3110 {
lab=#net15}
N 6300 -3090 6310 -3100 {
lab=#net16}
N 6310 -3100 6510 -3100 {
lab=#net16}
N 6510 -3100 6520 -3090 {
lab=#net16}
N 6360 -3250 6360 -3230 {
lab=vcm}
N 6400 -3250 6400 -3230 {
lab=ctop}
N 6280 -3150 6300 -3150 {
lab=row_n[7]}
N 6280 -3130 6300 -3130 {
lab=rowon_n[7]}
N 6280 -3110 6300 -3110 {
lab=#net15}
N 6280 -3090 6300 -3090 {
lab=#net16}
N 6520 -3090 6540 -3090 {
lab=#net16}
N 6520 -3110 6540 -3110 {
lab=#net15}
N 6520 -3130 6540 -3130 {
lab=rowon_n[7]}
N 6520 -3150 6540 -3150 {
lab=row_n[7]}
N 6340 -3010 6340 -3000 {
lab=VSS}
N 6340 -3240 6340 -3230 {
lab=VDD}
N 6680 -3010 6690 -3020 {
lab=col_n[23]}
N 6690 -3220 6690 -3020 {
lab=col_n[23]}
N 6680 -3230 6690 -3220 {
lab=col_n[23]}
N 6680 -3010 6680 -2990 {
lab=col_n[23]}
N 6680 -3250 6680 -3230 {
lab=col_n[23]}
N 6560 -3150 6570 -3160 {
lab=row_n[7]}
N 6570 -3160 6770 -3160 {
lab=row_n[7]}
N 6770 -3160 6780 -3150 {
lab=row_n[7]}
N 6560 -3130 6570 -3140 {
lab=rowon_n[7]}
N 6570 -3140 6770 -3140 {
lab=rowon_n[7]}
N 6770 -3140 6780 -3130 {
lab=rowon_n[7]}
N 6560 -3110 6570 -3120 {
lab=#net15}
N 6570 -3120 6770 -3120 {
lab=#net15}
N 6770 -3120 6780 -3110 {
lab=#net15}
N 6560 -3090 6570 -3100 {
lab=#net16}
N 6570 -3100 6770 -3100 {
lab=#net16}
N 6770 -3100 6780 -3090 {
lab=#net16}
N 6620 -3250 6620 -3230 {
lab=vcm}
N 6660 -3250 6660 -3230 {
lab=ctop}
N 6540 -3150 6560 -3150 {
lab=row_n[7]}
N 6540 -3130 6560 -3130 {
lab=rowon_n[7]}
N 6540 -3110 6560 -3110 {
lab=#net15}
N 6540 -3090 6560 -3090 {
lab=#net16}
N 6780 -3090 6800 -3090 {
lab=#net16}
N 6780 -3110 6800 -3110 {
lab=#net15}
N 6780 -3130 6800 -3130 {
lab=rowon_n[7]}
N 6780 -3150 6800 -3150 {
lab=row_n[7]}
N 6600 -3010 6600 -3000 {
lab=VSS}
N 6600 -3240 6600 -3230 {
lab=VDD}
N 6940 -3010 6950 -3020 {
lab=col_n[24]}
N 6950 -3220 6950 -3020 {
lab=col_n[24]}
N 6940 -3230 6950 -3220 {
lab=col_n[24]}
N 6940 -3010 6940 -2990 {
lab=col_n[24]}
N 6940 -3250 6940 -3230 {
lab=col_n[24]}
N 6820 -3150 6830 -3160 {
lab=row_n[7]}
N 6830 -3160 7030 -3160 {
lab=row_n[7]}
N 7030 -3160 7040 -3150 {
lab=row_n[7]}
N 6820 -3130 6830 -3140 {
lab=rowon_n[7]}
N 6830 -3140 7030 -3140 {
lab=rowon_n[7]}
N 7030 -3140 7040 -3130 {
lab=rowon_n[7]}
N 6820 -3110 6830 -3120 {
lab=#net15}
N 6830 -3120 7030 -3120 {
lab=#net15}
N 7030 -3120 7040 -3110 {
lab=#net15}
N 6820 -3090 6830 -3100 {
lab=#net16}
N 6830 -3100 7030 -3100 {
lab=#net16}
N 7030 -3100 7040 -3090 {
lab=#net16}
N 6880 -3250 6880 -3230 {
lab=vcm}
N 6920 -3250 6920 -3230 {
lab=ctop}
N 6800 -3150 6820 -3150 {
lab=row_n[7]}
N 6800 -3130 6820 -3130 {
lab=rowon_n[7]}
N 6800 -3110 6820 -3110 {
lab=#net15}
N 6800 -3090 6820 -3090 {
lab=#net16}
N 7040 -3090 7060 -3090 {
lab=#net16}
N 7040 -3110 7060 -3110 {
lab=#net15}
N 7040 -3130 7060 -3130 {
lab=rowon_n[7]}
N 7040 -3150 7060 -3150 {
lab=row_n[7]}
N 6860 -3010 6860 -3000 {
lab=VSS}
N 6860 -3240 6860 -3230 {
lab=VDD}
N 7200 -3010 7210 -3020 {
lab=col_n[25]}
N 7210 -3220 7210 -3020 {
lab=col_n[25]}
N 7200 -3230 7210 -3220 {
lab=col_n[25]}
N 7200 -3010 7200 -2990 {
lab=col_n[25]}
N 7200 -3250 7200 -3230 {
lab=col_n[25]}
N 7080 -3150 7090 -3160 {
lab=row_n[7]}
N 7090 -3160 7290 -3160 {
lab=row_n[7]}
N 7290 -3160 7300 -3150 {
lab=row_n[7]}
N 7080 -3130 7090 -3140 {
lab=rowon_n[7]}
N 7090 -3140 7290 -3140 {
lab=rowon_n[7]}
N 7290 -3140 7300 -3130 {
lab=rowon_n[7]}
N 7080 -3110 7090 -3120 {
lab=#net15}
N 7090 -3120 7290 -3120 {
lab=#net15}
N 7290 -3120 7300 -3110 {
lab=#net15}
N 7080 -3090 7090 -3100 {
lab=#net16}
N 7090 -3100 7290 -3100 {
lab=#net16}
N 7290 -3100 7300 -3090 {
lab=#net16}
N 7140 -3250 7140 -3230 {
lab=vcm}
N 7180 -3250 7180 -3230 {
lab=ctop}
N 7060 -3150 7080 -3150 {
lab=row_n[7]}
N 7060 -3130 7080 -3130 {
lab=rowon_n[7]}
N 7060 -3110 7080 -3110 {
lab=#net15}
N 7060 -3090 7080 -3090 {
lab=#net16}
N 7300 -3090 7320 -3090 {
lab=#net16}
N 7300 -3110 7320 -3110 {
lab=#net15}
N 7300 -3130 7320 -3130 {
lab=rowon_n[7]}
N 7300 -3150 7320 -3150 {
lab=row_n[7]}
N 7120 -3010 7120 -3000 {
lab=VSS}
N 7120 -3240 7120 -3230 {
lab=VDD}
N 7460 -3010 7470 -3020 {
lab=col_n[26]}
N 7470 -3220 7470 -3020 {
lab=col_n[26]}
N 7460 -3230 7470 -3220 {
lab=col_n[26]}
N 7460 -3010 7460 -2990 {
lab=col_n[26]}
N 7460 -3250 7460 -3230 {
lab=col_n[26]}
N 7340 -3150 7350 -3160 {
lab=row_n[7]}
N 7350 -3160 7550 -3160 {
lab=row_n[7]}
N 7550 -3160 7560 -3150 {
lab=row_n[7]}
N 7340 -3130 7350 -3140 {
lab=rowon_n[7]}
N 7350 -3140 7550 -3140 {
lab=rowon_n[7]}
N 7550 -3140 7560 -3130 {
lab=rowon_n[7]}
N 7340 -3110 7350 -3120 {
lab=#net15}
N 7350 -3120 7550 -3120 {
lab=#net15}
N 7550 -3120 7560 -3110 {
lab=#net15}
N 7340 -3090 7350 -3100 {
lab=#net16}
N 7350 -3100 7550 -3100 {
lab=#net16}
N 7550 -3100 7560 -3090 {
lab=#net16}
N 7400 -3250 7400 -3230 {
lab=vcm}
N 7440 -3250 7440 -3230 {
lab=ctop}
N 7320 -3150 7340 -3150 {
lab=row_n[7]}
N 7320 -3130 7340 -3130 {
lab=rowon_n[7]}
N 7320 -3110 7340 -3110 {
lab=#net15}
N 7320 -3090 7340 -3090 {
lab=#net16}
N 7560 -3090 7580 -3090 {
lab=#net16}
N 7560 -3110 7580 -3110 {
lab=#net15}
N 7560 -3130 7580 -3130 {
lab=rowon_n[7]}
N 7560 -3150 7580 -3150 {
lab=row_n[7]}
N 7380 -3010 7380 -3000 {
lab=VSS}
N 7380 -3240 7380 -3230 {
lab=VDD}
N 7720 -3010 7730 -3020 {
lab=col_n[27]}
N 7730 -3220 7730 -3020 {
lab=col_n[27]}
N 7720 -3230 7730 -3220 {
lab=col_n[27]}
N 7720 -3010 7720 -2990 {
lab=col_n[27]}
N 7720 -3250 7720 -3230 {
lab=col_n[27]}
N 7600 -3150 7610 -3160 {
lab=row_n[7]}
N 7610 -3160 7810 -3160 {
lab=row_n[7]}
N 7810 -3160 7820 -3150 {
lab=row_n[7]}
N 7600 -3130 7610 -3140 {
lab=rowon_n[7]}
N 7610 -3140 7810 -3140 {
lab=rowon_n[7]}
N 7810 -3140 7820 -3130 {
lab=rowon_n[7]}
N 7600 -3110 7610 -3120 {
lab=#net15}
N 7610 -3120 7810 -3120 {
lab=#net15}
N 7810 -3120 7820 -3110 {
lab=#net15}
N 7600 -3090 7610 -3100 {
lab=#net16}
N 7610 -3100 7810 -3100 {
lab=#net16}
N 7810 -3100 7820 -3090 {
lab=#net16}
N 7660 -3250 7660 -3230 {
lab=vcm}
N 7700 -3250 7700 -3230 {
lab=ctop}
N 7580 -3150 7600 -3150 {
lab=row_n[7]}
N 7580 -3130 7600 -3130 {
lab=rowon_n[7]}
N 7580 -3110 7600 -3110 {
lab=#net15}
N 7580 -3090 7600 -3090 {
lab=#net16}
N 7820 -3090 7840 -3090 {
lab=#net16}
N 7820 -3110 7840 -3110 {
lab=#net15}
N 7820 -3130 7840 -3130 {
lab=rowon_n[7]}
N 7820 -3150 7840 -3150 {
lab=row_n[7]}
N 7640 -3010 7640 -3000 {
lab=VSS}
N 7640 -3240 7640 -3230 {
lab=VDD}
N 7980 -3010 7990 -3020 {
lab=col_n[28]}
N 7990 -3220 7990 -3020 {
lab=col_n[28]}
N 7980 -3230 7990 -3220 {
lab=col_n[28]}
N 7980 -3010 7980 -2990 {
lab=col_n[28]}
N 7980 -3250 7980 -3230 {
lab=col_n[28]}
N 7860 -3150 7870 -3160 {
lab=row_n[7]}
N 7870 -3160 8070 -3160 {
lab=row_n[7]}
N 8070 -3160 8080 -3150 {
lab=row_n[7]}
N 7860 -3130 7870 -3140 {
lab=rowon_n[7]}
N 7870 -3140 8070 -3140 {
lab=rowon_n[7]}
N 8070 -3140 8080 -3130 {
lab=rowon_n[7]}
N 7860 -3110 7870 -3120 {
lab=#net15}
N 7870 -3120 8070 -3120 {
lab=#net15}
N 8070 -3120 8080 -3110 {
lab=#net15}
N 7860 -3090 7870 -3100 {
lab=#net16}
N 7870 -3100 8070 -3100 {
lab=#net16}
N 8070 -3100 8080 -3090 {
lab=#net16}
N 7920 -3250 7920 -3230 {
lab=vcm}
N 7960 -3250 7960 -3230 {
lab=ctop}
N 7840 -3150 7860 -3150 {
lab=row_n[7]}
N 7840 -3130 7860 -3130 {
lab=rowon_n[7]}
N 7840 -3110 7860 -3110 {
lab=#net15}
N 7840 -3090 7860 -3090 {
lab=#net16}
N 8080 -3090 8100 -3090 {
lab=#net16}
N 8080 -3110 8100 -3110 {
lab=#net15}
N 8080 -3130 8100 -3130 {
lab=rowon_n[7]}
N 8080 -3150 8100 -3150 {
lab=row_n[7]}
N 7900 -3010 7900 -3000 {
lab=VSS}
N 7900 -3240 7900 -3230 {
lab=VDD}
N 8240 -3010 8250 -3020 {
lab=col_n[29]}
N 8250 -3220 8250 -3020 {
lab=col_n[29]}
N 8240 -3230 8250 -3220 {
lab=col_n[29]}
N 8240 -3010 8240 -2990 {
lab=col_n[29]}
N 8240 -3250 8240 -3230 {
lab=col_n[29]}
N 8120 -3150 8130 -3160 {
lab=row_n[7]}
N 8130 -3160 8330 -3160 {
lab=row_n[7]}
N 8330 -3160 8340 -3150 {
lab=row_n[7]}
N 8120 -3130 8130 -3140 {
lab=rowon_n[7]}
N 8130 -3140 8330 -3140 {
lab=rowon_n[7]}
N 8330 -3140 8340 -3130 {
lab=rowon_n[7]}
N 8120 -3110 8130 -3120 {
lab=#net15}
N 8130 -3120 8330 -3120 {
lab=#net15}
N 8330 -3120 8340 -3110 {
lab=#net15}
N 8120 -3090 8130 -3100 {
lab=#net16}
N 8130 -3100 8330 -3100 {
lab=#net16}
N 8330 -3100 8340 -3090 {
lab=#net16}
N 8180 -3250 8180 -3230 {
lab=vcm}
N 8220 -3250 8220 -3230 {
lab=ctop}
N 8100 -3150 8120 -3150 {
lab=row_n[7]}
N 8100 -3130 8120 -3130 {
lab=rowon_n[7]}
N 8100 -3110 8120 -3110 {
lab=#net15}
N 8100 -3090 8120 -3090 {
lab=#net16}
N 8340 -3090 8360 -3090 {
lab=#net16}
N 8340 -3110 8360 -3110 {
lab=#net15}
N 8340 -3130 8360 -3130 {
lab=rowon_n[7]}
N 8340 -3150 8360 -3150 {
lab=row_n[7]}
N 8160 -3010 8160 -3000 {
lab=VSS}
N 8160 -3240 8160 -3230 {
lab=VDD}
N 8500 -3010 8510 -3020 {
lab=col_n[30]}
N 8510 -3220 8510 -3020 {
lab=col_n[30]}
N 8500 -3230 8510 -3220 {
lab=col_n[30]}
N 8500 -3010 8500 -2990 {
lab=col_n[30]}
N 8500 -3250 8500 -3230 {
lab=col_n[30]}
N 8380 -3150 8390 -3160 {
lab=row_n[7]}
N 8390 -3160 8590 -3160 {
lab=row_n[7]}
N 8590 -3160 8600 -3150 {
lab=row_n[7]}
N 8380 -3130 8390 -3140 {
lab=rowon_n[7]}
N 8390 -3140 8590 -3140 {
lab=rowon_n[7]}
N 8590 -3140 8600 -3130 {
lab=rowon_n[7]}
N 8380 -3110 8390 -3120 {
lab=#net15}
N 8390 -3120 8590 -3120 {
lab=#net15}
N 8590 -3120 8600 -3110 {
lab=#net15}
N 8380 -3090 8390 -3100 {
lab=#net16}
N 8390 -3100 8590 -3100 {
lab=#net16}
N 8590 -3100 8600 -3090 {
lab=#net16}
N 8440 -3250 8440 -3230 {
lab=vcm}
N 8480 -3250 8480 -3230 {
lab=ctop}
N 8360 -3150 8380 -3150 {
lab=row_n[7]}
N 8360 -3130 8380 -3130 {
lab=rowon_n[7]}
N 8360 -3110 8380 -3110 {
lab=#net15}
N 8360 -3090 8380 -3090 {
lab=#net16}
N 8600 -3090 8620 -3090 {
lab=#net16}
N 8600 -3110 8620 -3110 {
lab=#net15}
N 8600 -3130 8620 -3130 {
lab=rowon_n[7]}
N 8600 -3150 8620 -3150 {
lab=row_n[7]}
N 8420 -3010 8420 -3000 {
lab=VSS}
N 8420 -3240 8420 -3230 {
lab=VDD}
N 8760 -3010 8770 -3020 {
lab=col_n[31]}
N 8770 -3220 8770 -3020 {
lab=col_n[31]}
N 8760 -3230 8770 -3220 {
lab=col_n[31]}
N 8760 -3010 8760 -2990 {
lab=col_n[31]}
N 8760 -3250 8760 -3230 {
lab=col_n[31]}
N 8640 -3150 8650 -3160 {
lab=row_n[7]}
N 8650 -3160 8850 -3160 {
lab=row_n[7]}
N 8850 -3160 8860 -3150 {
lab=row_n[7]}
N 8640 -3130 8650 -3140 {
lab=rowon_n[7]}
N 8650 -3140 8850 -3140 {
lab=rowon_n[7]}
N 8850 -3140 8860 -3130 {
lab=rowon_n[7]}
N 8640 -3110 8650 -3120 {
lab=#net15}
N 8650 -3120 8850 -3120 {
lab=#net15}
N 8850 -3120 8860 -3110 {
lab=#net15}
N 8640 -3090 8650 -3100 {
lab=#net16}
N 8650 -3100 8850 -3100 {
lab=#net16}
N 8850 -3100 8860 -3090 {
lab=#net16}
N 8700 -3250 8700 -3230 {
lab=vcm}
N 8740 -3250 8740 -3230 {
lab=ctop}
N 8620 -3150 8640 -3150 {
lab=row_n[7]}
N 8620 -3130 8640 -3130 {
lab=rowon_n[7]}
N 8620 -3110 8640 -3110 {
lab=#net15}
N 8620 -3090 8640 -3090 {
lab=#net16}
N 8860 -3090 8880 -3090 {
lab=#net16}
N 8860 -3110 8880 -3110 {
lab=#net15}
N 8860 -3130 8880 -3130 {
lab=rowon_n[7]}
N 8860 -3150 8880 -3150 {
lab=row_n[7]}
N 8680 -3010 8680 -3000 {
lab=VSS}
N 8680 -3240 8680 -3230 {
lab=VDD}
N 700 -3270 710 -3280 {
lab=col_n[0]}
N 710 -3480 710 -3280 {
lab=col_n[0]}
N 700 -3490 710 -3480 {
lab=col_n[0]}
N 700 -3270 700 -3250 {
lab=col_n[0]}
N 700 -3510 700 -3490 {
lab=col_n[0]}
N 580 -3410 590 -3420 {
lab=row_n[8]}
N 590 -3420 790 -3420 {
lab=row_n[8]}
N 790 -3420 800 -3410 {
lab=row_n[8]}
N 580 -3390 590 -3400 {
lab=rowon_n[8]}
N 590 -3400 790 -3400 {
lab=rowon_n[8]}
N 790 -3400 800 -3390 {
lab=rowon_n[8]}
N 580 -3370 590 -3380 {
lab=#net17}
N 590 -3380 790 -3380 {
lab=#net17}
N 790 -3380 800 -3370 {
lab=#net17}
N 580 -3350 590 -3360 {
lab=#net18}
N 590 -3360 790 -3360 {
lab=#net18}
N 790 -3360 800 -3350 {
lab=#net18}
N 640 -3510 640 -3490 {
lab=vcm}
N 680 -3510 680 -3490 {
lab=ctop}
N 560 -3410 580 -3410 {
lab=row_n[8]}
N 560 -3390 580 -3390 {
lab=rowon_n[8]}
N 560 -3370 580 -3370 {
lab=#net17}
N 560 -3350 580 -3350 {
lab=#net18}
N 800 -3350 820 -3350 {
lab=#net18}
N 800 -3370 820 -3370 {
lab=#net17}
N 800 -3390 820 -3390 {
lab=rowon_n[8]}
N 800 -3410 820 -3410 {
lab=row_n[8]}
N 620 -3270 620 -3260 {
lab=VSS}
N 620 -3500 620 -3490 {
lab=VDD}
N 960 -3270 970 -3280 {
lab=col_n[1]}
N 970 -3480 970 -3280 {
lab=col_n[1]}
N 960 -3490 970 -3480 {
lab=col_n[1]}
N 960 -3270 960 -3250 {
lab=col_n[1]}
N 960 -3510 960 -3490 {
lab=col_n[1]}
N 840 -3410 850 -3420 {
lab=row_n[8]}
N 850 -3420 1050 -3420 {
lab=row_n[8]}
N 1050 -3420 1060 -3410 {
lab=row_n[8]}
N 840 -3390 850 -3400 {
lab=rowon_n[8]}
N 850 -3400 1050 -3400 {
lab=rowon_n[8]}
N 1050 -3400 1060 -3390 {
lab=rowon_n[8]}
N 840 -3370 850 -3380 {
lab=#net17}
N 850 -3380 1050 -3380 {
lab=#net17}
N 1050 -3380 1060 -3370 {
lab=#net17}
N 840 -3350 850 -3360 {
lab=#net18}
N 850 -3360 1050 -3360 {
lab=#net18}
N 1050 -3360 1060 -3350 {
lab=#net18}
N 900 -3510 900 -3490 {
lab=vcm}
N 940 -3510 940 -3490 {
lab=ctop}
N 820 -3410 840 -3410 {
lab=row_n[8]}
N 820 -3390 840 -3390 {
lab=rowon_n[8]}
N 820 -3370 840 -3370 {
lab=#net17}
N 820 -3350 840 -3350 {
lab=#net18}
N 1060 -3350 1080 -3350 {
lab=#net18}
N 1060 -3370 1080 -3370 {
lab=#net17}
N 1060 -3390 1080 -3390 {
lab=rowon_n[8]}
N 1060 -3410 1080 -3410 {
lab=row_n[8]}
N 880 -3270 880 -3260 {
lab=VSS}
N 880 -3500 880 -3490 {
lab=VDD}
N 1220 -3270 1230 -3280 {
lab=col_n[2]}
N 1230 -3480 1230 -3280 {
lab=col_n[2]}
N 1220 -3490 1230 -3480 {
lab=col_n[2]}
N 1220 -3270 1220 -3250 {
lab=col_n[2]}
N 1220 -3510 1220 -3490 {
lab=col_n[2]}
N 1100 -3410 1110 -3420 {
lab=row_n[8]}
N 1110 -3420 1310 -3420 {
lab=row_n[8]}
N 1310 -3420 1320 -3410 {
lab=row_n[8]}
N 1100 -3390 1110 -3400 {
lab=rowon_n[8]}
N 1110 -3400 1310 -3400 {
lab=rowon_n[8]}
N 1310 -3400 1320 -3390 {
lab=rowon_n[8]}
N 1100 -3370 1110 -3380 {
lab=#net17}
N 1110 -3380 1310 -3380 {
lab=#net17}
N 1310 -3380 1320 -3370 {
lab=#net17}
N 1100 -3350 1110 -3360 {
lab=#net18}
N 1110 -3360 1310 -3360 {
lab=#net18}
N 1310 -3360 1320 -3350 {
lab=#net18}
N 1160 -3510 1160 -3490 {
lab=vcm}
N 1200 -3510 1200 -3490 {
lab=ctop}
N 1080 -3410 1100 -3410 {
lab=row_n[8]}
N 1080 -3390 1100 -3390 {
lab=rowon_n[8]}
N 1080 -3370 1100 -3370 {
lab=#net17}
N 1080 -3350 1100 -3350 {
lab=#net18}
N 1320 -3350 1340 -3350 {
lab=#net18}
N 1320 -3370 1340 -3370 {
lab=#net17}
N 1320 -3390 1340 -3390 {
lab=rowon_n[8]}
N 1320 -3410 1340 -3410 {
lab=row_n[8]}
N 1140 -3270 1140 -3260 {
lab=VSS}
N 1140 -3500 1140 -3490 {
lab=VDD}
N 1480 -3270 1490 -3280 {
lab=col_n[3]}
N 1490 -3480 1490 -3280 {
lab=col_n[3]}
N 1480 -3490 1490 -3480 {
lab=col_n[3]}
N 1480 -3270 1480 -3250 {
lab=col_n[3]}
N 1480 -3510 1480 -3490 {
lab=col_n[3]}
N 1360 -3410 1370 -3420 {
lab=row_n[8]}
N 1370 -3420 1570 -3420 {
lab=row_n[8]}
N 1570 -3420 1580 -3410 {
lab=row_n[8]}
N 1360 -3390 1370 -3400 {
lab=rowon_n[8]}
N 1370 -3400 1570 -3400 {
lab=rowon_n[8]}
N 1570 -3400 1580 -3390 {
lab=rowon_n[8]}
N 1360 -3370 1370 -3380 {
lab=#net17}
N 1370 -3380 1570 -3380 {
lab=#net17}
N 1570 -3380 1580 -3370 {
lab=#net17}
N 1360 -3350 1370 -3360 {
lab=#net18}
N 1370 -3360 1570 -3360 {
lab=#net18}
N 1570 -3360 1580 -3350 {
lab=#net18}
N 1420 -3510 1420 -3490 {
lab=vcm}
N 1460 -3510 1460 -3490 {
lab=ctop}
N 1340 -3410 1360 -3410 {
lab=row_n[8]}
N 1340 -3390 1360 -3390 {
lab=rowon_n[8]}
N 1340 -3370 1360 -3370 {
lab=#net17}
N 1340 -3350 1360 -3350 {
lab=#net18}
N 1580 -3350 1600 -3350 {
lab=#net18}
N 1580 -3370 1600 -3370 {
lab=#net17}
N 1580 -3390 1600 -3390 {
lab=rowon_n[8]}
N 1580 -3410 1600 -3410 {
lab=row_n[8]}
N 1400 -3270 1400 -3260 {
lab=VSS}
N 1400 -3500 1400 -3490 {
lab=VDD}
N 1740 -3270 1750 -3280 {
lab=col_n[4]}
N 1750 -3480 1750 -3280 {
lab=col_n[4]}
N 1740 -3490 1750 -3480 {
lab=col_n[4]}
N 1740 -3270 1740 -3250 {
lab=col_n[4]}
N 1740 -3510 1740 -3490 {
lab=col_n[4]}
N 1620 -3410 1630 -3420 {
lab=row_n[8]}
N 1630 -3420 1830 -3420 {
lab=row_n[8]}
N 1830 -3420 1840 -3410 {
lab=row_n[8]}
N 1620 -3390 1630 -3400 {
lab=rowon_n[8]}
N 1630 -3400 1830 -3400 {
lab=rowon_n[8]}
N 1830 -3400 1840 -3390 {
lab=rowon_n[8]}
N 1620 -3370 1630 -3380 {
lab=#net17}
N 1630 -3380 1830 -3380 {
lab=#net17}
N 1830 -3380 1840 -3370 {
lab=#net17}
N 1620 -3350 1630 -3360 {
lab=#net18}
N 1630 -3360 1830 -3360 {
lab=#net18}
N 1830 -3360 1840 -3350 {
lab=#net18}
N 1680 -3510 1680 -3490 {
lab=vcm}
N 1720 -3510 1720 -3490 {
lab=ctop}
N 1600 -3410 1620 -3410 {
lab=row_n[8]}
N 1600 -3390 1620 -3390 {
lab=rowon_n[8]}
N 1600 -3370 1620 -3370 {
lab=#net17}
N 1600 -3350 1620 -3350 {
lab=#net18}
N 1840 -3350 1860 -3350 {
lab=#net18}
N 1840 -3370 1860 -3370 {
lab=#net17}
N 1840 -3390 1860 -3390 {
lab=rowon_n[8]}
N 1840 -3410 1860 -3410 {
lab=row_n[8]}
N 1660 -3270 1660 -3260 {
lab=VSS}
N 1660 -3500 1660 -3490 {
lab=VDD}
N 2000 -3270 2010 -3280 {
lab=col_n[5]}
N 2010 -3480 2010 -3280 {
lab=col_n[5]}
N 2000 -3490 2010 -3480 {
lab=col_n[5]}
N 2000 -3270 2000 -3250 {
lab=col_n[5]}
N 2000 -3510 2000 -3490 {
lab=col_n[5]}
N 1880 -3410 1890 -3420 {
lab=row_n[8]}
N 1890 -3420 2090 -3420 {
lab=row_n[8]}
N 2090 -3420 2100 -3410 {
lab=row_n[8]}
N 1880 -3390 1890 -3400 {
lab=rowon_n[8]}
N 1890 -3400 2090 -3400 {
lab=rowon_n[8]}
N 2090 -3400 2100 -3390 {
lab=rowon_n[8]}
N 1880 -3370 1890 -3380 {
lab=#net17}
N 1890 -3380 2090 -3380 {
lab=#net17}
N 2090 -3380 2100 -3370 {
lab=#net17}
N 1880 -3350 1890 -3360 {
lab=#net18}
N 1890 -3360 2090 -3360 {
lab=#net18}
N 2090 -3360 2100 -3350 {
lab=#net18}
N 1940 -3510 1940 -3490 {
lab=vcm}
N 1980 -3510 1980 -3490 {
lab=ctop}
N 1860 -3410 1880 -3410 {
lab=row_n[8]}
N 1860 -3390 1880 -3390 {
lab=rowon_n[8]}
N 1860 -3370 1880 -3370 {
lab=#net17}
N 1860 -3350 1880 -3350 {
lab=#net18}
N 2100 -3350 2120 -3350 {
lab=#net18}
N 2100 -3370 2120 -3370 {
lab=#net17}
N 2100 -3390 2120 -3390 {
lab=rowon_n[8]}
N 2100 -3410 2120 -3410 {
lab=row_n[8]}
N 1920 -3270 1920 -3260 {
lab=VSS}
N 1920 -3500 1920 -3490 {
lab=VDD}
N 2260 -3270 2270 -3280 {
lab=col_n[6]}
N 2270 -3480 2270 -3280 {
lab=col_n[6]}
N 2260 -3490 2270 -3480 {
lab=col_n[6]}
N 2260 -3270 2260 -3250 {
lab=col_n[6]}
N 2260 -3510 2260 -3490 {
lab=col_n[6]}
N 2140 -3410 2150 -3420 {
lab=row_n[8]}
N 2150 -3420 2350 -3420 {
lab=row_n[8]}
N 2350 -3420 2360 -3410 {
lab=row_n[8]}
N 2140 -3390 2150 -3400 {
lab=rowon_n[8]}
N 2150 -3400 2350 -3400 {
lab=rowon_n[8]}
N 2350 -3400 2360 -3390 {
lab=rowon_n[8]}
N 2140 -3370 2150 -3380 {
lab=#net17}
N 2150 -3380 2350 -3380 {
lab=#net17}
N 2350 -3380 2360 -3370 {
lab=#net17}
N 2140 -3350 2150 -3360 {
lab=#net18}
N 2150 -3360 2350 -3360 {
lab=#net18}
N 2350 -3360 2360 -3350 {
lab=#net18}
N 2200 -3510 2200 -3490 {
lab=vcm}
N 2240 -3510 2240 -3490 {
lab=ctop}
N 2120 -3410 2140 -3410 {
lab=row_n[8]}
N 2120 -3390 2140 -3390 {
lab=rowon_n[8]}
N 2120 -3370 2140 -3370 {
lab=#net17}
N 2120 -3350 2140 -3350 {
lab=#net18}
N 2360 -3350 2380 -3350 {
lab=#net18}
N 2360 -3370 2380 -3370 {
lab=#net17}
N 2360 -3390 2380 -3390 {
lab=rowon_n[8]}
N 2360 -3410 2380 -3410 {
lab=row_n[8]}
N 2180 -3270 2180 -3260 {
lab=VSS}
N 2180 -3500 2180 -3490 {
lab=VDD}
N 2520 -3270 2530 -3280 {
lab=col_n[7]}
N 2530 -3480 2530 -3280 {
lab=col_n[7]}
N 2520 -3490 2530 -3480 {
lab=col_n[7]}
N 2520 -3270 2520 -3250 {
lab=col_n[7]}
N 2520 -3510 2520 -3490 {
lab=col_n[7]}
N 2400 -3410 2410 -3420 {
lab=row_n[8]}
N 2410 -3420 2610 -3420 {
lab=row_n[8]}
N 2610 -3420 2620 -3410 {
lab=row_n[8]}
N 2400 -3390 2410 -3400 {
lab=rowon_n[8]}
N 2410 -3400 2610 -3400 {
lab=rowon_n[8]}
N 2610 -3400 2620 -3390 {
lab=rowon_n[8]}
N 2400 -3370 2410 -3380 {
lab=#net17}
N 2410 -3380 2610 -3380 {
lab=#net17}
N 2610 -3380 2620 -3370 {
lab=#net17}
N 2400 -3350 2410 -3360 {
lab=#net18}
N 2410 -3360 2610 -3360 {
lab=#net18}
N 2610 -3360 2620 -3350 {
lab=#net18}
N 2460 -3510 2460 -3490 {
lab=vcm}
N 2500 -3510 2500 -3490 {
lab=ctop}
N 2380 -3410 2400 -3410 {
lab=row_n[8]}
N 2380 -3390 2400 -3390 {
lab=rowon_n[8]}
N 2380 -3370 2400 -3370 {
lab=#net17}
N 2380 -3350 2400 -3350 {
lab=#net18}
N 2620 -3350 2640 -3350 {
lab=#net18}
N 2620 -3370 2640 -3370 {
lab=#net17}
N 2620 -3390 2640 -3390 {
lab=rowon_n[8]}
N 2620 -3410 2640 -3410 {
lab=row_n[8]}
N 2440 -3270 2440 -3260 {
lab=VSS}
N 2440 -3500 2440 -3490 {
lab=VDD}
N 2780 -3270 2790 -3280 {
lab=col_n[8]}
N 2790 -3480 2790 -3280 {
lab=col_n[8]}
N 2780 -3490 2790 -3480 {
lab=col_n[8]}
N 2780 -3270 2780 -3250 {
lab=col_n[8]}
N 2780 -3510 2780 -3490 {
lab=col_n[8]}
N 2660 -3410 2670 -3420 {
lab=row_n[8]}
N 2670 -3420 2870 -3420 {
lab=row_n[8]}
N 2870 -3420 2880 -3410 {
lab=row_n[8]}
N 2660 -3390 2670 -3400 {
lab=rowon_n[8]}
N 2670 -3400 2870 -3400 {
lab=rowon_n[8]}
N 2870 -3400 2880 -3390 {
lab=rowon_n[8]}
N 2660 -3370 2670 -3380 {
lab=#net17}
N 2670 -3380 2870 -3380 {
lab=#net17}
N 2870 -3380 2880 -3370 {
lab=#net17}
N 2660 -3350 2670 -3360 {
lab=#net18}
N 2670 -3360 2870 -3360 {
lab=#net18}
N 2870 -3360 2880 -3350 {
lab=#net18}
N 2720 -3510 2720 -3490 {
lab=vcm}
N 2760 -3510 2760 -3490 {
lab=ctop}
N 2640 -3410 2660 -3410 {
lab=row_n[8]}
N 2640 -3390 2660 -3390 {
lab=rowon_n[8]}
N 2640 -3370 2660 -3370 {
lab=#net17}
N 2640 -3350 2660 -3350 {
lab=#net18}
N 2880 -3350 2900 -3350 {
lab=#net18}
N 2880 -3370 2900 -3370 {
lab=#net17}
N 2880 -3390 2900 -3390 {
lab=rowon_n[8]}
N 2880 -3410 2900 -3410 {
lab=row_n[8]}
N 2700 -3270 2700 -3260 {
lab=VSS}
N 2700 -3500 2700 -3490 {
lab=VDD}
N 3040 -3270 3050 -3280 {
lab=col_n[9]}
N 3050 -3480 3050 -3280 {
lab=col_n[9]}
N 3040 -3490 3050 -3480 {
lab=col_n[9]}
N 3040 -3270 3040 -3250 {
lab=col_n[9]}
N 3040 -3510 3040 -3490 {
lab=col_n[9]}
N 2920 -3410 2930 -3420 {
lab=row_n[8]}
N 2930 -3420 3130 -3420 {
lab=row_n[8]}
N 3130 -3420 3140 -3410 {
lab=row_n[8]}
N 2920 -3390 2930 -3400 {
lab=rowon_n[8]}
N 2930 -3400 3130 -3400 {
lab=rowon_n[8]}
N 3130 -3400 3140 -3390 {
lab=rowon_n[8]}
N 2920 -3370 2930 -3380 {
lab=#net17}
N 2930 -3380 3130 -3380 {
lab=#net17}
N 3130 -3380 3140 -3370 {
lab=#net17}
N 2920 -3350 2930 -3360 {
lab=#net18}
N 2930 -3360 3130 -3360 {
lab=#net18}
N 3130 -3360 3140 -3350 {
lab=#net18}
N 2980 -3510 2980 -3490 {
lab=vcm}
N 3020 -3510 3020 -3490 {
lab=ctop}
N 2900 -3410 2920 -3410 {
lab=row_n[8]}
N 2900 -3390 2920 -3390 {
lab=rowon_n[8]}
N 2900 -3370 2920 -3370 {
lab=#net17}
N 2900 -3350 2920 -3350 {
lab=#net18}
N 3140 -3350 3160 -3350 {
lab=#net18}
N 3140 -3370 3160 -3370 {
lab=#net17}
N 3140 -3390 3160 -3390 {
lab=rowon_n[8]}
N 3140 -3410 3160 -3410 {
lab=row_n[8]}
N 2960 -3270 2960 -3260 {
lab=VSS}
N 2960 -3500 2960 -3490 {
lab=VDD}
N 3300 -3270 3310 -3280 {
lab=col_n[10]}
N 3310 -3480 3310 -3280 {
lab=col_n[10]}
N 3300 -3490 3310 -3480 {
lab=col_n[10]}
N 3300 -3270 3300 -3250 {
lab=col_n[10]}
N 3300 -3510 3300 -3490 {
lab=col_n[10]}
N 3180 -3410 3190 -3420 {
lab=row_n[8]}
N 3190 -3420 3390 -3420 {
lab=row_n[8]}
N 3390 -3420 3400 -3410 {
lab=row_n[8]}
N 3180 -3390 3190 -3400 {
lab=rowon_n[8]}
N 3190 -3400 3390 -3400 {
lab=rowon_n[8]}
N 3390 -3400 3400 -3390 {
lab=rowon_n[8]}
N 3180 -3370 3190 -3380 {
lab=#net17}
N 3190 -3380 3390 -3380 {
lab=#net17}
N 3390 -3380 3400 -3370 {
lab=#net17}
N 3180 -3350 3190 -3360 {
lab=#net18}
N 3190 -3360 3390 -3360 {
lab=#net18}
N 3390 -3360 3400 -3350 {
lab=#net18}
N 3240 -3510 3240 -3490 {
lab=vcm}
N 3280 -3510 3280 -3490 {
lab=ctop}
N 3160 -3410 3180 -3410 {
lab=row_n[8]}
N 3160 -3390 3180 -3390 {
lab=rowon_n[8]}
N 3160 -3370 3180 -3370 {
lab=#net17}
N 3160 -3350 3180 -3350 {
lab=#net18}
N 3400 -3350 3420 -3350 {
lab=#net18}
N 3400 -3370 3420 -3370 {
lab=#net17}
N 3400 -3390 3420 -3390 {
lab=rowon_n[8]}
N 3400 -3410 3420 -3410 {
lab=row_n[8]}
N 3220 -3270 3220 -3260 {
lab=VSS}
N 3220 -3500 3220 -3490 {
lab=VDD}
N 3560 -3270 3570 -3280 {
lab=col_n[11]}
N 3570 -3480 3570 -3280 {
lab=col_n[11]}
N 3560 -3490 3570 -3480 {
lab=col_n[11]}
N 3560 -3270 3560 -3250 {
lab=col_n[11]}
N 3560 -3510 3560 -3490 {
lab=col_n[11]}
N 3440 -3410 3450 -3420 {
lab=row_n[8]}
N 3450 -3420 3650 -3420 {
lab=row_n[8]}
N 3650 -3420 3660 -3410 {
lab=row_n[8]}
N 3440 -3390 3450 -3400 {
lab=rowon_n[8]}
N 3450 -3400 3650 -3400 {
lab=rowon_n[8]}
N 3650 -3400 3660 -3390 {
lab=rowon_n[8]}
N 3440 -3370 3450 -3380 {
lab=#net17}
N 3450 -3380 3650 -3380 {
lab=#net17}
N 3650 -3380 3660 -3370 {
lab=#net17}
N 3440 -3350 3450 -3360 {
lab=#net18}
N 3450 -3360 3650 -3360 {
lab=#net18}
N 3650 -3360 3660 -3350 {
lab=#net18}
N 3500 -3510 3500 -3490 {
lab=vcm}
N 3540 -3510 3540 -3490 {
lab=ctop}
N 3420 -3410 3440 -3410 {
lab=row_n[8]}
N 3420 -3390 3440 -3390 {
lab=rowon_n[8]}
N 3420 -3370 3440 -3370 {
lab=#net17}
N 3420 -3350 3440 -3350 {
lab=#net18}
N 3660 -3350 3680 -3350 {
lab=#net18}
N 3660 -3370 3680 -3370 {
lab=#net17}
N 3660 -3390 3680 -3390 {
lab=rowon_n[8]}
N 3660 -3410 3680 -3410 {
lab=row_n[8]}
N 3480 -3270 3480 -3260 {
lab=VSS}
N 3480 -3500 3480 -3490 {
lab=VDD}
N 3820 -3270 3830 -3280 {
lab=col_n[12]}
N 3830 -3480 3830 -3280 {
lab=col_n[12]}
N 3820 -3490 3830 -3480 {
lab=col_n[12]}
N 3820 -3270 3820 -3250 {
lab=col_n[12]}
N 3820 -3510 3820 -3490 {
lab=col_n[12]}
N 3700 -3410 3710 -3420 {
lab=row_n[8]}
N 3710 -3420 3910 -3420 {
lab=row_n[8]}
N 3910 -3420 3920 -3410 {
lab=row_n[8]}
N 3700 -3390 3710 -3400 {
lab=rowon_n[8]}
N 3710 -3400 3910 -3400 {
lab=rowon_n[8]}
N 3910 -3400 3920 -3390 {
lab=rowon_n[8]}
N 3700 -3370 3710 -3380 {
lab=#net17}
N 3710 -3380 3910 -3380 {
lab=#net17}
N 3910 -3380 3920 -3370 {
lab=#net17}
N 3700 -3350 3710 -3360 {
lab=#net18}
N 3710 -3360 3910 -3360 {
lab=#net18}
N 3910 -3360 3920 -3350 {
lab=#net18}
N 3760 -3510 3760 -3490 {
lab=vcm}
N 3800 -3510 3800 -3490 {
lab=ctop}
N 3680 -3410 3700 -3410 {
lab=row_n[8]}
N 3680 -3390 3700 -3390 {
lab=rowon_n[8]}
N 3680 -3370 3700 -3370 {
lab=#net17}
N 3680 -3350 3700 -3350 {
lab=#net18}
N 3920 -3350 3940 -3350 {
lab=#net18}
N 3920 -3370 3940 -3370 {
lab=#net17}
N 3920 -3390 3940 -3390 {
lab=rowon_n[8]}
N 3920 -3410 3940 -3410 {
lab=row_n[8]}
N 3740 -3270 3740 -3260 {
lab=VSS}
N 3740 -3500 3740 -3490 {
lab=VDD}
N 4080 -3270 4090 -3280 {
lab=col_n[13]}
N 4090 -3480 4090 -3280 {
lab=col_n[13]}
N 4080 -3490 4090 -3480 {
lab=col_n[13]}
N 4080 -3270 4080 -3250 {
lab=col_n[13]}
N 4080 -3510 4080 -3490 {
lab=col_n[13]}
N 3960 -3410 3970 -3420 {
lab=row_n[8]}
N 3970 -3420 4170 -3420 {
lab=row_n[8]}
N 4170 -3420 4180 -3410 {
lab=row_n[8]}
N 3960 -3390 3970 -3400 {
lab=rowon_n[8]}
N 3970 -3400 4170 -3400 {
lab=rowon_n[8]}
N 4170 -3400 4180 -3390 {
lab=rowon_n[8]}
N 3960 -3370 3970 -3380 {
lab=#net17}
N 3970 -3380 4170 -3380 {
lab=#net17}
N 4170 -3380 4180 -3370 {
lab=#net17}
N 3960 -3350 3970 -3360 {
lab=#net18}
N 3970 -3360 4170 -3360 {
lab=#net18}
N 4170 -3360 4180 -3350 {
lab=#net18}
N 4020 -3510 4020 -3490 {
lab=vcm}
N 4060 -3510 4060 -3490 {
lab=ctop}
N 3940 -3410 3960 -3410 {
lab=row_n[8]}
N 3940 -3390 3960 -3390 {
lab=rowon_n[8]}
N 3940 -3370 3960 -3370 {
lab=#net17}
N 3940 -3350 3960 -3350 {
lab=#net18}
N 4180 -3350 4200 -3350 {
lab=#net18}
N 4180 -3370 4200 -3370 {
lab=#net17}
N 4180 -3390 4200 -3390 {
lab=rowon_n[8]}
N 4180 -3410 4200 -3410 {
lab=row_n[8]}
N 4000 -3270 4000 -3260 {
lab=VSS}
N 4000 -3500 4000 -3490 {
lab=VDD}
N 4340 -3270 4350 -3280 {
lab=col_n[14]}
N 4350 -3480 4350 -3280 {
lab=col_n[14]}
N 4340 -3490 4350 -3480 {
lab=col_n[14]}
N 4340 -3270 4340 -3250 {
lab=col_n[14]}
N 4340 -3510 4340 -3490 {
lab=col_n[14]}
N 4220 -3410 4230 -3420 {
lab=row_n[8]}
N 4230 -3420 4430 -3420 {
lab=row_n[8]}
N 4430 -3420 4440 -3410 {
lab=row_n[8]}
N 4220 -3390 4230 -3400 {
lab=rowon_n[8]}
N 4230 -3400 4430 -3400 {
lab=rowon_n[8]}
N 4430 -3400 4440 -3390 {
lab=rowon_n[8]}
N 4220 -3370 4230 -3380 {
lab=#net17}
N 4230 -3380 4430 -3380 {
lab=#net17}
N 4430 -3380 4440 -3370 {
lab=#net17}
N 4220 -3350 4230 -3360 {
lab=#net18}
N 4230 -3360 4430 -3360 {
lab=#net18}
N 4430 -3360 4440 -3350 {
lab=#net18}
N 4280 -3510 4280 -3490 {
lab=vcm}
N 4320 -3510 4320 -3490 {
lab=ctop}
N 4200 -3410 4220 -3410 {
lab=row_n[8]}
N 4200 -3390 4220 -3390 {
lab=rowon_n[8]}
N 4200 -3370 4220 -3370 {
lab=#net17}
N 4200 -3350 4220 -3350 {
lab=#net18}
N 4440 -3350 4460 -3350 {
lab=#net18}
N 4440 -3370 4460 -3370 {
lab=#net17}
N 4440 -3390 4460 -3390 {
lab=rowon_n[8]}
N 4440 -3410 4460 -3410 {
lab=row_n[8]}
N 4260 -3270 4260 -3260 {
lab=VSS}
N 4260 -3500 4260 -3490 {
lab=VDD}
N 4600 -3270 4610 -3280 {
lab=col_n[15]}
N 4610 -3480 4610 -3280 {
lab=col_n[15]}
N 4600 -3490 4610 -3480 {
lab=col_n[15]}
N 4600 -3270 4600 -3250 {
lab=col_n[15]}
N 4600 -3510 4600 -3490 {
lab=col_n[15]}
N 4480 -3410 4490 -3420 {
lab=row_n[8]}
N 4490 -3420 4690 -3420 {
lab=row_n[8]}
N 4690 -3420 4700 -3410 {
lab=row_n[8]}
N 4480 -3390 4490 -3400 {
lab=rowon_n[8]}
N 4490 -3400 4690 -3400 {
lab=rowon_n[8]}
N 4690 -3400 4700 -3390 {
lab=rowon_n[8]}
N 4480 -3370 4490 -3380 {
lab=#net17}
N 4490 -3380 4690 -3380 {
lab=#net17}
N 4690 -3380 4700 -3370 {
lab=#net17}
N 4480 -3350 4490 -3360 {
lab=#net18}
N 4490 -3360 4690 -3360 {
lab=#net18}
N 4690 -3360 4700 -3350 {
lab=#net18}
N 4540 -3510 4540 -3490 {
lab=vcm}
N 4580 -3510 4580 -3490 {
lab=ctop}
N 4460 -3410 4480 -3410 {
lab=row_n[8]}
N 4460 -3390 4480 -3390 {
lab=rowon_n[8]}
N 4460 -3370 4480 -3370 {
lab=#net17}
N 4460 -3350 4480 -3350 {
lab=#net18}
N 4700 -3350 4720 -3350 {
lab=#net18}
N 4700 -3370 4720 -3370 {
lab=#net17}
N 4700 -3390 4720 -3390 {
lab=rowon_n[8]}
N 4700 -3410 4720 -3410 {
lab=row_n[8]}
N 4520 -3270 4520 -3260 {
lab=VSS}
N 4520 -3500 4520 -3490 {
lab=VDD}
N 4860 -3270 4870 -3280 {
lab=col_n[16]}
N 4870 -3480 4870 -3280 {
lab=col_n[16]}
N 4860 -3490 4870 -3480 {
lab=col_n[16]}
N 4860 -3270 4860 -3250 {
lab=col_n[16]}
N 4860 -3510 4860 -3490 {
lab=col_n[16]}
N 4740 -3410 4750 -3420 {
lab=row_n[8]}
N 4750 -3420 4950 -3420 {
lab=row_n[8]}
N 4950 -3420 4960 -3410 {
lab=row_n[8]}
N 4740 -3390 4750 -3400 {
lab=rowon_n[8]}
N 4750 -3400 4950 -3400 {
lab=rowon_n[8]}
N 4950 -3400 4960 -3390 {
lab=rowon_n[8]}
N 4740 -3370 4750 -3380 {
lab=#net17}
N 4750 -3380 4950 -3380 {
lab=#net17}
N 4950 -3380 4960 -3370 {
lab=#net17}
N 4740 -3350 4750 -3360 {
lab=#net18}
N 4750 -3360 4950 -3360 {
lab=#net18}
N 4950 -3360 4960 -3350 {
lab=#net18}
N 4800 -3510 4800 -3490 {
lab=vcm}
N 4840 -3510 4840 -3490 {
lab=ctop}
N 4720 -3410 4740 -3410 {
lab=row_n[8]}
N 4720 -3390 4740 -3390 {
lab=rowon_n[8]}
N 4720 -3370 4740 -3370 {
lab=#net17}
N 4720 -3350 4740 -3350 {
lab=#net18}
N 4960 -3350 4980 -3350 {
lab=#net18}
N 4960 -3370 4980 -3370 {
lab=#net17}
N 4960 -3390 4980 -3390 {
lab=rowon_n[8]}
N 4960 -3410 4980 -3410 {
lab=row_n[8]}
N 4780 -3270 4780 -3260 {
lab=VSS}
N 4780 -3500 4780 -3490 {
lab=VDD}
N 5120 -3270 5130 -3280 {
lab=col_n[17]}
N 5130 -3480 5130 -3280 {
lab=col_n[17]}
N 5120 -3490 5130 -3480 {
lab=col_n[17]}
N 5120 -3270 5120 -3250 {
lab=col_n[17]}
N 5120 -3510 5120 -3490 {
lab=col_n[17]}
N 5000 -3410 5010 -3420 {
lab=row_n[8]}
N 5010 -3420 5210 -3420 {
lab=row_n[8]}
N 5210 -3420 5220 -3410 {
lab=row_n[8]}
N 5000 -3390 5010 -3400 {
lab=rowon_n[8]}
N 5010 -3400 5210 -3400 {
lab=rowon_n[8]}
N 5210 -3400 5220 -3390 {
lab=rowon_n[8]}
N 5000 -3370 5010 -3380 {
lab=#net17}
N 5010 -3380 5210 -3380 {
lab=#net17}
N 5210 -3380 5220 -3370 {
lab=#net17}
N 5000 -3350 5010 -3360 {
lab=#net18}
N 5010 -3360 5210 -3360 {
lab=#net18}
N 5210 -3360 5220 -3350 {
lab=#net18}
N 5060 -3510 5060 -3490 {
lab=vcm}
N 5100 -3510 5100 -3490 {
lab=ctop}
N 4980 -3410 5000 -3410 {
lab=row_n[8]}
N 4980 -3390 5000 -3390 {
lab=rowon_n[8]}
N 4980 -3370 5000 -3370 {
lab=#net17}
N 4980 -3350 5000 -3350 {
lab=#net18}
N 5220 -3350 5240 -3350 {
lab=#net18}
N 5220 -3370 5240 -3370 {
lab=#net17}
N 5220 -3390 5240 -3390 {
lab=rowon_n[8]}
N 5220 -3410 5240 -3410 {
lab=row_n[8]}
N 5040 -3270 5040 -3260 {
lab=VSS}
N 5040 -3500 5040 -3490 {
lab=VDD}
N 5380 -3270 5390 -3280 {
lab=col_n[18]}
N 5390 -3480 5390 -3280 {
lab=col_n[18]}
N 5380 -3490 5390 -3480 {
lab=col_n[18]}
N 5380 -3270 5380 -3250 {
lab=col_n[18]}
N 5380 -3510 5380 -3490 {
lab=col_n[18]}
N 5260 -3410 5270 -3420 {
lab=row_n[8]}
N 5270 -3420 5470 -3420 {
lab=row_n[8]}
N 5470 -3420 5480 -3410 {
lab=row_n[8]}
N 5260 -3390 5270 -3400 {
lab=rowon_n[8]}
N 5270 -3400 5470 -3400 {
lab=rowon_n[8]}
N 5470 -3400 5480 -3390 {
lab=rowon_n[8]}
N 5260 -3370 5270 -3380 {
lab=#net17}
N 5270 -3380 5470 -3380 {
lab=#net17}
N 5470 -3380 5480 -3370 {
lab=#net17}
N 5260 -3350 5270 -3360 {
lab=#net18}
N 5270 -3360 5470 -3360 {
lab=#net18}
N 5470 -3360 5480 -3350 {
lab=#net18}
N 5320 -3510 5320 -3490 {
lab=vcm}
N 5360 -3510 5360 -3490 {
lab=ctop}
N 5240 -3410 5260 -3410 {
lab=row_n[8]}
N 5240 -3390 5260 -3390 {
lab=rowon_n[8]}
N 5240 -3370 5260 -3370 {
lab=#net17}
N 5240 -3350 5260 -3350 {
lab=#net18}
N 5480 -3350 5500 -3350 {
lab=#net18}
N 5480 -3370 5500 -3370 {
lab=#net17}
N 5480 -3390 5500 -3390 {
lab=rowon_n[8]}
N 5480 -3410 5500 -3410 {
lab=row_n[8]}
N 5300 -3270 5300 -3260 {
lab=VSS}
N 5300 -3500 5300 -3490 {
lab=VDD}
N 5640 -3270 5650 -3280 {
lab=col_n[19]}
N 5650 -3480 5650 -3280 {
lab=col_n[19]}
N 5640 -3490 5650 -3480 {
lab=col_n[19]}
N 5640 -3270 5640 -3250 {
lab=col_n[19]}
N 5640 -3510 5640 -3490 {
lab=col_n[19]}
N 5520 -3410 5530 -3420 {
lab=row_n[8]}
N 5530 -3420 5730 -3420 {
lab=row_n[8]}
N 5730 -3420 5740 -3410 {
lab=row_n[8]}
N 5520 -3390 5530 -3400 {
lab=rowon_n[8]}
N 5530 -3400 5730 -3400 {
lab=rowon_n[8]}
N 5730 -3400 5740 -3390 {
lab=rowon_n[8]}
N 5520 -3370 5530 -3380 {
lab=#net17}
N 5530 -3380 5730 -3380 {
lab=#net17}
N 5730 -3380 5740 -3370 {
lab=#net17}
N 5520 -3350 5530 -3360 {
lab=#net18}
N 5530 -3360 5730 -3360 {
lab=#net18}
N 5730 -3360 5740 -3350 {
lab=#net18}
N 5580 -3510 5580 -3490 {
lab=vcm}
N 5620 -3510 5620 -3490 {
lab=ctop}
N 5500 -3410 5520 -3410 {
lab=row_n[8]}
N 5500 -3390 5520 -3390 {
lab=rowon_n[8]}
N 5500 -3370 5520 -3370 {
lab=#net17}
N 5500 -3350 5520 -3350 {
lab=#net18}
N 5740 -3350 5760 -3350 {
lab=#net18}
N 5740 -3370 5760 -3370 {
lab=#net17}
N 5740 -3390 5760 -3390 {
lab=rowon_n[8]}
N 5740 -3410 5760 -3410 {
lab=row_n[8]}
N 5560 -3270 5560 -3260 {
lab=VSS}
N 5560 -3500 5560 -3490 {
lab=VDD}
N 5900 -3270 5910 -3280 {
lab=col_n[20]}
N 5910 -3480 5910 -3280 {
lab=col_n[20]}
N 5900 -3490 5910 -3480 {
lab=col_n[20]}
N 5900 -3270 5900 -3250 {
lab=col_n[20]}
N 5900 -3510 5900 -3490 {
lab=col_n[20]}
N 5780 -3410 5790 -3420 {
lab=row_n[8]}
N 5790 -3420 5990 -3420 {
lab=row_n[8]}
N 5990 -3420 6000 -3410 {
lab=row_n[8]}
N 5780 -3390 5790 -3400 {
lab=rowon_n[8]}
N 5790 -3400 5990 -3400 {
lab=rowon_n[8]}
N 5990 -3400 6000 -3390 {
lab=rowon_n[8]}
N 5780 -3370 5790 -3380 {
lab=#net17}
N 5790 -3380 5990 -3380 {
lab=#net17}
N 5990 -3380 6000 -3370 {
lab=#net17}
N 5780 -3350 5790 -3360 {
lab=#net18}
N 5790 -3360 5990 -3360 {
lab=#net18}
N 5990 -3360 6000 -3350 {
lab=#net18}
N 5840 -3510 5840 -3490 {
lab=vcm}
N 5880 -3510 5880 -3490 {
lab=ctop}
N 5760 -3410 5780 -3410 {
lab=row_n[8]}
N 5760 -3390 5780 -3390 {
lab=rowon_n[8]}
N 5760 -3370 5780 -3370 {
lab=#net17}
N 5760 -3350 5780 -3350 {
lab=#net18}
N 6000 -3350 6020 -3350 {
lab=#net18}
N 6000 -3370 6020 -3370 {
lab=#net17}
N 6000 -3390 6020 -3390 {
lab=rowon_n[8]}
N 6000 -3410 6020 -3410 {
lab=row_n[8]}
N 5820 -3270 5820 -3260 {
lab=VSS}
N 5820 -3500 5820 -3490 {
lab=VDD}
N 6160 -3270 6170 -3280 {
lab=col_n[21]}
N 6170 -3480 6170 -3280 {
lab=col_n[21]}
N 6160 -3490 6170 -3480 {
lab=col_n[21]}
N 6160 -3270 6160 -3250 {
lab=col_n[21]}
N 6160 -3510 6160 -3490 {
lab=col_n[21]}
N 6040 -3410 6050 -3420 {
lab=row_n[8]}
N 6050 -3420 6250 -3420 {
lab=row_n[8]}
N 6250 -3420 6260 -3410 {
lab=row_n[8]}
N 6040 -3390 6050 -3400 {
lab=rowon_n[8]}
N 6050 -3400 6250 -3400 {
lab=rowon_n[8]}
N 6250 -3400 6260 -3390 {
lab=rowon_n[8]}
N 6040 -3370 6050 -3380 {
lab=#net17}
N 6050 -3380 6250 -3380 {
lab=#net17}
N 6250 -3380 6260 -3370 {
lab=#net17}
N 6040 -3350 6050 -3360 {
lab=#net18}
N 6050 -3360 6250 -3360 {
lab=#net18}
N 6250 -3360 6260 -3350 {
lab=#net18}
N 6100 -3510 6100 -3490 {
lab=vcm}
N 6140 -3510 6140 -3490 {
lab=ctop}
N 6020 -3410 6040 -3410 {
lab=row_n[8]}
N 6020 -3390 6040 -3390 {
lab=rowon_n[8]}
N 6020 -3370 6040 -3370 {
lab=#net17}
N 6020 -3350 6040 -3350 {
lab=#net18}
N 6260 -3350 6280 -3350 {
lab=#net18}
N 6260 -3370 6280 -3370 {
lab=#net17}
N 6260 -3390 6280 -3390 {
lab=rowon_n[8]}
N 6260 -3410 6280 -3410 {
lab=row_n[8]}
N 6080 -3270 6080 -3260 {
lab=VSS}
N 6080 -3500 6080 -3490 {
lab=VDD}
N 6420 -3270 6430 -3280 {
lab=col_n[22]}
N 6430 -3480 6430 -3280 {
lab=col_n[22]}
N 6420 -3490 6430 -3480 {
lab=col_n[22]}
N 6420 -3270 6420 -3250 {
lab=col_n[22]}
N 6420 -3510 6420 -3490 {
lab=col_n[22]}
N 6300 -3410 6310 -3420 {
lab=row_n[8]}
N 6310 -3420 6510 -3420 {
lab=row_n[8]}
N 6510 -3420 6520 -3410 {
lab=row_n[8]}
N 6300 -3390 6310 -3400 {
lab=rowon_n[8]}
N 6310 -3400 6510 -3400 {
lab=rowon_n[8]}
N 6510 -3400 6520 -3390 {
lab=rowon_n[8]}
N 6300 -3370 6310 -3380 {
lab=#net17}
N 6310 -3380 6510 -3380 {
lab=#net17}
N 6510 -3380 6520 -3370 {
lab=#net17}
N 6300 -3350 6310 -3360 {
lab=#net18}
N 6310 -3360 6510 -3360 {
lab=#net18}
N 6510 -3360 6520 -3350 {
lab=#net18}
N 6360 -3510 6360 -3490 {
lab=vcm}
N 6400 -3510 6400 -3490 {
lab=ctop}
N 6280 -3410 6300 -3410 {
lab=row_n[8]}
N 6280 -3390 6300 -3390 {
lab=rowon_n[8]}
N 6280 -3370 6300 -3370 {
lab=#net17}
N 6280 -3350 6300 -3350 {
lab=#net18}
N 6520 -3350 6540 -3350 {
lab=#net18}
N 6520 -3370 6540 -3370 {
lab=#net17}
N 6520 -3390 6540 -3390 {
lab=rowon_n[8]}
N 6520 -3410 6540 -3410 {
lab=row_n[8]}
N 6340 -3270 6340 -3260 {
lab=VSS}
N 6340 -3500 6340 -3490 {
lab=VDD}
N 6680 -3270 6690 -3280 {
lab=col_n[23]}
N 6690 -3480 6690 -3280 {
lab=col_n[23]}
N 6680 -3490 6690 -3480 {
lab=col_n[23]}
N 6680 -3270 6680 -3250 {
lab=col_n[23]}
N 6680 -3510 6680 -3490 {
lab=col_n[23]}
N 6560 -3410 6570 -3420 {
lab=row_n[8]}
N 6570 -3420 6770 -3420 {
lab=row_n[8]}
N 6770 -3420 6780 -3410 {
lab=row_n[8]}
N 6560 -3390 6570 -3400 {
lab=rowon_n[8]}
N 6570 -3400 6770 -3400 {
lab=rowon_n[8]}
N 6770 -3400 6780 -3390 {
lab=rowon_n[8]}
N 6560 -3370 6570 -3380 {
lab=#net17}
N 6570 -3380 6770 -3380 {
lab=#net17}
N 6770 -3380 6780 -3370 {
lab=#net17}
N 6560 -3350 6570 -3360 {
lab=#net18}
N 6570 -3360 6770 -3360 {
lab=#net18}
N 6770 -3360 6780 -3350 {
lab=#net18}
N 6620 -3510 6620 -3490 {
lab=vcm}
N 6660 -3510 6660 -3490 {
lab=ctop}
N 6540 -3410 6560 -3410 {
lab=row_n[8]}
N 6540 -3390 6560 -3390 {
lab=rowon_n[8]}
N 6540 -3370 6560 -3370 {
lab=#net17}
N 6540 -3350 6560 -3350 {
lab=#net18}
N 6780 -3350 6800 -3350 {
lab=#net18}
N 6780 -3370 6800 -3370 {
lab=#net17}
N 6780 -3390 6800 -3390 {
lab=rowon_n[8]}
N 6780 -3410 6800 -3410 {
lab=row_n[8]}
N 6600 -3270 6600 -3260 {
lab=VSS}
N 6600 -3500 6600 -3490 {
lab=VDD}
N 6940 -3270 6950 -3280 {
lab=col_n[24]}
N 6950 -3480 6950 -3280 {
lab=col_n[24]}
N 6940 -3490 6950 -3480 {
lab=col_n[24]}
N 6940 -3270 6940 -3250 {
lab=col_n[24]}
N 6940 -3510 6940 -3490 {
lab=col_n[24]}
N 6820 -3410 6830 -3420 {
lab=row_n[8]}
N 6830 -3420 7030 -3420 {
lab=row_n[8]}
N 7030 -3420 7040 -3410 {
lab=row_n[8]}
N 6820 -3390 6830 -3400 {
lab=rowon_n[8]}
N 6830 -3400 7030 -3400 {
lab=rowon_n[8]}
N 7030 -3400 7040 -3390 {
lab=rowon_n[8]}
N 6820 -3370 6830 -3380 {
lab=#net17}
N 6830 -3380 7030 -3380 {
lab=#net17}
N 7030 -3380 7040 -3370 {
lab=#net17}
N 6820 -3350 6830 -3360 {
lab=#net18}
N 6830 -3360 7030 -3360 {
lab=#net18}
N 7030 -3360 7040 -3350 {
lab=#net18}
N 6880 -3510 6880 -3490 {
lab=vcm}
N 6920 -3510 6920 -3490 {
lab=ctop}
N 6800 -3410 6820 -3410 {
lab=row_n[8]}
N 6800 -3390 6820 -3390 {
lab=rowon_n[8]}
N 6800 -3370 6820 -3370 {
lab=#net17}
N 6800 -3350 6820 -3350 {
lab=#net18}
N 7040 -3350 7060 -3350 {
lab=#net18}
N 7040 -3370 7060 -3370 {
lab=#net17}
N 7040 -3390 7060 -3390 {
lab=rowon_n[8]}
N 7040 -3410 7060 -3410 {
lab=row_n[8]}
N 6860 -3270 6860 -3260 {
lab=VSS}
N 6860 -3500 6860 -3490 {
lab=VDD}
N 7200 -3270 7210 -3280 {
lab=col_n[25]}
N 7210 -3480 7210 -3280 {
lab=col_n[25]}
N 7200 -3490 7210 -3480 {
lab=col_n[25]}
N 7200 -3270 7200 -3250 {
lab=col_n[25]}
N 7200 -3510 7200 -3490 {
lab=col_n[25]}
N 7080 -3410 7090 -3420 {
lab=row_n[8]}
N 7090 -3420 7290 -3420 {
lab=row_n[8]}
N 7290 -3420 7300 -3410 {
lab=row_n[8]}
N 7080 -3390 7090 -3400 {
lab=rowon_n[8]}
N 7090 -3400 7290 -3400 {
lab=rowon_n[8]}
N 7290 -3400 7300 -3390 {
lab=rowon_n[8]}
N 7080 -3370 7090 -3380 {
lab=#net17}
N 7090 -3380 7290 -3380 {
lab=#net17}
N 7290 -3380 7300 -3370 {
lab=#net17}
N 7080 -3350 7090 -3360 {
lab=#net18}
N 7090 -3360 7290 -3360 {
lab=#net18}
N 7290 -3360 7300 -3350 {
lab=#net18}
N 7140 -3510 7140 -3490 {
lab=vcm}
N 7180 -3510 7180 -3490 {
lab=ctop}
N 7060 -3410 7080 -3410 {
lab=row_n[8]}
N 7060 -3390 7080 -3390 {
lab=rowon_n[8]}
N 7060 -3370 7080 -3370 {
lab=#net17}
N 7060 -3350 7080 -3350 {
lab=#net18}
N 7300 -3350 7320 -3350 {
lab=#net18}
N 7300 -3370 7320 -3370 {
lab=#net17}
N 7300 -3390 7320 -3390 {
lab=rowon_n[8]}
N 7300 -3410 7320 -3410 {
lab=row_n[8]}
N 7120 -3270 7120 -3260 {
lab=VSS}
N 7120 -3500 7120 -3490 {
lab=VDD}
N 7460 -3270 7470 -3280 {
lab=col_n[26]}
N 7470 -3480 7470 -3280 {
lab=col_n[26]}
N 7460 -3490 7470 -3480 {
lab=col_n[26]}
N 7460 -3270 7460 -3250 {
lab=col_n[26]}
N 7460 -3510 7460 -3490 {
lab=col_n[26]}
N 7340 -3410 7350 -3420 {
lab=row_n[8]}
N 7350 -3420 7550 -3420 {
lab=row_n[8]}
N 7550 -3420 7560 -3410 {
lab=row_n[8]}
N 7340 -3390 7350 -3400 {
lab=rowon_n[8]}
N 7350 -3400 7550 -3400 {
lab=rowon_n[8]}
N 7550 -3400 7560 -3390 {
lab=rowon_n[8]}
N 7340 -3370 7350 -3380 {
lab=#net17}
N 7350 -3380 7550 -3380 {
lab=#net17}
N 7550 -3380 7560 -3370 {
lab=#net17}
N 7340 -3350 7350 -3360 {
lab=#net18}
N 7350 -3360 7550 -3360 {
lab=#net18}
N 7550 -3360 7560 -3350 {
lab=#net18}
N 7400 -3510 7400 -3490 {
lab=vcm}
N 7440 -3510 7440 -3490 {
lab=ctop}
N 7320 -3410 7340 -3410 {
lab=row_n[8]}
N 7320 -3390 7340 -3390 {
lab=rowon_n[8]}
N 7320 -3370 7340 -3370 {
lab=#net17}
N 7320 -3350 7340 -3350 {
lab=#net18}
N 7560 -3350 7580 -3350 {
lab=#net18}
N 7560 -3370 7580 -3370 {
lab=#net17}
N 7560 -3390 7580 -3390 {
lab=rowon_n[8]}
N 7560 -3410 7580 -3410 {
lab=row_n[8]}
N 7380 -3270 7380 -3260 {
lab=VSS}
N 7380 -3500 7380 -3490 {
lab=VDD}
N 7720 -3270 7730 -3280 {
lab=col_n[27]}
N 7730 -3480 7730 -3280 {
lab=col_n[27]}
N 7720 -3490 7730 -3480 {
lab=col_n[27]}
N 7720 -3270 7720 -3250 {
lab=col_n[27]}
N 7720 -3510 7720 -3490 {
lab=col_n[27]}
N 7600 -3410 7610 -3420 {
lab=row_n[8]}
N 7610 -3420 7810 -3420 {
lab=row_n[8]}
N 7810 -3420 7820 -3410 {
lab=row_n[8]}
N 7600 -3390 7610 -3400 {
lab=rowon_n[8]}
N 7610 -3400 7810 -3400 {
lab=rowon_n[8]}
N 7810 -3400 7820 -3390 {
lab=rowon_n[8]}
N 7600 -3370 7610 -3380 {
lab=#net17}
N 7610 -3380 7810 -3380 {
lab=#net17}
N 7810 -3380 7820 -3370 {
lab=#net17}
N 7600 -3350 7610 -3360 {
lab=#net18}
N 7610 -3360 7810 -3360 {
lab=#net18}
N 7810 -3360 7820 -3350 {
lab=#net18}
N 7660 -3510 7660 -3490 {
lab=vcm}
N 7700 -3510 7700 -3490 {
lab=ctop}
N 7580 -3410 7600 -3410 {
lab=row_n[8]}
N 7580 -3390 7600 -3390 {
lab=rowon_n[8]}
N 7580 -3370 7600 -3370 {
lab=#net17}
N 7580 -3350 7600 -3350 {
lab=#net18}
N 7820 -3350 7840 -3350 {
lab=#net18}
N 7820 -3370 7840 -3370 {
lab=#net17}
N 7820 -3390 7840 -3390 {
lab=rowon_n[8]}
N 7820 -3410 7840 -3410 {
lab=row_n[8]}
N 7640 -3270 7640 -3260 {
lab=VSS}
N 7640 -3500 7640 -3490 {
lab=VDD}
N 7980 -3270 7990 -3280 {
lab=col_n[28]}
N 7990 -3480 7990 -3280 {
lab=col_n[28]}
N 7980 -3490 7990 -3480 {
lab=col_n[28]}
N 7980 -3270 7980 -3250 {
lab=col_n[28]}
N 7980 -3510 7980 -3490 {
lab=col_n[28]}
N 7860 -3410 7870 -3420 {
lab=row_n[8]}
N 7870 -3420 8070 -3420 {
lab=row_n[8]}
N 8070 -3420 8080 -3410 {
lab=row_n[8]}
N 7860 -3390 7870 -3400 {
lab=rowon_n[8]}
N 7870 -3400 8070 -3400 {
lab=rowon_n[8]}
N 8070 -3400 8080 -3390 {
lab=rowon_n[8]}
N 7860 -3370 7870 -3380 {
lab=#net17}
N 7870 -3380 8070 -3380 {
lab=#net17}
N 8070 -3380 8080 -3370 {
lab=#net17}
N 7860 -3350 7870 -3360 {
lab=#net18}
N 7870 -3360 8070 -3360 {
lab=#net18}
N 8070 -3360 8080 -3350 {
lab=#net18}
N 7920 -3510 7920 -3490 {
lab=vcm}
N 7960 -3510 7960 -3490 {
lab=ctop}
N 7840 -3410 7860 -3410 {
lab=row_n[8]}
N 7840 -3390 7860 -3390 {
lab=rowon_n[8]}
N 7840 -3370 7860 -3370 {
lab=#net17}
N 7840 -3350 7860 -3350 {
lab=#net18}
N 8080 -3350 8100 -3350 {
lab=#net18}
N 8080 -3370 8100 -3370 {
lab=#net17}
N 8080 -3390 8100 -3390 {
lab=rowon_n[8]}
N 8080 -3410 8100 -3410 {
lab=row_n[8]}
N 7900 -3270 7900 -3260 {
lab=VSS}
N 7900 -3500 7900 -3490 {
lab=VDD}
N 8240 -3270 8250 -3280 {
lab=col_n[29]}
N 8250 -3480 8250 -3280 {
lab=col_n[29]}
N 8240 -3490 8250 -3480 {
lab=col_n[29]}
N 8240 -3270 8240 -3250 {
lab=col_n[29]}
N 8240 -3510 8240 -3490 {
lab=col_n[29]}
N 8120 -3410 8130 -3420 {
lab=row_n[8]}
N 8130 -3420 8330 -3420 {
lab=row_n[8]}
N 8330 -3420 8340 -3410 {
lab=row_n[8]}
N 8120 -3390 8130 -3400 {
lab=rowon_n[8]}
N 8130 -3400 8330 -3400 {
lab=rowon_n[8]}
N 8330 -3400 8340 -3390 {
lab=rowon_n[8]}
N 8120 -3370 8130 -3380 {
lab=#net17}
N 8130 -3380 8330 -3380 {
lab=#net17}
N 8330 -3380 8340 -3370 {
lab=#net17}
N 8120 -3350 8130 -3360 {
lab=#net18}
N 8130 -3360 8330 -3360 {
lab=#net18}
N 8330 -3360 8340 -3350 {
lab=#net18}
N 8180 -3510 8180 -3490 {
lab=vcm}
N 8220 -3510 8220 -3490 {
lab=ctop}
N 8100 -3410 8120 -3410 {
lab=row_n[8]}
N 8100 -3390 8120 -3390 {
lab=rowon_n[8]}
N 8100 -3370 8120 -3370 {
lab=#net17}
N 8100 -3350 8120 -3350 {
lab=#net18}
N 8340 -3350 8360 -3350 {
lab=#net18}
N 8340 -3370 8360 -3370 {
lab=#net17}
N 8340 -3390 8360 -3390 {
lab=rowon_n[8]}
N 8340 -3410 8360 -3410 {
lab=row_n[8]}
N 8160 -3270 8160 -3260 {
lab=VSS}
N 8160 -3500 8160 -3490 {
lab=VDD}
N 8500 -3270 8510 -3280 {
lab=col_n[30]}
N 8510 -3480 8510 -3280 {
lab=col_n[30]}
N 8500 -3490 8510 -3480 {
lab=col_n[30]}
N 8500 -3270 8500 -3250 {
lab=col_n[30]}
N 8500 -3510 8500 -3490 {
lab=col_n[30]}
N 8380 -3410 8390 -3420 {
lab=row_n[8]}
N 8390 -3420 8590 -3420 {
lab=row_n[8]}
N 8590 -3420 8600 -3410 {
lab=row_n[8]}
N 8380 -3390 8390 -3400 {
lab=rowon_n[8]}
N 8390 -3400 8590 -3400 {
lab=rowon_n[8]}
N 8590 -3400 8600 -3390 {
lab=rowon_n[8]}
N 8380 -3370 8390 -3380 {
lab=#net17}
N 8390 -3380 8590 -3380 {
lab=#net17}
N 8590 -3380 8600 -3370 {
lab=#net17}
N 8380 -3350 8390 -3360 {
lab=#net18}
N 8390 -3360 8590 -3360 {
lab=#net18}
N 8590 -3360 8600 -3350 {
lab=#net18}
N 8440 -3510 8440 -3490 {
lab=vcm}
N 8480 -3510 8480 -3490 {
lab=ctop}
N 8360 -3410 8380 -3410 {
lab=row_n[8]}
N 8360 -3390 8380 -3390 {
lab=rowon_n[8]}
N 8360 -3370 8380 -3370 {
lab=#net17}
N 8360 -3350 8380 -3350 {
lab=#net18}
N 8600 -3350 8620 -3350 {
lab=#net18}
N 8600 -3370 8620 -3370 {
lab=#net17}
N 8600 -3390 8620 -3390 {
lab=rowon_n[8]}
N 8600 -3410 8620 -3410 {
lab=row_n[8]}
N 8420 -3270 8420 -3260 {
lab=VSS}
N 8420 -3500 8420 -3490 {
lab=VDD}
N 8760 -3270 8770 -3280 {
lab=col_n[31]}
N 8770 -3480 8770 -3280 {
lab=col_n[31]}
N 8760 -3490 8770 -3480 {
lab=col_n[31]}
N 8760 -3270 8760 -3250 {
lab=col_n[31]}
N 8760 -3510 8760 -3490 {
lab=col_n[31]}
N 8640 -3410 8650 -3420 {
lab=row_n[8]}
N 8650 -3420 8850 -3420 {
lab=row_n[8]}
N 8850 -3420 8860 -3410 {
lab=row_n[8]}
N 8640 -3390 8650 -3400 {
lab=rowon_n[8]}
N 8650 -3400 8850 -3400 {
lab=rowon_n[8]}
N 8850 -3400 8860 -3390 {
lab=rowon_n[8]}
N 8640 -3370 8650 -3380 {
lab=#net17}
N 8650 -3380 8850 -3380 {
lab=#net17}
N 8850 -3380 8860 -3370 {
lab=#net17}
N 8640 -3350 8650 -3360 {
lab=#net18}
N 8650 -3360 8850 -3360 {
lab=#net18}
N 8850 -3360 8860 -3350 {
lab=#net18}
N 8700 -3510 8700 -3490 {
lab=vcm}
N 8740 -3510 8740 -3490 {
lab=ctop}
N 8620 -3410 8640 -3410 {
lab=row_n[8]}
N 8620 -3390 8640 -3390 {
lab=rowon_n[8]}
N 8620 -3370 8640 -3370 {
lab=#net17}
N 8620 -3350 8640 -3350 {
lab=#net18}
N 8860 -3350 8880 -3350 {
lab=#net18}
N 8860 -3370 8880 -3370 {
lab=#net17}
N 8860 -3390 8880 -3390 {
lab=rowon_n[8]}
N 8860 -3410 8880 -3410 {
lab=row_n[8]}
N 8680 -3270 8680 -3260 {
lab=VSS}
N 8680 -3500 8680 -3490 {
lab=VDD}
N 700 -3530 710 -3540 {
lab=col_n[0]}
N 710 -3740 710 -3540 {
lab=col_n[0]}
N 700 -3750 710 -3740 {
lab=col_n[0]}
N 700 -3530 700 -3510 {
lab=col_n[0]}
N 700 -3770 700 -3750 {
lab=col_n[0]}
N 580 -3670 590 -3680 {
lab=row_n[9]}
N 590 -3680 790 -3680 {
lab=row_n[9]}
N 790 -3680 800 -3670 {
lab=row_n[9]}
N 580 -3650 590 -3660 {
lab=rowon_n[9]}
N 590 -3660 790 -3660 {
lab=rowon_n[9]}
N 790 -3660 800 -3650 {
lab=rowon_n[9]}
N 580 -3630 590 -3640 {
lab=#net19}
N 590 -3640 790 -3640 {
lab=#net19}
N 790 -3640 800 -3630 {
lab=#net19}
N 580 -3610 590 -3620 {
lab=#net20}
N 590 -3620 790 -3620 {
lab=#net20}
N 790 -3620 800 -3610 {
lab=#net20}
N 640 -3770 640 -3750 {
lab=vcm}
N 680 -3770 680 -3750 {
lab=ctop}
N 560 -3670 580 -3670 {
lab=row_n[9]}
N 560 -3650 580 -3650 {
lab=rowon_n[9]}
N 560 -3630 580 -3630 {
lab=#net19}
N 560 -3610 580 -3610 {
lab=#net20}
N 800 -3610 820 -3610 {
lab=#net20}
N 800 -3630 820 -3630 {
lab=#net19}
N 800 -3650 820 -3650 {
lab=rowon_n[9]}
N 800 -3670 820 -3670 {
lab=row_n[9]}
N 620 -3530 620 -3520 {
lab=VSS}
N 620 -3760 620 -3750 {
lab=VDD}
N 960 -3530 970 -3540 {
lab=col_n[1]}
N 970 -3740 970 -3540 {
lab=col_n[1]}
N 960 -3750 970 -3740 {
lab=col_n[1]}
N 960 -3530 960 -3510 {
lab=col_n[1]}
N 960 -3770 960 -3750 {
lab=col_n[1]}
N 840 -3670 850 -3680 {
lab=row_n[9]}
N 850 -3680 1050 -3680 {
lab=row_n[9]}
N 1050 -3680 1060 -3670 {
lab=row_n[9]}
N 840 -3650 850 -3660 {
lab=rowon_n[9]}
N 850 -3660 1050 -3660 {
lab=rowon_n[9]}
N 1050 -3660 1060 -3650 {
lab=rowon_n[9]}
N 840 -3630 850 -3640 {
lab=#net19}
N 850 -3640 1050 -3640 {
lab=#net19}
N 1050 -3640 1060 -3630 {
lab=#net19}
N 840 -3610 850 -3620 {
lab=#net20}
N 850 -3620 1050 -3620 {
lab=#net20}
N 1050 -3620 1060 -3610 {
lab=#net20}
N 900 -3770 900 -3750 {
lab=vcm}
N 940 -3770 940 -3750 {
lab=ctop}
N 820 -3670 840 -3670 {
lab=row_n[9]}
N 820 -3650 840 -3650 {
lab=rowon_n[9]}
N 820 -3630 840 -3630 {
lab=#net19}
N 820 -3610 840 -3610 {
lab=#net20}
N 1060 -3610 1080 -3610 {
lab=#net20}
N 1060 -3630 1080 -3630 {
lab=#net19}
N 1060 -3650 1080 -3650 {
lab=rowon_n[9]}
N 1060 -3670 1080 -3670 {
lab=row_n[9]}
N 880 -3530 880 -3520 {
lab=VSS}
N 880 -3760 880 -3750 {
lab=VDD}
N 1220 -3530 1230 -3540 {
lab=col_n[2]}
N 1230 -3740 1230 -3540 {
lab=col_n[2]}
N 1220 -3750 1230 -3740 {
lab=col_n[2]}
N 1220 -3530 1220 -3510 {
lab=col_n[2]}
N 1220 -3770 1220 -3750 {
lab=col_n[2]}
N 1100 -3670 1110 -3680 {
lab=row_n[9]}
N 1110 -3680 1310 -3680 {
lab=row_n[9]}
N 1310 -3680 1320 -3670 {
lab=row_n[9]}
N 1100 -3650 1110 -3660 {
lab=rowon_n[9]}
N 1110 -3660 1310 -3660 {
lab=rowon_n[9]}
N 1310 -3660 1320 -3650 {
lab=rowon_n[9]}
N 1100 -3630 1110 -3640 {
lab=#net19}
N 1110 -3640 1310 -3640 {
lab=#net19}
N 1310 -3640 1320 -3630 {
lab=#net19}
N 1100 -3610 1110 -3620 {
lab=#net20}
N 1110 -3620 1310 -3620 {
lab=#net20}
N 1310 -3620 1320 -3610 {
lab=#net20}
N 1160 -3770 1160 -3750 {
lab=vcm}
N 1200 -3770 1200 -3750 {
lab=ctop}
N 1080 -3670 1100 -3670 {
lab=row_n[9]}
N 1080 -3650 1100 -3650 {
lab=rowon_n[9]}
N 1080 -3630 1100 -3630 {
lab=#net19}
N 1080 -3610 1100 -3610 {
lab=#net20}
N 1320 -3610 1340 -3610 {
lab=#net20}
N 1320 -3630 1340 -3630 {
lab=#net19}
N 1320 -3650 1340 -3650 {
lab=rowon_n[9]}
N 1320 -3670 1340 -3670 {
lab=row_n[9]}
N 1140 -3530 1140 -3520 {
lab=VSS}
N 1140 -3760 1140 -3750 {
lab=VDD}
N 1480 -3530 1490 -3540 {
lab=col_n[3]}
N 1490 -3740 1490 -3540 {
lab=col_n[3]}
N 1480 -3750 1490 -3740 {
lab=col_n[3]}
N 1480 -3530 1480 -3510 {
lab=col_n[3]}
N 1480 -3770 1480 -3750 {
lab=col_n[3]}
N 1360 -3670 1370 -3680 {
lab=row_n[9]}
N 1370 -3680 1570 -3680 {
lab=row_n[9]}
N 1570 -3680 1580 -3670 {
lab=row_n[9]}
N 1360 -3650 1370 -3660 {
lab=rowon_n[9]}
N 1370 -3660 1570 -3660 {
lab=rowon_n[9]}
N 1570 -3660 1580 -3650 {
lab=rowon_n[9]}
N 1360 -3630 1370 -3640 {
lab=#net19}
N 1370 -3640 1570 -3640 {
lab=#net19}
N 1570 -3640 1580 -3630 {
lab=#net19}
N 1360 -3610 1370 -3620 {
lab=#net20}
N 1370 -3620 1570 -3620 {
lab=#net20}
N 1570 -3620 1580 -3610 {
lab=#net20}
N 1420 -3770 1420 -3750 {
lab=vcm}
N 1460 -3770 1460 -3750 {
lab=ctop}
N 1340 -3670 1360 -3670 {
lab=row_n[9]}
N 1340 -3650 1360 -3650 {
lab=rowon_n[9]}
N 1340 -3630 1360 -3630 {
lab=#net19}
N 1340 -3610 1360 -3610 {
lab=#net20}
N 1580 -3610 1600 -3610 {
lab=#net20}
N 1580 -3630 1600 -3630 {
lab=#net19}
N 1580 -3650 1600 -3650 {
lab=rowon_n[9]}
N 1580 -3670 1600 -3670 {
lab=row_n[9]}
N 1400 -3530 1400 -3520 {
lab=VSS}
N 1400 -3760 1400 -3750 {
lab=VDD}
N 1740 -3530 1750 -3540 {
lab=col_n[4]}
N 1750 -3740 1750 -3540 {
lab=col_n[4]}
N 1740 -3750 1750 -3740 {
lab=col_n[4]}
N 1740 -3530 1740 -3510 {
lab=col_n[4]}
N 1740 -3770 1740 -3750 {
lab=col_n[4]}
N 1620 -3670 1630 -3680 {
lab=row_n[9]}
N 1630 -3680 1830 -3680 {
lab=row_n[9]}
N 1830 -3680 1840 -3670 {
lab=row_n[9]}
N 1620 -3650 1630 -3660 {
lab=rowon_n[9]}
N 1630 -3660 1830 -3660 {
lab=rowon_n[9]}
N 1830 -3660 1840 -3650 {
lab=rowon_n[9]}
N 1620 -3630 1630 -3640 {
lab=#net19}
N 1630 -3640 1830 -3640 {
lab=#net19}
N 1830 -3640 1840 -3630 {
lab=#net19}
N 1620 -3610 1630 -3620 {
lab=#net20}
N 1630 -3620 1830 -3620 {
lab=#net20}
N 1830 -3620 1840 -3610 {
lab=#net20}
N 1680 -3770 1680 -3750 {
lab=vcm}
N 1720 -3770 1720 -3750 {
lab=ctop}
N 1600 -3670 1620 -3670 {
lab=row_n[9]}
N 1600 -3650 1620 -3650 {
lab=rowon_n[9]}
N 1600 -3630 1620 -3630 {
lab=#net19}
N 1600 -3610 1620 -3610 {
lab=#net20}
N 1840 -3610 1860 -3610 {
lab=#net20}
N 1840 -3630 1860 -3630 {
lab=#net19}
N 1840 -3650 1860 -3650 {
lab=rowon_n[9]}
N 1840 -3670 1860 -3670 {
lab=row_n[9]}
N 1660 -3530 1660 -3520 {
lab=VSS}
N 1660 -3760 1660 -3750 {
lab=VDD}
N 2000 -3530 2010 -3540 {
lab=col_n[5]}
N 2010 -3740 2010 -3540 {
lab=col_n[5]}
N 2000 -3750 2010 -3740 {
lab=col_n[5]}
N 2000 -3530 2000 -3510 {
lab=col_n[5]}
N 2000 -3770 2000 -3750 {
lab=col_n[5]}
N 1880 -3670 1890 -3680 {
lab=row_n[9]}
N 1890 -3680 2090 -3680 {
lab=row_n[9]}
N 2090 -3680 2100 -3670 {
lab=row_n[9]}
N 1880 -3650 1890 -3660 {
lab=rowon_n[9]}
N 1890 -3660 2090 -3660 {
lab=rowon_n[9]}
N 2090 -3660 2100 -3650 {
lab=rowon_n[9]}
N 1880 -3630 1890 -3640 {
lab=#net19}
N 1890 -3640 2090 -3640 {
lab=#net19}
N 2090 -3640 2100 -3630 {
lab=#net19}
N 1880 -3610 1890 -3620 {
lab=#net20}
N 1890 -3620 2090 -3620 {
lab=#net20}
N 2090 -3620 2100 -3610 {
lab=#net20}
N 1940 -3770 1940 -3750 {
lab=vcm}
N 1980 -3770 1980 -3750 {
lab=ctop}
N 1860 -3670 1880 -3670 {
lab=row_n[9]}
N 1860 -3650 1880 -3650 {
lab=rowon_n[9]}
N 1860 -3630 1880 -3630 {
lab=#net19}
N 1860 -3610 1880 -3610 {
lab=#net20}
N 2100 -3610 2120 -3610 {
lab=#net20}
N 2100 -3630 2120 -3630 {
lab=#net19}
N 2100 -3650 2120 -3650 {
lab=rowon_n[9]}
N 2100 -3670 2120 -3670 {
lab=row_n[9]}
N 1920 -3530 1920 -3520 {
lab=VSS}
N 1920 -3760 1920 -3750 {
lab=VDD}
N 2260 -3530 2270 -3540 {
lab=col_n[6]}
N 2270 -3740 2270 -3540 {
lab=col_n[6]}
N 2260 -3750 2270 -3740 {
lab=col_n[6]}
N 2260 -3530 2260 -3510 {
lab=col_n[6]}
N 2260 -3770 2260 -3750 {
lab=col_n[6]}
N 2140 -3670 2150 -3680 {
lab=row_n[9]}
N 2150 -3680 2350 -3680 {
lab=row_n[9]}
N 2350 -3680 2360 -3670 {
lab=row_n[9]}
N 2140 -3650 2150 -3660 {
lab=rowon_n[9]}
N 2150 -3660 2350 -3660 {
lab=rowon_n[9]}
N 2350 -3660 2360 -3650 {
lab=rowon_n[9]}
N 2140 -3630 2150 -3640 {
lab=#net19}
N 2150 -3640 2350 -3640 {
lab=#net19}
N 2350 -3640 2360 -3630 {
lab=#net19}
N 2140 -3610 2150 -3620 {
lab=#net20}
N 2150 -3620 2350 -3620 {
lab=#net20}
N 2350 -3620 2360 -3610 {
lab=#net20}
N 2200 -3770 2200 -3750 {
lab=vcm}
N 2240 -3770 2240 -3750 {
lab=ctop}
N 2120 -3670 2140 -3670 {
lab=row_n[9]}
N 2120 -3650 2140 -3650 {
lab=rowon_n[9]}
N 2120 -3630 2140 -3630 {
lab=#net19}
N 2120 -3610 2140 -3610 {
lab=#net20}
N 2360 -3610 2380 -3610 {
lab=#net20}
N 2360 -3630 2380 -3630 {
lab=#net19}
N 2360 -3650 2380 -3650 {
lab=rowon_n[9]}
N 2360 -3670 2380 -3670 {
lab=row_n[9]}
N 2180 -3530 2180 -3520 {
lab=VSS}
N 2180 -3760 2180 -3750 {
lab=VDD}
N 2520 -3530 2530 -3540 {
lab=col_n[7]}
N 2530 -3740 2530 -3540 {
lab=col_n[7]}
N 2520 -3750 2530 -3740 {
lab=col_n[7]}
N 2520 -3530 2520 -3510 {
lab=col_n[7]}
N 2520 -3770 2520 -3750 {
lab=col_n[7]}
N 2400 -3670 2410 -3680 {
lab=row_n[9]}
N 2410 -3680 2610 -3680 {
lab=row_n[9]}
N 2610 -3680 2620 -3670 {
lab=row_n[9]}
N 2400 -3650 2410 -3660 {
lab=rowon_n[9]}
N 2410 -3660 2610 -3660 {
lab=rowon_n[9]}
N 2610 -3660 2620 -3650 {
lab=rowon_n[9]}
N 2400 -3630 2410 -3640 {
lab=#net19}
N 2410 -3640 2610 -3640 {
lab=#net19}
N 2610 -3640 2620 -3630 {
lab=#net19}
N 2400 -3610 2410 -3620 {
lab=#net20}
N 2410 -3620 2610 -3620 {
lab=#net20}
N 2610 -3620 2620 -3610 {
lab=#net20}
N 2460 -3770 2460 -3750 {
lab=vcm}
N 2500 -3770 2500 -3750 {
lab=ctop}
N 2380 -3670 2400 -3670 {
lab=row_n[9]}
N 2380 -3650 2400 -3650 {
lab=rowon_n[9]}
N 2380 -3630 2400 -3630 {
lab=#net19}
N 2380 -3610 2400 -3610 {
lab=#net20}
N 2620 -3610 2640 -3610 {
lab=#net20}
N 2620 -3630 2640 -3630 {
lab=#net19}
N 2620 -3650 2640 -3650 {
lab=rowon_n[9]}
N 2620 -3670 2640 -3670 {
lab=row_n[9]}
N 2440 -3530 2440 -3520 {
lab=VSS}
N 2440 -3760 2440 -3750 {
lab=VDD}
N 2780 -3530 2790 -3540 {
lab=col_n[8]}
N 2790 -3740 2790 -3540 {
lab=col_n[8]}
N 2780 -3750 2790 -3740 {
lab=col_n[8]}
N 2780 -3530 2780 -3510 {
lab=col_n[8]}
N 2780 -3770 2780 -3750 {
lab=col_n[8]}
N 2660 -3670 2670 -3680 {
lab=row_n[9]}
N 2670 -3680 2870 -3680 {
lab=row_n[9]}
N 2870 -3680 2880 -3670 {
lab=row_n[9]}
N 2660 -3650 2670 -3660 {
lab=rowon_n[9]}
N 2670 -3660 2870 -3660 {
lab=rowon_n[9]}
N 2870 -3660 2880 -3650 {
lab=rowon_n[9]}
N 2660 -3630 2670 -3640 {
lab=#net19}
N 2670 -3640 2870 -3640 {
lab=#net19}
N 2870 -3640 2880 -3630 {
lab=#net19}
N 2660 -3610 2670 -3620 {
lab=#net20}
N 2670 -3620 2870 -3620 {
lab=#net20}
N 2870 -3620 2880 -3610 {
lab=#net20}
N 2720 -3770 2720 -3750 {
lab=vcm}
N 2760 -3770 2760 -3750 {
lab=ctop}
N 2640 -3670 2660 -3670 {
lab=row_n[9]}
N 2640 -3650 2660 -3650 {
lab=rowon_n[9]}
N 2640 -3630 2660 -3630 {
lab=#net19}
N 2640 -3610 2660 -3610 {
lab=#net20}
N 2880 -3610 2900 -3610 {
lab=#net20}
N 2880 -3630 2900 -3630 {
lab=#net19}
N 2880 -3650 2900 -3650 {
lab=rowon_n[9]}
N 2880 -3670 2900 -3670 {
lab=row_n[9]}
N 2700 -3530 2700 -3520 {
lab=VSS}
N 2700 -3760 2700 -3750 {
lab=VDD}
N 3040 -3530 3050 -3540 {
lab=col_n[9]}
N 3050 -3740 3050 -3540 {
lab=col_n[9]}
N 3040 -3750 3050 -3740 {
lab=col_n[9]}
N 3040 -3530 3040 -3510 {
lab=col_n[9]}
N 3040 -3770 3040 -3750 {
lab=col_n[9]}
N 2920 -3670 2930 -3680 {
lab=row_n[9]}
N 2930 -3680 3130 -3680 {
lab=row_n[9]}
N 3130 -3680 3140 -3670 {
lab=row_n[9]}
N 2920 -3650 2930 -3660 {
lab=rowon_n[9]}
N 2930 -3660 3130 -3660 {
lab=rowon_n[9]}
N 3130 -3660 3140 -3650 {
lab=rowon_n[9]}
N 2920 -3630 2930 -3640 {
lab=#net19}
N 2930 -3640 3130 -3640 {
lab=#net19}
N 3130 -3640 3140 -3630 {
lab=#net19}
N 2920 -3610 2930 -3620 {
lab=#net20}
N 2930 -3620 3130 -3620 {
lab=#net20}
N 3130 -3620 3140 -3610 {
lab=#net20}
N 2980 -3770 2980 -3750 {
lab=vcm}
N 3020 -3770 3020 -3750 {
lab=ctop}
N 2900 -3670 2920 -3670 {
lab=row_n[9]}
N 2900 -3650 2920 -3650 {
lab=rowon_n[9]}
N 2900 -3630 2920 -3630 {
lab=#net19}
N 2900 -3610 2920 -3610 {
lab=#net20}
N 3140 -3610 3160 -3610 {
lab=#net20}
N 3140 -3630 3160 -3630 {
lab=#net19}
N 3140 -3650 3160 -3650 {
lab=rowon_n[9]}
N 3140 -3670 3160 -3670 {
lab=row_n[9]}
N 2960 -3530 2960 -3520 {
lab=VSS}
N 2960 -3760 2960 -3750 {
lab=VDD}
N 3300 -3530 3310 -3540 {
lab=col_n[10]}
N 3310 -3740 3310 -3540 {
lab=col_n[10]}
N 3300 -3750 3310 -3740 {
lab=col_n[10]}
N 3300 -3530 3300 -3510 {
lab=col_n[10]}
N 3300 -3770 3300 -3750 {
lab=col_n[10]}
N 3180 -3670 3190 -3680 {
lab=row_n[9]}
N 3190 -3680 3390 -3680 {
lab=row_n[9]}
N 3390 -3680 3400 -3670 {
lab=row_n[9]}
N 3180 -3650 3190 -3660 {
lab=rowon_n[9]}
N 3190 -3660 3390 -3660 {
lab=rowon_n[9]}
N 3390 -3660 3400 -3650 {
lab=rowon_n[9]}
N 3180 -3630 3190 -3640 {
lab=#net19}
N 3190 -3640 3390 -3640 {
lab=#net19}
N 3390 -3640 3400 -3630 {
lab=#net19}
N 3180 -3610 3190 -3620 {
lab=#net20}
N 3190 -3620 3390 -3620 {
lab=#net20}
N 3390 -3620 3400 -3610 {
lab=#net20}
N 3240 -3770 3240 -3750 {
lab=vcm}
N 3280 -3770 3280 -3750 {
lab=ctop}
N 3160 -3670 3180 -3670 {
lab=row_n[9]}
N 3160 -3650 3180 -3650 {
lab=rowon_n[9]}
N 3160 -3630 3180 -3630 {
lab=#net19}
N 3160 -3610 3180 -3610 {
lab=#net20}
N 3400 -3610 3420 -3610 {
lab=#net20}
N 3400 -3630 3420 -3630 {
lab=#net19}
N 3400 -3650 3420 -3650 {
lab=rowon_n[9]}
N 3400 -3670 3420 -3670 {
lab=row_n[9]}
N 3220 -3530 3220 -3520 {
lab=VSS}
N 3220 -3760 3220 -3750 {
lab=VDD}
N 3560 -3530 3570 -3540 {
lab=col_n[11]}
N 3570 -3740 3570 -3540 {
lab=col_n[11]}
N 3560 -3750 3570 -3740 {
lab=col_n[11]}
N 3560 -3530 3560 -3510 {
lab=col_n[11]}
N 3560 -3770 3560 -3750 {
lab=col_n[11]}
N 3440 -3670 3450 -3680 {
lab=row_n[9]}
N 3450 -3680 3650 -3680 {
lab=row_n[9]}
N 3650 -3680 3660 -3670 {
lab=row_n[9]}
N 3440 -3650 3450 -3660 {
lab=rowon_n[9]}
N 3450 -3660 3650 -3660 {
lab=rowon_n[9]}
N 3650 -3660 3660 -3650 {
lab=rowon_n[9]}
N 3440 -3630 3450 -3640 {
lab=#net19}
N 3450 -3640 3650 -3640 {
lab=#net19}
N 3650 -3640 3660 -3630 {
lab=#net19}
N 3440 -3610 3450 -3620 {
lab=#net20}
N 3450 -3620 3650 -3620 {
lab=#net20}
N 3650 -3620 3660 -3610 {
lab=#net20}
N 3500 -3770 3500 -3750 {
lab=vcm}
N 3540 -3770 3540 -3750 {
lab=ctop}
N 3420 -3670 3440 -3670 {
lab=row_n[9]}
N 3420 -3650 3440 -3650 {
lab=rowon_n[9]}
N 3420 -3630 3440 -3630 {
lab=#net19}
N 3420 -3610 3440 -3610 {
lab=#net20}
N 3660 -3610 3680 -3610 {
lab=#net20}
N 3660 -3630 3680 -3630 {
lab=#net19}
N 3660 -3650 3680 -3650 {
lab=rowon_n[9]}
N 3660 -3670 3680 -3670 {
lab=row_n[9]}
N 3480 -3530 3480 -3520 {
lab=VSS}
N 3480 -3760 3480 -3750 {
lab=VDD}
N 3820 -3530 3830 -3540 {
lab=col_n[12]}
N 3830 -3740 3830 -3540 {
lab=col_n[12]}
N 3820 -3750 3830 -3740 {
lab=col_n[12]}
N 3820 -3530 3820 -3510 {
lab=col_n[12]}
N 3820 -3770 3820 -3750 {
lab=col_n[12]}
N 3700 -3670 3710 -3680 {
lab=row_n[9]}
N 3710 -3680 3910 -3680 {
lab=row_n[9]}
N 3910 -3680 3920 -3670 {
lab=row_n[9]}
N 3700 -3650 3710 -3660 {
lab=rowon_n[9]}
N 3710 -3660 3910 -3660 {
lab=rowon_n[9]}
N 3910 -3660 3920 -3650 {
lab=rowon_n[9]}
N 3700 -3630 3710 -3640 {
lab=#net19}
N 3710 -3640 3910 -3640 {
lab=#net19}
N 3910 -3640 3920 -3630 {
lab=#net19}
N 3700 -3610 3710 -3620 {
lab=#net20}
N 3710 -3620 3910 -3620 {
lab=#net20}
N 3910 -3620 3920 -3610 {
lab=#net20}
N 3760 -3770 3760 -3750 {
lab=vcm}
N 3800 -3770 3800 -3750 {
lab=ctop}
N 3680 -3670 3700 -3670 {
lab=row_n[9]}
N 3680 -3650 3700 -3650 {
lab=rowon_n[9]}
N 3680 -3630 3700 -3630 {
lab=#net19}
N 3680 -3610 3700 -3610 {
lab=#net20}
N 3920 -3610 3940 -3610 {
lab=#net20}
N 3920 -3630 3940 -3630 {
lab=#net19}
N 3920 -3650 3940 -3650 {
lab=rowon_n[9]}
N 3920 -3670 3940 -3670 {
lab=row_n[9]}
N 3740 -3530 3740 -3520 {
lab=VSS}
N 3740 -3760 3740 -3750 {
lab=VDD}
N 4080 -3530 4090 -3540 {
lab=col_n[13]}
N 4090 -3740 4090 -3540 {
lab=col_n[13]}
N 4080 -3750 4090 -3740 {
lab=col_n[13]}
N 4080 -3530 4080 -3510 {
lab=col_n[13]}
N 4080 -3770 4080 -3750 {
lab=col_n[13]}
N 3960 -3670 3970 -3680 {
lab=row_n[9]}
N 3970 -3680 4170 -3680 {
lab=row_n[9]}
N 4170 -3680 4180 -3670 {
lab=row_n[9]}
N 3960 -3650 3970 -3660 {
lab=rowon_n[9]}
N 3970 -3660 4170 -3660 {
lab=rowon_n[9]}
N 4170 -3660 4180 -3650 {
lab=rowon_n[9]}
N 3960 -3630 3970 -3640 {
lab=#net19}
N 3970 -3640 4170 -3640 {
lab=#net19}
N 4170 -3640 4180 -3630 {
lab=#net19}
N 3960 -3610 3970 -3620 {
lab=#net20}
N 3970 -3620 4170 -3620 {
lab=#net20}
N 4170 -3620 4180 -3610 {
lab=#net20}
N 4020 -3770 4020 -3750 {
lab=vcm}
N 4060 -3770 4060 -3750 {
lab=ctop}
N 3940 -3670 3960 -3670 {
lab=row_n[9]}
N 3940 -3650 3960 -3650 {
lab=rowon_n[9]}
N 3940 -3630 3960 -3630 {
lab=#net19}
N 3940 -3610 3960 -3610 {
lab=#net20}
N 4180 -3610 4200 -3610 {
lab=#net20}
N 4180 -3630 4200 -3630 {
lab=#net19}
N 4180 -3650 4200 -3650 {
lab=rowon_n[9]}
N 4180 -3670 4200 -3670 {
lab=row_n[9]}
N 4000 -3530 4000 -3520 {
lab=VSS}
N 4000 -3760 4000 -3750 {
lab=VDD}
N 4340 -3530 4350 -3540 {
lab=col_n[14]}
N 4350 -3740 4350 -3540 {
lab=col_n[14]}
N 4340 -3750 4350 -3740 {
lab=col_n[14]}
N 4340 -3530 4340 -3510 {
lab=col_n[14]}
N 4340 -3770 4340 -3750 {
lab=col_n[14]}
N 4220 -3670 4230 -3680 {
lab=row_n[9]}
N 4230 -3680 4430 -3680 {
lab=row_n[9]}
N 4430 -3680 4440 -3670 {
lab=row_n[9]}
N 4220 -3650 4230 -3660 {
lab=rowon_n[9]}
N 4230 -3660 4430 -3660 {
lab=rowon_n[9]}
N 4430 -3660 4440 -3650 {
lab=rowon_n[9]}
N 4220 -3630 4230 -3640 {
lab=#net19}
N 4230 -3640 4430 -3640 {
lab=#net19}
N 4430 -3640 4440 -3630 {
lab=#net19}
N 4220 -3610 4230 -3620 {
lab=#net20}
N 4230 -3620 4430 -3620 {
lab=#net20}
N 4430 -3620 4440 -3610 {
lab=#net20}
N 4280 -3770 4280 -3750 {
lab=vcm}
N 4320 -3770 4320 -3750 {
lab=ctop}
N 4200 -3670 4220 -3670 {
lab=row_n[9]}
N 4200 -3650 4220 -3650 {
lab=rowon_n[9]}
N 4200 -3630 4220 -3630 {
lab=#net19}
N 4200 -3610 4220 -3610 {
lab=#net20}
N 4440 -3610 4460 -3610 {
lab=#net20}
N 4440 -3630 4460 -3630 {
lab=#net19}
N 4440 -3650 4460 -3650 {
lab=rowon_n[9]}
N 4440 -3670 4460 -3670 {
lab=row_n[9]}
N 4260 -3530 4260 -3520 {
lab=VSS}
N 4260 -3760 4260 -3750 {
lab=VDD}
N 4600 -3530 4610 -3540 {
lab=col_n[15]}
N 4610 -3740 4610 -3540 {
lab=col_n[15]}
N 4600 -3750 4610 -3740 {
lab=col_n[15]}
N 4600 -3530 4600 -3510 {
lab=col_n[15]}
N 4600 -3770 4600 -3750 {
lab=col_n[15]}
N 4480 -3670 4490 -3680 {
lab=row_n[9]}
N 4490 -3680 4690 -3680 {
lab=row_n[9]}
N 4690 -3680 4700 -3670 {
lab=row_n[9]}
N 4480 -3650 4490 -3660 {
lab=rowon_n[9]}
N 4490 -3660 4690 -3660 {
lab=rowon_n[9]}
N 4690 -3660 4700 -3650 {
lab=rowon_n[9]}
N 4480 -3630 4490 -3640 {
lab=#net19}
N 4490 -3640 4690 -3640 {
lab=#net19}
N 4690 -3640 4700 -3630 {
lab=#net19}
N 4480 -3610 4490 -3620 {
lab=#net20}
N 4490 -3620 4690 -3620 {
lab=#net20}
N 4690 -3620 4700 -3610 {
lab=#net20}
N 4540 -3770 4540 -3750 {
lab=vcm}
N 4580 -3770 4580 -3750 {
lab=ctop}
N 4460 -3670 4480 -3670 {
lab=row_n[9]}
N 4460 -3650 4480 -3650 {
lab=rowon_n[9]}
N 4460 -3630 4480 -3630 {
lab=#net19}
N 4460 -3610 4480 -3610 {
lab=#net20}
N 4700 -3610 4720 -3610 {
lab=#net20}
N 4700 -3630 4720 -3630 {
lab=#net19}
N 4700 -3650 4720 -3650 {
lab=rowon_n[9]}
N 4700 -3670 4720 -3670 {
lab=row_n[9]}
N 4520 -3530 4520 -3520 {
lab=VSS}
N 4520 -3760 4520 -3750 {
lab=VDD}
N 4860 -3530 4870 -3540 {
lab=col_n[16]}
N 4870 -3740 4870 -3540 {
lab=col_n[16]}
N 4860 -3750 4870 -3740 {
lab=col_n[16]}
N 4860 -3530 4860 -3510 {
lab=col_n[16]}
N 4860 -3770 4860 -3750 {
lab=col_n[16]}
N 4740 -3670 4750 -3680 {
lab=row_n[9]}
N 4750 -3680 4950 -3680 {
lab=row_n[9]}
N 4950 -3680 4960 -3670 {
lab=row_n[9]}
N 4740 -3650 4750 -3660 {
lab=rowon_n[9]}
N 4750 -3660 4950 -3660 {
lab=rowon_n[9]}
N 4950 -3660 4960 -3650 {
lab=rowon_n[9]}
N 4740 -3630 4750 -3640 {
lab=#net19}
N 4750 -3640 4950 -3640 {
lab=#net19}
N 4950 -3640 4960 -3630 {
lab=#net19}
N 4740 -3610 4750 -3620 {
lab=#net20}
N 4750 -3620 4950 -3620 {
lab=#net20}
N 4950 -3620 4960 -3610 {
lab=#net20}
N 4800 -3770 4800 -3750 {
lab=vcm}
N 4840 -3770 4840 -3750 {
lab=ctop}
N 4720 -3670 4740 -3670 {
lab=row_n[9]}
N 4720 -3650 4740 -3650 {
lab=rowon_n[9]}
N 4720 -3630 4740 -3630 {
lab=#net19}
N 4720 -3610 4740 -3610 {
lab=#net20}
N 4960 -3610 4980 -3610 {
lab=#net20}
N 4960 -3630 4980 -3630 {
lab=#net19}
N 4960 -3650 4980 -3650 {
lab=rowon_n[9]}
N 4960 -3670 4980 -3670 {
lab=row_n[9]}
N 4780 -3530 4780 -3520 {
lab=VSS}
N 4780 -3760 4780 -3750 {
lab=VDD}
N 5120 -3530 5130 -3540 {
lab=col_n[17]}
N 5130 -3740 5130 -3540 {
lab=col_n[17]}
N 5120 -3750 5130 -3740 {
lab=col_n[17]}
N 5120 -3530 5120 -3510 {
lab=col_n[17]}
N 5120 -3770 5120 -3750 {
lab=col_n[17]}
N 5000 -3670 5010 -3680 {
lab=row_n[9]}
N 5010 -3680 5210 -3680 {
lab=row_n[9]}
N 5210 -3680 5220 -3670 {
lab=row_n[9]}
N 5000 -3650 5010 -3660 {
lab=rowon_n[9]}
N 5010 -3660 5210 -3660 {
lab=rowon_n[9]}
N 5210 -3660 5220 -3650 {
lab=rowon_n[9]}
N 5000 -3630 5010 -3640 {
lab=#net19}
N 5010 -3640 5210 -3640 {
lab=#net19}
N 5210 -3640 5220 -3630 {
lab=#net19}
N 5000 -3610 5010 -3620 {
lab=#net20}
N 5010 -3620 5210 -3620 {
lab=#net20}
N 5210 -3620 5220 -3610 {
lab=#net20}
N 5060 -3770 5060 -3750 {
lab=vcm}
N 5100 -3770 5100 -3750 {
lab=ctop}
N 4980 -3670 5000 -3670 {
lab=row_n[9]}
N 4980 -3650 5000 -3650 {
lab=rowon_n[9]}
N 4980 -3630 5000 -3630 {
lab=#net19}
N 4980 -3610 5000 -3610 {
lab=#net20}
N 5220 -3610 5240 -3610 {
lab=#net20}
N 5220 -3630 5240 -3630 {
lab=#net19}
N 5220 -3650 5240 -3650 {
lab=rowon_n[9]}
N 5220 -3670 5240 -3670 {
lab=row_n[9]}
N 5040 -3530 5040 -3520 {
lab=VSS}
N 5040 -3760 5040 -3750 {
lab=VDD}
N 5380 -3530 5390 -3540 {
lab=col_n[18]}
N 5390 -3740 5390 -3540 {
lab=col_n[18]}
N 5380 -3750 5390 -3740 {
lab=col_n[18]}
N 5380 -3530 5380 -3510 {
lab=col_n[18]}
N 5380 -3770 5380 -3750 {
lab=col_n[18]}
N 5260 -3670 5270 -3680 {
lab=row_n[9]}
N 5270 -3680 5470 -3680 {
lab=row_n[9]}
N 5470 -3680 5480 -3670 {
lab=row_n[9]}
N 5260 -3650 5270 -3660 {
lab=rowon_n[9]}
N 5270 -3660 5470 -3660 {
lab=rowon_n[9]}
N 5470 -3660 5480 -3650 {
lab=rowon_n[9]}
N 5260 -3630 5270 -3640 {
lab=#net19}
N 5270 -3640 5470 -3640 {
lab=#net19}
N 5470 -3640 5480 -3630 {
lab=#net19}
N 5260 -3610 5270 -3620 {
lab=#net20}
N 5270 -3620 5470 -3620 {
lab=#net20}
N 5470 -3620 5480 -3610 {
lab=#net20}
N 5320 -3770 5320 -3750 {
lab=vcm}
N 5360 -3770 5360 -3750 {
lab=ctop}
N 5240 -3670 5260 -3670 {
lab=row_n[9]}
N 5240 -3650 5260 -3650 {
lab=rowon_n[9]}
N 5240 -3630 5260 -3630 {
lab=#net19}
N 5240 -3610 5260 -3610 {
lab=#net20}
N 5480 -3610 5500 -3610 {
lab=#net20}
N 5480 -3630 5500 -3630 {
lab=#net19}
N 5480 -3650 5500 -3650 {
lab=rowon_n[9]}
N 5480 -3670 5500 -3670 {
lab=row_n[9]}
N 5300 -3530 5300 -3520 {
lab=VSS}
N 5300 -3760 5300 -3750 {
lab=VDD}
N 5640 -3530 5650 -3540 {
lab=col_n[19]}
N 5650 -3740 5650 -3540 {
lab=col_n[19]}
N 5640 -3750 5650 -3740 {
lab=col_n[19]}
N 5640 -3530 5640 -3510 {
lab=col_n[19]}
N 5640 -3770 5640 -3750 {
lab=col_n[19]}
N 5520 -3670 5530 -3680 {
lab=row_n[9]}
N 5530 -3680 5730 -3680 {
lab=row_n[9]}
N 5730 -3680 5740 -3670 {
lab=row_n[9]}
N 5520 -3650 5530 -3660 {
lab=rowon_n[9]}
N 5530 -3660 5730 -3660 {
lab=rowon_n[9]}
N 5730 -3660 5740 -3650 {
lab=rowon_n[9]}
N 5520 -3630 5530 -3640 {
lab=#net19}
N 5530 -3640 5730 -3640 {
lab=#net19}
N 5730 -3640 5740 -3630 {
lab=#net19}
N 5520 -3610 5530 -3620 {
lab=#net20}
N 5530 -3620 5730 -3620 {
lab=#net20}
N 5730 -3620 5740 -3610 {
lab=#net20}
N 5580 -3770 5580 -3750 {
lab=vcm}
N 5620 -3770 5620 -3750 {
lab=ctop}
N 5500 -3670 5520 -3670 {
lab=row_n[9]}
N 5500 -3650 5520 -3650 {
lab=rowon_n[9]}
N 5500 -3630 5520 -3630 {
lab=#net19}
N 5500 -3610 5520 -3610 {
lab=#net20}
N 5740 -3610 5760 -3610 {
lab=#net20}
N 5740 -3630 5760 -3630 {
lab=#net19}
N 5740 -3650 5760 -3650 {
lab=rowon_n[9]}
N 5740 -3670 5760 -3670 {
lab=row_n[9]}
N 5560 -3530 5560 -3520 {
lab=VSS}
N 5560 -3760 5560 -3750 {
lab=VDD}
N 5900 -3530 5910 -3540 {
lab=col_n[20]}
N 5910 -3740 5910 -3540 {
lab=col_n[20]}
N 5900 -3750 5910 -3740 {
lab=col_n[20]}
N 5900 -3530 5900 -3510 {
lab=col_n[20]}
N 5900 -3770 5900 -3750 {
lab=col_n[20]}
N 5780 -3670 5790 -3680 {
lab=row_n[9]}
N 5790 -3680 5990 -3680 {
lab=row_n[9]}
N 5990 -3680 6000 -3670 {
lab=row_n[9]}
N 5780 -3650 5790 -3660 {
lab=rowon_n[9]}
N 5790 -3660 5990 -3660 {
lab=rowon_n[9]}
N 5990 -3660 6000 -3650 {
lab=rowon_n[9]}
N 5780 -3630 5790 -3640 {
lab=#net19}
N 5790 -3640 5990 -3640 {
lab=#net19}
N 5990 -3640 6000 -3630 {
lab=#net19}
N 5780 -3610 5790 -3620 {
lab=#net20}
N 5790 -3620 5990 -3620 {
lab=#net20}
N 5990 -3620 6000 -3610 {
lab=#net20}
N 5840 -3770 5840 -3750 {
lab=vcm}
N 5880 -3770 5880 -3750 {
lab=ctop}
N 5760 -3670 5780 -3670 {
lab=row_n[9]}
N 5760 -3650 5780 -3650 {
lab=rowon_n[9]}
N 5760 -3630 5780 -3630 {
lab=#net19}
N 5760 -3610 5780 -3610 {
lab=#net20}
N 6000 -3610 6020 -3610 {
lab=#net20}
N 6000 -3630 6020 -3630 {
lab=#net19}
N 6000 -3650 6020 -3650 {
lab=rowon_n[9]}
N 6000 -3670 6020 -3670 {
lab=row_n[9]}
N 5820 -3530 5820 -3520 {
lab=VSS}
N 5820 -3760 5820 -3750 {
lab=VDD}
N 6160 -3530 6170 -3540 {
lab=col_n[21]}
N 6170 -3740 6170 -3540 {
lab=col_n[21]}
N 6160 -3750 6170 -3740 {
lab=col_n[21]}
N 6160 -3530 6160 -3510 {
lab=col_n[21]}
N 6160 -3770 6160 -3750 {
lab=col_n[21]}
N 6040 -3670 6050 -3680 {
lab=row_n[9]}
N 6050 -3680 6250 -3680 {
lab=row_n[9]}
N 6250 -3680 6260 -3670 {
lab=row_n[9]}
N 6040 -3650 6050 -3660 {
lab=rowon_n[9]}
N 6050 -3660 6250 -3660 {
lab=rowon_n[9]}
N 6250 -3660 6260 -3650 {
lab=rowon_n[9]}
N 6040 -3630 6050 -3640 {
lab=#net19}
N 6050 -3640 6250 -3640 {
lab=#net19}
N 6250 -3640 6260 -3630 {
lab=#net19}
N 6040 -3610 6050 -3620 {
lab=#net20}
N 6050 -3620 6250 -3620 {
lab=#net20}
N 6250 -3620 6260 -3610 {
lab=#net20}
N 6100 -3770 6100 -3750 {
lab=vcm}
N 6140 -3770 6140 -3750 {
lab=ctop}
N 6020 -3670 6040 -3670 {
lab=row_n[9]}
N 6020 -3650 6040 -3650 {
lab=rowon_n[9]}
N 6020 -3630 6040 -3630 {
lab=#net19}
N 6020 -3610 6040 -3610 {
lab=#net20}
N 6260 -3610 6280 -3610 {
lab=#net20}
N 6260 -3630 6280 -3630 {
lab=#net19}
N 6260 -3650 6280 -3650 {
lab=rowon_n[9]}
N 6260 -3670 6280 -3670 {
lab=row_n[9]}
N 6080 -3530 6080 -3520 {
lab=VSS}
N 6080 -3760 6080 -3750 {
lab=VDD}
N 6420 -3530 6430 -3540 {
lab=col_n[22]}
N 6430 -3740 6430 -3540 {
lab=col_n[22]}
N 6420 -3750 6430 -3740 {
lab=col_n[22]}
N 6420 -3530 6420 -3510 {
lab=col_n[22]}
N 6420 -3770 6420 -3750 {
lab=col_n[22]}
N 6300 -3670 6310 -3680 {
lab=row_n[9]}
N 6310 -3680 6510 -3680 {
lab=row_n[9]}
N 6510 -3680 6520 -3670 {
lab=row_n[9]}
N 6300 -3650 6310 -3660 {
lab=rowon_n[9]}
N 6310 -3660 6510 -3660 {
lab=rowon_n[9]}
N 6510 -3660 6520 -3650 {
lab=rowon_n[9]}
N 6300 -3630 6310 -3640 {
lab=#net19}
N 6310 -3640 6510 -3640 {
lab=#net19}
N 6510 -3640 6520 -3630 {
lab=#net19}
N 6300 -3610 6310 -3620 {
lab=#net20}
N 6310 -3620 6510 -3620 {
lab=#net20}
N 6510 -3620 6520 -3610 {
lab=#net20}
N 6360 -3770 6360 -3750 {
lab=vcm}
N 6400 -3770 6400 -3750 {
lab=ctop}
N 6280 -3670 6300 -3670 {
lab=row_n[9]}
N 6280 -3650 6300 -3650 {
lab=rowon_n[9]}
N 6280 -3630 6300 -3630 {
lab=#net19}
N 6280 -3610 6300 -3610 {
lab=#net20}
N 6520 -3610 6540 -3610 {
lab=#net20}
N 6520 -3630 6540 -3630 {
lab=#net19}
N 6520 -3650 6540 -3650 {
lab=rowon_n[9]}
N 6520 -3670 6540 -3670 {
lab=row_n[9]}
N 6340 -3530 6340 -3520 {
lab=VSS}
N 6340 -3760 6340 -3750 {
lab=VDD}
N 6680 -3530 6690 -3540 {
lab=col_n[23]}
N 6690 -3740 6690 -3540 {
lab=col_n[23]}
N 6680 -3750 6690 -3740 {
lab=col_n[23]}
N 6680 -3530 6680 -3510 {
lab=col_n[23]}
N 6680 -3770 6680 -3750 {
lab=col_n[23]}
N 6560 -3670 6570 -3680 {
lab=row_n[9]}
N 6570 -3680 6770 -3680 {
lab=row_n[9]}
N 6770 -3680 6780 -3670 {
lab=row_n[9]}
N 6560 -3650 6570 -3660 {
lab=rowon_n[9]}
N 6570 -3660 6770 -3660 {
lab=rowon_n[9]}
N 6770 -3660 6780 -3650 {
lab=rowon_n[9]}
N 6560 -3630 6570 -3640 {
lab=#net19}
N 6570 -3640 6770 -3640 {
lab=#net19}
N 6770 -3640 6780 -3630 {
lab=#net19}
N 6560 -3610 6570 -3620 {
lab=#net20}
N 6570 -3620 6770 -3620 {
lab=#net20}
N 6770 -3620 6780 -3610 {
lab=#net20}
N 6620 -3770 6620 -3750 {
lab=vcm}
N 6660 -3770 6660 -3750 {
lab=ctop}
N 6540 -3670 6560 -3670 {
lab=row_n[9]}
N 6540 -3650 6560 -3650 {
lab=rowon_n[9]}
N 6540 -3630 6560 -3630 {
lab=#net19}
N 6540 -3610 6560 -3610 {
lab=#net20}
N 6780 -3610 6800 -3610 {
lab=#net20}
N 6780 -3630 6800 -3630 {
lab=#net19}
N 6780 -3650 6800 -3650 {
lab=rowon_n[9]}
N 6780 -3670 6800 -3670 {
lab=row_n[9]}
N 6600 -3530 6600 -3520 {
lab=VSS}
N 6600 -3760 6600 -3750 {
lab=VDD}
N 6940 -3530 6950 -3540 {
lab=col_n[24]}
N 6950 -3740 6950 -3540 {
lab=col_n[24]}
N 6940 -3750 6950 -3740 {
lab=col_n[24]}
N 6940 -3530 6940 -3510 {
lab=col_n[24]}
N 6940 -3770 6940 -3750 {
lab=col_n[24]}
N 6820 -3670 6830 -3680 {
lab=row_n[9]}
N 6830 -3680 7030 -3680 {
lab=row_n[9]}
N 7030 -3680 7040 -3670 {
lab=row_n[9]}
N 6820 -3650 6830 -3660 {
lab=rowon_n[9]}
N 6830 -3660 7030 -3660 {
lab=rowon_n[9]}
N 7030 -3660 7040 -3650 {
lab=rowon_n[9]}
N 6820 -3630 6830 -3640 {
lab=#net19}
N 6830 -3640 7030 -3640 {
lab=#net19}
N 7030 -3640 7040 -3630 {
lab=#net19}
N 6820 -3610 6830 -3620 {
lab=#net20}
N 6830 -3620 7030 -3620 {
lab=#net20}
N 7030 -3620 7040 -3610 {
lab=#net20}
N 6880 -3770 6880 -3750 {
lab=vcm}
N 6920 -3770 6920 -3750 {
lab=ctop}
N 6800 -3670 6820 -3670 {
lab=row_n[9]}
N 6800 -3650 6820 -3650 {
lab=rowon_n[9]}
N 6800 -3630 6820 -3630 {
lab=#net19}
N 6800 -3610 6820 -3610 {
lab=#net20}
N 7040 -3610 7060 -3610 {
lab=#net20}
N 7040 -3630 7060 -3630 {
lab=#net19}
N 7040 -3650 7060 -3650 {
lab=rowon_n[9]}
N 7040 -3670 7060 -3670 {
lab=row_n[9]}
N 6860 -3530 6860 -3520 {
lab=VSS}
N 6860 -3760 6860 -3750 {
lab=VDD}
N 7200 -3530 7210 -3540 {
lab=col_n[25]}
N 7210 -3740 7210 -3540 {
lab=col_n[25]}
N 7200 -3750 7210 -3740 {
lab=col_n[25]}
N 7200 -3530 7200 -3510 {
lab=col_n[25]}
N 7200 -3770 7200 -3750 {
lab=col_n[25]}
N 7080 -3670 7090 -3680 {
lab=row_n[9]}
N 7090 -3680 7290 -3680 {
lab=row_n[9]}
N 7290 -3680 7300 -3670 {
lab=row_n[9]}
N 7080 -3650 7090 -3660 {
lab=rowon_n[9]}
N 7090 -3660 7290 -3660 {
lab=rowon_n[9]}
N 7290 -3660 7300 -3650 {
lab=rowon_n[9]}
N 7080 -3630 7090 -3640 {
lab=#net19}
N 7090 -3640 7290 -3640 {
lab=#net19}
N 7290 -3640 7300 -3630 {
lab=#net19}
N 7080 -3610 7090 -3620 {
lab=#net20}
N 7090 -3620 7290 -3620 {
lab=#net20}
N 7290 -3620 7300 -3610 {
lab=#net20}
N 7140 -3770 7140 -3750 {
lab=vcm}
N 7180 -3770 7180 -3750 {
lab=ctop}
N 7060 -3670 7080 -3670 {
lab=row_n[9]}
N 7060 -3650 7080 -3650 {
lab=rowon_n[9]}
N 7060 -3630 7080 -3630 {
lab=#net19}
N 7060 -3610 7080 -3610 {
lab=#net20}
N 7300 -3610 7320 -3610 {
lab=#net20}
N 7300 -3630 7320 -3630 {
lab=#net19}
N 7300 -3650 7320 -3650 {
lab=rowon_n[9]}
N 7300 -3670 7320 -3670 {
lab=row_n[9]}
N 7120 -3530 7120 -3520 {
lab=VSS}
N 7120 -3760 7120 -3750 {
lab=VDD}
N 7460 -3530 7470 -3540 {
lab=col_n[26]}
N 7470 -3740 7470 -3540 {
lab=col_n[26]}
N 7460 -3750 7470 -3740 {
lab=col_n[26]}
N 7460 -3530 7460 -3510 {
lab=col_n[26]}
N 7460 -3770 7460 -3750 {
lab=col_n[26]}
N 7340 -3670 7350 -3680 {
lab=row_n[9]}
N 7350 -3680 7550 -3680 {
lab=row_n[9]}
N 7550 -3680 7560 -3670 {
lab=row_n[9]}
N 7340 -3650 7350 -3660 {
lab=rowon_n[9]}
N 7350 -3660 7550 -3660 {
lab=rowon_n[9]}
N 7550 -3660 7560 -3650 {
lab=rowon_n[9]}
N 7340 -3630 7350 -3640 {
lab=#net19}
N 7350 -3640 7550 -3640 {
lab=#net19}
N 7550 -3640 7560 -3630 {
lab=#net19}
N 7340 -3610 7350 -3620 {
lab=#net20}
N 7350 -3620 7550 -3620 {
lab=#net20}
N 7550 -3620 7560 -3610 {
lab=#net20}
N 7400 -3770 7400 -3750 {
lab=vcm}
N 7440 -3770 7440 -3750 {
lab=ctop}
N 7320 -3670 7340 -3670 {
lab=row_n[9]}
N 7320 -3650 7340 -3650 {
lab=rowon_n[9]}
N 7320 -3630 7340 -3630 {
lab=#net19}
N 7320 -3610 7340 -3610 {
lab=#net20}
N 7560 -3610 7580 -3610 {
lab=#net20}
N 7560 -3630 7580 -3630 {
lab=#net19}
N 7560 -3650 7580 -3650 {
lab=rowon_n[9]}
N 7560 -3670 7580 -3670 {
lab=row_n[9]}
N 7380 -3530 7380 -3520 {
lab=VSS}
N 7380 -3760 7380 -3750 {
lab=VDD}
N 7720 -3530 7730 -3540 {
lab=col_n[27]}
N 7730 -3740 7730 -3540 {
lab=col_n[27]}
N 7720 -3750 7730 -3740 {
lab=col_n[27]}
N 7720 -3530 7720 -3510 {
lab=col_n[27]}
N 7720 -3770 7720 -3750 {
lab=col_n[27]}
N 7600 -3670 7610 -3680 {
lab=row_n[9]}
N 7610 -3680 7810 -3680 {
lab=row_n[9]}
N 7810 -3680 7820 -3670 {
lab=row_n[9]}
N 7600 -3650 7610 -3660 {
lab=rowon_n[9]}
N 7610 -3660 7810 -3660 {
lab=rowon_n[9]}
N 7810 -3660 7820 -3650 {
lab=rowon_n[9]}
N 7600 -3630 7610 -3640 {
lab=#net19}
N 7610 -3640 7810 -3640 {
lab=#net19}
N 7810 -3640 7820 -3630 {
lab=#net19}
N 7600 -3610 7610 -3620 {
lab=#net20}
N 7610 -3620 7810 -3620 {
lab=#net20}
N 7810 -3620 7820 -3610 {
lab=#net20}
N 7660 -3770 7660 -3750 {
lab=vcm}
N 7700 -3770 7700 -3750 {
lab=ctop}
N 7580 -3670 7600 -3670 {
lab=row_n[9]}
N 7580 -3650 7600 -3650 {
lab=rowon_n[9]}
N 7580 -3630 7600 -3630 {
lab=#net19}
N 7580 -3610 7600 -3610 {
lab=#net20}
N 7820 -3610 7840 -3610 {
lab=#net20}
N 7820 -3630 7840 -3630 {
lab=#net19}
N 7820 -3650 7840 -3650 {
lab=rowon_n[9]}
N 7820 -3670 7840 -3670 {
lab=row_n[9]}
N 7640 -3530 7640 -3520 {
lab=VSS}
N 7640 -3760 7640 -3750 {
lab=VDD}
N 7980 -3530 7990 -3540 {
lab=col_n[28]}
N 7990 -3740 7990 -3540 {
lab=col_n[28]}
N 7980 -3750 7990 -3740 {
lab=col_n[28]}
N 7980 -3530 7980 -3510 {
lab=col_n[28]}
N 7980 -3770 7980 -3750 {
lab=col_n[28]}
N 7860 -3670 7870 -3680 {
lab=row_n[9]}
N 7870 -3680 8070 -3680 {
lab=row_n[9]}
N 8070 -3680 8080 -3670 {
lab=row_n[9]}
N 7860 -3650 7870 -3660 {
lab=rowon_n[9]}
N 7870 -3660 8070 -3660 {
lab=rowon_n[9]}
N 8070 -3660 8080 -3650 {
lab=rowon_n[9]}
N 7860 -3630 7870 -3640 {
lab=#net19}
N 7870 -3640 8070 -3640 {
lab=#net19}
N 8070 -3640 8080 -3630 {
lab=#net19}
N 7860 -3610 7870 -3620 {
lab=#net20}
N 7870 -3620 8070 -3620 {
lab=#net20}
N 8070 -3620 8080 -3610 {
lab=#net20}
N 7920 -3770 7920 -3750 {
lab=vcm}
N 7960 -3770 7960 -3750 {
lab=ctop}
N 7840 -3670 7860 -3670 {
lab=row_n[9]}
N 7840 -3650 7860 -3650 {
lab=rowon_n[9]}
N 7840 -3630 7860 -3630 {
lab=#net19}
N 7840 -3610 7860 -3610 {
lab=#net20}
N 8080 -3610 8100 -3610 {
lab=#net20}
N 8080 -3630 8100 -3630 {
lab=#net19}
N 8080 -3650 8100 -3650 {
lab=rowon_n[9]}
N 8080 -3670 8100 -3670 {
lab=row_n[9]}
N 7900 -3530 7900 -3520 {
lab=VSS}
N 7900 -3760 7900 -3750 {
lab=VDD}
N 8240 -3530 8250 -3540 {
lab=col_n[29]}
N 8250 -3740 8250 -3540 {
lab=col_n[29]}
N 8240 -3750 8250 -3740 {
lab=col_n[29]}
N 8240 -3530 8240 -3510 {
lab=col_n[29]}
N 8240 -3770 8240 -3750 {
lab=col_n[29]}
N 8120 -3670 8130 -3680 {
lab=row_n[9]}
N 8130 -3680 8330 -3680 {
lab=row_n[9]}
N 8330 -3680 8340 -3670 {
lab=row_n[9]}
N 8120 -3650 8130 -3660 {
lab=rowon_n[9]}
N 8130 -3660 8330 -3660 {
lab=rowon_n[9]}
N 8330 -3660 8340 -3650 {
lab=rowon_n[9]}
N 8120 -3630 8130 -3640 {
lab=#net19}
N 8130 -3640 8330 -3640 {
lab=#net19}
N 8330 -3640 8340 -3630 {
lab=#net19}
N 8120 -3610 8130 -3620 {
lab=#net20}
N 8130 -3620 8330 -3620 {
lab=#net20}
N 8330 -3620 8340 -3610 {
lab=#net20}
N 8180 -3770 8180 -3750 {
lab=vcm}
N 8220 -3770 8220 -3750 {
lab=ctop}
N 8100 -3670 8120 -3670 {
lab=row_n[9]}
N 8100 -3650 8120 -3650 {
lab=rowon_n[9]}
N 8100 -3630 8120 -3630 {
lab=#net19}
N 8100 -3610 8120 -3610 {
lab=#net20}
N 8340 -3610 8360 -3610 {
lab=#net20}
N 8340 -3630 8360 -3630 {
lab=#net19}
N 8340 -3650 8360 -3650 {
lab=rowon_n[9]}
N 8340 -3670 8360 -3670 {
lab=row_n[9]}
N 8160 -3530 8160 -3520 {
lab=VSS}
N 8160 -3760 8160 -3750 {
lab=VDD}
N 8500 -3530 8510 -3540 {
lab=col_n[30]}
N 8510 -3740 8510 -3540 {
lab=col_n[30]}
N 8500 -3750 8510 -3740 {
lab=col_n[30]}
N 8500 -3530 8500 -3510 {
lab=col_n[30]}
N 8500 -3770 8500 -3750 {
lab=col_n[30]}
N 8380 -3670 8390 -3680 {
lab=row_n[9]}
N 8390 -3680 8590 -3680 {
lab=row_n[9]}
N 8590 -3680 8600 -3670 {
lab=row_n[9]}
N 8380 -3650 8390 -3660 {
lab=rowon_n[9]}
N 8390 -3660 8590 -3660 {
lab=rowon_n[9]}
N 8590 -3660 8600 -3650 {
lab=rowon_n[9]}
N 8380 -3630 8390 -3640 {
lab=#net19}
N 8390 -3640 8590 -3640 {
lab=#net19}
N 8590 -3640 8600 -3630 {
lab=#net19}
N 8380 -3610 8390 -3620 {
lab=#net20}
N 8390 -3620 8590 -3620 {
lab=#net20}
N 8590 -3620 8600 -3610 {
lab=#net20}
N 8440 -3770 8440 -3750 {
lab=vcm}
N 8480 -3770 8480 -3750 {
lab=ctop}
N 8360 -3670 8380 -3670 {
lab=row_n[9]}
N 8360 -3650 8380 -3650 {
lab=rowon_n[9]}
N 8360 -3630 8380 -3630 {
lab=#net19}
N 8360 -3610 8380 -3610 {
lab=#net20}
N 8600 -3610 8620 -3610 {
lab=#net20}
N 8600 -3630 8620 -3630 {
lab=#net19}
N 8600 -3650 8620 -3650 {
lab=rowon_n[9]}
N 8600 -3670 8620 -3670 {
lab=row_n[9]}
N 8420 -3530 8420 -3520 {
lab=VSS}
N 8420 -3760 8420 -3750 {
lab=VDD}
N 8760 -3530 8770 -3540 {
lab=col_n[31]}
N 8770 -3740 8770 -3540 {
lab=col_n[31]}
N 8760 -3750 8770 -3740 {
lab=col_n[31]}
N 8760 -3530 8760 -3510 {
lab=col_n[31]}
N 8760 -3770 8760 -3750 {
lab=col_n[31]}
N 8640 -3670 8650 -3680 {
lab=row_n[9]}
N 8650 -3680 8850 -3680 {
lab=row_n[9]}
N 8850 -3680 8860 -3670 {
lab=row_n[9]}
N 8640 -3650 8650 -3660 {
lab=rowon_n[9]}
N 8650 -3660 8850 -3660 {
lab=rowon_n[9]}
N 8850 -3660 8860 -3650 {
lab=rowon_n[9]}
N 8640 -3630 8650 -3640 {
lab=#net19}
N 8650 -3640 8850 -3640 {
lab=#net19}
N 8850 -3640 8860 -3630 {
lab=#net19}
N 8640 -3610 8650 -3620 {
lab=#net20}
N 8650 -3620 8850 -3620 {
lab=#net20}
N 8850 -3620 8860 -3610 {
lab=#net20}
N 8700 -3770 8700 -3750 {
lab=vcm}
N 8740 -3770 8740 -3750 {
lab=ctop}
N 8620 -3670 8640 -3670 {
lab=row_n[9]}
N 8620 -3650 8640 -3650 {
lab=rowon_n[9]}
N 8620 -3630 8640 -3630 {
lab=#net19}
N 8620 -3610 8640 -3610 {
lab=#net20}
N 8860 -3610 8880 -3610 {
lab=#net20}
N 8860 -3630 8880 -3630 {
lab=#net19}
N 8860 -3650 8880 -3650 {
lab=rowon_n[9]}
N 8860 -3670 8880 -3670 {
lab=row_n[9]}
N 8680 -3530 8680 -3520 {
lab=VSS}
N 8680 -3760 8680 -3750 {
lab=VDD}
N 700 -3790 710 -3800 {
lab=col_n[0]}
N 710 -4000 710 -3800 {
lab=col_n[0]}
N 700 -4010 710 -4000 {
lab=col_n[0]}
N 700 -3790 700 -3770 {
lab=col_n[0]}
N 700 -4030 700 -4010 {
lab=col_n[0]}
N 580 -3930 590 -3940 {
lab=row_n[10]}
N 590 -3940 790 -3940 {
lab=row_n[10]}
N 790 -3940 800 -3930 {
lab=row_n[10]}
N 580 -3910 590 -3920 {
lab=rowon_n[10]}
N 590 -3920 790 -3920 {
lab=rowon_n[10]}
N 790 -3920 800 -3910 {
lab=rowon_n[10]}
N 580 -3890 590 -3900 {
lab=#net21}
N 590 -3900 790 -3900 {
lab=#net21}
N 790 -3900 800 -3890 {
lab=#net21}
N 580 -3870 590 -3880 {
lab=#net22}
N 590 -3880 790 -3880 {
lab=#net22}
N 790 -3880 800 -3870 {
lab=#net22}
N 640 -4030 640 -4010 {
lab=vcm}
N 680 -4030 680 -4010 {
lab=ctop}
N 560 -3930 580 -3930 {
lab=row_n[10]}
N 560 -3910 580 -3910 {
lab=rowon_n[10]}
N 560 -3890 580 -3890 {
lab=#net21}
N 560 -3870 580 -3870 {
lab=#net22}
N 800 -3870 820 -3870 {
lab=#net22}
N 800 -3890 820 -3890 {
lab=#net21}
N 800 -3910 820 -3910 {
lab=rowon_n[10]}
N 800 -3930 820 -3930 {
lab=row_n[10]}
N 620 -3790 620 -3780 {
lab=VSS}
N 620 -4020 620 -4010 {
lab=VDD}
N 960 -3790 970 -3800 {
lab=col_n[1]}
N 970 -4000 970 -3800 {
lab=col_n[1]}
N 960 -4010 970 -4000 {
lab=col_n[1]}
N 960 -3790 960 -3770 {
lab=col_n[1]}
N 960 -4030 960 -4010 {
lab=col_n[1]}
N 840 -3930 850 -3940 {
lab=row_n[10]}
N 850 -3940 1050 -3940 {
lab=row_n[10]}
N 1050 -3940 1060 -3930 {
lab=row_n[10]}
N 840 -3910 850 -3920 {
lab=rowon_n[10]}
N 850 -3920 1050 -3920 {
lab=rowon_n[10]}
N 1050 -3920 1060 -3910 {
lab=rowon_n[10]}
N 840 -3890 850 -3900 {
lab=#net21}
N 850 -3900 1050 -3900 {
lab=#net21}
N 1050 -3900 1060 -3890 {
lab=#net21}
N 840 -3870 850 -3880 {
lab=#net22}
N 850 -3880 1050 -3880 {
lab=#net22}
N 1050 -3880 1060 -3870 {
lab=#net22}
N 900 -4030 900 -4010 {
lab=vcm}
N 940 -4030 940 -4010 {
lab=ctop}
N 820 -3930 840 -3930 {
lab=row_n[10]}
N 820 -3910 840 -3910 {
lab=rowon_n[10]}
N 820 -3890 840 -3890 {
lab=#net21}
N 820 -3870 840 -3870 {
lab=#net22}
N 1060 -3870 1080 -3870 {
lab=#net22}
N 1060 -3890 1080 -3890 {
lab=#net21}
N 1060 -3910 1080 -3910 {
lab=rowon_n[10]}
N 1060 -3930 1080 -3930 {
lab=row_n[10]}
N 880 -3790 880 -3780 {
lab=VSS}
N 880 -4020 880 -4010 {
lab=VDD}
N 1220 -3790 1230 -3800 {
lab=col_n[2]}
N 1230 -4000 1230 -3800 {
lab=col_n[2]}
N 1220 -4010 1230 -4000 {
lab=col_n[2]}
N 1220 -3790 1220 -3770 {
lab=col_n[2]}
N 1220 -4030 1220 -4010 {
lab=col_n[2]}
N 1100 -3930 1110 -3940 {
lab=row_n[10]}
N 1110 -3940 1310 -3940 {
lab=row_n[10]}
N 1310 -3940 1320 -3930 {
lab=row_n[10]}
N 1100 -3910 1110 -3920 {
lab=rowon_n[10]}
N 1110 -3920 1310 -3920 {
lab=rowon_n[10]}
N 1310 -3920 1320 -3910 {
lab=rowon_n[10]}
N 1100 -3890 1110 -3900 {
lab=#net21}
N 1110 -3900 1310 -3900 {
lab=#net21}
N 1310 -3900 1320 -3890 {
lab=#net21}
N 1100 -3870 1110 -3880 {
lab=#net22}
N 1110 -3880 1310 -3880 {
lab=#net22}
N 1310 -3880 1320 -3870 {
lab=#net22}
N 1160 -4030 1160 -4010 {
lab=vcm}
N 1200 -4030 1200 -4010 {
lab=ctop}
N 1080 -3930 1100 -3930 {
lab=row_n[10]}
N 1080 -3910 1100 -3910 {
lab=rowon_n[10]}
N 1080 -3890 1100 -3890 {
lab=#net21}
N 1080 -3870 1100 -3870 {
lab=#net22}
N 1320 -3870 1340 -3870 {
lab=#net22}
N 1320 -3890 1340 -3890 {
lab=#net21}
N 1320 -3910 1340 -3910 {
lab=rowon_n[10]}
N 1320 -3930 1340 -3930 {
lab=row_n[10]}
N 1140 -3790 1140 -3780 {
lab=VSS}
N 1140 -4020 1140 -4010 {
lab=VDD}
N 1480 -3790 1490 -3800 {
lab=col_n[3]}
N 1490 -4000 1490 -3800 {
lab=col_n[3]}
N 1480 -4010 1490 -4000 {
lab=col_n[3]}
N 1480 -3790 1480 -3770 {
lab=col_n[3]}
N 1480 -4030 1480 -4010 {
lab=col_n[3]}
N 1360 -3930 1370 -3940 {
lab=row_n[10]}
N 1370 -3940 1570 -3940 {
lab=row_n[10]}
N 1570 -3940 1580 -3930 {
lab=row_n[10]}
N 1360 -3910 1370 -3920 {
lab=rowon_n[10]}
N 1370 -3920 1570 -3920 {
lab=rowon_n[10]}
N 1570 -3920 1580 -3910 {
lab=rowon_n[10]}
N 1360 -3890 1370 -3900 {
lab=#net21}
N 1370 -3900 1570 -3900 {
lab=#net21}
N 1570 -3900 1580 -3890 {
lab=#net21}
N 1360 -3870 1370 -3880 {
lab=#net22}
N 1370 -3880 1570 -3880 {
lab=#net22}
N 1570 -3880 1580 -3870 {
lab=#net22}
N 1420 -4030 1420 -4010 {
lab=vcm}
N 1460 -4030 1460 -4010 {
lab=ctop}
N 1340 -3930 1360 -3930 {
lab=row_n[10]}
N 1340 -3910 1360 -3910 {
lab=rowon_n[10]}
N 1340 -3890 1360 -3890 {
lab=#net21}
N 1340 -3870 1360 -3870 {
lab=#net22}
N 1580 -3870 1600 -3870 {
lab=#net22}
N 1580 -3890 1600 -3890 {
lab=#net21}
N 1580 -3910 1600 -3910 {
lab=rowon_n[10]}
N 1580 -3930 1600 -3930 {
lab=row_n[10]}
N 1400 -3790 1400 -3780 {
lab=VSS}
N 1400 -4020 1400 -4010 {
lab=VDD}
N 1740 -3790 1750 -3800 {
lab=col_n[4]}
N 1750 -4000 1750 -3800 {
lab=col_n[4]}
N 1740 -4010 1750 -4000 {
lab=col_n[4]}
N 1740 -3790 1740 -3770 {
lab=col_n[4]}
N 1740 -4030 1740 -4010 {
lab=col_n[4]}
N 1620 -3930 1630 -3940 {
lab=row_n[10]}
N 1630 -3940 1830 -3940 {
lab=row_n[10]}
N 1830 -3940 1840 -3930 {
lab=row_n[10]}
N 1620 -3910 1630 -3920 {
lab=rowon_n[10]}
N 1630 -3920 1830 -3920 {
lab=rowon_n[10]}
N 1830 -3920 1840 -3910 {
lab=rowon_n[10]}
N 1620 -3890 1630 -3900 {
lab=#net21}
N 1630 -3900 1830 -3900 {
lab=#net21}
N 1830 -3900 1840 -3890 {
lab=#net21}
N 1620 -3870 1630 -3880 {
lab=#net22}
N 1630 -3880 1830 -3880 {
lab=#net22}
N 1830 -3880 1840 -3870 {
lab=#net22}
N 1680 -4030 1680 -4010 {
lab=vcm}
N 1720 -4030 1720 -4010 {
lab=ctop}
N 1600 -3930 1620 -3930 {
lab=row_n[10]}
N 1600 -3910 1620 -3910 {
lab=rowon_n[10]}
N 1600 -3890 1620 -3890 {
lab=#net21}
N 1600 -3870 1620 -3870 {
lab=#net22}
N 1840 -3870 1860 -3870 {
lab=#net22}
N 1840 -3890 1860 -3890 {
lab=#net21}
N 1840 -3910 1860 -3910 {
lab=rowon_n[10]}
N 1840 -3930 1860 -3930 {
lab=row_n[10]}
N 1660 -3790 1660 -3780 {
lab=VSS}
N 1660 -4020 1660 -4010 {
lab=VDD}
N 2000 -3790 2010 -3800 {
lab=col_n[5]}
N 2010 -4000 2010 -3800 {
lab=col_n[5]}
N 2000 -4010 2010 -4000 {
lab=col_n[5]}
N 2000 -3790 2000 -3770 {
lab=col_n[5]}
N 2000 -4030 2000 -4010 {
lab=col_n[5]}
N 1880 -3930 1890 -3940 {
lab=row_n[10]}
N 1890 -3940 2090 -3940 {
lab=row_n[10]}
N 2090 -3940 2100 -3930 {
lab=row_n[10]}
N 1880 -3910 1890 -3920 {
lab=rowon_n[10]}
N 1890 -3920 2090 -3920 {
lab=rowon_n[10]}
N 2090 -3920 2100 -3910 {
lab=rowon_n[10]}
N 1880 -3890 1890 -3900 {
lab=#net21}
N 1890 -3900 2090 -3900 {
lab=#net21}
N 2090 -3900 2100 -3890 {
lab=#net21}
N 1880 -3870 1890 -3880 {
lab=#net22}
N 1890 -3880 2090 -3880 {
lab=#net22}
N 2090 -3880 2100 -3870 {
lab=#net22}
N 1940 -4030 1940 -4010 {
lab=vcm}
N 1980 -4030 1980 -4010 {
lab=ctop}
N 1860 -3930 1880 -3930 {
lab=row_n[10]}
N 1860 -3910 1880 -3910 {
lab=rowon_n[10]}
N 1860 -3890 1880 -3890 {
lab=#net21}
N 1860 -3870 1880 -3870 {
lab=#net22}
N 2100 -3870 2120 -3870 {
lab=#net22}
N 2100 -3890 2120 -3890 {
lab=#net21}
N 2100 -3910 2120 -3910 {
lab=rowon_n[10]}
N 2100 -3930 2120 -3930 {
lab=row_n[10]}
N 1920 -3790 1920 -3780 {
lab=VSS}
N 1920 -4020 1920 -4010 {
lab=VDD}
N 2260 -3790 2270 -3800 {
lab=col_n[6]}
N 2270 -4000 2270 -3800 {
lab=col_n[6]}
N 2260 -4010 2270 -4000 {
lab=col_n[6]}
N 2260 -3790 2260 -3770 {
lab=col_n[6]}
N 2260 -4030 2260 -4010 {
lab=col_n[6]}
N 2140 -3930 2150 -3940 {
lab=row_n[10]}
N 2150 -3940 2350 -3940 {
lab=row_n[10]}
N 2350 -3940 2360 -3930 {
lab=row_n[10]}
N 2140 -3910 2150 -3920 {
lab=rowon_n[10]}
N 2150 -3920 2350 -3920 {
lab=rowon_n[10]}
N 2350 -3920 2360 -3910 {
lab=rowon_n[10]}
N 2140 -3890 2150 -3900 {
lab=#net21}
N 2150 -3900 2350 -3900 {
lab=#net21}
N 2350 -3900 2360 -3890 {
lab=#net21}
N 2140 -3870 2150 -3880 {
lab=#net22}
N 2150 -3880 2350 -3880 {
lab=#net22}
N 2350 -3880 2360 -3870 {
lab=#net22}
N 2200 -4030 2200 -4010 {
lab=vcm}
N 2240 -4030 2240 -4010 {
lab=ctop}
N 2120 -3930 2140 -3930 {
lab=row_n[10]}
N 2120 -3910 2140 -3910 {
lab=rowon_n[10]}
N 2120 -3890 2140 -3890 {
lab=#net21}
N 2120 -3870 2140 -3870 {
lab=#net22}
N 2360 -3870 2380 -3870 {
lab=#net22}
N 2360 -3890 2380 -3890 {
lab=#net21}
N 2360 -3910 2380 -3910 {
lab=rowon_n[10]}
N 2360 -3930 2380 -3930 {
lab=row_n[10]}
N 2180 -3790 2180 -3780 {
lab=VSS}
N 2180 -4020 2180 -4010 {
lab=VDD}
N 2520 -3790 2530 -3800 {
lab=col_n[7]}
N 2530 -4000 2530 -3800 {
lab=col_n[7]}
N 2520 -4010 2530 -4000 {
lab=col_n[7]}
N 2520 -3790 2520 -3770 {
lab=col_n[7]}
N 2520 -4030 2520 -4010 {
lab=col_n[7]}
N 2400 -3930 2410 -3940 {
lab=row_n[10]}
N 2410 -3940 2610 -3940 {
lab=row_n[10]}
N 2610 -3940 2620 -3930 {
lab=row_n[10]}
N 2400 -3910 2410 -3920 {
lab=rowon_n[10]}
N 2410 -3920 2610 -3920 {
lab=rowon_n[10]}
N 2610 -3920 2620 -3910 {
lab=rowon_n[10]}
N 2400 -3890 2410 -3900 {
lab=#net21}
N 2410 -3900 2610 -3900 {
lab=#net21}
N 2610 -3900 2620 -3890 {
lab=#net21}
N 2400 -3870 2410 -3880 {
lab=#net22}
N 2410 -3880 2610 -3880 {
lab=#net22}
N 2610 -3880 2620 -3870 {
lab=#net22}
N 2460 -4030 2460 -4010 {
lab=vcm}
N 2500 -4030 2500 -4010 {
lab=ctop}
N 2380 -3930 2400 -3930 {
lab=row_n[10]}
N 2380 -3910 2400 -3910 {
lab=rowon_n[10]}
N 2380 -3890 2400 -3890 {
lab=#net21}
N 2380 -3870 2400 -3870 {
lab=#net22}
N 2620 -3870 2640 -3870 {
lab=#net22}
N 2620 -3890 2640 -3890 {
lab=#net21}
N 2620 -3910 2640 -3910 {
lab=rowon_n[10]}
N 2620 -3930 2640 -3930 {
lab=row_n[10]}
N 2440 -3790 2440 -3780 {
lab=VSS}
N 2440 -4020 2440 -4010 {
lab=VDD}
N 2780 -3790 2790 -3800 {
lab=col_n[8]}
N 2790 -4000 2790 -3800 {
lab=col_n[8]}
N 2780 -4010 2790 -4000 {
lab=col_n[8]}
N 2780 -3790 2780 -3770 {
lab=col_n[8]}
N 2780 -4030 2780 -4010 {
lab=col_n[8]}
N 2660 -3930 2670 -3940 {
lab=row_n[10]}
N 2670 -3940 2870 -3940 {
lab=row_n[10]}
N 2870 -3940 2880 -3930 {
lab=row_n[10]}
N 2660 -3910 2670 -3920 {
lab=rowon_n[10]}
N 2670 -3920 2870 -3920 {
lab=rowon_n[10]}
N 2870 -3920 2880 -3910 {
lab=rowon_n[10]}
N 2660 -3890 2670 -3900 {
lab=#net21}
N 2670 -3900 2870 -3900 {
lab=#net21}
N 2870 -3900 2880 -3890 {
lab=#net21}
N 2660 -3870 2670 -3880 {
lab=#net22}
N 2670 -3880 2870 -3880 {
lab=#net22}
N 2870 -3880 2880 -3870 {
lab=#net22}
N 2720 -4030 2720 -4010 {
lab=vcm}
N 2760 -4030 2760 -4010 {
lab=ctop}
N 2640 -3930 2660 -3930 {
lab=row_n[10]}
N 2640 -3910 2660 -3910 {
lab=rowon_n[10]}
N 2640 -3890 2660 -3890 {
lab=#net21}
N 2640 -3870 2660 -3870 {
lab=#net22}
N 2880 -3870 2900 -3870 {
lab=#net22}
N 2880 -3890 2900 -3890 {
lab=#net21}
N 2880 -3910 2900 -3910 {
lab=rowon_n[10]}
N 2880 -3930 2900 -3930 {
lab=row_n[10]}
N 2700 -3790 2700 -3780 {
lab=VSS}
N 2700 -4020 2700 -4010 {
lab=VDD}
N 3040 -3790 3050 -3800 {
lab=col_n[9]}
N 3050 -4000 3050 -3800 {
lab=col_n[9]}
N 3040 -4010 3050 -4000 {
lab=col_n[9]}
N 3040 -3790 3040 -3770 {
lab=col_n[9]}
N 3040 -4030 3040 -4010 {
lab=col_n[9]}
N 2920 -3930 2930 -3940 {
lab=row_n[10]}
N 2930 -3940 3130 -3940 {
lab=row_n[10]}
N 3130 -3940 3140 -3930 {
lab=row_n[10]}
N 2920 -3910 2930 -3920 {
lab=rowon_n[10]}
N 2930 -3920 3130 -3920 {
lab=rowon_n[10]}
N 3130 -3920 3140 -3910 {
lab=rowon_n[10]}
N 2920 -3890 2930 -3900 {
lab=#net21}
N 2930 -3900 3130 -3900 {
lab=#net21}
N 3130 -3900 3140 -3890 {
lab=#net21}
N 2920 -3870 2930 -3880 {
lab=#net22}
N 2930 -3880 3130 -3880 {
lab=#net22}
N 3130 -3880 3140 -3870 {
lab=#net22}
N 2980 -4030 2980 -4010 {
lab=vcm}
N 3020 -4030 3020 -4010 {
lab=ctop}
N 2900 -3930 2920 -3930 {
lab=row_n[10]}
N 2900 -3910 2920 -3910 {
lab=rowon_n[10]}
N 2900 -3890 2920 -3890 {
lab=#net21}
N 2900 -3870 2920 -3870 {
lab=#net22}
N 3140 -3870 3160 -3870 {
lab=#net22}
N 3140 -3890 3160 -3890 {
lab=#net21}
N 3140 -3910 3160 -3910 {
lab=rowon_n[10]}
N 3140 -3930 3160 -3930 {
lab=row_n[10]}
N 2960 -3790 2960 -3780 {
lab=VSS}
N 2960 -4020 2960 -4010 {
lab=VDD}
N 3300 -3790 3310 -3800 {
lab=col_n[10]}
N 3310 -4000 3310 -3800 {
lab=col_n[10]}
N 3300 -4010 3310 -4000 {
lab=col_n[10]}
N 3300 -3790 3300 -3770 {
lab=col_n[10]}
N 3300 -4030 3300 -4010 {
lab=col_n[10]}
N 3180 -3930 3190 -3940 {
lab=row_n[10]}
N 3190 -3940 3390 -3940 {
lab=row_n[10]}
N 3390 -3940 3400 -3930 {
lab=row_n[10]}
N 3180 -3910 3190 -3920 {
lab=rowon_n[10]}
N 3190 -3920 3390 -3920 {
lab=rowon_n[10]}
N 3390 -3920 3400 -3910 {
lab=rowon_n[10]}
N 3180 -3890 3190 -3900 {
lab=#net21}
N 3190 -3900 3390 -3900 {
lab=#net21}
N 3390 -3900 3400 -3890 {
lab=#net21}
N 3180 -3870 3190 -3880 {
lab=#net22}
N 3190 -3880 3390 -3880 {
lab=#net22}
N 3390 -3880 3400 -3870 {
lab=#net22}
N 3240 -4030 3240 -4010 {
lab=vcm}
N 3280 -4030 3280 -4010 {
lab=ctop}
N 3160 -3930 3180 -3930 {
lab=row_n[10]}
N 3160 -3910 3180 -3910 {
lab=rowon_n[10]}
N 3160 -3890 3180 -3890 {
lab=#net21}
N 3160 -3870 3180 -3870 {
lab=#net22}
N 3400 -3870 3420 -3870 {
lab=#net22}
N 3400 -3890 3420 -3890 {
lab=#net21}
N 3400 -3910 3420 -3910 {
lab=rowon_n[10]}
N 3400 -3930 3420 -3930 {
lab=row_n[10]}
N 3220 -3790 3220 -3780 {
lab=VSS}
N 3220 -4020 3220 -4010 {
lab=VDD}
N 3560 -3790 3570 -3800 {
lab=col_n[11]}
N 3570 -4000 3570 -3800 {
lab=col_n[11]}
N 3560 -4010 3570 -4000 {
lab=col_n[11]}
N 3560 -3790 3560 -3770 {
lab=col_n[11]}
N 3560 -4030 3560 -4010 {
lab=col_n[11]}
N 3440 -3930 3450 -3940 {
lab=row_n[10]}
N 3450 -3940 3650 -3940 {
lab=row_n[10]}
N 3650 -3940 3660 -3930 {
lab=row_n[10]}
N 3440 -3910 3450 -3920 {
lab=rowon_n[10]}
N 3450 -3920 3650 -3920 {
lab=rowon_n[10]}
N 3650 -3920 3660 -3910 {
lab=rowon_n[10]}
N 3440 -3890 3450 -3900 {
lab=#net21}
N 3450 -3900 3650 -3900 {
lab=#net21}
N 3650 -3900 3660 -3890 {
lab=#net21}
N 3440 -3870 3450 -3880 {
lab=#net22}
N 3450 -3880 3650 -3880 {
lab=#net22}
N 3650 -3880 3660 -3870 {
lab=#net22}
N 3500 -4030 3500 -4010 {
lab=vcm}
N 3540 -4030 3540 -4010 {
lab=ctop}
N 3420 -3930 3440 -3930 {
lab=row_n[10]}
N 3420 -3910 3440 -3910 {
lab=rowon_n[10]}
N 3420 -3890 3440 -3890 {
lab=#net21}
N 3420 -3870 3440 -3870 {
lab=#net22}
N 3660 -3870 3680 -3870 {
lab=#net22}
N 3660 -3890 3680 -3890 {
lab=#net21}
N 3660 -3910 3680 -3910 {
lab=rowon_n[10]}
N 3660 -3930 3680 -3930 {
lab=row_n[10]}
N 3480 -3790 3480 -3780 {
lab=VSS}
N 3480 -4020 3480 -4010 {
lab=VDD}
N 3820 -3790 3830 -3800 {
lab=col_n[12]}
N 3830 -4000 3830 -3800 {
lab=col_n[12]}
N 3820 -4010 3830 -4000 {
lab=col_n[12]}
N 3820 -3790 3820 -3770 {
lab=col_n[12]}
N 3820 -4030 3820 -4010 {
lab=col_n[12]}
N 3700 -3930 3710 -3940 {
lab=row_n[10]}
N 3710 -3940 3910 -3940 {
lab=row_n[10]}
N 3910 -3940 3920 -3930 {
lab=row_n[10]}
N 3700 -3910 3710 -3920 {
lab=rowon_n[10]}
N 3710 -3920 3910 -3920 {
lab=rowon_n[10]}
N 3910 -3920 3920 -3910 {
lab=rowon_n[10]}
N 3700 -3890 3710 -3900 {
lab=#net21}
N 3710 -3900 3910 -3900 {
lab=#net21}
N 3910 -3900 3920 -3890 {
lab=#net21}
N 3700 -3870 3710 -3880 {
lab=#net22}
N 3710 -3880 3910 -3880 {
lab=#net22}
N 3910 -3880 3920 -3870 {
lab=#net22}
N 3760 -4030 3760 -4010 {
lab=vcm}
N 3800 -4030 3800 -4010 {
lab=ctop}
N 3680 -3930 3700 -3930 {
lab=row_n[10]}
N 3680 -3910 3700 -3910 {
lab=rowon_n[10]}
N 3680 -3890 3700 -3890 {
lab=#net21}
N 3680 -3870 3700 -3870 {
lab=#net22}
N 3920 -3870 3940 -3870 {
lab=#net22}
N 3920 -3890 3940 -3890 {
lab=#net21}
N 3920 -3910 3940 -3910 {
lab=rowon_n[10]}
N 3920 -3930 3940 -3930 {
lab=row_n[10]}
N 3740 -3790 3740 -3780 {
lab=VSS}
N 3740 -4020 3740 -4010 {
lab=VDD}
N 4080 -3790 4090 -3800 {
lab=col_n[13]}
N 4090 -4000 4090 -3800 {
lab=col_n[13]}
N 4080 -4010 4090 -4000 {
lab=col_n[13]}
N 4080 -3790 4080 -3770 {
lab=col_n[13]}
N 4080 -4030 4080 -4010 {
lab=col_n[13]}
N 3960 -3930 3970 -3940 {
lab=row_n[10]}
N 3970 -3940 4170 -3940 {
lab=row_n[10]}
N 4170 -3940 4180 -3930 {
lab=row_n[10]}
N 3960 -3910 3970 -3920 {
lab=rowon_n[10]}
N 3970 -3920 4170 -3920 {
lab=rowon_n[10]}
N 4170 -3920 4180 -3910 {
lab=rowon_n[10]}
N 3960 -3890 3970 -3900 {
lab=#net21}
N 3970 -3900 4170 -3900 {
lab=#net21}
N 4170 -3900 4180 -3890 {
lab=#net21}
N 3960 -3870 3970 -3880 {
lab=#net22}
N 3970 -3880 4170 -3880 {
lab=#net22}
N 4170 -3880 4180 -3870 {
lab=#net22}
N 4020 -4030 4020 -4010 {
lab=vcm}
N 4060 -4030 4060 -4010 {
lab=ctop}
N 3940 -3930 3960 -3930 {
lab=row_n[10]}
N 3940 -3910 3960 -3910 {
lab=rowon_n[10]}
N 3940 -3890 3960 -3890 {
lab=#net21}
N 3940 -3870 3960 -3870 {
lab=#net22}
N 4180 -3870 4200 -3870 {
lab=#net22}
N 4180 -3890 4200 -3890 {
lab=#net21}
N 4180 -3910 4200 -3910 {
lab=rowon_n[10]}
N 4180 -3930 4200 -3930 {
lab=row_n[10]}
N 4000 -3790 4000 -3780 {
lab=VSS}
N 4000 -4020 4000 -4010 {
lab=VDD}
N 4340 -3790 4350 -3800 {
lab=col_n[14]}
N 4350 -4000 4350 -3800 {
lab=col_n[14]}
N 4340 -4010 4350 -4000 {
lab=col_n[14]}
N 4340 -3790 4340 -3770 {
lab=col_n[14]}
N 4340 -4030 4340 -4010 {
lab=col_n[14]}
N 4220 -3930 4230 -3940 {
lab=row_n[10]}
N 4230 -3940 4430 -3940 {
lab=row_n[10]}
N 4430 -3940 4440 -3930 {
lab=row_n[10]}
N 4220 -3910 4230 -3920 {
lab=rowon_n[10]}
N 4230 -3920 4430 -3920 {
lab=rowon_n[10]}
N 4430 -3920 4440 -3910 {
lab=rowon_n[10]}
N 4220 -3890 4230 -3900 {
lab=#net21}
N 4230 -3900 4430 -3900 {
lab=#net21}
N 4430 -3900 4440 -3890 {
lab=#net21}
N 4220 -3870 4230 -3880 {
lab=#net22}
N 4230 -3880 4430 -3880 {
lab=#net22}
N 4430 -3880 4440 -3870 {
lab=#net22}
N 4280 -4030 4280 -4010 {
lab=vcm}
N 4320 -4030 4320 -4010 {
lab=ctop}
N 4200 -3930 4220 -3930 {
lab=row_n[10]}
N 4200 -3910 4220 -3910 {
lab=rowon_n[10]}
N 4200 -3890 4220 -3890 {
lab=#net21}
N 4200 -3870 4220 -3870 {
lab=#net22}
N 4440 -3870 4460 -3870 {
lab=#net22}
N 4440 -3890 4460 -3890 {
lab=#net21}
N 4440 -3910 4460 -3910 {
lab=rowon_n[10]}
N 4440 -3930 4460 -3930 {
lab=row_n[10]}
N 4260 -3790 4260 -3780 {
lab=VSS}
N 4260 -4020 4260 -4010 {
lab=VDD}
N 4600 -3790 4610 -3800 {
lab=col_n[15]}
N 4610 -4000 4610 -3800 {
lab=col_n[15]}
N 4600 -4010 4610 -4000 {
lab=col_n[15]}
N 4600 -3790 4600 -3770 {
lab=col_n[15]}
N 4600 -4030 4600 -4010 {
lab=col_n[15]}
N 4480 -3930 4490 -3940 {
lab=row_n[10]}
N 4490 -3940 4690 -3940 {
lab=row_n[10]}
N 4690 -3940 4700 -3930 {
lab=row_n[10]}
N 4480 -3910 4490 -3920 {
lab=rowon_n[10]}
N 4490 -3920 4690 -3920 {
lab=rowon_n[10]}
N 4690 -3920 4700 -3910 {
lab=rowon_n[10]}
N 4480 -3890 4490 -3900 {
lab=#net21}
N 4490 -3900 4690 -3900 {
lab=#net21}
N 4690 -3900 4700 -3890 {
lab=#net21}
N 4480 -3870 4490 -3880 {
lab=#net22}
N 4490 -3880 4690 -3880 {
lab=#net22}
N 4690 -3880 4700 -3870 {
lab=#net22}
N 4540 -4030 4540 -4010 {
lab=vcm}
N 4580 -4030 4580 -4010 {
lab=ctop}
N 4460 -3930 4480 -3930 {
lab=row_n[10]}
N 4460 -3910 4480 -3910 {
lab=rowon_n[10]}
N 4460 -3890 4480 -3890 {
lab=#net21}
N 4460 -3870 4480 -3870 {
lab=#net22}
N 4700 -3870 4720 -3870 {
lab=#net22}
N 4700 -3890 4720 -3890 {
lab=#net21}
N 4700 -3910 4720 -3910 {
lab=rowon_n[10]}
N 4700 -3930 4720 -3930 {
lab=row_n[10]}
N 4520 -3790 4520 -3780 {
lab=VSS}
N 4520 -4020 4520 -4010 {
lab=VDD}
N 4860 -3790 4870 -3800 {
lab=col_n[16]}
N 4870 -4000 4870 -3800 {
lab=col_n[16]}
N 4860 -4010 4870 -4000 {
lab=col_n[16]}
N 4860 -3790 4860 -3770 {
lab=col_n[16]}
N 4860 -4030 4860 -4010 {
lab=col_n[16]}
N 4740 -3930 4750 -3940 {
lab=row_n[10]}
N 4750 -3940 4950 -3940 {
lab=row_n[10]}
N 4950 -3940 4960 -3930 {
lab=row_n[10]}
N 4740 -3910 4750 -3920 {
lab=rowon_n[10]}
N 4750 -3920 4950 -3920 {
lab=rowon_n[10]}
N 4950 -3920 4960 -3910 {
lab=rowon_n[10]}
N 4740 -3890 4750 -3900 {
lab=#net21}
N 4750 -3900 4950 -3900 {
lab=#net21}
N 4950 -3900 4960 -3890 {
lab=#net21}
N 4740 -3870 4750 -3880 {
lab=#net22}
N 4750 -3880 4950 -3880 {
lab=#net22}
N 4950 -3880 4960 -3870 {
lab=#net22}
N 4800 -4030 4800 -4010 {
lab=vcm}
N 4840 -4030 4840 -4010 {
lab=ctop}
N 4720 -3930 4740 -3930 {
lab=row_n[10]}
N 4720 -3910 4740 -3910 {
lab=rowon_n[10]}
N 4720 -3890 4740 -3890 {
lab=#net21}
N 4720 -3870 4740 -3870 {
lab=#net22}
N 4960 -3870 4980 -3870 {
lab=#net22}
N 4960 -3890 4980 -3890 {
lab=#net21}
N 4960 -3910 4980 -3910 {
lab=rowon_n[10]}
N 4960 -3930 4980 -3930 {
lab=row_n[10]}
N 4780 -3790 4780 -3780 {
lab=VSS}
N 4780 -4020 4780 -4010 {
lab=VDD}
N 5120 -3790 5130 -3800 {
lab=col_n[17]}
N 5130 -4000 5130 -3800 {
lab=col_n[17]}
N 5120 -4010 5130 -4000 {
lab=col_n[17]}
N 5120 -3790 5120 -3770 {
lab=col_n[17]}
N 5120 -4030 5120 -4010 {
lab=col_n[17]}
N 5000 -3930 5010 -3940 {
lab=row_n[10]}
N 5010 -3940 5210 -3940 {
lab=row_n[10]}
N 5210 -3940 5220 -3930 {
lab=row_n[10]}
N 5000 -3910 5010 -3920 {
lab=rowon_n[10]}
N 5010 -3920 5210 -3920 {
lab=rowon_n[10]}
N 5210 -3920 5220 -3910 {
lab=rowon_n[10]}
N 5000 -3890 5010 -3900 {
lab=#net21}
N 5010 -3900 5210 -3900 {
lab=#net21}
N 5210 -3900 5220 -3890 {
lab=#net21}
N 5000 -3870 5010 -3880 {
lab=#net22}
N 5010 -3880 5210 -3880 {
lab=#net22}
N 5210 -3880 5220 -3870 {
lab=#net22}
N 5060 -4030 5060 -4010 {
lab=vcm}
N 5100 -4030 5100 -4010 {
lab=ctop}
N 4980 -3930 5000 -3930 {
lab=row_n[10]}
N 4980 -3910 5000 -3910 {
lab=rowon_n[10]}
N 4980 -3890 5000 -3890 {
lab=#net21}
N 4980 -3870 5000 -3870 {
lab=#net22}
N 5220 -3870 5240 -3870 {
lab=#net22}
N 5220 -3890 5240 -3890 {
lab=#net21}
N 5220 -3910 5240 -3910 {
lab=rowon_n[10]}
N 5220 -3930 5240 -3930 {
lab=row_n[10]}
N 5040 -3790 5040 -3780 {
lab=VSS}
N 5040 -4020 5040 -4010 {
lab=VDD}
N 5380 -3790 5390 -3800 {
lab=col_n[18]}
N 5390 -4000 5390 -3800 {
lab=col_n[18]}
N 5380 -4010 5390 -4000 {
lab=col_n[18]}
N 5380 -3790 5380 -3770 {
lab=col_n[18]}
N 5380 -4030 5380 -4010 {
lab=col_n[18]}
N 5260 -3930 5270 -3940 {
lab=row_n[10]}
N 5270 -3940 5470 -3940 {
lab=row_n[10]}
N 5470 -3940 5480 -3930 {
lab=row_n[10]}
N 5260 -3910 5270 -3920 {
lab=rowon_n[10]}
N 5270 -3920 5470 -3920 {
lab=rowon_n[10]}
N 5470 -3920 5480 -3910 {
lab=rowon_n[10]}
N 5260 -3890 5270 -3900 {
lab=#net21}
N 5270 -3900 5470 -3900 {
lab=#net21}
N 5470 -3900 5480 -3890 {
lab=#net21}
N 5260 -3870 5270 -3880 {
lab=#net22}
N 5270 -3880 5470 -3880 {
lab=#net22}
N 5470 -3880 5480 -3870 {
lab=#net22}
N 5320 -4030 5320 -4010 {
lab=vcm}
N 5360 -4030 5360 -4010 {
lab=ctop}
N 5240 -3930 5260 -3930 {
lab=row_n[10]}
N 5240 -3910 5260 -3910 {
lab=rowon_n[10]}
N 5240 -3890 5260 -3890 {
lab=#net21}
N 5240 -3870 5260 -3870 {
lab=#net22}
N 5480 -3870 5500 -3870 {
lab=#net22}
N 5480 -3890 5500 -3890 {
lab=#net21}
N 5480 -3910 5500 -3910 {
lab=rowon_n[10]}
N 5480 -3930 5500 -3930 {
lab=row_n[10]}
N 5300 -3790 5300 -3780 {
lab=VSS}
N 5300 -4020 5300 -4010 {
lab=VDD}
N 5640 -3790 5650 -3800 {
lab=col_n[19]}
N 5650 -4000 5650 -3800 {
lab=col_n[19]}
N 5640 -4010 5650 -4000 {
lab=col_n[19]}
N 5640 -3790 5640 -3770 {
lab=col_n[19]}
N 5640 -4030 5640 -4010 {
lab=col_n[19]}
N 5520 -3930 5530 -3940 {
lab=row_n[10]}
N 5530 -3940 5730 -3940 {
lab=row_n[10]}
N 5730 -3940 5740 -3930 {
lab=row_n[10]}
N 5520 -3910 5530 -3920 {
lab=rowon_n[10]}
N 5530 -3920 5730 -3920 {
lab=rowon_n[10]}
N 5730 -3920 5740 -3910 {
lab=rowon_n[10]}
N 5520 -3890 5530 -3900 {
lab=#net21}
N 5530 -3900 5730 -3900 {
lab=#net21}
N 5730 -3900 5740 -3890 {
lab=#net21}
N 5520 -3870 5530 -3880 {
lab=#net22}
N 5530 -3880 5730 -3880 {
lab=#net22}
N 5730 -3880 5740 -3870 {
lab=#net22}
N 5580 -4030 5580 -4010 {
lab=vcm}
N 5620 -4030 5620 -4010 {
lab=ctop}
N 5500 -3930 5520 -3930 {
lab=row_n[10]}
N 5500 -3910 5520 -3910 {
lab=rowon_n[10]}
N 5500 -3890 5520 -3890 {
lab=#net21}
N 5500 -3870 5520 -3870 {
lab=#net22}
N 5740 -3870 5760 -3870 {
lab=#net22}
N 5740 -3890 5760 -3890 {
lab=#net21}
N 5740 -3910 5760 -3910 {
lab=rowon_n[10]}
N 5740 -3930 5760 -3930 {
lab=row_n[10]}
N 5560 -3790 5560 -3780 {
lab=VSS}
N 5560 -4020 5560 -4010 {
lab=VDD}
N 5900 -3790 5910 -3800 {
lab=col_n[20]}
N 5910 -4000 5910 -3800 {
lab=col_n[20]}
N 5900 -4010 5910 -4000 {
lab=col_n[20]}
N 5900 -3790 5900 -3770 {
lab=col_n[20]}
N 5900 -4030 5900 -4010 {
lab=col_n[20]}
N 5780 -3930 5790 -3940 {
lab=row_n[10]}
N 5790 -3940 5990 -3940 {
lab=row_n[10]}
N 5990 -3940 6000 -3930 {
lab=row_n[10]}
N 5780 -3910 5790 -3920 {
lab=rowon_n[10]}
N 5790 -3920 5990 -3920 {
lab=rowon_n[10]}
N 5990 -3920 6000 -3910 {
lab=rowon_n[10]}
N 5780 -3890 5790 -3900 {
lab=#net21}
N 5790 -3900 5990 -3900 {
lab=#net21}
N 5990 -3900 6000 -3890 {
lab=#net21}
N 5780 -3870 5790 -3880 {
lab=#net22}
N 5790 -3880 5990 -3880 {
lab=#net22}
N 5990 -3880 6000 -3870 {
lab=#net22}
N 5840 -4030 5840 -4010 {
lab=vcm}
N 5880 -4030 5880 -4010 {
lab=ctop}
N 5760 -3930 5780 -3930 {
lab=row_n[10]}
N 5760 -3910 5780 -3910 {
lab=rowon_n[10]}
N 5760 -3890 5780 -3890 {
lab=#net21}
N 5760 -3870 5780 -3870 {
lab=#net22}
N 6000 -3870 6020 -3870 {
lab=#net22}
N 6000 -3890 6020 -3890 {
lab=#net21}
N 6000 -3910 6020 -3910 {
lab=rowon_n[10]}
N 6000 -3930 6020 -3930 {
lab=row_n[10]}
N 5820 -3790 5820 -3780 {
lab=VSS}
N 5820 -4020 5820 -4010 {
lab=VDD}
N 6160 -3790 6170 -3800 {
lab=col_n[21]}
N 6170 -4000 6170 -3800 {
lab=col_n[21]}
N 6160 -4010 6170 -4000 {
lab=col_n[21]}
N 6160 -3790 6160 -3770 {
lab=col_n[21]}
N 6160 -4030 6160 -4010 {
lab=col_n[21]}
N 6040 -3930 6050 -3940 {
lab=row_n[10]}
N 6050 -3940 6250 -3940 {
lab=row_n[10]}
N 6250 -3940 6260 -3930 {
lab=row_n[10]}
N 6040 -3910 6050 -3920 {
lab=rowon_n[10]}
N 6050 -3920 6250 -3920 {
lab=rowon_n[10]}
N 6250 -3920 6260 -3910 {
lab=rowon_n[10]}
N 6040 -3890 6050 -3900 {
lab=#net21}
N 6050 -3900 6250 -3900 {
lab=#net21}
N 6250 -3900 6260 -3890 {
lab=#net21}
N 6040 -3870 6050 -3880 {
lab=#net22}
N 6050 -3880 6250 -3880 {
lab=#net22}
N 6250 -3880 6260 -3870 {
lab=#net22}
N 6100 -4030 6100 -4010 {
lab=vcm}
N 6140 -4030 6140 -4010 {
lab=ctop}
N 6020 -3930 6040 -3930 {
lab=row_n[10]}
N 6020 -3910 6040 -3910 {
lab=rowon_n[10]}
N 6020 -3890 6040 -3890 {
lab=#net21}
N 6020 -3870 6040 -3870 {
lab=#net22}
N 6260 -3870 6280 -3870 {
lab=#net22}
N 6260 -3890 6280 -3890 {
lab=#net21}
N 6260 -3910 6280 -3910 {
lab=rowon_n[10]}
N 6260 -3930 6280 -3930 {
lab=row_n[10]}
N 6080 -3790 6080 -3780 {
lab=VSS}
N 6080 -4020 6080 -4010 {
lab=VDD}
N 6420 -3790 6430 -3800 {
lab=col_n[22]}
N 6430 -4000 6430 -3800 {
lab=col_n[22]}
N 6420 -4010 6430 -4000 {
lab=col_n[22]}
N 6420 -3790 6420 -3770 {
lab=col_n[22]}
N 6420 -4030 6420 -4010 {
lab=col_n[22]}
N 6300 -3930 6310 -3940 {
lab=row_n[10]}
N 6310 -3940 6510 -3940 {
lab=row_n[10]}
N 6510 -3940 6520 -3930 {
lab=row_n[10]}
N 6300 -3910 6310 -3920 {
lab=rowon_n[10]}
N 6310 -3920 6510 -3920 {
lab=rowon_n[10]}
N 6510 -3920 6520 -3910 {
lab=rowon_n[10]}
N 6300 -3890 6310 -3900 {
lab=#net21}
N 6310 -3900 6510 -3900 {
lab=#net21}
N 6510 -3900 6520 -3890 {
lab=#net21}
N 6300 -3870 6310 -3880 {
lab=#net22}
N 6310 -3880 6510 -3880 {
lab=#net22}
N 6510 -3880 6520 -3870 {
lab=#net22}
N 6360 -4030 6360 -4010 {
lab=vcm}
N 6400 -4030 6400 -4010 {
lab=ctop}
N 6280 -3930 6300 -3930 {
lab=row_n[10]}
N 6280 -3910 6300 -3910 {
lab=rowon_n[10]}
N 6280 -3890 6300 -3890 {
lab=#net21}
N 6280 -3870 6300 -3870 {
lab=#net22}
N 6520 -3870 6540 -3870 {
lab=#net22}
N 6520 -3890 6540 -3890 {
lab=#net21}
N 6520 -3910 6540 -3910 {
lab=rowon_n[10]}
N 6520 -3930 6540 -3930 {
lab=row_n[10]}
N 6340 -3790 6340 -3780 {
lab=VSS}
N 6340 -4020 6340 -4010 {
lab=VDD}
N 6680 -3790 6690 -3800 {
lab=col_n[23]}
N 6690 -4000 6690 -3800 {
lab=col_n[23]}
N 6680 -4010 6690 -4000 {
lab=col_n[23]}
N 6680 -3790 6680 -3770 {
lab=col_n[23]}
N 6680 -4030 6680 -4010 {
lab=col_n[23]}
N 6560 -3930 6570 -3940 {
lab=row_n[10]}
N 6570 -3940 6770 -3940 {
lab=row_n[10]}
N 6770 -3940 6780 -3930 {
lab=row_n[10]}
N 6560 -3910 6570 -3920 {
lab=rowon_n[10]}
N 6570 -3920 6770 -3920 {
lab=rowon_n[10]}
N 6770 -3920 6780 -3910 {
lab=rowon_n[10]}
N 6560 -3890 6570 -3900 {
lab=#net21}
N 6570 -3900 6770 -3900 {
lab=#net21}
N 6770 -3900 6780 -3890 {
lab=#net21}
N 6560 -3870 6570 -3880 {
lab=#net22}
N 6570 -3880 6770 -3880 {
lab=#net22}
N 6770 -3880 6780 -3870 {
lab=#net22}
N 6620 -4030 6620 -4010 {
lab=vcm}
N 6660 -4030 6660 -4010 {
lab=ctop}
N 6540 -3930 6560 -3930 {
lab=row_n[10]}
N 6540 -3910 6560 -3910 {
lab=rowon_n[10]}
N 6540 -3890 6560 -3890 {
lab=#net21}
N 6540 -3870 6560 -3870 {
lab=#net22}
N 6780 -3870 6800 -3870 {
lab=#net22}
N 6780 -3890 6800 -3890 {
lab=#net21}
N 6780 -3910 6800 -3910 {
lab=rowon_n[10]}
N 6780 -3930 6800 -3930 {
lab=row_n[10]}
N 6600 -3790 6600 -3780 {
lab=VSS}
N 6600 -4020 6600 -4010 {
lab=VDD}
N 6940 -3790 6950 -3800 {
lab=col_n[24]}
N 6950 -4000 6950 -3800 {
lab=col_n[24]}
N 6940 -4010 6950 -4000 {
lab=col_n[24]}
N 6940 -3790 6940 -3770 {
lab=col_n[24]}
N 6940 -4030 6940 -4010 {
lab=col_n[24]}
N 6820 -3930 6830 -3940 {
lab=row_n[10]}
N 6830 -3940 7030 -3940 {
lab=row_n[10]}
N 7030 -3940 7040 -3930 {
lab=row_n[10]}
N 6820 -3910 6830 -3920 {
lab=rowon_n[10]}
N 6830 -3920 7030 -3920 {
lab=rowon_n[10]}
N 7030 -3920 7040 -3910 {
lab=rowon_n[10]}
N 6820 -3890 6830 -3900 {
lab=#net21}
N 6830 -3900 7030 -3900 {
lab=#net21}
N 7030 -3900 7040 -3890 {
lab=#net21}
N 6820 -3870 6830 -3880 {
lab=#net22}
N 6830 -3880 7030 -3880 {
lab=#net22}
N 7030 -3880 7040 -3870 {
lab=#net22}
N 6880 -4030 6880 -4010 {
lab=vcm}
N 6920 -4030 6920 -4010 {
lab=ctop}
N 6800 -3930 6820 -3930 {
lab=row_n[10]}
N 6800 -3910 6820 -3910 {
lab=rowon_n[10]}
N 6800 -3890 6820 -3890 {
lab=#net21}
N 6800 -3870 6820 -3870 {
lab=#net22}
N 7040 -3870 7060 -3870 {
lab=#net22}
N 7040 -3890 7060 -3890 {
lab=#net21}
N 7040 -3910 7060 -3910 {
lab=rowon_n[10]}
N 7040 -3930 7060 -3930 {
lab=row_n[10]}
N 6860 -3790 6860 -3780 {
lab=VSS}
N 6860 -4020 6860 -4010 {
lab=VDD}
N 7200 -3790 7210 -3800 {
lab=col_n[25]}
N 7210 -4000 7210 -3800 {
lab=col_n[25]}
N 7200 -4010 7210 -4000 {
lab=col_n[25]}
N 7200 -3790 7200 -3770 {
lab=col_n[25]}
N 7200 -4030 7200 -4010 {
lab=col_n[25]}
N 7080 -3930 7090 -3940 {
lab=row_n[10]}
N 7090 -3940 7290 -3940 {
lab=row_n[10]}
N 7290 -3940 7300 -3930 {
lab=row_n[10]}
N 7080 -3910 7090 -3920 {
lab=rowon_n[10]}
N 7090 -3920 7290 -3920 {
lab=rowon_n[10]}
N 7290 -3920 7300 -3910 {
lab=rowon_n[10]}
N 7080 -3890 7090 -3900 {
lab=#net21}
N 7090 -3900 7290 -3900 {
lab=#net21}
N 7290 -3900 7300 -3890 {
lab=#net21}
N 7080 -3870 7090 -3880 {
lab=#net22}
N 7090 -3880 7290 -3880 {
lab=#net22}
N 7290 -3880 7300 -3870 {
lab=#net22}
N 7140 -4030 7140 -4010 {
lab=vcm}
N 7180 -4030 7180 -4010 {
lab=ctop}
N 7060 -3930 7080 -3930 {
lab=row_n[10]}
N 7060 -3910 7080 -3910 {
lab=rowon_n[10]}
N 7060 -3890 7080 -3890 {
lab=#net21}
N 7060 -3870 7080 -3870 {
lab=#net22}
N 7300 -3870 7320 -3870 {
lab=#net22}
N 7300 -3890 7320 -3890 {
lab=#net21}
N 7300 -3910 7320 -3910 {
lab=rowon_n[10]}
N 7300 -3930 7320 -3930 {
lab=row_n[10]}
N 7120 -3790 7120 -3780 {
lab=VSS}
N 7120 -4020 7120 -4010 {
lab=VDD}
N 7460 -3790 7470 -3800 {
lab=col_n[26]}
N 7470 -4000 7470 -3800 {
lab=col_n[26]}
N 7460 -4010 7470 -4000 {
lab=col_n[26]}
N 7460 -3790 7460 -3770 {
lab=col_n[26]}
N 7460 -4030 7460 -4010 {
lab=col_n[26]}
N 7340 -3930 7350 -3940 {
lab=row_n[10]}
N 7350 -3940 7550 -3940 {
lab=row_n[10]}
N 7550 -3940 7560 -3930 {
lab=row_n[10]}
N 7340 -3910 7350 -3920 {
lab=rowon_n[10]}
N 7350 -3920 7550 -3920 {
lab=rowon_n[10]}
N 7550 -3920 7560 -3910 {
lab=rowon_n[10]}
N 7340 -3890 7350 -3900 {
lab=#net21}
N 7350 -3900 7550 -3900 {
lab=#net21}
N 7550 -3900 7560 -3890 {
lab=#net21}
N 7340 -3870 7350 -3880 {
lab=#net22}
N 7350 -3880 7550 -3880 {
lab=#net22}
N 7550 -3880 7560 -3870 {
lab=#net22}
N 7400 -4030 7400 -4010 {
lab=vcm}
N 7440 -4030 7440 -4010 {
lab=ctop}
N 7320 -3930 7340 -3930 {
lab=row_n[10]}
N 7320 -3910 7340 -3910 {
lab=rowon_n[10]}
N 7320 -3890 7340 -3890 {
lab=#net21}
N 7320 -3870 7340 -3870 {
lab=#net22}
N 7560 -3870 7580 -3870 {
lab=#net22}
N 7560 -3890 7580 -3890 {
lab=#net21}
N 7560 -3910 7580 -3910 {
lab=rowon_n[10]}
N 7560 -3930 7580 -3930 {
lab=row_n[10]}
N 7380 -3790 7380 -3780 {
lab=VSS}
N 7380 -4020 7380 -4010 {
lab=VDD}
N 7720 -3790 7730 -3800 {
lab=col_n[27]}
N 7730 -4000 7730 -3800 {
lab=col_n[27]}
N 7720 -4010 7730 -4000 {
lab=col_n[27]}
N 7720 -3790 7720 -3770 {
lab=col_n[27]}
N 7720 -4030 7720 -4010 {
lab=col_n[27]}
N 7600 -3930 7610 -3940 {
lab=row_n[10]}
N 7610 -3940 7810 -3940 {
lab=row_n[10]}
N 7810 -3940 7820 -3930 {
lab=row_n[10]}
N 7600 -3910 7610 -3920 {
lab=rowon_n[10]}
N 7610 -3920 7810 -3920 {
lab=rowon_n[10]}
N 7810 -3920 7820 -3910 {
lab=rowon_n[10]}
N 7600 -3890 7610 -3900 {
lab=#net21}
N 7610 -3900 7810 -3900 {
lab=#net21}
N 7810 -3900 7820 -3890 {
lab=#net21}
N 7600 -3870 7610 -3880 {
lab=#net22}
N 7610 -3880 7810 -3880 {
lab=#net22}
N 7810 -3880 7820 -3870 {
lab=#net22}
N 7660 -4030 7660 -4010 {
lab=vcm}
N 7700 -4030 7700 -4010 {
lab=ctop}
N 7580 -3930 7600 -3930 {
lab=row_n[10]}
N 7580 -3910 7600 -3910 {
lab=rowon_n[10]}
N 7580 -3890 7600 -3890 {
lab=#net21}
N 7580 -3870 7600 -3870 {
lab=#net22}
N 7820 -3870 7840 -3870 {
lab=#net22}
N 7820 -3890 7840 -3890 {
lab=#net21}
N 7820 -3910 7840 -3910 {
lab=rowon_n[10]}
N 7820 -3930 7840 -3930 {
lab=row_n[10]}
N 7640 -3790 7640 -3780 {
lab=VSS}
N 7640 -4020 7640 -4010 {
lab=VDD}
N 7980 -3790 7990 -3800 {
lab=col_n[28]}
N 7990 -4000 7990 -3800 {
lab=col_n[28]}
N 7980 -4010 7990 -4000 {
lab=col_n[28]}
N 7980 -3790 7980 -3770 {
lab=col_n[28]}
N 7980 -4030 7980 -4010 {
lab=col_n[28]}
N 7860 -3930 7870 -3940 {
lab=row_n[10]}
N 7870 -3940 8070 -3940 {
lab=row_n[10]}
N 8070 -3940 8080 -3930 {
lab=row_n[10]}
N 7860 -3910 7870 -3920 {
lab=rowon_n[10]}
N 7870 -3920 8070 -3920 {
lab=rowon_n[10]}
N 8070 -3920 8080 -3910 {
lab=rowon_n[10]}
N 7860 -3890 7870 -3900 {
lab=#net21}
N 7870 -3900 8070 -3900 {
lab=#net21}
N 8070 -3900 8080 -3890 {
lab=#net21}
N 7860 -3870 7870 -3880 {
lab=#net22}
N 7870 -3880 8070 -3880 {
lab=#net22}
N 8070 -3880 8080 -3870 {
lab=#net22}
N 7920 -4030 7920 -4010 {
lab=vcm}
N 7960 -4030 7960 -4010 {
lab=ctop}
N 7840 -3930 7860 -3930 {
lab=row_n[10]}
N 7840 -3910 7860 -3910 {
lab=rowon_n[10]}
N 7840 -3890 7860 -3890 {
lab=#net21}
N 7840 -3870 7860 -3870 {
lab=#net22}
N 8080 -3870 8100 -3870 {
lab=#net22}
N 8080 -3890 8100 -3890 {
lab=#net21}
N 8080 -3910 8100 -3910 {
lab=rowon_n[10]}
N 8080 -3930 8100 -3930 {
lab=row_n[10]}
N 7900 -3790 7900 -3780 {
lab=VSS}
N 7900 -4020 7900 -4010 {
lab=VDD}
N 8240 -3790 8250 -3800 {
lab=col_n[29]}
N 8250 -4000 8250 -3800 {
lab=col_n[29]}
N 8240 -4010 8250 -4000 {
lab=col_n[29]}
N 8240 -3790 8240 -3770 {
lab=col_n[29]}
N 8240 -4030 8240 -4010 {
lab=col_n[29]}
