C {devices/lab_wire.sym} 2440 -3520 0 0 {name=l1185 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2770 -3640 0 0 {name=x297}
C {devices/lab_wire.sym} 2700 -3760 2 1 {name=l1186 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2720 -3770 1 1 {name=l1187 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2760 -3770 3 0 {name=l1188 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2700 -3520 0 0 {name=l1189 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3030 -3640 0 0 {name=x298}
C {devices/lab_wire.sym} 2960 -3760 2 1 {name=l1190 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2980 -3770 1 1 {name=l1191 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3020 -3770 3 0 {name=l1192 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2960 -3520 0 0 {name=l1193 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3290 -3640 0 0 {name=x299}
C {devices/lab_wire.sym} 3220 -3760 2 1 {name=l1194 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3240 -3770 1 1 {name=l1195 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3280 -3770 3 0 {name=l1196 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3220 -3520 0 0 {name=l1197 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3550 -3640 0 0 {name=x300}
C {devices/lab_wire.sym} 3480 -3760 2 1 {name=l1198 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3500 -3770 1 1 {name=l1199 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3540 -3770 3 0 {name=l1200 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3480 -3520 0 0 {name=l1201 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3810 -3640 0 0 {name=x301}
C {devices/lab_wire.sym} 3740 -3760 2 1 {name=l1202 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3760 -3770 1 1 {name=l1203 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3800 -3770 3 0 {name=l1204 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3740 -3520 0 0 {name=l1205 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4070 -3640 0 0 {name=x302}
C {devices/lab_wire.sym} 4000 -3760 2 1 {name=l1206 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4020 -3770 1 1 {name=l1207 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4060 -3770 3 0 {name=l1208 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4000 -3520 0 0 {name=l1209 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4330 -3640 0 0 {name=x303}
C {devices/lab_wire.sym} 4260 -3760 2 1 {name=l1210 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4280 -3770 1 1 {name=l1211 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4320 -3770 3 0 {name=l1212 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4260 -3520 0 0 {name=l1213 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4590 -3640 0 0 {name=x304}
C {devices/lab_wire.sym} 4520 -3760 2 1 {name=l1214 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4540 -3770 1 1 {name=l1215 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4580 -3770 3 0 {name=l1216 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4520 -3520 0 0 {name=l1217 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4850 -3640 0 0 {name=x305}
C {devices/lab_wire.sym} 4780 -3760 2 1 {name=l1218 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4800 -3770 1 1 {name=l1219 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4840 -3770 3 0 {name=l1220 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4780 -3520 0 0 {name=l1221 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5110 -3640 0 0 {name=x306}
C {devices/lab_wire.sym} 5040 -3760 2 1 {name=l1222 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5060 -3770 1 1 {name=l1223 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5100 -3770 3 0 {name=l1224 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5040 -3520 0 0 {name=l1225 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5370 -3640 0 0 {name=x307}
C {devices/lab_wire.sym} 5300 -3760 2 1 {name=l1226 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5320 -3770 1 1 {name=l1227 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5360 -3770 3 0 {name=l1228 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5300 -3520 0 0 {name=l1229 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5630 -3640 0 0 {name=x308}
C {devices/lab_wire.sym} 5560 -3760 2 1 {name=l1230 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5580 -3770 1 1 {name=l1231 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5620 -3770 3 0 {name=l1232 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5560 -3520 0 0 {name=l1233 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5890 -3640 0 0 {name=x309}
C {devices/lab_wire.sym} 5820 -3760 2 1 {name=l1234 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5840 -3770 1 1 {name=l1235 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5880 -3770 3 0 {name=l1236 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5820 -3520 0 0 {name=l1237 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6150 -3640 0 0 {name=x310}
C {devices/lab_wire.sym} 6080 -3760 2 1 {name=l1238 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6100 -3770 1 1 {name=l1239 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6140 -3770 3 0 {name=l1240 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6080 -3520 0 0 {name=l1241 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6410 -3640 0 0 {name=x311}
C {devices/lab_wire.sym} 6340 -3760 2 1 {name=l1242 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6360 -3770 1 1 {name=l1243 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6400 -3770 3 0 {name=l1244 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6340 -3520 0 0 {name=l1245 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6670 -3640 0 0 {name=x312}
C {devices/lab_wire.sym} 6600 -3760 2 1 {name=l1246 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6620 -3770 1 1 {name=l1247 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6660 -3770 3 0 {name=l1248 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6600 -3520 0 0 {name=l1249 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6930 -3640 0 0 {name=x313}
C {devices/lab_wire.sym} 6860 -3760 2 1 {name=l1250 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6880 -3770 1 1 {name=l1251 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6920 -3770 3 0 {name=l1252 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6860 -3520 0 0 {name=l1253 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7190 -3640 0 0 {name=x314}
C {devices/lab_wire.sym} 7120 -3760 2 1 {name=l1254 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7140 -3770 1 1 {name=l1255 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7180 -3770 3 0 {name=l1256 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7120 -3520 0 0 {name=l1257 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7450 -3640 0 0 {name=x315}
C {devices/lab_wire.sym} 7380 -3760 2 1 {name=l1258 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7400 -3770 1 1 {name=l1259 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7440 -3770 3 0 {name=l1260 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7380 -3520 0 0 {name=l1261 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7710 -3640 0 0 {name=x316}
C {devices/lab_wire.sym} 7640 -3760 2 1 {name=l1262 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7660 -3770 1 1 {name=l1263 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7700 -3770 3 0 {name=l1264 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7640 -3520 0 0 {name=l1265 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7970 -3640 0 0 {name=x317}
C {devices/lab_wire.sym} 7900 -3760 2 1 {name=l1266 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7920 -3770 1 1 {name=l1267 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7960 -3770 3 0 {name=l1268 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7900 -3520 0 0 {name=l1269 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8230 -3640 0 0 {name=x318}
C {devices/lab_wire.sym} 8160 -3760 2 1 {name=l1270 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8180 -3770 1 1 {name=l1271 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8220 -3770 3 0 {name=l1272 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8160 -3520 0 0 {name=l1273 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8490 -3640 0 0 {name=x319}
C {devices/lab_wire.sym} 8420 -3760 2 1 {name=l1274 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8440 -3770 1 1 {name=l1275 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8480 -3770 3 0 {name=l1276 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8420 -3520 0 0 {name=l1277 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8750 -3640 0 0 {name=x320}
C {devices/lab_wire.sym} 8680 -3760 2 1 {name=l1278 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8700 -3770 1 1 {name=l1279 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8740 -3770 3 0 {name=l1280 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8680 -3520 0 0 {name=l1281 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 690 -3900 0 0 {name=x321}
C {devices/lab_wire.sym} 620 -4020 2 1 {name=l1282 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 640 -4030 1 1 {name=l1283 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 680 -4030 3 0 {name=l1284 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 620 -3780 0 0 {name=l1285 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 950 -3900 0 0 {name=x322}
C {devices/lab_wire.sym} 880 -4020 2 1 {name=l1286 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 900 -4030 1 1 {name=l1287 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 940 -4030 3 0 {name=l1288 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 880 -3780 0 0 {name=l1289 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1210 -3900 0 0 {name=x323}
C {devices/lab_wire.sym} 1140 -4020 2 1 {name=l1290 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1160 -4030 1 1 {name=l1291 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1200 -4030 3 0 {name=l1292 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1140 -3780 0 0 {name=l1293 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1470 -3900 0 0 {name=x324}
C {devices/lab_wire.sym} 1400 -4020 2 1 {name=l1294 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 -4030 1 1 {name=l1295 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1460 -4030 3 0 {name=l1296 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1400 -3780 0 0 {name=l1297 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1730 -3900 0 0 {name=x325}
C {devices/lab_wire.sym} 1660 -4020 2 1 {name=l1298 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1680 -4030 1 1 {name=l1299 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1720 -4030 3 0 {name=l1300 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1660 -3780 0 0 {name=l1301 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1990 -3900 0 0 {name=x326}
C {devices/lab_wire.sym} 1920 -4020 2 1 {name=l1302 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1940 -4030 1 1 {name=l1303 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1980 -4030 3 0 {name=l1304 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1920 -3780 0 0 {name=l1305 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2250 -3900 0 0 {name=x327}
C {devices/lab_wire.sym} 2180 -4020 2 1 {name=l1306 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2200 -4030 1 1 {name=l1307 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2240 -4030 3 0 {name=l1308 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2180 -3780 0 0 {name=l1309 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2510 -3900 0 0 {name=x328}
C {devices/lab_wire.sym} 2440 -4020 2 1 {name=l1310 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2460 -4030 1 1 {name=l1311 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2500 -4030 3 0 {name=l1312 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2440 -3780 0 0 {name=l1313 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2770 -3900 0 0 {name=x329}
C {devices/lab_wire.sym} 2700 -4020 2 1 {name=l1314 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2720 -4030 1 1 {name=l1315 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2760 -4030 3 0 {name=l1316 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2700 -3780 0 0 {name=l1317 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3030 -3900 0 0 {name=x330}
C {devices/lab_wire.sym} 2960 -4020 2 1 {name=l1318 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2980 -4030 1 1 {name=l1319 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3020 -4030 3 0 {name=l1320 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2960 -3780 0 0 {name=l1321 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3290 -3900 0 0 {name=x331}
C {devices/lab_wire.sym} 3220 -4020 2 1 {name=l1322 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3240 -4030 1 1 {name=l1323 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3280 -4030 3 0 {name=l1324 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3220 -3780 0 0 {name=l1325 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3550 -3900 0 0 {name=x332}
C {devices/lab_wire.sym} 3480 -4020 2 1 {name=l1326 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3500 -4030 1 1 {name=l1327 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3540 -4030 3 0 {name=l1328 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3480 -3780 0 0 {name=l1329 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3810 -3900 0 0 {name=x333}
C {devices/lab_wire.sym} 3740 -4020 2 1 {name=l1330 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3760 -4030 1 1 {name=l1331 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3800 -4030 3 0 {name=l1332 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3740 -3780 0 0 {name=l1333 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4070 -3900 0 0 {name=x334}
C {devices/lab_wire.sym} 4000 -4020 2 1 {name=l1334 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4020 -4030 1 1 {name=l1335 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4060 -4030 3 0 {name=l1336 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4000 -3780 0 0 {name=l1337 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4330 -3900 0 0 {name=x335}
C {devices/lab_wire.sym} 4260 -4020 2 1 {name=l1338 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4280 -4030 1 1 {name=l1339 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4320 -4030 3 0 {name=l1340 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4260 -3780 0 0 {name=l1341 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4590 -3900 0 0 {name=x336}
C {devices/lab_wire.sym} 4520 -4020 2 1 {name=l1342 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4540 -4030 1 1 {name=l1343 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4580 -4030 3 0 {name=l1344 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4520 -3780 0 0 {name=l1345 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4850 -3900 0 0 {name=x337}
C {devices/lab_wire.sym} 4780 -4020 2 1 {name=l1346 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4800 -4030 1 1 {name=l1347 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4840 -4030 3 0 {name=l1348 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4780 -3780 0 0 {name=l1349 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5110 -3900 0 0 {name=x338}
C {devices/lab_wire.sym} 5040 -4020 2 1 {name=l1350 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5060 -4030 1 1 {name=l1351 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5100 -4030 3 0 {name=l1352 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5040 -3780 0 0 {name=l1353 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5370 -3900 0 0 {name=x339}
C {devices/lab_wire.sym} 5300 -4020 2 1 {name=l1354 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5320 -4030 1 1 {name=l1355 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5360 -4030 3 0 {name=l1356 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5300 -3780 0 0 {name=l1357 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5630 -3900 0 0 {name=x340}
C {devices/lab_wire.sym} 5560 -4020 2 1 {name=l1358 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5580 -4030 1 1 {name=l1359 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5620 -4030 3 0 {name=l1360 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5560 -3780 0 0 {name=l1361 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5890 -3900 0 0 {name=x341}
C {devices/lab_wire.sym} 5820 -4020 2 1 {name=l1362 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5840 -4030 1 1 {name=l1363 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5880 -4030 3 0 {name=l1364 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5820 -3780 0 0 {name=l1365 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6150 -3900 0 0 {name=x342}
C {devices/lab_wire.sym} 6080 -4020 2 1 {name=l1366 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6100 -4030 1 1 {name=l1367 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6140 -4030 3 0 {name=l1368 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6080 -3780 0 0 {name=l1369 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6410 -3900 0 0 {name=x343}
C {devices/lab_wire.sym} 6340 -4020 2 1 {name=l1370 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6360 -4030 1 1 {name=l1371 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6400 -4030 3 0 {name=l1372 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6340 -3780 0 0 {name=l1373 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6670 -3900 0 0 {name=x344}
C {devices/lab_wire.sym} 6600 -4020 2 1 {name=l1374 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6620 -4030 1 1 {name=l1375 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6660 -4030 3 0 {name=l1376 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6600 -3780 0 0 {name=l1377 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6930 -3900 0 0 {name=x345}
C {devices/lab_wire.sym} 6860 -4020 2 1 {name=l1378 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6880 -4030 1 1 {name=l1379 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6920 -4030 3 0 {name=l1380 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6860 -3780 0 0 {name=l1381 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7190 -3900 0 0 {name=x346}
C {devices/lab_wire.sym} 7120 -4020 2 1 {name=l1382 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7140 -4030 1 1 {name=l1383 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7180 -4030 3 0 {name=l1384 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7120 -3780 0 0 {name=l1385 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7450 -3900 0 0 {name=x347}
C {devices/lab_wire.sym} 7380 -4020 2 1 {name=l1386 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7400 -4030 1 1 {name=l1387 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7440 -4030 3 0 {name=l1388 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7380 -3780 0 0 {name=l1389 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7710 -3900 0 0 {name=x348}
C {devices/lab_wire.sym} 7640 -4020 2 1 {name=l1390 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7660 -4030 1 1 {name=l1391 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7700 -4030 3 0 {name=l1392 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7640 -3780 0 0 {name=l1393 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7970 -3900 0 0 {name=x349}
C {devices/lab_wire.sym} 7900 -4020 2 1 {name=l1394 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7920 -4030 1 1 {name=l1395 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7960 -4030 3 0 {name=l1396 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7900 -3780 0 0 {name=l1397 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8230 -3900 0 0 {name=x350}
C {devices/lab_wire.sym} 8160 -4020 2 1 {name=l1398 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8180 -4030 1 1 {name=l1399 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8220 -4030 3 0 {name=l1400 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8160 -3780 0 0 {name=l1401 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8490 -3900 0 0 {name=x351}
C {devices/lab_wire.sym} 8420 -4020 2 1 {name=l1402 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8440 -4030 1 1 {name=l1403 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8480 -4030 3 0 {name=l1404 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8420 -3780 0 0 {name=l1405 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8750 -3900 0 0 {name=x352}
C {devices/lab_wire.sym} 8680 -4020 2 1 {name=l1406 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8700 -4030 1 1 {name=l1407 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8740 -4030 3 0 {name=l1408 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8680 -3780 0 0 {name=l1409 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 690 -4160 0 0 {name=x353}
C {devices/lab_wire.sym} 620 -4280 2 1 {name=l1410 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 640 -4290 1 1 {name=l1411 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 680 -4290 3 0 {name=l1412 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 620 -4040 0 0 {name=l1413 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 950 -4160 0 0 {name=x354}
C {devices/lab_wire.sym} 880 -4280 2 1 {name=l1414 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 900 -4290 1 1 {name=l1415 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 940 -4290 3 0 {name=l1416 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 880 -4040 0 0 {name=l1417 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1210 -4160 0 0 {name=x355}
C {devices/lab_wire.sym} 1140 -4280 2 1 {name=l1418 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1160 -4290 1 1 {name=l1419 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1200 -4290 3 0 {name=l1420 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1140 -4040 0 0 {name=l1421 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1470 -4160 0 0 {name=x356}
C {devices/lab_wire.sym} 1400 -4280 2 1 {name=l1422 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 -4290 1 1 {name=l1423 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1460 -4290 3 0 {name=l1424 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1400 -4040 0 0 {name=l1425 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1730 -4160 0 0 {name=x357}
C {devices/lab_wire.sym} 1660 -4280 2 1 {name=l1426 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1680 -4290 1 1 {name=l1427 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1720 -4290 3 0 {name=l1428 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1660 -4040 0 0 {name=l1429 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1990 -4160 0 0 {name=x358}
C {devices/lab_wire.sym} 1920 -4280 2 1 {name=l1430 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1940 -4290 1 1 {name=l1431 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1980 -4290 3 0 {name=l1432 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1920 -4040 0 0 {name=l1433 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2250 -4160 0 0 {name=x359}
C {devices/lab_wire.sym} 2180 -4280 2 1 {name=l1434 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2200 -4290 1 1 {name=l1435 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2240 -4290 3 0 {name=l1436 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2180 -4040 0 0 {name=l1437 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2510 -4160 0 0 {name=x360}
C {devices/lab_wire.sym} 2440 -4280 2 1 {name=l1438 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2460 -4290 1 1 {name=l1439 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2500 -4290 3 0 {name=l1440 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2440 -4040 0 0 {name=l1441 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2770 -4160 0 0 {name=x361}
C {devices/lab_wire.sym} 2700 -4280 2 1 {name=l1442 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2720 -4290 1 1 {name=l1443 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2760 -4290 3 0 {name=l1444 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2700 -4040 0 0 {name=l1445 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3030 -4160 0 0 {name=x362}
C {devices/lab_wire.sym} 2960 -4280 2 1 {name=l1446 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2980 -4290 1 1 {name=l1447 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3020 -4290 3 0 {name=l1448 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2960 -4040 0 0 {name=l1449 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3290 -4160 0 0 {name=x363}
C {devices/lab_wire.sym} 3220 -4280 2 1 {name=l1450 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3240 -4290 1 1 {name=l1451 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3280 -4290 3 0 {name=l1452 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3220 -4040 0 0 {name=l1453 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3550 -4160 0 0 {name=x364}
C {devices/lab_wire.sym} 3480 -4280 2 1 {name=l1454 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3500 -4290 1 1 {name=l1455 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3540 -4290 3 0 {name=l1456 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3480 -4040 0 0 {name=l1457 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3810 -4160 0 0 {name=x365}
C {devices/lab_wire.sym} 3740 -4280 2 1 {name=l1458 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3760 -4290 1 1 {name=l1459 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3800 -4290 3 0 {name=l1460 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3740 -4040 0 0 {name=l1461 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4070 -4160 0 0 {name=x366}
C {devices/lab_wire.sym} 4000 -4280 2 1 {name=l1462 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4020 -4290 1 1 {name=l1463 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4060 -4290 3 0 {name=l1464 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4000 -4040 0 0 {name=l1465 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4330 -4160 0 0 {name=x367}
C {devices/lab_wire.sym} 4260 -4280 2 1 {name=l1466 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4280 -4290 1 1 {name=l1467 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4320 -4290 3 0 {name=l1468 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4260 -4040 0 0 {name=l1469 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4590 -4160 0 0 {name=x368}
C {devices/lab_wire.sym} 4520 -4280 2 1 {name=l1470 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4540 -4290 1 1 {name=l1471 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4580 -4290 3 0 {name=l1472 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4520 -4040 0 0 {name=l1473 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4850 -4160 0 0 {name=x369}
C {devices/lab_wire.sym} 4780 -4280 2 1 {name=l1474 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4800 -4290 1 1 {name=l1475 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4840 -4290 3 0 {name=l1476 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4780 -4040 0 0 {name=l1477 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5110 -4160 0 0 {name=x370}
C {devices/lab_wire.sym} 5040 -4280 2 1 {name=l1478 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5060 -4290 1 1 {name=l1479 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5100 -4290 3 0 {name=l1480 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5040 -4040 0 0 {name=l1481 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5370 -4160 0 0 {name=x371}
C {devices/lab_wire.sym} 5300 -4280 2 1 {name=l1482 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5320 -4290 1 1 {name=l1483 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5360 -4290 3 0 {name=l1484 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5300 -4040 0 0 {name=l1485 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5630 -4160 0 0 {name=x372}
C {devices/lab_wire.sym} 5560 -4280 2 1 {name=l1486 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5580 -4290 1 1 {name=l1487 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5620 -4290 3 0 {name=l1488 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5560 -4040 0 0 {name=l1489 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5890 -4160 0 0 {name=x373}
C {devices/lab_wire.sym} 5820 -4280 2 1 {name=l1490 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5840 -4290 1 1 {name=l1491 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5880 -4290 3 0 {name=l1492 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5820 -4040 0 0 {name=l1493 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6150 -4160 0 0 {name=x374}
C {devices/lab_wire.sym} 6080 -4280 2 1 {name=l1494 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6100 -4290 1 1 {name=l1495 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6140 -4290 3 0 {name=l1496 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6080 -4040 0 0 {name=l1497 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6410 -4160 0 0 {name=x375}
C {devices/lab_wire.sym} 6340 -4280 2 1 {name=l1498 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6360 -4290 1 1 {name=l1499 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6400 -4290 3 0 {name=l1500 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6340 -4040 0 0 {name=l1501 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6670 -4160 0 0 {name=x376}
C {devices/lab_wire.sym} 6600 -4280 2 1 {name=l1502 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6620 -4290 1 1 {name=l1503 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6660 -4290 3 0 {name=l1504 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6600 -4040 0 0 {name=l1505 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6930 -4160 0 0 {name=x377}
C {devices/lab_wire.sym} 6860 -4280 2 1 {name=l1506 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6880 -4290 1 1 {name=l1507 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6920 -4290 3 0 {name=l1508 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6860 -4040 0 0 {name=l1509 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7190 -4160 0 0 {name=x378}
C {devices/lab_wire.sym} 7120 -4280 2 1 {name=l1510 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7140 -4290 1 1 {name=l1511 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7180 -4290 3 0 {name=l1512 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7120 -4040 0 0 {name=l1513 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7450 -4160 0 0 {name=x379}
C {devices/lab_wire.sym} 7380 -4280 2 1 {name=l1514 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7400 -4290 1 1 {name=l1515 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7440 -4290 3 0 {name=l1516 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7380 -4040 0 0 {name=l1517 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7710 -4160 0 0 {name=x380}
C {devices/lab_wire.sym} 7640 -4280 2 1 {name=l1518 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7660 -4290 1 1 {name=l1519 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7700 -4290 3 0 {name=l1520 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7640 -4040 0 0 {name=l1521 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7970 -4160 0 0 {name=x381}
C {devices/lab_wire.sym} 7900 -4280 2 1 {name=l1522 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7920 -4290 1 1 {name=l1523 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7960 -4290 3 0 {name=l1524 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7900 -4040 0 0 {name=l1525 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8230 -4160 0 0 {name=x382}
C {devices/lab_wire.sym} 8160 -4280 2 1 {name=l1526 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8180 -4290 1 1 {name=l1527 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8220 -4290 3 0 {name=l1528 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8160 -4040 0 0 {name=l1529 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8490 -4160 0 0 {name=x383}
C {devices/lab_wire.sym} 8420 -4280 2 1 {name=l1530 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8440 -4290 1 1 {name=l1531 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8480 -4290 3 0 {name=l1532 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8420 -4040 0 0 {name=l1533 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8750 -4160 0 0 {name=x384}
C {devices/lab_wire.sym} 8680 -4280 2 1 {name=l1534 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8700 -4290 1 1 {name=l1535 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8740 -4290 3 0 {name=l1536 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8680 -4040 0 0 {name=l1537 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 690 -4420 0 0 {name=x385}
C {devices/lab_wire.sym} 620 -4540 2 1 {name=l1538 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 640 -4550 1 1 {name=l1539 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 680 -4550 3 0 {name=l1540 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 620 -4300 0 0 {name=l1541 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 950 -4420 0 0 {name=x386}
C {devices/lab_wire.sym} 880 -4540 2 1 {name=l1542 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 900 -4550 1 1 {name=l1543 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 940 -4550 3 0 {name=l1544 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 880 -4300 0 0 {name=l1545 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1210 -4420 0 0 {name=x387}
C {devices/lab_wire.sym} 1140 -4540 2 1 {name=l1546 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1160 -4550 1 1 {name=l1547 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1200 -4550 3 0 {name=l1548 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1140 -4300 0 0 {name=l1549 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1470 -4420 0 0 {name=x388}
C {devices/lab_wire.sym} 1400 -4540 2 1 {name=l1550 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 -4550 1 1 {name=l1551 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1460 -4550 3 0 {name=l1552 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1400 -4300 0 0 {name=l1553 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1730 -4420 0 0 {name=x389}
C {devices/lab_wire.sym} 1660 -4540 2 1 {name=l1554 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1680 -4550 1 1 {name=l1555 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1720 -4550 3 0 {name=l1556 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1660 -4300 0 0 {name=l1557 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1990 -4420 0 0 {name=x390}
C {devices/lab_wire.sym} 1920 -4540 2 1 {name=l1558 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1940 -4550 1 1 {name=l1559 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1980 -4550 3 0 {name=l1560 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1920 -4300 0 0 {name=l1561 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2250 -4420 0 0 {name=x391}
C {devices/lab_wire.sym} 2180 -4540 2 1 {name=l1562 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2200 -4550 1 1 {name=l1563 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2240 -4550 3 0 {name=l1564 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2180 -4300 0 0 {name=l1565 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2510 -4420 0 0 {name=x392}
C {devices/lab_wire.sym} 2440 -4540 2 1 {name=l1566 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2460 -4550 1 1 {name=l1567 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2500 -4550 3 0 {name=l1568 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2440 -4300 0 0 {name=l1569 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2770 -4420 0 0 {name=x393}
C {devices/lab_wire.sym} 2700 -4540 2 1 {name=l1570 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2720 -4550 1 1 {name=l1571 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2760 -4550 3 0 {name=l1572 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2700 -4300 0 0 {name=l1573 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3030 -4420 0 0 {name=x394}
C {devices/lab_wire.sym} 2960 -4540 2 1 {name=l1574 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2980 -4550 1 1 {name=l1575 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3020 -4550 3 0 {name=l1576 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2960 -4300 0 0 {name=l1577 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3290 -4420 0 0 {name=x395}
C {devices/lab_wire.sym} 3220 -4540 2 1 {name=l1578 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3240 -4550 1 1 {name=l1579 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3280 -4550 3 0 {name=l1580 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3220 -4300 0 0 {name=l1581 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3550 -4420 0 0 {name=x396}
C {devices/lab_wire.sym} 3480 -4540 2 1 {name=l1582 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3500 -4550 1 1 {name=l1583 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3540 -4550 3 0 {name=l1584 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3480 -4300 0 0 {name=l1585 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3810 -4420 0 0 {name=x397}
C {devices/lab_wire.sym} 3740 -4540 2 1 {name=l1586 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3760 -4550 1 1 {name=l1587 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3800 -4550 3 0 {name=l1588 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3740 -4300 0 0 {name=l1589 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4070 -4420 0 0 {name=x398}
C {devices/lab_wire.sym} 4000 -4540 2 1 {name=l1590 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4020 -4550 1 1 {name=l1591 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4060 -4550 3 0 {name=l1592 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4000 -4300 0 0 {name=l1593 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4330 -4420 0 0 {name=x399}
C {devices/lab_wire.sym} 4260 -4540 2 1 {name=l1594 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4280 -4550 1 1 {name=l1595 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4320 -4550 3 0 {name=l1596 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4260 -4300 0 0 {name=l1597 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4590 -4420 0 0 {name=x400}
C {devices/lab_wire.sym} 4520 -4540 2 1 {name=l1598 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4540 -4550 1 1 {name=l1599 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4580 -4550 3 0 {name=l1600 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4520 -4300 0 0 {name=l1601 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4850 -4420 0 0 {name=x401}
C {devices/lab_wire.sym} 4780 -4540 2 1 {name=l1602 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4800 -4550 1 1 {name=l1603 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4840 -4550 3 0 {name=l1604 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4780 -4300 0 0 {name=l1605 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5110 -4420 0 0 {name=x402}
C {devices/lab_wire.sym} 5040 -4540 2 1 {name=l1606 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5060 -4550 1 1 {name=l1607 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5100 -4550 3 0 {name=l1608 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5040 -4300 0 0 {name=l1609 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5370 -4420 0 0 {name=x403}
C {devices/lab_wire.sym} 5300 -4540 2 1 {name=l1610 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5320 -4550 1 1 {name=l1611 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5360 -4550 3 0 {name=l1612 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5300 -4300 0 0 {name=l1613 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5630 -4420 0 0 {name=x404}
C {devices/lab_wire.sym} 5560 -4540 2 1 {name=l1614 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5580 -4550 1 1 {name=l1615 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5620 -4550 3 0 {name=l1616 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5560 -4300 0 0 {name=l1617 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5890 -4420 0 0 {name=x405}
C {devices/lab_wire.sym} 5820 -4540 2 1 {name=l1618 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5840 -4550 1 1 {name=l1619 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5880 -4550 3 0 {name=l1620 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5820 -4300 0 0 {name=l1621 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6150 -4420 0 0 {name=x406}
C {devices/lab_wire.sym} 6080 -4540 2 1 {name=l1622 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6100 -4550 1 1 {name=l1623 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6140 -4550 3 0 {name=l1624 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6080 -4300 0 0 {name=l1625 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6410 -4420 0 0 {name=x407}
C {devices/lab_wire.sym} 6340 -4540 2 1 {name=l1626 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6360 -4550 1 1 {name=l1627 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6400 -4550 3 0 {name=l1628 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6340 -4300 0 0 {name=l1629 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6670 -4420 0 0 {name=x408}
C {devices/lab_wire.sym} 6600 -4540 2 1 {name=l1630 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6620 -4550 1 1 {name=l1631 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6660 -4550 3 0 {name=l1632 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6600 -4300 0 0 {name=l1633 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6930 -4420 0 0 {name=x409}
C {devices/lab_wire.sym} 6860 -4540 2 1 {name=l1634 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6880 -4550 1 1 {name=l1635 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6920 -4550 3 0 {name=l1636 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6860 -4300 0 0 {name=l1637 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7190 -4420 0 0 {name=x410}
C {devices/lab_wire.sym} 7120 -4540 2 1 {name=l1638 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7140 -4550 1 1 {name=l1639 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7180 -4550 3 0 {name=l1640 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7120 -4300 0 0 {name=l1641 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7450 -4420 0 0 {name=x411}
C {devices/lab_wire.sym} 7380 -4540 2 1 {name=l1642 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7400 -4550 1 1 {name=l1643 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7440 -4550 3 0 {name=l1644 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7380 -4300 0 0 {name=l1645 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7710 -4420 0 0 {name=x412}
C {devices/lab_wire.sym} 7640 -4540 2 1 {name=l1646 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7660 -4550 1 1 {name=l1647 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7700 -4550 3 0 {name=l1648 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7640 -4300 0 0 {name=l1649 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7970 -4420 0 0 {name=x413}
C {devices/lab_wire.sym} 7900 -4540 2 1 {name=l1650 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7920 -4550 1 1 {name=l1651 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7960 -4550 3 0 {name=l1652 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7900 -4300 0 0 {name=l1653 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8230 -4420 0 0 {name=x414}
C {devices/lab_wire.sym} 8160 -4540 2 1 {name=l1654 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8180 -4550 1 1 {name=l1655 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8220 -4550 3 0 {name=l1656 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8160 -4300 0 0 {name=l1657 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8490 -4420 0 0 {name=x415}
C {devices/lab_wire.sym} 8420 -4540 2 1 {name=l1658 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8440 -4550 1 1 {name=l1659 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8480 -4550 3 0 {name=l1660 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8420 -4300 0 0 {name=l1661 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8750 -4420 0 0 {name=x416}
C {devices/lab_wire.sym} 8680 -4540 2 1 {name=l1662 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8700 -4550 1 1 {name=l1663 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8740 -4550 3 0 {name=l1664 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8680 -4300 0 0 {name=l1665 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 690 -4680 0 0 {name=x417}
C {devices/lab_wire.sym} 620 -4800 2 1 {name=l1666 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 640 -4810 1 1 {name=l1667 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 680 -4810 3 0 {name=l1668 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 620 -4560 0 0 {name=l1669 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 950 -4680 0 0 {name=x418}
C {devices/lab_wire.sym} 880 -4800 2 1 {name=l1670 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 900 -4810 1 1 {name=l1671 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 940 -4810 3 0 {name=l1672 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 880 -4560 0 0 {name=l1673 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1210 -4680 0 0 {name=x419}
C {devices/lab_wire.sym} 1140 -4800 2 1 {name=l1674 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1160 -4810 1 1 {name=l1675 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1200 -4810 3 0 {name=l1676 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1140 -4560 0 0 {name=l1677 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1470 -4680 0 0 {name=x420}
C {devices/lab_wire.sym} 1400 -4800 2 1 {name=l1678 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 -4810 1 1 {name=l1679 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1460 -4810 3 0 {name=l1680 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1400 -4560 0 0 {name=l1681 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1730 -4680 0 0 {name=x421}
C {devices/lab_wire.sym} 1660 -4800 2 1 {name=l1682 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1680 -4810 1 1 {name=l1683 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1720 -4810 3 0 {name=l1684 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1660 -4560 0 0 {name=l1685 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1990 -4680 0 0 {name=x422}
C {devices/lab_wire.sym} 1920 -4800 2 1 {name=l1686 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1940 -4810 1 1 {name=l1687 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1980 -4810 3 0 {name=l1688 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1920 -4560 0 0 {name=l1689 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2250 -4680 0 0 {name=x423}
C {devices/lab_wire.sym} 2180 -4800 2 1 {name=l1690 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2200 -4810 1 1 {name=l1691 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2240 -4810 3 0 {name=l1692 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2180 -4560 0 0 {name=l1693 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2510 -4680 0 0 {name=x424}
C {devices/lab_wire.sym} 2440 -4800 2 1 {name=l1694 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2460 -4810 1 1 {name=l1695 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2500 -4810 3 0 {name=l1696 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2440 -4560 0 0 {name=l1697 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2770 -4680 0 0 {name=x425}
C {devices/lab_wire.sym} 2700 -4800 2 1 {name=l1698 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2720 -4810 1 1 {name=l1699 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2760 -4810 3 0 {name=l1700 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2700 -4560 0 0 {name=l1701 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3030 -4680 0 0 {name=x426}
C {devices/lab_wire.sym} 2960 -4800 2 1 {name=l1702 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2980 -4810 1 1 {name=l1703 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3020 -4810 3 0 {name=l1704 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2960 -4560 0 0 {name=l1705 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3290 -4680 0 0 {name=x427}
C {devices/lab_wire.sym} 3220 -4800 2 1 {name=l1706 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3240 -4810 1 1 {name=l1707 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3280 -4810 3 0 {name=l1708 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3220 -4560 0 0 {name=l1709 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3550 -4680 0 0 {name=x428}
C {devices/lab_wire.sym} 3480 -4800 2 1 {name=l1710 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3500 -4810 1 1 {name=l1711 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3540 -4810 3 0 {name=l1712 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3480 -4560 0 0 {name=l1713 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3810 -4680 0 0 {name=x429}
C {devices/lab_wire.sym} 3740 -4800 2 1 {name=l1714 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3760 -4810 1 1 {name=l1715 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3800 -4810 3 0 {name=l1716 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3740 -4560 0 0 {name=l1717 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4070 -4680 0 0 {name=x430}
C {devices/lab_wire.sym} 4000 -4800 2 1 {name=l1718 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4020 -4810 1 1 {name=l1719 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4060 -4810 3 0 {name=l1720 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4000 -4560 0 0 {name=l1721 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4330 -4680 0 0 {name=x431}
C {devices/lab_wire.sym} 4260 -4800 2 1 {name=l1722 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4280 -4810 1 1 {name=l1723 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4320 -4810 3 0 {name=l1724 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4260 -4560 0 0 {name=l1725 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4590 -4680 0 0 {name=x432}
C {devices/lab_wire.sym} 4520 -4800 2 1 {name=l1726 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4540 -4810 1 1 {name=l1727 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4580 -4810 3 0 {name=l1728 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4520 -4560 0 0 {name=l1729 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4850 -4680 0 0 {name=x433}
C {devices/lab_wire.sym} 4780 -4800 2 1 {name=l1730 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4800 -4810 1 1 {name=l1731 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4840 -4810 3 0 {name=l1732 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4780 -4560 0 0 {name=l1733 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5110 -4680 0 0 {name=x434}
C {devices/lab_wire.sym} 5040 -4800 2 1 {name=l1734 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5060 -4810 1 1 {name=l1735 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5100 -4810 3 0 {name=l1736 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5040 -4560 0 0 {name=l1737 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5370 -4680 0 0 {name=x435}
C {devices/lab_wire.sym} 5300 -4800 2 1 {name=l1738 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5320 -4810 1 1 {name=l1739 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5360 -4810 3 0 {name=l1740 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5300 -4560 0 0 {name=l1741 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5630 -4680 0 0 {name=x436}
C {devices/lab_wire.sym} 5560 -4800 2 1 {name=l1742 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5580 -4810 1 1 {name=l1743 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5620 -4810 3 0 {name=l1744 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5560 -4560 0 0 {name=l1745 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5890 -4680 0 0 {name=x437}
C {devices/lab_wire.sym} 5820 -4800 2 1 {name=l1746 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5840 -4810 1 1 {name=l1747 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5880 -4810 3 0 {name=l1748 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5820 -4560 0 0 {name=l1749 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6150 -4680 0 0 {name=x438}
C {devices/lab_wire.sym} 6080 -4800 2 1 {name=l1750 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6100 -4810 1 1 {name=l1751 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6140 -4810 3 0 {name=l1752 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6080 -4560 0 0 {name=l1753 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6410 -4680 0 0 {name=x439}
C {devices/lab_wire.sym} 6340 -4800 2 1 {name=l1754 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6360 -4810 1 1 {name=l1755 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6400 -4810 3 0 {name=l1756 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6340 -4560 0 0 {name=l1757 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6670 -4680 0 0 {name=x440}
C {devices/lab_wire.sym} 6600 -4800 2 1 {name=l1758 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6620 -4810 1 1 {name=l1759 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6660 -4810 3 0 {name=l1760 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6600 -4560 0 0 {name=l1761 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6930 -4680 0 0 {name=x441}
C {devices/lab_wire.sym} 6860 -4800 2 1 {name=l1762 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6880 -4810 1 1 {name=l1763 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6920 -4810 3 0 {name=l1764 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6860 -4560 0 0 {name=l1765 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7190 -4680 0 0 {name=x442}
C {devices/lab_wire.sym} 7120 -4800 2 1 {name=l1766 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7140 -4810 1 1 {name=l1767 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7180 -4810 3 0 {name=l1768 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7120 -4560 0 0 {name=l1769 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7450 -4680 0 0 {name=x443}
C {devices/lab_wire.sym} 7380 -4800 2 1 {name=l1770 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7400 -4810 1 1 {name=l1771 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7440 -4810 3 0 {name=l1772 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7380 -4560 0 0 {name=l1773 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7710 -4680 0 0 {name=x444}
C {devices/lab_wire.sym} 7640 -4800 2 1 {name=l1774 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7660 -4810 1 1 {name=l1775 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7700 -4810 3 0 {name=l1776 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7640 -4560 0 0 {name=l1777 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7970 -4680 0 0 {name=x445}
C {devices/lab_wire.sym} 7900 -4800 2 1 {name=l1778 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7920 -4810 1 1 {name=l1779 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7960 -4810 3 0 {name=l1780 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7900 -4560 0 0 {name=l1781 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8230 -4680 0 0 {name=x446}
C {devices/lab_wire.sym} 8160 -4800 2 1 {name=l1782 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8180 -4810 1 1 {name=l1783 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8220 -4810 3 0 {name=l1784 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8160 -4560 0 0 {name=l1785 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8490 -4680 0 0 {name=x447}
C {devices/lab_wire.sym} 8420 -4800 2 1 {name=l1786 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8440 -4810 1 1 {name=l1787 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8480 -4810 3 0 {name=l1788 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8420 -4560 0 0 {name=l1789 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8750 -4680 0 0 {name=x448}
C {devices/lab_wire.sym} 8680 -4800 2 1 {name=l1790 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8700 -4810 1 1 {name=l1791 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8740 -4810 3 0 {name=l1792 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8680 -4560 0 0 {name=l1793 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 690 -4940 0 0 {name=x449}
C {devices/lab_wire.sym} 620 -5060 2 1 {name=l1794 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 640 -5070 1 1 {name=l1795 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 680 -5070 3 0 {name=l1796 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 620 -4820 0 0 {name=l1797 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 950 -4940 0 0 {name=x450}
C {devices/lab_wire.sym} 880 -5060 2 1 {name=l1798 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 900 -5070 1 1 {name=l1799 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 940 -5070 3 0 {name=l1800 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 880 -4820 0 0 {name=l1801 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1210 -4940 0 0 {name=x451}
C {devices/lab_wire.sym} 1140 -5060 2 1 {name=l1802 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1160 -5070 1 1 {name=l1803 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1200 -5070 3 0 {name=l1804 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1140 -4820 0 0 {name=l1805 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1470 -4940 0 0 {name=x452}
C {devices/lab_wire.sym} 1400 -5060 2 1 {name=l1806 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 -5070 1 1 {name=l1807 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1460 -5070 3 0 {name=l1808 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1400 -4820 0 0 {name=l1809 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1730 -4940 0 0 {name=x453}
C {devices/lab_wire.sym} 1660 -5060 2 1 {name=l1810 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1680 -5070 1 1 {name=l1811 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1720 -5070 3 0 {name=l1812 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1660 -4820 0 0 {name=l1813 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1990 -4940 0 0 {name=x454}
C {devices/lab_wire.sym} 1920 -5060 2 1 {name=l1814 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1940 -5070 1 1 {name=l1815 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1980 -5070 3 0 {name=l1816 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1920 -4820 0 0 {name=l1817 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2250 -4940 0 0 {name=x455}
C {devices/lab_wire.sym} 2180 -5060 2 1 {name=l1818 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2200 -5070 1 1 {name=l1819 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2240 -5070 3 0 {name=l1820 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2180 -4820 0 0 {name=l1821 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2510 -4940 0 0 {name=x456}
C {devices/lab_wire.sym} 2440 -5060 2 1 {name=l1822 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2460 -5070 1 1 {name=l1823 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2500 -5070 3 0 {name=l1824 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2440 -4820 0 0 {name=l1825 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2770 -4940 0 0 {name=x457}
C {devices/lab_wire.sym} 2700 -5060 2 1 {name=l1826 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2720 -5070 1 1 {name=l1827 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2760 -5070 3 0 {name=l1828 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2700 -4820 0 0 {name=l1829 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3030 -4940 0 0 {name=x458}
C {devices/lab_wire.sym} 2960 -5060 2 1 {name=l1830 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2980 -5070 1 1 {name=l1831 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3020 -5070 3 0 {name=l1832 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2960 -4820 0 0 {name=l1833 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3290 -4940 0 0 {name=x459}
C {devices/lab_wire.sym} 3220 -5060 2 1 {name=l1834 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3240 -5070 1 1 {name=l1835 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3280 -5070 3 0 {name=l1836 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3220 -4820 0 0 {name=l1837 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3550 -4940 0 0 {name=x460}
C {devices/lab_wire.sym} 3480 -5060 2 1 {name=l1838 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3500 -5070 1 1 {name=l1839 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3540 -5070 3 0 {name=l1840 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3480 -4820 0 0 {name=l1841 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3810 -4940 0 0 {name=x461}
C {devices/lab_wire.sym} 3740 -5060 2 1 {name=l1842 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3760 -5070 1 1 {name=l1843 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3800 -5070 3 0 {name=l1844 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3740 -4820 0 0 {name=l1845 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4070 -4940 0 0 {name=x462}
C {devices/lab_wire.sym} 4000 -5060 2 1 {name=l1846 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4020 -5070 1 1 {name=l1847 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4060 -5070 3 0 {name=l1848 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4000 -4820 0 0 {name=l1849 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4330 -4940 0 0 {name=x463}
C {devices/lab_wire.sym} 4260 -5060 2 1 {name=l1850 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4280 -5070 1 1 {name=l1851 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4320 -5070 3 0 {name=l1852 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4260 -4820 0 0 {name=l1853 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4590 -4940 0 0 {name=x464}
C {devices/lab_wire.sym} 4520 -5060 2 1 {name=l1854 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4540 -5070 1 1 {name=l1855 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4580 -5070 3 0 {name=l1856 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4520 -4820 0 0 {name=l1857 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4850 -4940 0 0 {name=x465}
C {devices/lab_wire.sym} 4780 -5060 2 1 {name=l1858 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4800 -5070 1 1 {name=l1859 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4840 -5070 3 0 {name=l1860 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4780 -4820 0 0 {name=l1861 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5110 -4940 0 0 {name=x466}
C {devices/lab_wire.sym} 5040 -5060 2 1 {name=l1862 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5060 -5070 1 1 {name=l1863 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5100 -5070 3 0 {name=l1864 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5040 -4820 0 0 {name=l1865 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5370 -4940 0 0 {name=x467}
C {devices/lab_wire.sym} 5300 -5060 2 1 {name=l1866 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5320 -5070 1 1 {name=l1867 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5360 -5070 3 0 {name=l1868 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5300 -4820 0 0 {name=l1869 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5630 -4940 0 0 {name=x468}
C {devices/lab_wire.sym} 5560 -5060 2 1 {name=l1870 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5580 -5070 1 1 {name=l1871 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5620 -5070 3 0 {name=l1872 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5560 -4820 0 0 {name=l1873 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5890 -4940 0 0 {name=x469}
C {devices/lab_wire.sym} 5820 -5060 2 1 {name=l1874 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5840 -5070 1 1 {name=l1875 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5880 -5070 3 0 {name=l1876 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5820 -4820 0 0 {name=l1877 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6150 -4940 0 0 {name=x470}
C {devices/lab_wire.sym} 6080 -5060 2 1 {name=l1878 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6100 -5070 1 1 {name=l1879 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6140 -5070 3 0 {name=l1880 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6080 -4820 0 0 {name=l1881 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6410 -4940 0 0 {name=x471}
C {devices/lab_wire.sym} 6340 -5060 2 1 {name=l1882 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6360 -5070 1 1 {name=l1883 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6400 -5070 3 0 {name=l1884 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6340 -4820 0 0 {name=l1885 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6670 -4940 0 0 {name=x472}
C {devices/lab_wire.sym} 6600 -5060 2 1 {name=l1886 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6620 -5070 1 1 {name=l1887 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6660 -5070 3 0 {name=l1888 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6600 -4820 0 0 {name=l1889 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6930 -4940 0 0 {name=x473}
C {devices/lab_wire.sym} 6860 -5060 2 1 {name=l1890 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6880 -5070 1 1 {name=l1891 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6920 -5070 3 0 {name=l1892 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6860 -4820 0 0 {name=l1893 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7190 -4940 0 0 {name=x474}
C {devices/lab_wire.sym} 7120 -5060 2 1 {name=l1894 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7140 -5070 1 1 {name=l1895 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7180 -5070 3 0 {name=l1896 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7120 -4820 0 0 {name=l1897 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7450 -4940 0 0 {name=x475}
C {devices/lab_wire.sym} 7380 -5060 2 1 {name=l1898 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7400 -5070 1 1 {name=l1899 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7440 -5070 3 0 {name=l1900 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7380 -4820 0 0 {name=l1901 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7710 -4940 0 0 {name=x476}
C {devices/lab_wire.sym} 7640 -5060 2 1 {name=l1902 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7660 -5070 1 1 {name=l1903 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7700 -5070 3 0 {name=l1904 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7640 -4820 0 0 {name=l1905 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7970 -4940 0 0 {name=x477}
C {devices/lab_wire.sym} 7900 -5060 2 1 {name=l1906 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7920 -5070 1 1 {name=l1907 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7960 -5070 3 0 {name=l1908 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7900 -4820 0 0 {name=l1909 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8230 -4940 0 0 {name=x478}
C {devices/lab_wire.sym} 8160 -5060 2 1 {name=l1910 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8180 -5070 1 1 {name=l1911 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8220 -5070 3 0 {name=l1912 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8160 -4820 0 0 {name=l1913 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8490 -4940 0 0 {name=x479}
C {devices/lab_wire.sym} 8420 -5060 2 1 {name=l1914 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8440 -5070 1 1 {name=l1915 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8480 -5070 3 0 {name=l1916 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8420 -4820 0 0 {name=l1917 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8750 -4940 0 0 {name=x480}
C {devices/lab_wire.sym} 8680 -5060 2 1 {name=l1918 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8700 -5070 1 1 {name=l1919 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8740 -5070 3 0 {name=l1920 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8680 -4820 0 0 {name=l1921 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 690 -5200 0 0 {name=x481}
C {devices/lab_wire.sym} 620 -5320 2 1 {name=l1922 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 640 -5330 1 1 {name=l1923 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 680 -5330 3 0 {name=l1924 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 620 -5080 0 0 {name=l1925 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 950 -5200 0 0 {name=x482}
C {devices/lab_wire.sym} 880 -5320 2 1 {name=l1926 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 900 -5330 1 1 {name=l1927 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 940 -5330 3 0 {name=l1928 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 880 -5080 0 0 {name=l1929 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1210 -5200 0 0 {name=x483}
C {devices/lab_wire.sym} 1140 -5320 2 1 {name=l1930 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1160 -5330 1 1 {name=l1931 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1200 -5330 3 0 {name=l1932 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1140 -5080 0 0 {name=l1933 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1470 -5200 0 0 {name=x484}
C {devices/lab_wire.sym} 1400 -5320 2 1 {name=l1934 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 -5330 1 1 {name=l1935 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1460 -5330 3 0 {name=l1936 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1400 -5080 0 0 {name=l1937 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1730 -5200 0 0 {name=x485}
C {devices/lab_wire.sym} 1660 -5320 2 1 {name=l1938 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1680 -5330 1 1 {name=l1939 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1720 -5330 3 0 {name=l1940 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1660 -5080 0 0 {name=l1941 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 1990 -5200 0 0 {name=x486}
C {devices/lab_wire.sym} 1920 -5320 2 1 {name=l1942 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1940 -5330 1 1 {name=l1943 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1980 -5330 3 0 {name=l1944 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1920 -5080 0 0 {name=l1945 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2250 -5200 0 0 {name=x487}
C {devices/lab_wire.sym} 2180 -5320 2 1 {name=l1946 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2200 -5330 1 1 {name=l1947 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2240 -5330 3 0 {name=l1948 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2180 -5080 0 0 {name=l1949 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2510 -5200 0 0 {name=x488}
C {devices/lab_wire.sym} 2440 -5320 2 1 {name=l1950 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2460 -5330 1 1 {name=l1951 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2500 -5330 3 0 {name=l1952 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2440 -5080 0 0 {name=l1953 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 2770 -5200 0 0 {name=x489}
C {devices/lab_wire.sym} 2700 -5320 2 1 {name=l1954 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2720 -5330 1 1 {name=l1955 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2760 -5330 3 0 {name=l1956 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2700 -5080 0 0 {name=l1957 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3030 -5200 0 0 {name=x490}
C {devices/lab_wire.sym} 2960 -5320 2 1 {name=l1958 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2980 -5330 1 1 {name=l1959 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3020 -5330 3 0 {name=l1960 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2960 -5080 0 0 {name=l1961 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3290 -5200 0 0 {name=x491}
C {devices/lab_wire.sym} 3220 -5320 2 1 {name=l1962 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3240 -5330 1 1 {name=l1963 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3280 -5330 3 0 {name=l1964 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3220 -5080 0 0 {name=l1965 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3550 -5200 0 0 {name=x492}
C {devices/lab_wire.sym} 3480 -5320 2 1 {name=l1966 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3500 -5330 1 1 {name=l1967 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3540 -5330 3 0 {name=l1968 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3480 -5080 0 0 {name=l1969 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 3810 -5200 0 0 {name=x493}
C {devices/lab_wire.sym} 3740 -5320 2 1 {name=l1970 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3760 -5330 1 1 {name=l1971 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3800 -5330 3 0 {name=l1972 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3740 -5080 0 0 {name=l1973 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4070 -5200 0 0 {name=x494}
C {devices/lab_wire.sym} 4000 -5320 2 1 {name=l1974 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4020 -5330 1 1 {name=l1975 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4060 -5330 3 0 {name=l1976 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4000 -5080 0 0 {name=l1977 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4330 -5200 0 0 {name=x495}
C {devices/lab_wire.sym} 4260 -5320 2 1 {name=l1978 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4280 -5330 1 1 {name=l1979 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4320 -5330 3 0 {name=l1980 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4260 -5080 0 0 {name=l1981 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4590 -5200 0 0 {name=x496}
C {devices/lab_wire.sym} 4520 -5320 2 1 {name=l1982 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4540 -5330 1 1 {name=l1983 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4580 -5330 3 0 {name=l1984 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4520 -5080 0 0 {name=l1985 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 4850 -5200 0 0 {name=x497}
C {devices/lab_wire.sym} 4780 -5320 2 1 {name=l1986 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4800 -5330 1 1 {name=l1987 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4840 -5330 3 0 {name=l1988 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4780 -5080 0 0 {name=l1989 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5110 -5200 0 0 {name=x498}
C {devices/lab_wire.sym} 5040 -5320 2 1 {name=l1990 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5060 -5330 1 1 {name=l1991 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5100 -5330 3 0 {name=l1992 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5040 -5080 0 0 {name=l1993 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5370 -5200 0 0 {name=x499}
C {devices/lab_wire.sym} 5300 -5320 2 1 {name=l1994 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5320 -5330 1 1 {name=l1995 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5360 -5330 3 0 {name=l1996 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5300 -5080 0 0 {name=l1997 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5630 -5200 0 0 {name=x500}
C {devices/lab_wire.sym} 5560 -5320 2 1 {name=l1998 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5580 -5330 1 1 {name=l1999 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5620 -5330 3 0 {name=l2000 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5560 -5080 0 0 {name=l2001 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 5890 -5200 0 0 {name=x501}
C {devices/lab_wire.sym} 5820 -5320 2 1 {name=l2002 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5840 -5330 1 1 {name=l2003 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5880 -5330 3 0 {name=l2004 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5820 -5080 0 0 {name=l2005 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6150 -5200 0 0 {name=x502}
C {devices/lab_wire.sym} 6080 -5320 2 1 {name=l2006 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6100 -5330 1 1 {name=l2007 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6140 -5330 3 0 {name=l2008 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6080 -5080 0 0 {name=l2009 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6410 -5200 0 0 {name=x503}
C {devices/lab_wire.sym} 6340 -5320 2 1 {name=l2010 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6360 -5330 1 1 {name=l2011 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6400 -5330 3 0 {name=l2012 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6340 -5080 0 0 {name=l2013 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6670 -5200 0 0 {name=x504}
C {devices/lab_wire.sym} 6600 -5320 2 1 {name=l2014 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6620 -5330 1 1 {name=l2015 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6660 -5330 3 0 {name=l2016 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6600 -5080 0 0 {name=l2017 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 6930 -5200 0 0 {name=x505}
C {devices/lab_wire.sym} 6860 -5320 2 1 {name=l2018 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6880 -5330 1 1 {name=l2019 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6920 -5330 3 0 {name=l2020 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6860 -5080 0 0 {name=l2021 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7190 -5200 0 0 {name=x506}
C {devices/lab_wire.sym} 7120 -5320 2 1 {name=l2022 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7140 -5330 1 1 {name=l2023 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7180 -5330 3 0 {name=l2024 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7120 -5080 0 0 {name=l2025 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7450 -5200 0 0 {name=x507}
C {devices/lab_wire.sym} 7380 -5320 2 1 {name=l2026 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7400 -5330 1 1 {name=l2027 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7440 -5330 3 0 {name=l2028 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7380 -5080 0 0 {name=l2029 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7710 -5200 0 0 {name=x508}
C {devices/lab_wire.sym} 7640 -5320 2 1 {name=l2030 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7660 -5330 1 1 {name=l2031 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7700 -5330 3 0 {name=l2032 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7640 -5080 0 0 {name=l2033 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 7970 -5200 0 0 {name=x509}
C {devices/lab_wire.sym} 7900 -5320 2 1 {name=l2034 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7920 -5330 1 1 {name=l2035 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7960 -5330 3 0 {name=l2036 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7900 -5080 0 0 {name=l2037 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8230 -5200 0 0 {name=x510}
C {devices/lab_wire.sym} 8160 -5320 2 1 {name=l2038 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8180 -5330 1 1 {name=l2039 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8220 -5330 3 0 {name=l2040 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8160 -5080 0 0 {name=l2041 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8490 -5200 0 0 {name=x511}
C {devices/lab_wire.sym} 8420 -5320 2 1 {name=l2042 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8440 -5330 1 1 {name=l2043 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8480 -5330 3 0 {name=l2044 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8420 -5080 0 0 {name=l2045 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_8.sym} 8750 -5200 0 0 {name=x512}
C {devices/lab_wire.sym} 8680 -5320 2 1 {name=l2046 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8700 -5330 1 1 {name=l2047 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8740 -5330 3 0 {name=l2048 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8680 -5080 0 0 {name=l2049 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_drv.sym} 430 -1300 0 0 {name=x1025}
C {devices/lab_wire.sym} 360 -1420 2 1 {name=l4098 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 380 -1430 1 1 {name=l4099 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 420 -1430 3 0 {name=l4100 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 360 -1180 0 0 {name=l4101 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 300 -1270 0 0 {name=l4102 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 300 -1330 0 0 {name=l4105 sig_type=std_logic lab=row_n[0]}
C {devices/lab_wire.sym} 300 -1310 0 0 {name=l4104 sig_type=std_logic lab=rowon_n[0]}
C {devices/lab_wire.sym} 300 -1290 0 0 {name=l4103 sig_type=std_logic lab=sample}
C {adc_array_wafflecap_8_drv.sym} 430 -1560 0 0 {name=x1026}
C {devices/lab_wire.sym} 360 -1680 2 1 {name=l4106 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 380 -1690 1 1 {name=l4107 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 420 -1690 3 0 {name=l4108 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 360 -1440 0 0 {name=l4109 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 300 -1530 0 0 {name=l4110 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 300 -1590 0 0 {name=l4111 sig_type=std_logic lab=row_n[1]}
C {devices/lab_wire.sym} 300 -1570 0 0 {name=l4112 sig_type=std_logic lab=rowon_n[1]}
C {devices/lab_wire.sym} 300 -1550 0 0 {name=l4113 sig_type=std_logic lab=sample}
C {adc_array_wafflecap_8_drv.sym} 430 -1820 0 0 {name=x1027}
C {devices/lab_wire.sym} 360 -1940 2 1 {name=l4114 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 380 -1950 1 1 {name=l4115 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 420 -1950 3 0 {name=l4116 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 360 -1700 0 0 {name=l4117 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 300 -1790 0 0 {name=l4118 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 300 -1850 0 0 {name=l4119 sig_type=std_logic lab=row_n[2]}
C {devices/lab_wire.sym} 300 -1830 0 0 {name=l4120 sig_type=std_logic lab=rowon_n[2]}
C {devices/lab_wire.sym} 300 -1810 0 0 {name=l4121 sig_type=std_logic lab=sample}
C {adc_array_wafflecap_8_drv.sym} 430 -2080 0 0 {name=x1028}
C {devices/lab_wire.sym} 360 -2200 2 1 {name=l4122 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 380 -2210 1 1 {name=l4123 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 420 -2210 3 0 {name=l4124 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_drv.sym} 430 -2340 0 0 {name=x1029}
C {devices/lab_wire.sym} 360 -2460 2 1 {name=l4129 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 380 -2470 1 1 {name=l4130 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 420 -2470 3 0 {name=l4131 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 360 -2220 0 0 {name=l4132 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 300 -2050 0 0 {name=l4133 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 300 -2110 0 0 {name=l4134 sig_type=std_logic lab=row_n[3]}
C {devices/lab_wire.sym} 300 -2090 0 0 {name=l4135 sig_type=std_logic lab=rowon_n[3]}
C {devices/lab_wire.sym} 300 -2070 0 0 {name=l4136 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 360 -1960 0 0 {name=l4137 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_drv.sym} 430 -2600 0 0 {name=x1030}
C {devices/lab_wire.sym} 360 -2720 2 1 {name=l4138 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 380 -2730 1 1 {name=l4139 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 420 -2730 3 0 {name=l4140 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 360 -2480 0 0 {name=l4141 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 300 -2310 0 0 {name=l4142 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 300 -2370 0 0 {name=l4143 sig_type=std_logic lab=row_n[4]}
C {devices/lab_wire.sym} 300 -2350 0 0 {name=l4144 sig_type=std_logic lab=rowon_n[4]}
C {devices/lab_wire.sym} 300 -2330 0 0 {name=l4145 sig_type=std_logic lab=sample}
C {adc_array_wafflecap_8_drv.sym} 430 -2860 0 0 {name=x1031}
C {devices/lab_wire.sym} 360 -2980 2 1 {name=l4146 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 380 -2990 1 1 {name=l4147 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 420 -2990 3 0 {name=l4148 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 360 -2740 0 0 {name=l4149 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 300 -2570 0 0 {name=l4150 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 300 -2630 0 0 {name=l4151 sig_type=std_logic lab=row_n[5]}
C {devices/lab_wire.sym} 300 -2610 0 0 {name=l4152 sig_type=std_logic lab=rowon_n[5]}
C {devices/lab_wire.sym} 300 -2590 0 0 {name=l4153 sig_type=std_logic lab=sample}
C {adc_array_wafflecap_8_drv.sym} 430 -3120 0 0 {name=x1032}
C {devices/lab_wire.sym} 360 -3240 2 1 {name=l4154 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 380 -3250 1 1 {name=l4155 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 420 -3250 3 0 {name=l4156 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 360 -3000 0 0 {name=l4157 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 300 -2830 0 0 {name=l4158 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 300 -2890 0 0 {name=l4159 sig_type=std_logic lab=row_n[6]}
C {devices/lab_wire.sym} 300 -2870 0 0 {name=l4160 sig_type=std_logic lab=rowon_n[6]}
C {devices/lab_wire.sym} 300 -2850 0 0 {name=l4161 sig_type=std_logic lab=sample}
C {adc_array_wafflecap_8_drv.sym} 430 -3380 0 0 {name=x1033}
C {devices/lab_wire.sym} 360 -3500 2 1 {name=l4162 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 380 -3510 1 1 {name=l4163 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 420 -3510 3 0 {name=l4164 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 300 -3090 0 0 {name=l4165 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 300 -3150 0 0 {name=l4166 sig_type=std_logic lab=row_n[7]}
C {devices/lab_wire.sym} 300 -3130 0 0 {name=l4167 sig_type=std_logic lab=rowon_n[7]}
C {devices/lab_wire.sym} 300 -3110 0 0 {name=l4168 sig_type=std_logic lab=sample}
C {adc_array_wafflecap_8_drv.sym} 430 -3640 0 0 {name=x1034}
C {devices/lab_wire.sym} 360 -3760 2 1 {name=l4169 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 380 -3770 1 1 {name=l4170 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 420 -3770 3 0 {name=l4171 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 360 -3520 0 0 {name=l4172 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 300 -3350 0 0 {name=l4173 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 300 -3410 0 0 {name=l4174 sig_type=std_logic lab=row_n[8]}
C {devices/lab_wire.sym} 300 -3390 0 0 {name=l4175 sig_type=std_logic lab=rowon_n[8]}
C {devices/lab_wire.sym} 300 -3370 0 0 {name=l4176 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 360 -3260 0 0 {name=l4177 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_drv.sym} 430 -3900 0 0 {name=x1035}
C {devices/lab_wire.sym} 360 -4020 2 1 {name=l4178 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 380 -4030 1 1 {name=l4179 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 420 -4030 3 0 {name=l4180 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 360 -3780 0 0 {name=l4181 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 300 -3610 0 0 {name=l4182 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 300 -3670 0 0 {name=l4183 sig_type=std_logic lab=row_n[9]}
C {devices/lab_wire.sym} 300 -3650 0 0 {name=l4184 sig_type=std_logic lab=rowon_n[9]}
C {devices/lab_wire.sym} 300 -3630 0 0 {name=l4185 sig_type=std_logic lab=sample}
C {adc_array_wafflecap_8_drv.sym} 430 -4160 0 0 {name=x1036}
C {devices/lab_wire.sym} 360 -4280 2 1 {name=l4186 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 380 -4290 1 1 {name=l4187 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 420 -4290 3 0 {name=l4188 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 360 -4040 0 0 {name=l4189 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 300 -3870 0 0 {name=l4190 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 300 -3930 0 0 {name=l4191 sig_type=std_logic lab=row_n[10]}
C {devices/lab_wire.sym} 300 -3910 0 0 {name=l4192 sig_type=std_logic lab=rowon_n[10]}
C {devices/lab_wire.sym} 300 -3890 0 0 {name=l4193 sig_type=std_logic lab=sample}
C {adc_array_wafflecap_8_drv.sym} 430 -4420 0 0 {name=x1037}
C {devices/lab_wire.sym} 360 -4540 2 1 {name=l4194 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 380 -4550 1 1 {name=l4195 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 420 -4550 3 0 {name=l4196 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 360 -4300 0 0 {name=l4197 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 300 -4130 0 0 {name=l4198 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 300 -4190 0 0 {name=l4199 sig_type=std_logic lab=row_n[11]}
C {devices/lab_wire.sym} 300 -4170 0 0 {name=l4200 sig_type=std_logic lab=rowon_n[11]}
C {devices/lab_wire.sym} 300 -4150 0 0 {name=l4201 sig_type=std_logic lab=sample}
C {adc_array_wafflecap_8_drv.sym} 430 -4680 0 0 {name=x1038}
C {devices/lab_wire.sym} 360 -4800 2 1 {name=l4202 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 380 -4810 1 1 {name=l4203 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 420 -4810 3 0 {name=l4204 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 300 -4390 0 0 {name=l4205 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 300 -4450 0 0 {name=l4206 sig_type=std_logic lab=row_n[12]}
C {devices/lab_wire.sym} 300 -4430 0 0 {name=l4207 sig_type=std_logic lab=rowon_n[12]}
C {devices/lab_wire.sym} 300 -4410 0 0 {name=l4208 sig_type=std_logic lab=sample}
C {adc_array_wafflecap_8_drv.sym} 430 -4940 0 0 {name=x1039}
C {devices/lab_wire.sym} 360 -5060 2 1 {name=l4209 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 380 -5070 1 1 {name=l4210 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 420 -5070 3 0 {name=l4211 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 360 -4820 0 0 {name=l4212 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 300 -4650 0 0 {name=l4213 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 300 -4710 0 0 {name=l4214 sig_type=std_logic lab=row_n[13]}
C {devices/lab_wire.sym} 300 -4690 0 0 {name=l4215 sig_type=std_logic lab=rowon_n[13]}
C {devices/lab_wire.sym} 300 -4670 0 0 {name=l4216 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 360 -4560 0 0 {name=l4217 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_drv.sym} 430 -5200 0 0 {name=x1040}
C {devices/lab_wire.sym} 360 -5320 2 1 {name=l4218 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 380 -5330 1 1 {name=l4219 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 420 -5330 3 0 {name=l4220 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 360 -5080 0 0 {name=l4221 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 300 -4910 0 0 {name=l4222 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 300 -4970 0 0 {name=l4223 sig_type=std_logic lab=row_n[14]}
C {devices/lab_wire.sym} 300 -4950 0 0 {name=l4224 sig_type=std_logic lab=rowon_n[14]}
C {devices/lab_wire.sym} 300 -4930 0 0 {name=l4225 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 300 -5170 0 0 {name=l4230 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 300 -5230 0 0 {name=l4231 sig_type=std_logic lab=row_n[15]}
C {devices/lab_wire.sym} 300 -5210 0 0 {name=l4232 sig_type=std_logic lab=rowon_n[15]}
C {devices/lab_wire.sym} 300 -5190 0 0 {name=l4233 sig_type=std_logic lab=sample}
C {adc_array_wafflecap_8_dummy.sym} 430 -1040 0 0 {name=x1057}
C {devices/lab_wire.sym} 360 -920 0 0 {name=l4354 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 360 -1160 2 1 {name=l4355 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 380 -1170 1 1 {name=l4356 sig_type=std_logic lab=vcm}
C {adc_array_wafflecap_8_dummy.sym} 690 -1040 0 0 {name=x1058}
C {devices/lab_wire.sym} 620 -920 0 0 {name=l4359 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 620 -1160 2 1 {name=l4360 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 640 -1170 1 1 {name=l4361 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 700 -910 3 0 {name=l4363 sig_type=std_logic lab=col_n[0]}
C {devices/lab_wire.sym} 420 -1170 3 0 {name=l4357 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 680 -1170 3 0 {name=l4362 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 880 -920 0 0 {name=l4364 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 880 -1160 2 1 {name=l4365 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 900 -1170 1 1 {name=l4366 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 960 -910 3 0 {name=l4367 sig_type=std_logic lab=col_n[1]}
C {devices/lab_wire.sym} 1140 -920 0 0 {name=l4368 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1140 -1160 2 1 {name=l4369 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1160 -1170 1 1 {name=l4370 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1220 -910 3 0 {name=l4371 sig_type=std_logic lab=col_n[2]}
C {devices/lab_wire.sym} 940 -1170 3 0 {name=l4372 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1200 -1170 3 0 {name=l4373 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 1470 -1040 0 0 {name=x1061}
C {devices/lab_wire.sym} 1400 -920 0 0 {name=l4374 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1400 -1160 2 1 {name=l4375 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 -1170 1 1 {name=l4376 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1480 -910 3 0 {name=l4377 sig_type=std_logic lab=col_n[3]}
C {adc_array_wafflecap_8_dummy.sym} 1730 -1040 0 0 {name=x1062}
C {devices/lab_wire.sym} 1660 -920 0 0 {name=l4378 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1660 -1160 2 1 {name=l4379 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1680 -1170 1 1 {name=l4380 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1740 -910 3 0 {name=l4381 sig_type=std_logic lab=col_n[4]}
C {devices/lab_wire.sym} 1460 -1170 3 0 {name=l4382 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1720 -1170 3 0 {name=l4383 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 1990 -1040 0 0 {name=x1063}
C {devices/lab_wire.sym} 1920 -920 0 0 {name=l4384 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1920 -1160 2 1 {name=l4385 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1940 -1170 1 1 {name=l4386 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2000 -910 3 0 {name=l4387 sig_type=std_logic lab=col_n[5]}
C {adc_array_wafflecap_8_dummy.sym} 2250 -1040 0 0 {name=x1064}
C {devices/lab_wire.sym} 2180 -920 0 0 {name=l4388 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2180 -1160 2 1 {name=l4389 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2200 -1170 1 1 {name=l4390 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2260 -910 3 0 {name=l4391 sig_type=std_logic lab=col_n[6]}
C {devices/lab_wire.sym} 1980 -1170 3 0 {name=l4392 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2240 -1170 3 0 {name=l4393 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 2510 -1040 0 0 {name=x1065}
C {devices/lab_wire.sym} 2440 -920 0 0 {name=l4394 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2440 -1160 2 1 {name=l4395 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2460 -1170 1 1 {name=l4396 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2520 -910 3 0 {name=l4397 sig_type=std_logic lab=col_n[7]}
C {devices/lab_wire.sym} 2700 -920 0 0 {name=l4398 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2700 -1160 2 1 {name=l4399 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2720 -1170 1 1 {name=l4400 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2780 -910 3 0 {name=l4401 sig_type=std_logic lab=col_n[8]}
C {devices/lab_wire.sym} 2500 -1170 3 0 {name=l4402 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2760 -1170 3 0 {name=l4403 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 3030 -1040 0 0 {name=x1067}
C {devices/lab_wire.sym} 2960 -920 0 0 {name=l4404 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2960 -1160 2 1 {name=l4405 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2980 -1170 1 1 {name=l4406 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3040 -910 3 0 {name=l4407 sig_type=std_logic lab=col_n[9]}
C {devices/lab_wire.sym} 3220 -920 0 0 {name=l4408 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3220 -1160 2 1 {name=l4409 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3240 -1170 1 1 {name=l4410 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3300 -910 3 0 {name=l4411 sig_type=std_logic lab=col_n[10]}
C {devices/lab_wire.sym} 3020 -1170 3 0 {name=l4412 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3280 -1170 3 0 {name=l4413 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 3550 -1040 0 0 {name=x1069}
C {devices/lab_wire.sym} 3480 -920 0 0 {name=l4414 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3480 -1160 2 1 {name=l4415 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3500 -1170 1 1 {name=l4416 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3560 -910 3 0 {name=l4417 sig_type=std_logic lab=col_n[11]}
C {devices/lab_wire.sym} 3740 -920 0 0 {name=l4418 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3740 -1160 2 1 {name=l4419 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3760 -1170 1 1 {name=l4420 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3820 -910 3 0 {name=l4421 sig_type=std_logic lab=col_n[12]}
C {devices/lab_wire.sym} 3540 -1170 3 0 {name=l4422 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3800 -1170 3 0 {name=l4423 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 4070 -1040 0 0 {name=x1071}
C {devices/lab_wire.sym} 4000 -920 0 0 {name=l4424 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4000 -1160 2 1 {name=l4425 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4020 -1170 1 1 {name=l4426 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4080 -910 3 0 {name=l4427 sig_type=std_logic lab=col_n[13]}
C {adc_array_wafflecap_8_dummy.sym} 4330 -1040 0 0 {name=x1072}
C {devices/lab_wire.sym} 4260 -920 0 0 {name=l4428 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4260 -1160 2 1 {name=l4429 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4280 -1170 1 1 {name=l4430 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4340 -910 3 0 {name=l4431 sig_type=std_logic lab=col_n[14]}
C {devices/lab_wire.sym} 4060 -1170 3 0 {name=l4432 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4320 -1170 3 0 {name=l4433 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 2770 -1040 0 0 {name=x1073}
C {devices/lab_wire.sym} 4520 -920 0 0 {name=l4434 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4520 -1160 2 1 {name=l4435 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4540 -1170 1 1 {name=l4436 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4600 -910 3 0 {name=l4437 sig_type=std_logic lab=col_n[15]}
C {devices/lab_wire.sym} 4780 -920 0 0 {name=l4438 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4780 -1160 2 1 {name=l4439 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4800 -1170 1 1 {name=l4440 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4860 -910 3 0 {name=l4441 sig_type=std_logic lab=col_n[16]}
C {devices/lab_wire.sym} 4580 -1170 3 0 {name=l4442 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4840 -1170 3 0 {name=l4443 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 6930 -1040 0 0 {name=x1075}
C {devices/lab_wire.sym} 5040 -920 0 0 {name=l4444 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5040 -1160 2 1 {name=l4445 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5060 -1170 1 1 {name=l4446 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5120 -910 3 0 {name=l4447 sig_type=std_logic lab=col_n[17]}
C {devices/lab_wire.sym} 5300 -920 0 0 {name=l4448 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5300 -1160 2 1 {name=l4449 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5320 -1170 1 1 {name=l4450 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5380 -910 3 0 {name=l4451 sig_type=std_logic lab=col_n[18]}
C {devices/lab_wire.sym} 5100 -1170 3 0 {name=l4452 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5360 -1170 3 0 {name=l4453 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 5630 -1040 0 0 {name=x1077}
C {devices/lab_wire.sym} 5560 -920 0 0 {name=l4454 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5560 -1160 2 1 {name=l4455 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5580 -1170 1 1 {name=l4456 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5640 -910 3 0 {name=l4457 sig_type=std_logic lab=col_n[19]}
C {adc_array_wafflecap_8_dummy.sym} 5890 -1040 0 0 {name=x1078}
C {devices/lab_wire.sym} 5820 -920 0 0 {name=l4458 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5820 -1160 2 1 {name=l4459 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5840 -1170 1 1 {name=l4460 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5900 -910 3 0 {name=l4461 sig_type=std_logic lab=col_n[20]}
C {devices/lab_wire.sym} 5620 -1170 3 0 {name=l4462 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5880 -1170 3 0 {name=l4463 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 6150 -1040 0 0 {name=x1079}
C {devices/lab_wire.sym} 6080 -920 0 0 {name=l4464 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6080 -1160 2 1 {name=l4465 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6100 -1170 1 1 {name=l4466 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6160 -910 3 0 {name=l4467 sig_type=std_logic lab=col_n[21]}
C {adc_array_wafflecap_8_dummy.sym} 6410 -1040 0 0 {name=x1080}
C {devices/lab_wire.sym} 6340 -920 0 0 {name=l4468 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6340 -1160 2 1 {name=l4469 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6360 -1170 1 1 {name=l4470 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6420 -910 3 0 {name=l4471 sig_type=std_logic lab=col_n[22]}
C {devices/lab_wire.sym} 6140 -1170 3 0 {name=l4472 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6400 -1170 3 0 {name=l4473 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 6670 -1040 0 0 {name=x1081}
C {devices/lab_wire.sym} 6600 -920 0 0 {name=l4474 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6600 -1160 2 1 {name=l4475 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6620 -1170 1 1 {name=l4476 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6680 -910 3 0 {name=l4477 sig_type=std_logic lab=col_n[23]}
C {devices/lab_wire.sym} 6860 -920 0 0 {name=l4478 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6860 -1160 2 1 {name=l4479 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6880 -1170 1 1 {name=l4480 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6940 -910 3 0 {name=l4481 sig_type=std_logic lab=col_n[24]}
C {devices/lab_wire.sym} 6660 -1170 3 0 {name=l4482 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6920 -1170 3 0 {name=l4483 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 7190 -1040 0 0 {name=x1083}
C {devices/lab_wire.sym} 7120 -920 0 0 {name=l4484 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 7120 -1160 2 1 {name=l4485 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7140 -1170 1 1 {name=l4486 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7200 -910 3 0 {name=l4487 sig_type=std_logic lab=col_n[25]}
C {devices/lab_wire.sym} 7380 -920 0 0 {name=l4488 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 7380 -1160 2 1 {name=l4489 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7400 -1170 1 1 {name=l4490 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7460 -910 3 0 {name=l4491 sig_type=std_logic lab=col_n[26]}
C {devices/lab_wire.sym} 7180 -1170 3 0 {name=l4492 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7440 -1170 3 0 {name=l4493 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 3810 -1040 0 0 {name=x1085}
C {devices/lab_wire.sym} 7640 -920 0 0 {name=l4494 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 7640 -1160 2 1 {name=l4495 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7660 -1170 1 1 {name=l4496 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7720 -910 3 0 {name=l4497 sig_type=std_logic lab=col_n[27]}
C {adc_array_wafflecap_8_dummy.sym} 7970 -1040 0 0 {name=x1086}
C {devices/lab_wire.sym} 7900 -920 0 0 {name=l4498 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 7900 -1160 2 1 {name=l4499 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7920 -1170 1 1 {name=l4500 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7980 -910 3 0 {name=l4501 sig_type=std_logic lab=col_n[28]}
C {devices/lab_wire.sym} 7700 -1170 3 0 {name=l4502 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7960 -1170 3 0 {name=l4503 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 8230 -1040 0 0 {name=x1087}
C {devices/lab_wire.sym} 8160 -920 0 0 {name=l4504 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8160 -1160 2 1 {name=l4505 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8180 -1170 1 1 {name=l4506 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8240 -910 3 0 {name=l4507 sig_type=std_logic lab=col_n[29]}
C {adc_array_wafflecap_8_dummy.sym} 8490 -1040 0 0 {name=x1088}
C {devices/lab_wire.sym} 8420 -920 0 0 {name=l4508 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8420 -1160 2 1 {name=l4509 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8440 -1170 1 1 {name=l4510 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8500 -910 3 0 {name=l4511 sig_type=std_logic lab=col_n[30]}
C {devices/lab_wire.sym} 8220 -1170 3 0 {name=l4512 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8480 -1170 3 0 {name=l4513 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 7710 -1040 0 0 {name=x1089}
C {devices/lab_wire.sym} 8680 -920 0 0 {name=l4514 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8680 -1160 2 1 {name=l4515 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8700 -1170 1 1 {name=l4516 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8760 -910 3 0 {name=l4517 sig_type=std_logic lab=col_n[31]}
C {devices/lab_wire.sym} 8740 -1170 3 0 {name=l4518 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 9010 -1040 0 0 {name=x1090}
C {devices/lab_wire.sym} 8940 -920 0 0 {name=l4519 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8940 -1160 2 1 {name=l4520 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8960 -1170 1 1 {name=l4521 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 9020 -910 3 0 {name=l4522 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 9000 -1170 3 0 {name=l4523 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 430 -5460 0 0 {name=x1091}
C {devices/lab_wire.sym} 360 -5340 0 0 {name=l4524 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 360 -5580 2 1 {name=l4525 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 380 -5590 1 1 {name=l4526 sig_type=std_logic lab=vcm}
C {adc_array_wafflecap_8_dummy.sym} 690 -5460 0 0 {name=x1092}
C {devices/lab_wire.sym} 620 -5340 0 0 {name=l4528 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 620 -5580 2 1 {name=l4529 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 640 -5590 1 1 {name=l4530 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 420 -5590 3 0 {name=l4532 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 680 -5590 3 0 {name=l4533 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 950 -5460 0 0 {name=x1093}
C {devices/lab_wire.sym} 880 -5340 0 0 {name=l4534 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 880 -5580 2 1 {name=l4535 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 900 -5590 1 1 {name=l4536 sig_type=std_logic lab=vcm}
C {adc_array_wafflecap_8_dummy.sym} 1210 -5460 0 0 {name=x1094}
C {devices/lab_wire.sym} 1140 -5340 0 0 {name=l4538 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1140 -5580 2 1 {name=l4539 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1160 -5590 1 1 {name=l4540 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 940 -5590 3 0 {name=l4542 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1200 -5590 3 0 {name=l4543 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 1470 -5460 0 0 {name=x1095}
C {devices/lab_wire.sym} 1400 -5340 0 0 {name=l4544 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1400 -5580 2 1 {name=l4545 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 -5590 1 1 {name=l4546 sig_type=std_logic lab=vcm}
C {adc_array_wafflecap_8_dummy.sym} 1730 -5460 0 0 {name=x1096}
C {devices/lab_wire.sym} 1660 -5340 0 0 {name=l4548 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1660 -5580 2 1 {name=l4549 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1680 -5590 1 1 {name=l4550 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1460 -5590 3 0 {name=l4552 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1720 -5590 3 0 {name=l4553 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 1990 -5460 0 0 {name=x1097}
C {devices/lab_wire.sym} 1920 -5340 0 0 {name=l4554 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1920 -5580 2 1 {name=l4555 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1940 -5590 1 1 {name=l4556 sig_type=std_logic lab=vcm}
C {adc_array_wafflecap_8_dummy.sym} 2250 -5460 0 0 {name=x1098}
C {devices/lab_wire.sym} 2180 -5340 0 0 {name=l4558 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2180 -5580 2 1 {name=l4559 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2200 -5590 1 1 {name=l4560 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1980 -5590 3 0 {name=l4562 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2240 -5590 3 0 {name=l4563 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 2510 -5460 0 0 {name=x1099}
C {devices/lab_wire.sym} 2440 -5340 0 0 {name=l4564 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2440 -5580 2 1 {name=l4565 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2460 -5590 1 1 {name=l4566 sig_type=std_logic lab=vcm}
C {adc_array_wafflecap_8_dummy.sym} 2770 -5460 0 0 {name=x1100}
C {devices/lab_wire.sym} 2700 -5340 0 0 {name=l4568 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2700 -5580 2 1 {name=l4569 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2720 -5590 1 1 {name=l4570 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2500 -5590 3 0 {name=l4572 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2760 -5590 3 0 {name=l4573 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 3030 -5460 0 0 {name=x1101}
C {devices/lab_wire.sym} 2960 -5340 0 0 {name=l4574 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2960 -5580 2 1 {name=l4575 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2980 -5590 1 1 {name=l4576 sig_type=std_logic lab=vcm}
C {adc_array_wafflecap_8_dummy.sym} 3290 -5460 0 0 {name=x1102}
C {devices/lab_wire.sym} 3220 -5340 0 0 {name=l4578 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3220 -5580 2 1 {name=l4579 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3240 -5590 1 1 {name=l4580 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3020 -5590 3 0 {name=l4582 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3280 -5590 3 0 {name=l4583 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 3550 -5460 0 0 {name=x1103}
C {devices/lab_wire.sym} 3480 -5340 0 0 {name=l4584 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3480 -5580 2 1 {name=l4585 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3500 -5590 1 1 {name=l4586 sig_type=std_logic lab=vcm}
C {adc_array_wafflecap_8_dummy.sym} 3810 -5460 0 0 {name=x1104}
C {devices/lab_wire.sym} 3740 -5340 0 0 {name=l4588 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3740 -5580 2 1 {name=l4589 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3760 -5590 1 1 {name=l4590 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3540 -5590 3 0 {name=l4592 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3800 -5590 3 0 {name=l4593 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 4070 -5460 0 0 {name=x1105}
C {devices/lab_wire.sym} 4000 -5340 0 0 {name=l4594 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4000 -5580 2 1 {name=l4595 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4020 -5590 1 1 {name=l4596 sig_type=std_logic lab=vcm}
C {adc_array_wafflecap_8_dummy.sym} 4330 -5460 0 0 {name=x1106}
C {devices/lab_wire.sym} 4260 -5340 0 0 {name=l4598 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4260 -5580 2 1 {name=l4599 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4280 -5590 1 1 {name=l4600 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4060 -5590 3 0 {name=l4602 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4320 -5590 3 0 {name=l4603 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 4590 -5460 0 0 {name=x1107}
C {devices/lab_wire.sym} 4520 -5340 0 0 {name=l4604 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4520 -5580 2 1 {name=l4605 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4540 -5590 1 1 {name=l4606 sig_type=std_logic lab=vcm}
C {adc_array_wafflecap_8_dummy.sym} 4850 -5460 0 0 {name=x1108}
C {devices/lab_wire.sym} 4780 -5340 0 0 {name=l4608 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4780 -5580 2 1 {name=l4609 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4800 -5590 1 1 {name=l4610 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4580 -5590 3 0 {name=l4612 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4840 -5590 3 0 {name=l4613 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 5110 -5460 0 0 {name=x1109}
C {devices/lab_wire.sym} 5040 -5340 0 0 {name=l4614 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5040 -5580 2 1 {name=l4615 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5060 -5590 1 1 {name=l4616 sig_type=std_logic lab=vcm}
C {adc_array_wafflecap_8_dummy.sym} 5370 -5460 0 0 {name=x1110}
C {devices/lab_wire.sym} 5300 -5340 0 0 {name=l4618 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5300 -5580 2 1 {name=l4619 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5320 -5590 1 1 {name=l4620 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5100 -5590 3 0 {name=l4622 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5360 -5590 3 0 {name=l4623 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 5630 -5460 0 0 {name=x1111}
C {devices/lab_wire.sym} 5560 -5340 0 0 {name=l4624 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5560 -5580 2 1 {name=l4625 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5580 -5590 1 1 {name=l4626 sig_type=std_logic lab=vcm}
C {adc_array_wafflecap_8_dummy.sym} 5890 -5460 0 0 {name=x1112}
C {devices/lab_wire.sym} 5820 -5340 0 0 {name=l4628 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5820 -5580 2 1 {name=l4629 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5840 -5590 1 1 {name=l4630 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5620 -5590 3 0 {name=l4632 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5880 -5590 3 0 {name=l4633 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 6150 -5460 0 0 {name=x1113}
C {devices/lab_wire.sym} 6080 -5340 0 0 {name=l4634 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6080 -5580 2 1 {name=l4635 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6100 -5590 1 1 {name=l4636 sig_type=std_logic lab=vcm}
C {adc_array_wafflecap_8_dummy.sym} 6410 -5460 0 0 {name=x1114}
C {devices/lab_wire.sym} 6340 -5340 0 0 {name=l4638 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6340 -5580 2 1 {name=l4639 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6360 -5590 1 1 {name=l4640 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6140 -5590 3 0 {name=l4642 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6400 -5590 3 0 {name=l4643 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 6670 -5460 0 0 {name=x1115}
C {devices/lab_wire.sym} 6600 -5340 0 0 {name=l4644 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6600 -5580 2 1 {name=l4645 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6620 -5590 1 1 {name=l4646 sig_type=std_logic lab=vcm}
C {adc_array_wafflecap_8_dummy.sym} 6930 -5460 0 0 {name=x1116}
C {devices/lab_wire.sym} 6860 -5340 0 0 {name=l4648 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6860 -5580 2 1 {name=l4649 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6880 -5590 1 1 {name=l4650 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 6660 -5590 3 0 {name=l4652 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 6920 -5590 3 0 {name=l4653 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 7190 -5460 0 0 {name=x1117}
C {devices/lab_wire.sym} 7120 -5340 0 0 {name=l4654 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 7120 -5580 2 1 {name=l4655 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7140 -5590 1 1 {name=l4656 sig_type=std_logic lab=vcm}
C {adc_array_wafflecap_8_dummy.sym} 7450 -5460 0 0 {name=x1118}
C {devices/lab_wire.sym} 7380 -5340 0 0 {name=l4658 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 7380 -5580 2 1 {name=l4659 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7400 -5590 1 1 {name=l4660 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7180 -5590 3 0 {name=l4662 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7440 -5590 3 0 {name=l4663 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 7710 -5460 0 0 {name=x1119}
C {devices/lab_wire.sym} 7640 -5340 0 0 {name=l4664 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 7640 -5580 2 1 {name=l4665 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7660 -5590 1 1 {name=l4666 sig_type=std_logic lab=vcm}
C {adc_array_wafflecap_8_dummy.sym} 7970 -5460 0 0 {name=x1120}
C {devices/lab_wire.sym} 7900 -5340 0 0 {name=l4668 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 7900 -5580 2 1 {name=l4669 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7920 -5590 1 1 {name=l4670 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 7700 -5590 3 0 {name=l4672 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 7960 -5590 3 0 {name=l4673 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 8230 -5460 0 0 {name=x1121}
C {devices/lab_wire.sym} 8160 -5340 0 0 {name=l4674 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8160 -5580 2 1 {name=l4675 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8180 -5590 1 1 {name=l4676 sig_type=std_logic lab=vcm}
C {adc_array_wafflecap_8_dummy.sym} 8490 -5460 0 0 {name=x1122}
C {devices/lab_wire.sym} 8420 -5340 0 0 {name=l4678 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8420 -5580 2 1 {name=l4679 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8440 -5590 1 1 {name=l4680 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8220 -5590 3 0 {name=l4682 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 8480 -5590 3 0 {name=l4683 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 8750 -5460 0 0 {name=x1123}
C {devices/lab_wire.sym} 8680 -5340 0 0 {name=l4684 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8680 -5580 2 1 {name=l4685 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8700 -5590 1 1 {name=l4686 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 8740 -5590 3 0 {name=l4688 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 9010 -5460 0 0 {name=x1124}
C {devices/lab_wire.sym} 8940 -5340 0 0 {name=l4689 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8940 -5580 2 1 {name=l4690 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8960 -5590 1 1 {name=l4691 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 9000 -5590 3 0 {name=l4693 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 9010 -1300 0 0 {name=x1125}
C {devices/lab_wire.sym} 8940 -1420 2 1 {name=l4527 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8960 -1430 1 1 {name=l4531 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 9000 -1430 3 0 {name=l4537 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 9010 -1560 0 0 {name=x1126}
C {devices/lab_wire.sym} 8940 -1680 2 1 {name=l4541 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8960 -1690 1 1 {name=l4557 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 9000 -1690 3 0 {name=l4561 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 9010 -1820 0 0 {name=x1127}
C {devices/lab_wire.sym} 8940 -1940 2 1 {name=l4567 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8960 -1950 1 1 {name=l4571 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 9000 -1950 3 0 {name=l4577 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 9010 -2080 0 0 {name=x1128}
C {devices/lab_wire.sym} 8940 -2200 2 1 {name=l4581 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8960 -2210 1 1 {name=l4587 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 9000 -2210 3 0 {name=l4591 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 9010 -2340 0 0 {name=x1129}
C {devices/lab_wire.sym} 8940 -2460 2 1 {name=l4547 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8960 -2470 1 1 {name=l4551 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 9000 -2470 3 0 {name=l4597 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 9010 -2600 0 0 {name=x1130}
C {devices/lab_wire.sym} 8940 -2720 2 1 {name=l4601 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8960 -2730 1 1 {name=l4607 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 9000 -2730 3 0 {name=l4611 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 9010 -2860 0 0 {name=x1131}
C {devices/lab_wire.sym} 8940 -2980 2 1 {name=l4617 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8960 -2990 1 1 {name=l4621 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 9000 -2990 3 0 {name=l4627 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 9010 -3120 0 0 {name=x1132}
C {devices/lab_wire.sym} 8940 -3240 2 1 {name=l4631 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8960 -3250 1 1 {name=l4637 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 9000 -3250 3 0 {name=l4641 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 9010 -3380 0 0 {name=x1133}
C {devices/lab_wire.sym} 8940 -3500 2 1 {name=l4647 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8960 -3510 1 1 {name=l4651 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 9000 -3510 3 0 {name=l4657 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 9010 -3640 0 0 {name=x1134}
C {devices/lab_wire.sym} 8940 -3760 2 1 {name=l4661 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8960 -3770 1 1 {name=l4667 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 9000 -3770 3 0 {name=l4671 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 9010 -3900 0 0 {name=x1135}
C {devices/lab_wire.sym} 8940 -4020 2 1 {name=l4677 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8960 -4030 1 1 {name=l4681 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 9000 -4030 3 0 {name=l4687 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 9010 -4160 0 0 {name=x1136}
C {devices/lab_wire.sym} 8940 -4280 2 1 {name=l4692 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8960 -4290 1 1 {name=l4694 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 9000 -4290 3 0 {name=l4695 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 9010 -4420 0 0 {name=x1137}
C {devices/lab_wire.sym} 8940 -4540 2 1 {name=l4696 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8960 -4550 1 1 {name=l4697 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 9000 -4550 3 0 {name=l4698 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 9010 -4680 0 0 {name=x1138}
C {devices/lab_wire.sym} 8940 -4800 2 1 {name=l4699 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8960 -4810 1 1 {name=l4700 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 9000 -4810 3 0 {name=l4701 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 9010 -4940 0 0 {name=x1139}
C {devices/lab_wire.sym} 8940 -5060 2 1 {name=l4702 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8960 -5070 1 1 {name=l4703 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 9000 -5070 3 0 {name=l4704 sig_type=std_logic lab=ctop}
C {adc_array_wafflecap_8_dummy.sym} 9010 -5200 0 0 {name=x1140}
C {devices/lab_wire.sym} 8940 -5320 2 1 {name=l4705 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8960 -5330 1 1 {name=l4706 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 9000 -5330 3 0 {name=l4707 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 300 -1010 0 0 {name=l4758 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 300 -1030 0 0 {name=l4759 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 300 -5490 0 0 {name=l4760 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 300 -5470 0 0 {name=l4761 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 300 -5430 0 0 {name=l4762 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 300 -5450 0 0 {name=l4763 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 440 -920 0 0 {name=l4358 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8940 -1180 0 0 {name=l4764 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8940 -1440 0 0 {name=l4765 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8940 -1700 0 0 {name=l4766 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8940 -1960 0 0 {name=l4767 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8940 -2220 0 0 {name=l4768 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8940 -2480 0 0 {name=l4769 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8940 -2740 0 0 {name=l4770 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8940 -3000 0 0 {name=l4771 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8940 -3260 0 0 {name=l4772 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8940 -3520 0 0 {name=l4773 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8940 -3780 0 0 {name=l4774 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8940 -4040 0 0 {name=l4775 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8940 -4300 0 0 {name=l4776 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8940 -4560 0 0 {name=l4777 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8940 -4820 0 0 {name=l4778 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8940 -5080 0 0 {name=l4779 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5070 -920 3 0 {name=l4796 sig_type=std_logic lab=en_bit_n[0]}
C {devices/lab_wire.sym} 4550 -910 3 0 {name=l4797 sig_type=std_logic lab=en_bit_n[1]}
C {devices/lab_wire.sym} 4810 -910 3 0 {name=l4798 sig_type=std_logic lab=en_bit_n[2]}
C {adc_array_wafflecap_8_dummy.sym} 1210 -1040 0 0 {name=x513}
C {adc_array_wafflecap_8_dummy.sym} 3290 -1040 0 0 {name=x514}
C {adc_array_wafflecap_8_dummy.sym} 5370 -1040 0 0 {name=x515}
C {adc_array_wafflecap_8_dummy.sym} 7450 -1040 0 0 {name=x516}
C {adc_array_wafflecap_8_4.sym} 4850 -1040 0 0 {name=x517}
C {adc_array_wafflecap_8_2.sym} 4590 -1040 0 0 {name=x518}
C {adc_array_wafflecap_8_1.sym} 5110 -1040 0 0 {name=x519}
C {devices/lab_wire.sym} 300 -1050 0 0 {name=l2050 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 300 -1070 0 0 {name=l2051 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_gate.sym} 8750 -1040 0 0 {name=x520}
C {devices/lab_wire.sym} 8780 -910 3 0 {name=l2052 sig_type=std_logic lab=sw}
C {devices/lab_wire.sym} 8800 -910 3 0 {name=l2053 sig_type=std_logic lab=analog_in}
C {devices/lab_wire.sym} 8820 -910 3 0 {name=l2054 sig_type=std_logic lab=sw_n}
C {devices/lab_wire.sym} 4020 -1430 1 1 {name=l55 sig_type=std_logic lab=vcm}
C {adc_array_wafflecap_8_8.sym} 4070 -1300 0 0 {name=x14}
C {devices/lab_wire.sym} 4000 -1420 2 1 {name=l54 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4060 -1430 3 0 {name=l56 sig_type=std_logic lab=ctop}
C {adc_noise_decoup_cell1.sym} 570 -500 0 0 {name=x521[1..15]}
C {devices/lab_wire.sym} 520 -580 0 0 {name=l2055 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 520 -460 0 0 {name=l2056 sig_type=std_logic lab=VSS}
C {adc_array_wafflecap_8_dummy.sym} 690 -1300 0 0 {name=x1}
C {adc_array_wafflecap_8_1.sym} 950 -1040 0 0 {name=x521}
C {devices/lab_wire.sym} 910 -910 3 0 {name=l4367 sig_type=std_logic lab=en_C0_n}
C {devices/lab_wire.sym} 3740 -1180 0 0 {name=l53 sig_type=std_logic lab=VSS}
