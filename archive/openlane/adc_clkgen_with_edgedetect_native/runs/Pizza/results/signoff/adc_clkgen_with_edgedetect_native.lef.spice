* NGSPICE file created from adc_clkgen_with_edgedetect_native.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkdlybuf4s50_2 abstract view
.subckt sky130_fd_sc_hd__clkdlybuf4s50_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VGND VPWR VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_2 abstract view
.subckt sky130_fd_sc_hd__o21ba_2 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_2 abstract view
.subckt sky130_fd_sc_hd__and2b_2 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

.subckt adc_clkgen_with_edgedetect_native VGND VPWR clk_comp clk_dig comp_trig ena_in
+ start_conv
XFILLER_54_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[294\].delay_unit edgedetect.delay_200ns.genblk1\[294\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[295\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[115\].delay_unit clkgen.delay_100ns_2.genblk1\[115\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[116\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_1.genblk1\[149\].delay_unit clkgen.delay_100ns_1.genblk1\[149\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[150\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[61\].delay_unit clkgen.delay_100ns_2.genblk1\[61\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[62\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_45_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[9\].delay_unit clkgen.delay_100ns_1.genblk1\[9\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[9\].delay_unit/X sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[93\].delay_unit clkgen.delay_100ns_3.genblk1\[93\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[94\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[151\].delay_unit clkgen.delay_100ns_1.genblk1\[151\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[152\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[147\].delay_unit clkgen.delay_100ns_3.genblk1\[147\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[148\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[95\].delay_unit clkgen.delay_100ns_1.genblk1\[95\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[96\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[174\].delay_unit edgedetect.delay_200ns.genblk1\[174\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[175\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[473\].delay_unit edgedetect.delay_200ns.genblk1\[473\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[474\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk1\[183\].delay_unit clkgen.delay_100ns_2.genblk1\[183\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[184\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[53\].delay_unit edgedetect.delay_200ns.genblk1\[53\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[54\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_294 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[353\].delay_unit edgedetect.delay_200ns.genblk1\[353\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[354\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_1.genblk1\[208\].delay_unit clkgen.delay_100ns_1.genblk1\[208\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[209\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[210\].delay_unit clkgen.delay_100ns_1.genblk1\[210\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[211\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkgen.delay_100ns_3.genblk1\[206\].delay_unit clkgen.delay_100ns_3.genblk1\[206\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[207\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_52_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[233\].delay_unit edgedetect.delay_200ns.genblk1\[233\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[234\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_60_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xedgedetect.delay_200ns.genblk1\[532\].delay_unit edgedetect.delay_200ns.genblk1\[532\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[533\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[242\].delay_unit clkgen.delay_100ns_2.genblk1\[242\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[243\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_3.genblk1\[32\].delay_unit clkgen.delay_100ns_3.genblk1\[32\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[33\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_100ns_1.genblk1\[34\].delay_unit clkgen.delay_100ns_1.genblk1\[34\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[35\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[299\].delay_unit edgedetect.delay_200ns.genblk1\[299\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[300\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[113\].delay_unit edgedetect.delay_200ns.genblk1\[113\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[114\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[412\].delay_unit edgedetect.delay_200ns.genblk1\[412\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[413\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[66\].delay_unit clkgen.delay_100ns_2.genblk1\[66\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[67\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_52_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[98\].delay_unit clkgen.delay_100ns_3.genblk1\[98\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[99\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[122\].delay_unit clkgen.delay_100ns_2.genblk1\[122\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[123\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[156\].delay_unit clkgen.delay_100ns_1.genblk1\[156\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[157\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_45_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_200ns.genblk1\[179\].delay_unit edgedetect.delay_200ns.genblk1\[179\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[180\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_13_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[478\].delay_unit edgedetect.delay_200ns.genblk1\[478\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[479\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_3.genblk1\[154\].delay_unit clkgen.delay_100ns_3.genblk1\[154\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[155\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[188\].delay_unit clkgen.delay_100ns_2.genblk1\[188\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[189\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[181\].delay_unit edgedetect.delay_200ns.genblk1\[181\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[182\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[480\].delay_unit edgedetect.delay_200ns.genblk1\[480\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[481\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_200ns.genblk1\[58\].delay_unit edgedetect.delay_200ns.genblk1\[58\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[59\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_2.genblk1\[190\].delay_unit clkgen.delay_100ns_2.genblk1\[190\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[191\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_200ns.genblk1\[358\].delay_unit edgedetect.delay_200ns.genblk1\[358\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[359\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[60\].delay_unit edgedetect.delay_200ns.genblk1\[60\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[61\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[360\].delay_unit edgedetect.delay_200ns.genblk1\[360\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[361\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[215\].delay_unit clkgen.delay_100ns_1.genblk1\[215\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[216\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_207 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[238\].delay_unit edgedetect.delay_200ns.genblk1\[238\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[239\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[537\].delay_unit edgedetect.delay_200ns.genblk1\[537\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[538\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_3.genblk1\[213\].delay_unit clkgen.delay_100ns_3.genblk1\[213\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[214\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_50_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[247\].delay_unit clkgen.delay_100ns_2.genblk1\[247\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[248\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_104 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[240\].delay_unit edgedetect.delay_200ns.genblk1\[240\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[241\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[37\].delay_unit clkgen.delay_100ns_3.genblk1\[37\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[38\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_58_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[39\].delay_unit clkgen.delay_100ns_1.genblk1\[39\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[40\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_53_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[118\].delay_unit edgedetect.delay_200ns.genblk1\[118\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[119\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[417\].delay_unit edgedetect.delay_200ns.genblk1\[417\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[418\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_1.genblk1\[41\].delay_unit clkgen.delay_100ns_1.genblk1\[41\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[42\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[127\].delay_unit clkgen.delay_100ns_2.genblk1\[127\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[128\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[120\].delay_unit edgedetect.delay_200ns.genblk1\[120\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[121\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_23_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_2.genblk1\[73\].delay_unit clkgen.delay_100ns_2.genblk1\[73\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[74\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[163\].delay_unit clkgen.delay_100ns_1.genblk1\[163\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[164\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_43_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_3.genblk1\[159\].delay_unit clkgen.delay_100ns_3.genblk1\[159\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[160\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_52_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[186\].delay_unit edgedetect.delay_200ns.genblk1\[186\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[187\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[3\].delay_unit edgedetect.delay_200ns.genblk1\[3\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[4\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[485\].delay_unit edgedetect.delay_200ns.genblk1\[485\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[486\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_55_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_3.genblk1\[161\].delay_unit clkgen.delay_100ns_3.genblk1\[161\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[162\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_50_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk1\[195\].delay_unit clkgen.delay_100ns_2.genblk1\[195\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[196\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[65\].delay_unit edgedetect.delay_200ns.genblk1\[65\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[66\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_37_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_200ns.genblk1\[365\].delay_unit edgedetect.delay_200ns.genblk1\[365\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[366\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_45_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_316 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[222\].delay_unit clkgen.delay_100ns_1.genblk1\[222\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[223\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[218\].delay_unit clkgen.delay_100ns_3.genblk1\[218\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[219\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[245\].delay_unit edgedetect.delay_200ns.genblk1\[245\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[246\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_25_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[12\].delay_unit clkgen.delay_100ns_2.genblk1\[12\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[13\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[220\].delay_unit clkgen.delay_100ns_3.genblk1\[220\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[221\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk1\[254\].delay_unit clkgen.delay_100ns_2.genblk1\[254\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[255\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_16_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_3.genblk1\[44\].delay_unit clkgen.delay_100ns_3.genblk1\[44\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[45\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[102\].delay_unit clkgen.delay_100ns_1.genblk1\[102\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[103\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[46\].delay_unit clkgen.delay_100ns_1.genblk1\[46\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[47\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[125\].delay_unit edgedetect.delay_200ns.genblk1\[125\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[126\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[424\].delay_unit edgedetect.delay_200ns.genblk1\[424\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[425\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[78\].delay_unit clkgen.delay_100ns_2.genblk1\[78\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[79\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[100\].delay_unit clkgen.delay_100ns_3.genblk1\[99\].delay_unit/X
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[101\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_26_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[134\].delay_unit clkgen.delay_100ns_2.genblk1\[134\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[135\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[168\].delay_unit clkgen.delay_100ns_1.genblk1\[168\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[169\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_51_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[80\].delay_unit clkgen.delay_100ns_2.genblk1\[80\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[81\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[8\].delay_unit edgedetect.delay_200ns.genblk1\[8\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[9\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[2\].delay_unit clkgen.delay_100ns_3.genblk1\[2\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[3\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[170\].delay_unit clkgen.delay_100ns_1.genblk1\[170\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[171\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[304\].delay_unit edgedetect.delay_200ns.genblk1\[304\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[305\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[166\].delay_unit clkgen.delay_100ns_3.genblk1\[166\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[167\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_348 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[193\].delay_unit edgedetect.delay_200ns.genblk1\[193\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[194\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[492\].delay_unit edgedetect.delay_200ns.genblk1\[492\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[493\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_17_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[72\].delay_unit edgedetect.delay_200ns.genblk1\[72\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[73\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[372\].delay_unit edgedetect.delay_200ns.genblk1\[372\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[373\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[227\].delay_unit clkgen.delay_100ns_1.genblk1\[227\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[228\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_3.genblk1\[225\].delay_unit clkgen.delay_100ns_3.genblk1\[225\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[226\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[17\].delay_unit clkgen.delay_100ns_2.genblk1\[17\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[18\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[259\].delay_unit clkgen.delay_100ns_2.genblk1\[259\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[260\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_50_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[252\].delay_unit edgedetect.delay_200ns.genblk1\[252\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[253\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[49\].delay_unit clkgen.delay_100ns_3.genblk1\[49\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[50\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_204 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[107\].delay_unit clkgen.delay_100ns_1.genblk1\[107\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[108\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_61_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[429\].delay_unit edgedetect.delay_200ns.genblk1\[429\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[430\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[261\].delay_unit clkgen.delay_100ns_2.genblk1\[261\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[262\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[51\].delay_unit clkgen.delay_100ns_3.genblk1\[51\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[52\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_25_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[53\].delay_unit clkgen.delay_100ns_1.genblk1\[53\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[54\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[105\].delay_unit clkgen.delay_100ns_3.genblk1\[105\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[106\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[139\].delay_unit clkgen.delay_100ns_2.genblk1\[139\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[140\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[431\].delay_unit edgedetect.delay_200ns.genblk1\[431\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[432\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[132\].delay_unit edgedetect.delay_200ns.genblk1\[132\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[133\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_2.genblk1\[85\].delay_unit clkgen.delay_100ns_2.genblk1\[85\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[86\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkgen.delay_100ns_3.genblk1\[7\].delay_unit clkgen.delay_100ns_3.genblk1\[7\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[8\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[141\].delay_unit clkgen.delay_100ns_2.genblk1\[141\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[142\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[175\].delay_unit clkgen.delay_100ns_1.genblk1\[175\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[176\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_34_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[309\].delay_unit edgedetect.delay_200ns.genblk1\[309\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[310\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_200ns.genblk1\[198\].delay_unit edgedetect.delay_200ns.genblk1\[198\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[199\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_25_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[497\].delay_unit edgedetect.delay_200ns.genblk1\[497\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[498\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[11\].delay_unit edgedetect.delay_200ns.genblk1\[11\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[12\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[311\].delay_unit edgedetect.delay_200ns.genblk1\[311\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[312\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_56_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[173\].delay_unit clkgen.delay_100ns_3.genblk1\[173\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[174\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_16_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[77\].delay_unit edgedetect.delay_200ns.genblk1\[77\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[78\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_60_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[377\].delay_unit edgedetect.delay_200ns.genblk1\[377\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[378\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_346 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[200\].delay_unit clkgen.delay_100ns_2.genblk1\[200\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[201\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[234\].delay_unit clkgen.delay_100ns_1.genblk1\[234\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[235\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_27_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[257\].delay_unit edgedetect.delay_200ns.genblk1\[257\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[258\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[232\].delay_unit clkgen.delay_100ns_3.genblk1\[232\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[233\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[24\].delay_unit clkgen.delay_100ns_2.genblk1\[24\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[25\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[56\].delay_unit clkgen.delay_100ns_3.genblk1\[56\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[57\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[266\].delay_unit clkgen.delay_100ns_2.genblk1\[266\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[267\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[114\].delay_unit clkgen.delay_100ns_1.genblk1\[114\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[115\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[58\].delay_unit clkgen.delay_100ns_1.genblk1\[58\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[59\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[436\].delay_unit edgedetect.delay_200ns.genblk1\[436\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[437\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[137\].delay_unit edgedetect.delay_200ns.genblk1\[137\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[138\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_23_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[112\].delay_unit clkgen.delay_100ns_3.genblk1\[112\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[113\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[60\].delay_unit clkgen.delay_100ns_1.genblk1\[60\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[61\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[146\].delay_unit clkgen.delay_100ns_2.genblk1\[146\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[147\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_2.genblk1\[92\].delay_unit clkgen.delay_100ns_2.genblk1\[92\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[93\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[16\].delay_unit edgedetect.delay_200ns.genblk1\[16\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[17\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[316\].delay_unit edgedetect.delay_200ns.genblk1\[316\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[317\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[178\].delay_unit clkgen.delay_100ns_3.genblk1\[178\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[179\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[182\].delay_unit clkgen.delay_100ns_1.genblk1\[182\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[183\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_96 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_3.genblk1\[180\].delay_unit clkgen.delay_100ns_3.genblk1\[180\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[181\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[84\].delay_unit edgedetect.delay_200ns.genblk1\[84\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[85\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_2.genblk1\[205\].delay_unit clkgen.delay_100ns_2.genblk1\[205\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[206\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[384\].delay_unit edgedetect.delay_200ns.genblk1\[384\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[385\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_100ns_1.genblk1\[239\].delay_unit clkgen.delay_100ns_1.genblk1\[239\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[240\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_34_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[29\].delay_unit clkgen.delay_100ns_2.genblk1\[29\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[30\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[237\].delay_unit clkgen.delay_100ns_3.genblk1\[237\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[238\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[241\].delay_unit clkgen.delay_100ns_1.genblk1\[241\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[242\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_13_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_200ns.genblk1\[264\].delay_unit edgedetect.delay_200ns.genblk1\[264\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[265\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_16_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[119\].delay_unit clkgen.delay_100ns_1.genblk1\[119\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[120\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[31\].delay_unit clkgen.delay_100ns_2.genblk1\[31\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[32\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_12_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_3.genblk1\[63\].delay_unit clkgen.delay_100ns_3.genblk1\[63\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[64\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[121\].delay_unit clkgen.delay_100ns_1.genblk1\[121\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[122\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[117\].delay_unit clkgen.delay_100ns_3.genblk1\[117\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[118\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[65\].delay_unit clkgen.delay_100ns_1.genblk1\[65\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[66\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_26_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[443\].delay_unit edgedetect.delay_200ns.genblk1\[443\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[444\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[144\].delay_unit edgedetect.delay_200ns.genblk1\[144\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[145\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkgen.delay_100ns_2.genblk1\[97\].delay_unit clkgen.delay_100ns_2.genblk1\[97\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[98\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_44_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[153\].delay_unit clkgen.delay_100ns_2.genblk1\[153\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[154\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[187\].delay_unit clkgen.delay_100ns_1.genblk1\[187\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[188\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[1\].delay_unit clk_dig VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[2\].delay_unit/A
+ sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_58_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_200ns.genblk1\[23\].delay_unit edgedetect.delay_200ns.genblk1\[23\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[24\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_26_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[323\].delay_unit edgedetect.delay_200ns.genblk1\[323\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[324\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[185\].delay_unit clkgen.delay_100ns_3.genblk1\[185\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[186\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_41_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[89\].delay_unit edgedetect.delay_200ns.genblk1\[89\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[90\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[389\].delay_unit edgedetect.delay_200ns.genblk1\[389\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[390\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_23_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_200ns.genblk1\[203\].delay_unit edgedetect.delay_200ns.genblk1\[203\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[204\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_61_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[502\].delay_unit edgedetect.delay_200ns.genblk1\[502\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[503\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_61_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[91\].delay_unit edgedetect.delay_200ns.genblk1\[91\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[92\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[212\].delay_unit clkgen.delay_100ns_2.genblk1\[212\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[213\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[391\].delay_unit edgedetect.delay_200ns.genblk1\[391\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[392\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_37_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_1.genblk1\[246\].delay_unit clkgen.delay_100ns_1.genblk1\[246\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[247\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_43_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[269\].delay_unit edgedetect.delay_200ns.genblk1\[269\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[270\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_34_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[36\].delay_unit clkgen.delay_100ns_2.genblk1\[36\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[37\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[244\].delay_unit clkgen.delay_100ns_3.genblk1\[244\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[245\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_61_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[68\].delay_unit clkgen.delay_100ns_3.genblk1\[68\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[69\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[271\].delay_unit edgedetect.delay_200ns.genblk1\[271\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[272\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_41_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_1.genblk1\[126\].delay_unit clkgen.delay_100ns_1.genblk1\[126\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[127\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_25_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_3.genblk1\[70\].delay_unit clkgen.delay_100ns_3.genblk1\[70\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[71\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[448\].delay_unit edgedetect.delay_200ns.genblk1\[448\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[449\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[149\].delay_unit edgedetect.delay_200ns.genblk1\[149\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[150\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_45_44 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[124\].delay_unit clkgen.delay_100ns_3.genblk1\[124\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[125\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[72\].delay_unit clkgen.delay_100ns_1.genblk1\[72\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[73\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[158\].delay_unit clkgen.delay_100ns_2.genblk1\[158\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[159\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_200ns.genblk1\[450\].delay_unit edgedetect.delay_200ns.genblk1\[450\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[451\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[151\].delay_unit edgedetect.delay_200ns.genblk1\[151\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[152\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[6\].delay_unit clkgen.delay_100ns_2.genblk1\[6\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[7\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_25_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk1\[160\].delay_unit clkgen.delay_100ns_2.genblk1\[160\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[161\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[28\].delay_unit edgedetect.delay_200ns.genblk1\[28\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[29\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[328\].delay_unit edgedetect.delay_200ns.genblk1\[328\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[329\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_15_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[194\].delay_unit clkgen.delay_100ns_1.genblk1\[194\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[195\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_31_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_238 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[30\].delay_unit edgedetect.delay_200ns.genblk1\[30\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[31\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_200ns.genblk1\[330\].delay_unit edgedetect.delay_200ns.genblk1\[330\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[331\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[192\].delay_unit clkgen.delay_100ns_3.genblk1\[192\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[193\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_182 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[208\].delay_unit edgedetect.delay_200ns.genblk1\[208\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[209\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_53_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[507\].delay_unit edgedetect.delay_200ns.genblk1\[507\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[508\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[96\].delay_unit edgedetect.delay_200ns.genblk1\[96\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[97\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[396\].delay_unit edgedetect.delay_200ns.genblk1\[396\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[397\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[217\].delay_unit clkgen.delay_100ns_2.genblk1\[217\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[218\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[210\].delay_unit edgedetect.delay_200ns.genblk1\[210\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[211\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_50_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[253\].delay_unit clkgen.delay_100ns_1.genblk1\[253\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[254\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_100ns_3.genblk1\[249\].delay_unit clkgen.delay_100ns_3.genblk1\[249\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[250\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_100ns_1.genblk1\[11\].delay_unit clkgen.delay_100ns_1.genblk1\[11\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[12\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_53_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[276\].delay_unit edgedetect.delay_200ns.genblk1\[276\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[277\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_2.genblk1\[43\].delay_unit clkgen.delay_100ns_2.genblk1\[43\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[44\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[251\].delay_unit clkgen.delay_100ns_3.genblk1\[251\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[252\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[75\].delay_unit clkgen.delay_100ns_3.genblk1\[75\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[76\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[129\].delay_unit clkgen.delay_100ns_3.genblk1\[129\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[130\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[133\].delay_unit clkgen.delay_100ns_1.genblk1\[133\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[134\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[77\].delay_unit clkgen.delay_100ns_1.genblk1\[77\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[78\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_23_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[156\].delay_unit edgedetect.delay_200ns.genblk1\[156\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[157\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xedgedetect.delay_200ns.genblk1\[455\].delay_unit edgedetect.delay_200ns.genblk1\[455\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[456\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[131\].delay_unit clkgen.delay_100ns_3.genblk1\[131\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[132\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_37_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_2.genblk1\[165\].delay_unit clkgen.delay_100ns_2.genblk1\[165\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[166\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_236 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_1.genblk1\[199\].delay_unit clkgen.delay_100ns_1.genblk1\[199\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[200\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_55_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[35\].delay_unit edgedetect.delay_200ns.genblk1\[35\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[36\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[335\].delay_unit edgedetect.delay_200ns.genblk1\[335\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[336\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_3.genblk1\[197\].delay_unit clkgen.delay_100ns_3.genblk1\[197\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[198\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[215\].delay_unit edgedetect.delay_200ns.genblk1\[215\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[216\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[514\].delay_unit edgedetect.delay_200ns.genblk1\[514\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[515\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_34_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[224\].delay_unit clkgen.delay_100ns_2.genblk1\[224\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[225\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[14\].delay_unit clkgen.delay_100ns_3.genblk1\[14\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[15\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[258\].delay_unit clkgen.delay_100ns_1.genblk1\[258\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[259\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[16\].delay_unit clkgen.delay_100ns_1.genblk1\[16\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[17\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_31_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_180 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_1.genblk1\[260\].delay_unit clkgen.delay_100ns_1.genblk1\[260\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[261\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_12_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_2.genblk1\[48\].delay_unit clkgen.delay_100ns_2.genblk1\[48\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[49\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_16_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[256\].delay_unit clkgen.delay_100ns_3.genblk1\[256\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[257\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[283\].delay_unit edgedetect.delay_200ns.genblk1\[283\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[284\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk1\[104\].delay_unit clkgen.delay_100ns_2.genblk1\[104\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[105\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[138\].delay_unit clkgen.delay_100ns_1.genblk1\[138\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[139\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[50\].delay_unit clkgen.delay_100ns_2.genblk1\[50\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[51\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_38_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_3.genblk1\[82\].delay_unit clkgen.delay_100ns_3.genblk1\[82\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[83\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[140\].delay_unit clkgen.delay_100ns_1.genblk1\[140\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[141\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[136\].delay_unit clkgen.delay_100ns_3.genblk1\[136\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[137\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[84\].delay_unit clkgen.delay_100ns_1.genblk1\[84\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[85\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_44_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[163\].delay_unit edgedetect.delay_200ns.genblk1\[163\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[164\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[462\].delay_unit edgedetect.delay_200ns.genblk1\[462\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[463\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[172\].delay_unit clkgen.delay_100ns_2.genblk1\[172\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[173\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[42\].delay_unit edgedetect.delay_200ns.genblk1\[42\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[43\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[342\].delay_unit edgedetect.delay_200ns.genblk1\[342\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[343\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[519\].delay_unit edgedetect.delay_200ns.genblk1\[519\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[520\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_61_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_28 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[229\].delay_unit clkgen.delay_100ns_2.genblk1\[229\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[230\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_52_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[222\].delay_unit edgedetect.delay_200ns.genblk1\[222\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[223\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_37_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_3.genblk1\[19\].delay_unit clkgen.delay_100ns_3.genblk1\[19\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[20\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_60_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[521\].delay_unit edgedetect.delay_200ns.genblk1\[521\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[522\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_2.genblk1\[231\].delay_unit clkgen.delay_100ns_2.genblk1\[231\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[232\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_1.genblk1\[265\].delay_unit clkgen.delay_100ns_1.genblk1\[265\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[266\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[21\].delay_unit clkgen.delay_100ns_3.genblk1\[21\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[22\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[23\].delay_unit clkgen.delay_100ns_1.genblk1\[23\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[24\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[288\].delay_unit edgedetect.delay_200ns.genblk1\[288\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[289\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[109\].delay_unit clkgen.delay_100ns_2.genblk1\[109\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[110\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[102\].delay_unit edgedetect.delay_200ns.genblk1\[102\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[103\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_24_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_2.genblk1\[55\].delay_unit clkgen.delay_100ns_2.genblk1\[55\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[56\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[401\].delay_unit edgedetect.delay_200ns.genblk1\[401\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[402\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[263\].delay_unit clkgen.delay_100ns_3.genblk1\[263\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[264\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_52_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_3.genblk1\[87\].delay_unit clkgen.delay_100ns_3.genblk1\[87\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[88\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[290\].delay_unit edgedetect.delay_200ns.genblk1\[290\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[291\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[111\].delay_unit clkgen.delay_100ns_2.genblk1\[111\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[112\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_1.genblk1\[145\].delay_unit clkgen.delay_100ns_1.genblk1\[145\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[146\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[89\].delay_unit clkgen.delay_100ns_1.genblk1\[89\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[90\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_45_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_200ns.genblk1\[168\].delay_unit edgedetect.delay_200ns.genblk1\[168\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[169\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_1.genblk1\[5\].delay_unit clkgen.delay_100ns_1.genblk1\[5\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[6\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[467\].delay_unit edgedetect.delay_200ns.genblk1\[467\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[468\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_3.genblk1\[143\].delay_unit clkgen.delay_100ns_3.genblk1\[143\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[144\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[91\].delay_unit clkgen.delay_100ns_1.genblk1\[91\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[92\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[177\].delay_unit clkgen.delay_100ns_2.genblk1\[177\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[178\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[170\].delay_unit edgedetect.delay_200ns.genblk1\[170\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[171\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_31_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_200ns.genblk1\[47\].delay_unit edgedetect.delay_200ns.genblk1\[47\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[48\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_24_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_200ns.genblk1\[347\].delay_unit edgedetect.delay_200ns.genblk1\[347\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[348\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_1.genblk1\[204\].delay_unit clkgen.delay_100ns_1.genblk1\[204\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[205\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[227\].delay_unit edgedetect.delay_200ns.genblk1\[227\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[228\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[526\].delay_unit edgedetect.delay_200ns.genblk1\[526\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[527\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_12_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_3.genblk1\[202\].delay_unit clkgen.delay_100ns_3.genblk1\[202\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[203\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[236\].delay_unit clkgen.delay_100ns_2.genblk1\[236\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[237\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[26\].delay_unit clkgen.delay_100ns_3.genblk1\[26\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[27\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_100ns_1.genblk1\[28\].delay_unit clkgen.delay_100ns_1.genblk1\[28\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[29\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_37_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[107\].delay_unit edgedetect.delay_200ns.genblk1\[107\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[108\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_200ns.genblk1\[406\].delay_unit edgedetect.delay_200ns.genblk1\[406\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[407\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[268\].delay_unit clkgen.delay_100ns_3.genblk1\[268\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[269\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_1.genblk1\[30\].delay_unit clkgen.delay_100ns_1.genblk1\[30\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[31\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[295\].delay_unit edgedetect.delay_200ns.genblk1\[295\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[296\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_2.genblk1\[116\].delay_unit clkgen.delay_100ns_2.genblk1\[116\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[117\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_55_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_2.genblk1\[62\].delay_unit clkgen.delay_100ns_2.genblk1\[62\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[63\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[270\].delay_unit clkgen.delay_100ns_3.genblk1\[270\].delay_unit/A
+ VGND VGND VPWR VPWR clk_comp sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_100ns_3.genblk1\[94\].delay_unit clkgen.delay_100ns_3.genblk1\[94\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[95\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_1.genblk1\[152\].delay_unit clkgen.delay_100ns_1.genblk1\[152\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[153\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_13_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[148\].delay_unit clkgen.delay_100ns_3.genblk1\[148\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[149\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[96\].delay_unit clkgen.delay_100ns_1.genblk1\[96\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[97\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[175\].delay_unit edgedetect.delay_200ns.genblk1\[175\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[176\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[474\].delay_unit edgedetect.delay_200ns.genblk1\[474\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[475\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_55_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[150\].delay_unit clkgen.delay_100ns_3.genblk1\[150\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[151\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_50_14 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_2.genblk1\[184\].delay_unit clkgen.delay_100ns_2.genblk1\[184\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[185\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_61_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_360 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[54\].delay_unit edgedetect.delay_200ns.genblk1\[54\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[55\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_275 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[354\].delay_unit edgedetect.delay_200ns.genblk1\[354\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[355\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[209\].delay_unit clkgen.delay_100ns_1.genblk1\[209\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[210\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_13 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_1.genblk1\[211\].delay_unit clkgen.delay_100ns_1.genblk1\[211\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[212\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_3.genblk1\[207\].delay_unit clkgen.delay_100ns_3.genblk1\[207\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[208\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_200ns.genblk1\[234\].delay_unit edgedetect.delay_200ns.genblk1\[234\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[235\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[533\].delay_unit edgedetect.delay_200ns.genblk1\[533\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[534\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_208 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkgen.delay_100ns_2.genblk1\[243\].delay_unit clkgen.delay_100ns_2.genblk1\[243\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[244\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_3.genblk1\[33\].delay_unit clkgen.delay_100ns_3.genblk1\[33\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[34\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[35\].delay_unit clkgen.delay_100ns_1.genblk1\[35\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[36\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[114\].delay_unit edgedetect.delay_200ns.genblk1\[114\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[115\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[413\].delay_unit edgedetect.delay_200ns.genblk1\[413\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[414\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[67\].delay_unit clkgen.delay_100ns_2.genblk1\[67\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[68\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_53_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_3.genblk1\[99\].delay_unit clkgen.delay_100ns_3.genblk1\[99\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[99\].delay_unit/X sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[123\].delay_unit clkgen.delay_100ns_2.genblk1\[123\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[124\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_13_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[157\].delay_unit clkgen.delay_100ns_1.genblk1\[157\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[158\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_200ns.genblk1\[479\].delay_unit edgedetect.delay_200ns.genblk1\[479\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[480\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_3.genblk1\[155\].delay_unit clkgen.delay_100ns_3.genblk1\[155\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[156\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[189\].delay_unit clkgen.delay_100ns_2.genblk1\[189\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[190\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_58_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[182\].delay_unit edgedetect.delay_200ns.genblk1\[182\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[183\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_53_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[481\].delay_unit edgedetect.delay_200ns.genblk1\[481\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[482\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[59\].delay_unit edgedetect.delay_200ns.genblk1\[59\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[60\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[191\].delay_unit clkgen.delay_100ns_2.genblk1\[191\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[192\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_17_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[359\].delay_unit edgedetect.delay_200ns.genblk1\[359\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[360\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_200ns.genblk1\[61\].delay_unit edgedetect.delay_200ns.genblk1\[61\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[62\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_23_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[361\].delay_unit edgedetect.delay_200ns.genblk1\[361\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[362\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_100 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_1.genblk1\[216\].delay_unit clkgen.delay_100ns_1.genblk1\[216\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[217\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_200ns.genblk1\[239\].delay_unit edgedetect.delay_200ns.genblk1\[239\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[240\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[538\].delay_unit edgedetect.delay_200ns.genblk1\[538\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[539\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[214\].delay_unit clkgen.delay_100ns_3.genblk1\[214\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[215\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_55_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[248\].delay_unit clkgen.delay_100ns_2.genblk1\[248\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[249\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_55_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[241\].delay_unit edgedetect.delay_200ns.genblk1\[241\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[242\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[38\].delay_unit clkgen.delay_100ns_3.genblk1\[38\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[39\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[540\].delay_unit edgedetect.delay_200ns.genblk1\[540\].delay_unit/A
+ VGND VGND VPWR VPWR _2_/A_N sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[119\].delay_unit edgedetect.delay_200ns.genblk1\[119\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[120\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[418\].delay_unit edgedetect.delay_200ns.genblk1\[418\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[419\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[250\].delay_unit clkgen.delay_100ns_2.genblk1\[250\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[251\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[40\].delay_unit clkgen.delay_100ns_3.genblk1\[40\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[41\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_172 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkgen.delay_100ns_1.genblk1\[42\].delay_unit clkgen.delay_100ns_1.genblk1\[42\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[43\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_52_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_320 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_2.genblk1\[128\].delay_unit clkgen.delay_100ns_2.genblk1\[128\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[129\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_200ns.genblk1\[121\].delay_unit edgedetect.delay_200ns.genblk1\[121\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[122\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[420\].delay_unit edgedetect.delay_200ns.genblk1\[420\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[421\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[74\].delay_unit clkgen.delay_100ns_2.genblk1\[74\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[75\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_61_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_25 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_202 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_2.genblk1\[130\].delay_unit clkgen.delay_100ns_2.genblk1\[130\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[131\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[164\].delay_unit clkgen.delay_100ns_1.genblk1\[164\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[165\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[187\].delay_unit edgedetect.delay_200ns.genblk1\[187\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[188\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[4\].delay_unit edgedetect.delay_200ns.genblk1\[4\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[5\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[486\].delay_unit edgedetect.delay_200ns.genblk1\[486\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[487\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_15_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[300\].delay_unit edgedetect.delay_200ns.genblk1\[300\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[301\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[162\].delay_unit clkgen.delay_100ns_3.genblk1\[162\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[163\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk1\[196\].delay_unit clkgen.delay_100ns_2.genblk1\[196\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[197\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_12_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[66\].delay_unit edgedetect.delay_200ns.genblk1\[66\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[67\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[366\].delay_unit edgedetect.delay_200ns.genblk1\[366\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[367\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_53_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[219\].delay_unit clkgen.delay_100ns_3.genblk1\[219\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[220\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[223\].delay_unit clkgen.delay_100ns_1.genblk1\[223\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[224\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_12_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[246\].delay_unit edgedetect.delay_200ns.genblk1\[246\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[247\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_100ns_3.genblk1\[221\].delay_unit clkgen.delay_100ns_3.genblk1\[221\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[222\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_100ns_2.genblk1\[13\].delay_unit clkgen.delay_100ns_2.genblk1\[13\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[14\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_41_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_3.genblk1\[45\].delay_unit clkgen.delay_100ns_3.genblk1\[45\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[46\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[255\].delay_unit clkgen.delay_100ns_2.genblk1\[255\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[256\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[103\].delay_unit clkgen.delay_100ns_1.genblk1\[103\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[104\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_17_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[47\].delay_unit clkgen.delay_100ns_1.genblk1\[47\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[48\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_55_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[425\].delay_unit edgedetect.delay_200ns.genblk1\[425\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[426\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[126\].delay_unit edgedetect.delay_200ns.genblk1\[126\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[127\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk1\[79\].delay_unit clkgen.delay_100ns_2.genblk1\[79\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[80\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[101\].delay_unit clkgen.delay_100ns_3.genblk1\[101\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[102\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_58_112 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_100ns_2.genblk1\[135\].delay_unit clkgen.delay_100ns_2.genblk1\[135\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[136\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_100ns_1.genblk1\[169\].delay_unit clkgen.delay_100ns_1.genblk1\[169\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[170\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[81\].delay_unit clkgen.delay_100ns_2.genblk1\[81\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[82\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_13_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[9\].delay_unit edgedetect.delay_200ns.genblk1\[9\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[9\].delay_unit/X sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_62_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[305\].delay_unit edgedetect.delay_200ns.genblk1\[305\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[306\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[3\].delay_unit clkgen.delay_100ns_3.genblk1\[3\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[4\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[167\].delay_unit clkgen.delay_100ns_3.genblk1\[167\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[168\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[171\].delay_unit clkgen.delay_100ns_1.genblk1\[171\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[172\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[194\].delay_unit edgedetect.delay_200ns.genblk1\[194\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[195\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[493\].delay_unit edgedetect.delay_200ns.genblk1\[493\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[494\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_43 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_184 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_200ns.genblk1\[73\].delay_unit edgedetect.delay_200ns.genblk1\[73\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[74\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[373\].delay_unit edgedetect.delay_200ns.genblk1\[373\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[374\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_61_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_1.genblk1\[228\].delay_unit clkgen.delay_100ns_1.genblk1\[228\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[229\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_2.genblk1\[18\].delay_unit clkgen.delay_100ns_2.genblk1\[18\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[19\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[226\].delay_unit clkgen.delay_100ns_3.genblk1\[226\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[227\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[230\].delay_unit clkgen.delay_100ns_1.genblk1\[230\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[231\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[253\].delay_unit edgedetect.delay_200ns.genblk1\[253\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[254\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_1.genblk1\[108\].delay_unit clkgen.delay_100ns_1.genblk1\[108\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[109\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[20\].delay_unit clkgen.delay_100ns_2.genblk1\[20\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[21\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_12_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[262\].delay_unit clkgen.delay_100ns_2.genblk1\[262\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[263\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_210 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_3.genblk1\[52\].delay_unit clkgen.delay_100ns_3.genblk1\[52\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[53\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[110\].delay_unit clkgen.delay_100ns_1.genblk1\[110\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[111\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[106\].delay_unit clkgen.delay_100ns_3.genblk1\[106\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[107\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[54\].delay_unit clkgen.delay_100ns_1.genblk1\[54\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[55\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_200ns.genblk1\[432\].delay_unit edgedetect.delay_200ns.genblk1\[432\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[433\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[133\].delay_unit edgedetect.delay_200ns.genblk1\[133\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[134\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[86\].delay_unit clkgen.delay_100ns_2.genblk1\[86\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[87\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_3.genblk1\[8\].delay_unit clkgen.delay_100ns_3.genblk1\[8\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[9\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[142\].delay_unit clkgen.delay_100ns_2.genblk1\[142\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[143\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[176\].delay_unit clkgen.delay_100ns_1.genblk1\[176\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[177\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_43_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_200ns.genblk1\[199\].delay_unit edgedetect.delay_200ns.genblk1\[199\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[200\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[12\].delay_unit edgedetect.delay_200ns.genblk1\[12\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[13\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[498\].delay_unit edgedetect.delay_200ns.genblk1\[498\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[499\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[312\].delay_unit edgedetect.delay_200ns.genblk1\[312\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[313\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[174\].delay_unit clkgen.delay_100ns_3.genblk1\[174\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[175\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_53_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_360 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[78\].delay_unit edgedetect.delay_200ns.genblk1\[78\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[79\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_31_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[378\].delay_unit edgedetect.delay_200ns.genblk1\[378\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[379\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_58_124 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[80\].delay_unit edgedetect.delay_200ns.genblk1\[80\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[81\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[201\].delay_unit clkgen.delay_100ns_2.genblk1\[201\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[202\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[380\].delay_unit edgedetect.delay_200ns.genblk1\[380\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[381\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[235\].delay_unit clkgen.delay_100ns_1.genblk1\[235\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[236\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_55_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[258\].delay_unit edgedetect.delay_200ns.genblk1\[258\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[259\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_55_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk1\[25\].delay_unit clkgen.delay_100ns_2.genblk1\[25\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[26\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[233\].delay_unit clkgen.delay_100ns_3.genblk1\[233\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[234\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[267\].delay_unit clkgen.delay_100ns_2.genblk1\[267\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[268\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[260\].delay_unit edgedetect.delay_200ns.genblk1\[260\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[261\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[57\].delay_unit clkgen.delay_100ns_3.genblk1\[57\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[58\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_1.genblk1\[59\].delay_unit clkgen.delay_100ns_1.genblk1\[59\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[60\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[115\].delay_unit clkgen.delay_100ns_1.genblk1\[115\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[116\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_52_108 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[437\].delay_unit edgedetect.delay_200ns.genblk1\[437\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[438\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[138\].delay_unit edgedetect.delay_200ns.genblk1\[138\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[139\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[113\].delay_unit clkgen.delay_100ns_3.genblk1\[113\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[114\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_43_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[61\].delay_unit clkgen.delay_100ns_1.genblk1\[61\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[62\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[147\].delay_unit clkgen.delay_100ns_2.genblk1\[147\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[148\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[140\].delay_unit edgedetect.delay_200ns.genblk1\[140\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[141\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[93\].delay_unit clkgen.delay_100ns_2.genblk1\[93\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[94\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[17\].delay_unit edgedetect.delay_200ns.genblk1\[17\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[18\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[317\].delay_unit edgedetect.delay_200ns.genblk1\[317\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[318\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[179\].delay_unit clkgen.delay_100ns_3.genblk1\[179\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[180\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[183\].delay_unit clkgen.delay_100ns_1.genblk1\[183\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[184\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_56_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[181\].delay_unit clkgen.delay_100ns_3.genblk1\[181\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[182\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_200ns.genblk1\[85\].delay_unit edgedetect.delay_200ns.genblk1\[85\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[86\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[206\].delay_unit clkgen.delay_100ns_2.genblk1\[206\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[207\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[385\].delay_unit edgedetect.delay_200ns.genblk1\[385\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[386\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_44_236 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_1.genblk1\[242\].delay_unit clkgen.delay_100ns_1.genblk1\[242\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[243\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[238\].delay_unit clkgen.delay_100ns_3.genblk1\[238\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[239\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_200ns.genblk1\[265\].delay_unit edgedetect.delay_200ns.genblk1\[265\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[266\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_346 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_2.genblk1\[32\].delay_unit clkgen.delay_100ns_2.genblk1\[32\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[33\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[240\].delay_unit clkgen.delay_100ns_3.genblk1\[240\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[241\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkgen.delay_100ns_3.genblk1\[64\].delay_unit clkgen.delay_100ns_3.genblk1\[64\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[65\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[122\].delay_unit clkgen.delay_100ns_1.genblk1\[122\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[123\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[66\].delay_unit clkgen.delay_100ns_1.genblk1\[66\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[67\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[118\].delay_unit clkgen.delay_100ns_3.genblk1\[118\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[119\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_58_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[145\].delay_unit edgedetect.delay_200ns.genblk1\[145\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[146\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[444\].delay_unit edgedetect.delay_200ns.genblk1\[444\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[445\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[98\].delay_unit clkgen.delay_100ns_2.genblk1\[98\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[99\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_239 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[120\].delay_unit clkgen.delay_100ns_3.genblk1\[120\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[121\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[154\].delay_unit clkgen.delay_100ns_2.genblk1\[154\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[155\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_60_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_2.genblk1\[2\].delay_unit clkgen.delay_100ns_2.genblk1\[2\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[3\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_1.genblk1\[188\].delay_unit clkgen.delay_100ns_1.genblk1\[188\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[189\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_331 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[24\].delay_unit edgedetect.delay_200ns.genblk1\[24\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[25\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_16 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[324\].delay_unit edgedetect.delay_200ns.genblk1\[324\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[325\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[186\].delay_unit clkgen.delay_100ns_3.genblk1\[186\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[187\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[190\].delay_unit clkgen.delay_100ns_1.genblk1\[190\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[191\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_24_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[204\].delay_unit edgedetect.delay_200ns.genblk1\[204\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[205\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_24_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[503\].delay_unit edgedetect.delay_200ns.genblk1\[503\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[504\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[92\].delay_unit edgedetect.delay_200ns.genblk1\[92\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[93\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[392\].delay_unit edgedetect.delay_200ns.genblk1\[392\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[393\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[213\].delay_unit clkgen.delay_100ns_2.genblk1\[213\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[214\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[247\].delay_unit clkgen.delay_100ns_1.genblk1\[247\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[248\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[37\].delay_unit clkgen.delay_100ns_2.genblk1\[37\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[38\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_3.genblk1\[245\].delay_unit clkgen.delay_100ns_3.genblk1\[245\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[246\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[69\].delay_unit clkgen.delay_100ns_3.genblk1\[69\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[70\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[272\].delay_unit edgedetect.delay_200ns.genblk1\[272\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[273\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[127\].delay_unit clkgen.delay_100ns_1.genblk1\[127\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[128\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_50 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_3.genblk1\[71\].delay_unit clkgen.delay_100ns_3.genblk1\[71\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[72\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[449\].delay_unit edgedetect.delay_200ns.genblk1\[449\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[450\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[125\].delay_unit clkgen.delay_100ns_3.genblk1\[125\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[126\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[73\].delay_unit clkgen.delay_100ns_1.genblk1\[73\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[74\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[159\].delay_unit clkgen.delay_100ns_2.genblk1\[159\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[160\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[152\].delay_unit edgedetect.delay_200ns.genblk1\[152\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[153\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[7\].delay_unit clkgen.delay_100ns_2.genblk1\[7\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[8\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[451\].delay_unit edgedetect.delay_200ns.genblk1\[451\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[452\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_50_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[161\].delay_unit clkgen.delay_100ns_2.genblk1\[161\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[162\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[29\].delay_unit edgedetect.delay_200ns.genblk1\[29\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[30\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_58_318 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_100ns_1.genblk1\[195\].delay_unit clkgen.delay_100ns_1.genblk1\[195\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[196\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[329\].delay_unit edgedetect.delay_200ns.genblk1\[329\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[330\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[31\].delay_unit edgedetect.delay_200ns.genblk1\[31\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[32\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[331\].delay_unit edgedetect.delay_200ns.genblk1\[331\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[332\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[193\].delay_unit clkgen.delay_100ns_3.genblk1\[193\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[194\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_43_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[209\].delay_unit edgedetect.delay_200ns.genblk1\[209\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[210\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_31_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[508\].delay_unit edgedetect.delay_200ns.genblk1\[508\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[509\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_200ns.genblk1\[97\].delay_unit edgedetect.delay_200ns.genblk1\[97\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[98\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_2.genblk1\[218\].delay_unit clkgen.delay_100ns_2.genblk1\[218\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[219\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[397\].delay_unit edgedetect.delay_200ns.genblk1\[397\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[398\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[211\].delay_unit edgedetect.delay_200ns.genblk1\[211\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[212\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[510\].delay_unit edgedetect.delay_200ns.genblk1\[510\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[511\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_60_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_2.genblk1\[220\].delay_unit clkgen.delay_100ns_2.genblk1\[220\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[221\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_51_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_343 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_3.genblk1\[10\].delay_unit clkgen.delay_100ns_3.genblk1\[9\].delay_unit/X
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[11\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[254\].delay_unit clkgen.delay_100ns_1.genblk1\[254\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[255\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkgen.delay_100ns_1.genblk1\[12\].delay_unit clkgen.delay_100ns_1.genblk1\[12\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[13\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[277\].delay_unit edgedetect.delay_200ns.genblk1\[277\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[278\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_54_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[44\].delay_unit clkgen.delay_100ns_2.genblk1\[44\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[45\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[252\].delay_unit clkgen.delay_100ns_3.genblk1\[252\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[253\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_3.genblk1\[76\].delay_unit clkgen.delay_100ns_3.genblk1\[76\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[77\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[100\].delay_unit clkgen.delay_100ns_2.genblk1\[99\].delay_unit/X
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[101\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[134\].delay_unit clkgen.delay_100ns_1.genblk1\[134\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[135\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[78\].delay_unit clkgen.delay_100ns_1.genblk1\[78\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[79\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_36_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[157\].delay_unit edgedetect.delay_200ns.genblk1\[157\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[158\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[456\].delay_unit edgedetect.delay_200ns.genblk1\[456\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[457\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[132\].delay_unit clkgen.delay_100ns_3.genblk1\[132\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[133\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[80\].delay_unit clkgen.delay_100ns_1.genblk1\[80\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[81\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[166\].delay_unit clkgen.delay_100ns_2.genblk1\[166\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[167\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_200ns.genblk1\[36\].delay_unit edgedetect.delay_200ns.genblk1\[36\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[37\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_24_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[336\].delay_unit edgedetect.delay_200ns.genblk1\[336\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[337\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[198\].delay_unit clkgen.delay_100ns_3.genblk1\[198\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[199\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_200ns.genblk1\[216\].delay_unit edgedetect.delay_200ns.genblk1\[216\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[217\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[515\].delay_unit edgedetect.delay_200ns.genblk1\[515\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[516\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_2.genblk1\[225\].delay_unit clkgen.delay_100ns_2.genblk1\[225\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[226\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_43_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[259\].delay_unit clkgen.delay_100ns_1.genblk1\[259\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[260\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[15\].delay_unit clkgen.delay_100ns_3.genblk1\[15\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[16\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_100ns_1.genblk1\[17\].delay_unit clkgen.delay_100ns_1.genblk1\[17\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[18\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_1.genblk1\[261\].delay_unit clkgen.delay_100ns_1.genblk1\[261\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[262\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[49\].delay_unit clkgen.delay_100ns_2.genblk1\[49\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[50\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[257\].delay_unit clkgen.delay_100ns_3.genblk1\[257\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[258\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_43_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[284\].delay_unit edgedetect.delay_200ns.genblk1\[284\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[285\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[105\].delay_unit clkgen.delay_100ns_2.genblk1\[105\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[106\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[139\].delay_unit clkgen.delay_100ns_1.genblk1\[139\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[140\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_2.genblk1\[51\].delay_unit clkgen.delay_100ns_2.genblk1\[51\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[52\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[83\].delay_unit clkgen.delay_100ns_3.genblk1\[83\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[84\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_100ns_1.genblk1\[141\].delay_unit clkgen.delay_100ns_1.genblk1\[141\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[142\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[137\].delay_unit clkgen.delay_100ns_3.genblk1\[137\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[138\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[85\].delay_unit clkgen.delay_100ns_1.genblk1\[85\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[86\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_13_44 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_200ns.genblk1\[164\].delay_unit edgedetect.delay_200ns.genblk1\[164\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[165\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[1\].delay_unit comp_trig VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[2\].delay_unit/A
+ sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[463\].delay_unit edgedetect.delay_200ns.genblk1\[463\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[464\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_2.genblk1\[173\].delay_unit clkgen.delay_100ns_2.genblk1\[173\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[174\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_54_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xedgedetect.delay_200ns.genblk1\[43\].delay_unit edgedetect.delay_200ns.genblk1\[43\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[44\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_24_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[343\].delay_unit edgedetect.delay_200ns.genblk1\[343\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[344\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_60_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_1.genblk1\[200\].delay_unit clkgen.delay_100ns_1.genblk1\[200\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[201\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[223\].delay_unit edgedetect.delay_200ns.genblk1\[223\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[224\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[522\].delay_unit edgedetect.delay_200ns.genblk1\[522\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[523\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk1\[232\].delay_unit clkgen.delay_100ns_2.genblk1\[232\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[233\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_56_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[266\].delay_unit clkgen.delay_100ns_1.genblk1\[266\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[267\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[22\].delay_unit clkgen.delay_100ns_3.genblk1\[22\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[23\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_1.genblk1\[24\].delay_unit clkgen.delay_100ns_1.genblk1\[24\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[25\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[289\].delay_unit edgedetect.delay_200ns.genblk1\[289\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[290\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_200ns.genblk1\[103\].delay_unit edgedetect.delay_200ns.genblk1\[103\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[104\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk1\[56\].delay_unit clkgen.delay_100ns_2.genblk1\[56\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[57\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[402\].delay_unit edgedetect.delay_200ns.genblk1\[402\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[403\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[264\].delay_unit clkgen.delay_100ns_3.genblk1\[264\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[265\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_3.genblk1\[88\].delay_unit clkgen.delay_100ns_3.genblk1\[88\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[89\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[291\].delay_unit edgedetect.delay_200ns.genblk1\[291\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[292\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[112\].delay_unit clkgen.delay_100ns_2.genblk1\[112\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[113\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[146\].delay_unit clkgen.delay_100ns_1.genblk1\[146\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[147\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[169\].delay_unit edgedetect.delay_200ns.genblk1\[169\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[170\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_12_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[6\].delay_unit clkgen.delay_100ns_1.genblk1\[6\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[7\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[90\].delay_unit clkgen.delay_100ns_3.genblk1\[90\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[91\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_200ns.genblk1\[468\].delay_unit edgedetect.delay_200ns.genblk1\[468\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[469\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[144\].delay_unit clkgen.delay_100ns_3.genblk1\[144\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[145\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[92\].delay_unit clkgen.delay_100ns_1.genblk1\[92\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[93\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[178\].delay_unit clkgen.delay_100ns_2.genblk1\[178\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[179\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_200ns.genblk1\[171\].delay_unit edgedetect.delay_200ns.genblk1\[171\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[172\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_200ns.genblk1\[470\].delay_unit edgedetect.delay_200ns.genblk1\[470\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[471\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[48\].delay_unit edgedetect.delay_200ns.genblk1\[48\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[49\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[180\].delay_unit clkgen.delay_100ns_2.genblk1\[180\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[181\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[348\].delay_unit edgedetect.delay_200ns.genblk1\[348\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[349\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_176 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_14 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[50\].delay_unit edgedetect.delay_200ns.genblk1\[50\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[51\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xedgedetect.delay_200ns.genblk1\[350\].delay_unit edgedetect.delay_200ns.genblk1\[350\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[351\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[205\].delay_unit clkgen.delay_100ns_1.genblk1\[205\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[206\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[228\].delay_unit edgedetect.delay_200ns.genblk1\[228\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[229\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[527\].delay_unit edgedetect.delay_200ns.genblk1\[527\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[528\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_38_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[203\].delay_unit clkgen.delay_100ns_3.genblk1\[203\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[204\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_13_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[237\].delay_unit clkgen.delay_100ns_2.genblk1\[237\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[238\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[230\].delay_unit edgedetect.delay_200ns.genblk1\[230\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[231\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_36_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_3.genblk1\[27\].delay_unit clkgen.delay_100ns_3.genblk1\[27\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[28\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[29\].delay_unit clkgen.delay_100ns_1.genblk1\[29\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[30\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[108\].delay_unit edgedetect.delay_200ns.genblk1\[108\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[109\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[407\].delay_unit edgedetect.delay_200ns.genblk1\[407\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[408\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[269\].delay_unit clkgen.delay_100ns_3.genblk1\[269\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[270\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[31\].delay_unit clkgen.delay_100ns_1.genblk1\[31\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[32\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[296\].delay_unit edgedetect.delay_200ns.genblk1\[296\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[297\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[117\].delay_unit clkgen.delay_100ns_2.genblk1\[117\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[118\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[110\].delay_unit edgedetect.delay_200ns.genblk1\[110\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[111\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_2.genblk1\[63\].delay_unit clkgen.delay_100ns_2.genblk1\[63\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[64\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_36_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_3.genblk1\[95\].delay_unit clkgen.delay_100ns_3.genblk1\[95\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[96\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_1.genblk1\[153\].delay_unit clkgen.delay_100ns_1.genblk1\[153\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[154\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_3.genblk1\[149\].delay_unit clkgen.delay_100ns_3.genblk1\[149\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[150\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[97\].delay_unit clkgen.delay_100ns_1.genblk1\[97\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[98\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_318 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_31 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[176\].delay_unit edgedetect.delay_200ns.genblk1\[176\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[177\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[475\].delay_unit edgedetect.delay_200ns.genblk1\[475\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[476\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_3.genblk1\[151\].delay_unit clkgen.delay_100ns_3.genblk1\[151\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[152\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[185\].delay_unit clkgen.delay_100ns_2.genblk1\[185\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[186\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[55\].delay_unit edgedetect.delay_200ns.genblk1\[55\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[56\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[355\].delay_unit edgedetect.delay_200ns.genblk1\[355\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[356\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_207 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_240 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_3.genblk1\[208\].delay_unit clkgen.delay_100ns_3.genblk1\[208\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[209\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[212\].delay_unit clkgen.delay_100ns_1.genblk1\[212\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[213\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_16_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[235\].delay_unit edgedetect.delay_200ns.genblk1\[235\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[236\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[534\].delay_unit edgedetect.delay_200ns.genblk1\[534\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[535\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[210\].delay_unit clkgen.delay_100ns_3.genblk1\[210\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[211\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[244\].delay_unit clkgen.delay_100ns_2.genblk1\[244\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[245\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[34\].delay_unit clkgen.delay_100ns_3.genblk1\[34\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[35\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[36\].delay_unit clkgen.delay_100ns_1.genblk1\[36\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[37\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_25_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[115\].delay_unit edgedetect.delay_200ns.genblk1\[115\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[116\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[414\].delay_unit edgedetect.delay_200ns.genblk1\[414\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[415\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_2.genblk1\[68\].delay_unit clkgen.delay_100ns_2.genblk1\[68\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[69\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_16_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_100ns_2.genblk1\[124\].delay_unit clkgen.delay_100ns_2.genblk1\[124\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[125\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_1.genblk1\[158\].delay_unit clkgen.delay_100ns_1.genblk1\[158\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[159\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[70\].delay_unit clkgen.delay_100ns_2.genblk1\[70\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[71\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_3.genblk1\[156\].delay_unit clkgen.delay_100ns_3.genblk1\[156\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[157\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[160\].delay_unit clkgen.delay_100ns_1.genblk1\[160\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[161\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[183\].delay_unit edgedetect.delay_200ns.genblk1\[183\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[184\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[482\].delay_unit edgedetect.delay_200ns.genblk1\[482\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[483\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_27_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_206 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_2.genblk1\[192\].delay_unit clkgen.delay_100ns_2.genblk1\[192\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[193\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_200ns.genblk1\[62\].delay_unit edgedetect.delay_200ns.genblk1\[62\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[63\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[362\].delay_unit edgedetect.delay_200ns.genblk1\[362\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[363\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_51_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_1.genblk1\[217\].delay_unit clkgen.delay_100ns_1.genblk1\[217\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[218\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_14 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[539\].delay_unit edgedetect.delay_200ns.genblk1\[539\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[540\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[215\].delay_unit clkgen.delay_100ns_3.genblk1\[215\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[216\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk1\[249\].delay_unit clkgen.delay_100ns_2.genblk1\[249\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[250\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[39\].delay_unit clkgen.delay_100ns_3.genblk1\[39\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[40\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[242\].delay_unit edgedetect.delay_200ns.genblk1\[242\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[243\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_56_238 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk1\[251\].delay_unit clkgen.delay_100ns_2.genblk1\[251\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[252\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_200ns.genblk1\[419\].delay_unit edgedetect.delay_200ns.genblk1\[419\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[420\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[41\].delay_unit clkgen.delay_100ns_3.genblk1\[41\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[42\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_55_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_1.genblk1\[43\].delay_unit clkgen.delay_100ns_1.genblk1\[43\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[44\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_53_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_238 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_2.genblk1\[129\].delay_unit clkgen.delay_100ns_2.genblk1\[129\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[130\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[122\].delay_unit edgedetect.delay_200ns.genblk1\[122\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[123\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[421\].delay_unit edgedetect.delay_200ns.genblk1\[421\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[422\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[75\].delay_unit clkgen.delay_100ns_2.genblk1\[75\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[76\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_2.genblk1\[131\].delay_unit clkgen.delay_100ns_2.genblk1\[131\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[132\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[165\].delay_unit clkgen.delay_100ns_1.genblk1\[165\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[166\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[188\].delay_unit edgedetect.delay_200ns.genblk1\[188\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[189\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[5\].delay_unit edgedetect.delay_200ns.genblk1\[5\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[6\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[487\].delay_unit edgedetect.delay_200ns.genblk1\[487\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[488\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_200ns.genblk1\[301\].delay_unit edgedetect.delay_200ns.genblk1\[301\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[302\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[163\].delay_unit clkgen.delay_100ns_3.genblk1\[163\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[164\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_307 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_2.genblk1\[197\].delay_unit clkgen.delay_100ns_2.genblk1\[197\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[198\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[190\].delay_unit edgedetect.delay_200ns.genblk1\[190\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[191\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[67\].delay_unit edgedetect.delay_200ns.genblk1\[67\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[68\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[367\].delay_unit edgedetect.delay_200ns.genblk1\[367\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[368\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[224\].delay_unit clkgen.delay_100ns_1.genblk1\[224\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[225\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_54_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[247\].delay_unit edgedetect.delay_200ns.genblk1\[247\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[248\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_2.genblk1\[14\].delay_unit clkgen.delay_100ns_2.genblk1\[14\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[15\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[222\].delay_unit clkgen.delay_100ns_3.genblk1\[222\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[223\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[256\].delay_unit clkgen.delay_100ns_2.genblk1\[256\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[257\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_54_111 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[46\].delay_unit clkgen.delay_100ns_3.genblk1\[46\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[47\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[48\].delay_unit clkgen.delay_100ns_1.genblk1\[48\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[49\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[104\].delay_unit clkgen.delay_100ns_1.genblk1\[104\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[105\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[127\].delay_unit edgedetect.delay_200ns.genblk1\[127\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[128\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[426\].delay_unit edgedetect.delay_200ns.genblk1\[426\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[427\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_3.genblk1\[102\].delay_unit clkgen.delay_100ns_3.genblk1\[102\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[103\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[50\].delay_unit clkgen.delay_100ns_1.genblk1\[50\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[51\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_51_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[136\].delay_unit clkgen.delay_100ns_2.genblk1\[136\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[137\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_203 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_2.genblk1\[82\].delay_unit clkgen.delay_100ns_2.genblk1\[82\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[83\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[306\].delay_unit edgedetect.delay_200ns.genblk1\[306\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[307\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_3.genblk1\[4\].delay_unit clkgen.delay_100ns_3.genblk1\[4\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[5\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[168\].delay_unit clkgen.delay_100ns_3.genblk1\[168\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[169\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[172\].delay_unit clkgen.delay_100ns_1.genblk1\[172\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[173\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[195\].delay_unit edgedetect.delay_200ns.genblk1\[195\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[196\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[494\].delay_unit edgedetect.delay_200ns.genblk1\[494\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[495\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[170\].delay_unit clkgen.delay_100ns_3.genblk1\[170\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[171\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[74\].delay_unit edgedetect.delay_200ns.genblk1\[74\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[75\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[374\].delay_unit edgedetect.delay_200ns.genblk1\[374\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[375\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[229\].delay_unit clkgen.delay_100ns_1.genblk1\[229\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[230\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_52_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_2.genblk1\[19\].delay_unit clkgen.delay_100ns_2.genblk1\[19\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[20\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[231\].delay_unit clkgen.delay_100ns_1.genblk1\[231\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[232\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[227\].delay_unit clkgen.delay_100ns_3.genblk1\[227\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[228\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[254\].delay_unit edgedetect.delay_200ns.genblk1\[254\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[255\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[109\].delay_unit clkgen.delay_100ns_1.genblk1\[109\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[110\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[21\].delay_unit clkgen.delay_100ns_2.genblk1\[21\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[22\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[263\].delay_unit clkgen.delay_100ns_2.genblk1\[263\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[264\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[53\].delay_unit clkgen.delay_100ns_3.genblk1\[53\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[54\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_1.genblk1\[55\].delay_unit clkgen.delay_100ns_1.genblk1\[55\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[56\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[111\].delay_unit clkgen.delay_100ns_1.genblk1\[111\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[112\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[107\].delay_unit clkgen.delay_100ns_3.genblk1\[107\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[108\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_16_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[134\].delay_unit edgedetect.delay_200ns.genblk1\[134\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[135\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_190 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_200ns.genblk1\[433\].delay_unit edgedetect.delay_200ns.genblk1\[433\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[434\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_100ns_2.genblk1\[87\].delay_unit clkgen.delay_100ns_2.genblk1\[87\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[88\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_2.genblk1\[143\].delay_unit clkgen.delay_100ns_2.genblk1\[143\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[144\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_60_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[9\].delay_unit clkgen.delay_100ns_3.genblk1\[9\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[9\].delay_unit/X sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[177\].delay_unit clkgen.delay_100ns_1.genblk1\[177\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[178\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_13_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[499\].delay_unit edgedetect.delay_200ns.genblk1\[499\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[500\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[13\].delay_unit edgedetect.delay_200ns.genblk1\[13\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[14\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[313\].delay_unit edgedetect.delay_200ns.genblk1\[313\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[314\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[175\].delay_unit clkgen.delay_100ns_3.genblk1\[175\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[176\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_54_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[79\].delay_unit edgedetect.delay_200ns.genblk1\[79\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[80\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[379\].delay_unit edgedetect.delay_200ns.genblk1\[379\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[380\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_36_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_38 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_200ns.genblk1\[81\].delay_unit edgedetect.delay_200ns.genblk1\[81\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[82\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[202\].delay_unit clkgen.delay_100ns_2.genblk1\[202\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[203\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_15_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[381\].delay_unit edgedetect.delay_200ns.genblk1\[381\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[382\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_50_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[236\].delay_unit clkgen.delay_100ns_1.genblk1\[236\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[237\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_200ns.genblk1\[259\].delay_unit edgedetect.delay_200ns.genblk1\[259\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[260\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_44_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_2.genblk1\[26\].delay_unit clkgen.delay_100ns_2.genblk1\[26\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[27\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[234\].delay_unit clkgen.delay_100ns_3.genblk1\[234\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[235\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[268\].delay_unit clkgen.delay_100ns_2.genblk1\[268\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[269\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_200ns.genblk1\[261\].delay_unit edgedetect.delay_200ns.genblk1\[261\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[262\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[58\].delay_unit clkgen.delay_100ns_3.genblk1\[58\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[59\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[116\].delay_unit clkgen.delay_100ns_1.genblk1\[116\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[117\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_62_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[139\].delay_unit edgedetect.delay_200ns.genblk1\[139\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[140\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[270\].delay_unit clkgen.delay_100ns_2.genblk1\[270\].delay_unit/A
+ VGND VGND VPWR VPWR _3_/B1_N sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[438\].delay_unit edgedetect.delay_200ns.genblk1\[438\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[439\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[60\].delay_unit clkgen.delay_100ns_3.genblk1\[60\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[61\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[62\].delay_unit clkgen.delay_100ns_1.genblk1\[62\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[63\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[114\].delay_unit clkgen.delay_100ns_3.genblk1\[114\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[115\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[148\].delay_unit clkgen.delay_100ns_2.genblk1\[148\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[149\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_37_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[141\].delay_unit edgedetect.delay_200ns.genblk1\[141\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[142\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_16_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[440\].delay_unit edgedetect.delay_200ns.genblk1\[440\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[441\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_2.genblk1\[94\].delay_unit clkgen.delay_100ns_2.genblk1\[94\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[95\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[18\].delay_unit edgedetect.delay_200ns.genblk1\[18\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[19\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_140 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_2.genblk1\[150\].delay_unit clkgen.delay_100ns_2.genblk1\[150\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[151\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_100ns_1.genblk1\[184\].delay_unit clkgen.delay_100ns_1.genblk1\[184\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[185\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[318\].delay_unit edgedetect.delay_200ns.genblk1\[318\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[319\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[20\].delay_unit edgedetect.delay_200ns.genblk1\[20\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[21\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[320\].delay_unit edgedetect.delay_200ns.genblk1\[320\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[321\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[182\].delay_unit clkgen.delay_100ns_3.genblk1\[182\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[183\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_43_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[86\].delay_unit edgedetect.delay_200ns.genblk1\[86\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[87\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_100ns_2.genblk1\[207\].delay_unit clkgen.delay_100ns_2.genblk1\[207\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[208\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[386\].delay_unit edgedetect.delay_200ns.genblk1\[386\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[387\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[200\].delay_unit edgedetect.delay_200ns.genblk1\[200\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[201\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_45_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_1.genblk1\[243\].delay_unit clkgen.delay_100ns_1.genblk1\[243\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[244\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[239\].delay_unit clkgen.delay_100ns_3.genblk1\[239\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[240\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[266\].delay_unit edgedetect.delay_200ns.genblk1\[266\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[267\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_154 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_2.genblk1\[33\].delay_unit clkgen.delay_100ns_2.genblk1\[33\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[34\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_3.genblk1\[241\].delay_unit clkgen.delay_100ns_3.genblk1\[241\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[242\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_45_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_3.genblk1\[65\].delay_unit clkgen.delay_100ns_3.genblk1\[65\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[66\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[123\].delay_unit clkgen.delay_100ns_1.genblk1\[123\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[124\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[67\].delay_unit clkgen.delay_100ns_1.genblk1\[67\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[68\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[119\].delay_unit clkgen.delay_100ns_3.genblk1\[119\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[120\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[146\].delay_unit edgedetect.delay_200ns.genblk1\[146\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[147\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[445\].delay_unit edgedetect.delay_200ns.genblk1\[445\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[446\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[99\].delay_unit clkgen.delay_100ns_2.genblk1\[99\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[99\].delay_unit/X sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_3.genblk1\[121\].delay_unit clkgen.delay_100ns_3.genblk1\[121\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[122\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[155\].delay_unit clkgen.delay_100ns_2.genblk1\[155\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[156\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[189\].delay_unit clkgen.delay_100ns_1.genblk1\[189\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[190\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkgen.delay_100ns_2.genblk1\[3\].delay_unit clkgen.delay_100ns_2.genblk1\[3\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[4\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3_ ena_in _2_/X _3_/B1_N VGND VGND VPWR VPWR _3_/X sky130_fd_sc_hd__o21ba_2
XFILLER_18_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[25\].delay_unit edgedetect.delay_200ns.genblk1\[25\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[26\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[191\].delay_unit clkgen.delay_100ns_1.genblk1\[191\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[192\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[325\].delay_unit edgedetect.delay_200ns.genblk1\[325\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[326\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[187\].delay_unit clkgen.delay_100ns_3.genblk1\[187\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[188\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_16 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[205\].delay_unit edgedetect.delay_200ns.genblk1\[205\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[206\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[504\].delay_unit edgedetect.delay_200ns.genblk1\[504\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[505\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_52_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_200ns.genblk1\[93\].delay_unit edgedetect.delay_200ns.genblk1\[93\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[94\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[393\].delay_unit edgedetect.delay_200ns.genblk1\[393\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[394\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[214\].delay_unit clkgen.delay_100ns_2.genblk1\[214\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[215\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_43_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[248\].delay_unit clkgen.delay_100ns_1.genblk1\[248\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[249\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[250\].delay_unit clkgen.delay_100ns_1.genblk1\[250\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[251\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[38\].delay_unit clkgen.delay_100ns_2.genblk1\[38\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[39\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[246\].delay_unit clkgen.delay_100ns_3.genblk1\[246\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[247\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[273\].delay_unit edgedetect.delay_200ns.genblk1\[273\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[274\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[128\].delay_unit clkgen.delay_100ns_1.genblk1\[128\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[129\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[40\].delay_unit clkgen.delay_100ns_2.genblk1\[40\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[41\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_31_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[72\].delay_unit clkgen.delay_100ns_3.genblk1\[72\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[73\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_100ns_1.genblk1\[130\].delay_unit clkgen.delay_100ns_1.genblk1\[130\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[131\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[126\].delay_unit clkgen.delay_100ns_3.genblk1\[126\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[127\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[74\].delay_unit clkgen.delay_100ns_1.genblk1\[74\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[75\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[153\].delay_unit edgedetect.delay_200ns.genblk1\[153\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[154\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[8\].delay_unit clkgen.delay_100ns_2.genblk1\[8\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[9\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_60_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[452\].delay_unit edgedetect.delay_200ns.genblk1\[452\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[453\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_13_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[162\].delay_unit clkgen.delay_100ns_2.genblk1\[162\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[163\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[196\].delay_unit clkgen.delay_100ns_1.genblk1\[196\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[197\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[32\].delay_unit edgedetect.delay_200ns.genblk1\[32\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[33\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[332\].delay_unit edgedetect.delay_200ns.genblk1\[332\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[333\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[194\].delay_unit clkgen.delay_100ns_3.genblk1\[194\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[195\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_45_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[509\].delay_unit edgedetect.delay_200ns.genblk1\[509\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[510\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_36_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_331 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[98\].delay_unit edgedetect.delay_200ns.genblk1\[98\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[99\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_27_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[398\].delay_unit edgedetect.delay_200ns.genblk1\[398\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[399\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[219\].delay_unit clkgen.delay_100ns_2.genblk1\[219\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[220\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[212\].delay_unit edgedetect.delay_200ns.genblk1\[212\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[213\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[511\].delay_unit edgedetect.delay_200ns.genblk1\[511\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[512\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
X_2_ _2_/A_N start_conv VGND VGND VPWR VPWR _2_/X sky130_fd_sc_hd__and2b_2
XFILLER_58_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk1\[221\].delay_unit clkgen.delay_100ns_2.genblk1\[221\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[222\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[11\].delay_unit clkgen.delay_100ns_3.genblk1\[11\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[12\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[255\].delay_unit clkgen.delay_100ns_1.genblk1\[255\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[256\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[13\].delay_unit clkgen.delay_100ns_1.genblk1\[13\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[14\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[278\].delay_unit edgedetect.delay_200ns.genblk1\[278\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[279\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[45\].delay_unit clkgen.delay_100ns_2.genblk1\[45\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[46\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[253\].delay_unit clkgen.delay_100ns_3.genblk1\[253\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[254\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[77\].delay_unit clkgen.delay_100ns_3.genblk1\[77\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[78\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[280\].delay_unit edgedetect.delay_200ns.genblk1\[280\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[281\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[101\].delay_unit clkgen.delay_100ns_2.genblk1\[101\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[102\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_61_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[135\].delay_unit clkgen.delay_100ns_1.genblk1\[135\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[136\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_36_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[79\].delay_unit clkgen.delay_100ns_1.genblk1\[79\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[80\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_37_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[158\].delay_unit edgedetect.delay_200ns.genblk1\[158\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[159\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_16_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[457\].delay_unit edgedetect.delay_200ns.genblk1\[457\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[458\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[133\].delay_unit clkgen.delay_100ns_3.genblk1\[133\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[134\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[81\].delay_unit clkgen.delay_100ns_1.genblk1\[81\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[82\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_43_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[167\].delay_unit clkgen.delay_100ns_2.genblk1\[167\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[168\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[160\].delay_unit edgedetect.delay_200ns.genblk1\[160\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[161\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_186 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[37\].delay_unit edgedetect.delay_200ns.genblk1\[37\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[38\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[337\].delay_unit edgedetect.delay_200ns.genblk1\[337\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[338\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[199\].delay_unit clkgen.delay_100ns_3.genblk1\[199\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[200\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_43_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[217\].delay_unit edgedetect.delay_200ns.genblk1\[217\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[218\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_13_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[516\].delay_unit edgedetect.delay_200ns.genblk1\[516\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[517\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_2.genblk1\[226\].delay_unit clkgen.delay_100ns_2.genblk1\[226\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[227\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[16\].delay_unit clkgen.delay_100ns_3.genblk1\[16\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[17\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_1.genblk1\[18\].delay_unit clkgen.delay_100ns_1.genblk1\[18\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[19\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_3.genblk1\[258\].delay_unit clkgen.delay_100ns_3.genblk1\[258\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[259\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_50_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_1.genblk1\[262\].delay_unit clkgen.delay_100ns_1.genblk1\[262\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[263\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[20\].delay_unit clkgen.delay_100ns_1.genblk1\[20\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[21\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[285\].delay_unit edgedetect.delay_200ns.genblk1\[285\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[286\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_26_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk1\[106\].delay_unit clkgen.delay_100ns_2.genblk1\[106\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[107\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[260\].delay_unit clkgen.delay_100ns_3.genblk1\[260\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[261\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[52\].delay_unit clkgen.delay_100ns_2.genblk1\[52\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[53\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_51_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_343 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_3.genblk1\[84\].delay_unit clkgen.delay_100ns_3.genblk1\[84\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[85\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[142\].delay_unit clkgen.delay_100ns_1.genblk1\[142\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[143\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[138\].delay_unit clkgen.delay_100ns_3.genblk1\[138\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[139\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[86\].delay_unit clkgen.delay_100ns_1.genblk1\[86\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[87\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[2\].delay_unit clkgen.delay_100ns_1.genblk1\[2\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[3\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[165\].delay_unit edgedetect.delay_200ns.genblk1\[165\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[166\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[464\].delay_unit edgedetect.delay_200ns.genblk1\[464\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[465\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_58_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_240 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1_ _1_/A VGND VGND VPWR VPWR clk_dig sky130_fd_sc_hd__inv_2
XPHY_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[140\].delay_unit clkgen.delay_100ns_3.genblk1\[140\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[141\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[174\].delay_unit clkgen.delay_100ns_2.genblk1\[174\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[175\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[44\].delay_unit edgedetect.delay_200ns.genblk1\[44\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[45\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_55_210 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[344\].delay_unit edgedetect.delay_200ns.genblk1\[344\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[345\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[201\].delay_unit clkgen.delay_100ns_1.genblk1\[201\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[202\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_16_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[224\].delay_unit edgedetect.delay_200ns.genblk1\[224\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[225\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_200ns.genblk1\[523\].delay_unit edgedetect.delay_200ns.genblk1\[523\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[524\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_51_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_2.genblk1\[233\].delay_unit clkgen.delay_100ns_2.genblk1\[233\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[234\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[23\].delay_unit clkgen.delay_100ns_3.genblk1\[23\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[24\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[267\].delay_unit clkgen.delay_100ns_1.genblk1\[267\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[268\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_1.genblk1\[25\].delay_unit clkgen.delay_100ns_1.genblk1\[25\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[26\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[104\].delay_unit edgedetect.delay_200ns.genblk1\[104\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[105\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[403\].delay_unit edgedetect.delay_200ns.genblk1\[403\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[404\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[265\].delay_unit clkgen.delay_100ns_3.genblk1\[265\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[266\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[57\].delay_unit clkgen.delay_100ns_2.genblk1\[57\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[58\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[89\].delay_unit clkgen.delay_100ns_3.genblk1\[89\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[90\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_200ns.genblk1\[292\].delay_unit edgedetect.delay_200ns.genblk1\[292\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[293\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_100ns_2.genblk1\[113\].delay_unit clkgen.delay_100ns_2.genblk1\[113\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[114\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[147\].delay_unit clkgen.delay_100ns_1.genblk1\[147\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[148\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[7\].delay_unit clkgen.delay_100ns_1.genblk1\[7\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[8\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[91\].delay_unit clkgen.delay_100ns_3.genblk1\[91\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[92\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[469\].delay_unit edgedetect.delay_200ns.genblk1\[469\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[470\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_3.genblk1\[145\].delay_unit clkgen.delay_100ns_3.genblk1\[145\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[146\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[93\].delay_unit clkgen.delay_100ns_1.genblk1\[93\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[94\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_124 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_2.genblk1\[179\].delay_unit clkgen.delay_100ns_2.genblk1\[179\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[180\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_44_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[172\].delay_unit edgedetect.delay_200ns.genblk1\[172\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[173\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[471\].delay_unit edgedetect.delay_200ns.genblk1\[471\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[472\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[49\].delay_unit edgedetect.delay_200ns.genblk1\[49\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[50\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_2.genblk1\[181\].delay_unit clkgen.delay_100ns_2.genblk1\[181\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[182\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[349\].delay_unit edgedetect.delay_200ns.genblk1\[349\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[350\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_322 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[51\].delay_unit edgedetect.delay_200ns.genblk1\[51\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[52\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[351\].delay_unit edgedetect.delay_200ns.genblk1\[351\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[352\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_1.genblk1\[206\].delay_unit clkgen.delay_100ns_1.genblk1\[206\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[207\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[229\].delay_unit edgedetect.delay_200ns.genblk1\[229\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[230\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[528\].delay_unit edgedetect.delay_200ns.genblk1\[528\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[529\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_50_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_3.genblk1\[204\].delay_unit clkgen.delay_100ns_3.genblk1\[204\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[205\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[238\].delay_unit clkgen.delay_100ns_2.genblk1\[238\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[239\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[28\].delay_unit clkgen.delay_100ns_3.genblk1\[28\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[29\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_41_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[231\].delay_unit edgedetect.delay_200ns.genblk1\[231\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[232\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[530\].delay_unit edgedetect.delay_200ns.genblk1\[530\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[531\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk1\[240\].delay_unit clkgen.delay_100ns_2.genblk1\[240\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[241\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[109\].delay_unit edgedetect.delay_200ns.genblk1\[109\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[110\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[408\].delay_unit edgedetect.delay_200ns.genblk1\[408\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[409\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[30\].delay_unit clkgen.delay_100ns_3.genblk1\[30\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[31\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_55_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_38 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[32\].delay_unit clkgen.delay_100ns_1.genblk1\[32\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[33\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[297\].delay_unit edgedetect.delay_200ns.genblk1\[297\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[298\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[118\].delay_unit clkgen.delay_100ns_2.genblk1\[118\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[119\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_61_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[111\].delay_unit edgedetect.delay_200ns.genblk1\[111\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[112\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[410\].delay_unit edgedetect.delay_200ns.genblk1\[410\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[411\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[64\].delay_unit clkgen.delay_100ns_2.genblk1\[64\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[65\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_3.genblk1\[96\].delay_unit clkgen.delay_100ns_3.genblk1\[96\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[97\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_2.genblk1\[120\].delay_unit clkgen.delay_100ns_2.genblk1\[120\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[121\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[154\].delay_unit clkgen.delay_100ns_1.genblk1\[154\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[155\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[98\].delay_unit clkgen.delay_100ns_1.genblk1\[98\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[99\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[177\].delay_unit edgedetect.delay_200ns.genblk1\[177\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[178\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[476\].delay_unit edgedetect.delay_200ns.genblk1\[476\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[477\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[152\].delay_unit clkgen.delay_100ns_3.genblk1\[152\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[153\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_211 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_236 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_2.genblk1\[186\].delay_unit clkgen.delay_100ns_2.genblk1\[186\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[187\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_25_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[56\].delay_unit edgedetect.delay_200ns.genblk1\[56\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[57\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[356\].delay_unit edgedetect.delay_200ns.genblk1\[356\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[357\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_3.genblk1\[209\].delay_unit clkgen.delay_100ns_3.genblk1\[209\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[210\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[213\].delay_unit clkgen.delay_100ns_1.genblk1\[213\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[214\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[236\].delay_unit edgedetect.delay_200ns.genblk1\[236\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[237\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[535\].delay_unit edgedetect.delay_200ns.genblk1\[535\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[536\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[211\].delay_unit clkgen.delay_100ns_3.genblk1\[211\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[212\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_44_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[245\].delay_unit clkgen.delay_100ns_2.genblk1\[245\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[246\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_3.genblk1\[35\].delay_unit clkgen.delay_100ns_3.genblk1\[35\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[36\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_1.genblk1\[37\].delay_unit clkgen.delay_100ns_1.genblk1\[37\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[38\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_50_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xedgedetect.delay_200ns.genblk1\[116\].delay_unit edgedetect.delay_200ns.genblk1\[116\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[117\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_26_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[415\].delay_unit edgedetect.delay_200ns.genblk1\[415\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[416\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[69\].delay_unit clkgen.delay_100ns_2.genblk1\[69\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[70\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[125\].delay_unit clkgen.delay_100ns_2.genblk1\[125\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[126\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[159\].delay_unit clkgen.delay_100ns_1.genblk1\[159\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[160\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[71\].delay_unit clkgen.delay_100ns_2.genblk1\[71\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[72\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_50_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_3.genblk1\[157\].delay_unit clkgen.delay_100ns_3.genblk1\[157\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[158\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[161\].delay_unit clkgen.delay_100ns_1.genblk1\[161\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[162\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[184\].delay_unit edgedetect.delay_200ns.genblk1\[184\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[185\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[1\].delay_unit start_conv VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[2\].delay_unit/A
+ sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[483\].delay_unit edgedetect.delay_200ns.genblk1\[483\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[484\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[193\].delay_unit clkgen.delay_100ns_2.genblk1\[193\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[194\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_55_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[63\].delay_unit edgedetect.delay_200ns.genblk1\[63\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[64\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[363\].delay_unit edgedetect.delay_200ns.genblk1\[363\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[364\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[218\].delay_unit clkgen.delay_100ns_1.genblk1\[218\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[219\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[220\].delay_unit clkgen.delay_100ns_1.genblk1\[220\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[221\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[216\].delay_unit clkgen.delay_100ns_3.genblk1\[216\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[217\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[243\].delay_unit edgedetect.delay_200ns.genblk1\[243\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[244\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_292 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_2.genblk1\[10\].delay_unit clkgen.delay_100ns_2.genblk1\[9\].delay_unit/X
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[11\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_2.genblk1\[252\].delay_unit clkgen.delay_100ns_2.genblk1\[252\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[253\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[42\].delay_unit clkgen.delay_100ns_3.genblk1\[42\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[43\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[44\].delay_unit clkgen.delay_100ns_1.genblk1\[44\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[45\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_1.genblk1\[100\].delay_unit clkgen.delay_100ns_1.genblk1\[99\].delay_unit/X
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[101\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_56_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[123\].delay_unit edgedetect.delay_200ns.genblk1\[123\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[124\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[422\].delay_unit edgedetect.delay_200ns.genblk1\[422\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[423\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[76\].delay_unit clkgen.delay_100ns_2.genblk1\[76\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[77\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_262 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_2.genblk1\[132\].delay_unit clkgen.delay_100ns_2.genblk1\[132\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[133\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_1.genblk1\[166\].delay_unit clkgen.delay_100ns_1.genblk1\[166\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[167\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_38_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[189\].delay_unit edgedetect.delay_200ns.genblk1\[189\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[190\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[6\].delay_unit edgedetect.delay_200ns.genblk1\[6\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[7\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_56_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_200ns.genblk1\[488\].delay_unit edgedetect.delay_200ns.genblk1\[488\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[489\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_44_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_200ns.genblk1\[302\].delay_unit edgedetect.delay_200ns.genblk1\[302\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[303\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_12_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[164\].delay_unit clkgen.delay_100ns_3.genblk1\[164\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[165\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkgen.delay_100ns_2.genblk1\[198\].delay_unit clkgen.delay_100ns_2.genblk1\[198\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[199\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[191\].delay_unit edgedetect.delay_200ns.genblk1\[191\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[192\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_62_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[490\].delay_unit edgedetect.delay_200ns.genblk1\[490\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[491\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_195 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[68\].delay_unit edgedetect.delay_200ns.genblk1\[68\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[69\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_26_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_203 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[368\].delay_unit edgedetect.delay_200ns.genblk1\[368\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[369\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[70\].delay_unit edgedetect.delay_200ns.genblk1\[70\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[71\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_27_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[370\].delay_unit edgedetect.delay_200ns.genblk1\[370\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[371\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_50_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[225\].delay_unit clkgen.delay_100ns_1.genblk1\[225\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[226\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_23_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_200ns.genblk1\[248\].delay_unit edgedetect.delay_200ns.genblk1\[248\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[249\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[15\].delay_unit clkgen.delay_100ns_2.genblk1\[15\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[16\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[223\].delay_unit clkgen.delay_100ns_3.genblk1\[223\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[224\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[257\].delay_unit clkgen.delay_100ns_2.genblk1\[257\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[258\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_17_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[250\].delay_unit edgedetect.delay_200ns.genblk1\[250\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[251\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[47\].delay_unit clkgen.delay_100ns_3.genblk1\[47\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[48\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[105\].delay_unit clkgen.delay_100ns_1.genblk1\[105\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[106\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[49\].delay_unit clkgen.delay_100ns_1.genblk1\[49\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[50\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_55_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[128\].delay_unit edgedetect.delay_200ns.genblk1\[128\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[129\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[427\].delay_unit edgedetect.delay_200ns.genblk1\[427\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[428\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_61_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[51\].delay_unit clkgen.delay_100ns_1.genblk1\[51\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[52\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[103\].delay_unit clkgen.delay_100ns_3.genblk1\[103\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[104\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[137\].delay_unit clkgen.delay_100ns_2.genblk1\[137\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[138\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_37_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[130\].delay_unit edgedetect.delay_200ns.genblk1\[130\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[131\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_45_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[83\].delay_unit clkgen.delay_100ns_2.genblk1\[83\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[84\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[173\].delay_unit clkgen.delay_100ns_1.genblk1\[173\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[174\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[307\].delay_unit edgedetect.delay_200ns.genblk1\[307\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[308\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_3.genblk1\[5\].delay_unit clkgen.delay_100ns_3.genblk1\[5\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[6\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[169\].delay_unit clkgen.delay_100ns_3.genblk1\[169\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[170\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[196\].delay_unit edgedetect.delay_200ns.genblk1\[196\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[197\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_27_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[495\].delay_unit edgedetect.delay_200ns.genblk1\[495\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[496\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_3.genblk1\[171\].delay_unit clkgen.delay_100ns_3.genblk1\[171\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[172\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[75\].delay_unit edgedetect.delay_200ns.genblk1\[75\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[76\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[375\].delay_unit edgedetect.delay_200ns.genblk1\[375\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[376\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[232\].delay_unit clkgen.delay_100ns_1.genblk1\[232\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[233\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[228\].delay_unit clkgen.delay_100ns_3.genblk1\[228\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[229\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_44_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_51 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[255\].delay_unit edgedetect.delay_200ns.genblk1\[255\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[256\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_62_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_2.genblk1\[22\].delay_unit clkgen.delay_100ns_2.genblk1\[22\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[23\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[230\].delay_unit clkgen.delay_100ns_3.genblk1\[230\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[231\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_100ns_2.genblk1\[264\].delay_unit clkgen.delay_100ns_2.genblk1\[264\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[265\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_45_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[54\].delay_unit clkgen.delay_100ns_3.genblk1\[54\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[55\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_26_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[112\].delay_unit clkgen.delay_100ns_1.genblk1\[112\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[113\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[56\].delay_unit clkgen.delay_100ns_1.genblk1\[56\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[57\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[108\].delay_unit clkgen.delay_100ns_3.genblk1\[108\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[109\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_200ns.genblk1\[135\].delay_unit edgedetect.delay_200ns.genblk1\[135\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[136\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[434\].delay_unit edgedetect.delay_200ns.genblk1\[434\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[435\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[88\].delay_unit clkgen.delay_100ns_2.genblk1\[88\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[89\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[110\].delay_unit clkgen.delay_100ns_3.genblk1\[110\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[111\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_51_19 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[144\].delay_unit clkgen.delay_100ns_2.genblk1\[144\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[145\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[178\].delay_unit clkgen.delay_100ns_1.genblk1\[178\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[179\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_100ns_2.genblk1\[90\].delay_unit clkgen.delay_100ns_2.genblk1\[90\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[91\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_58_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_200ns.genblk1\[14\].delay_unit edgedetect.delay_200ns.genblk1\[14\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[15\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkgen.delay_100ns_1.genblk1\[180\].delay_unit clkgen.delay_100ns_1.genblk1\[180\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[181\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_46 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[314\].delay_unit edgedetect.delay_200ns.genblk1\[314\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[315\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[176\].delay_unit clkgen.delay_100ns_3.genblk1\[176\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[177\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_206 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[82\].delay_unit edgedetect.delay_200ns.genblk1\[82\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[83\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[203\].delay_unit clkgen.delay_100ns_2.genblk1\[203\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[204\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[382\].delay_unit edgedetect.delay_200ns.genblk1\[382\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[383\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[237\].delay_unit clkgen.delay_100ns_1.genblk1\[237\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[238\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_346 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[27\].delay_unit clkgen.delay_100ns_2.genblk1\[27\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[28\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[235\].delay_unit clkgen.delay_100ns_3.genblk1\[235\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[236\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_180 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_2.genblk1\[269\].delay_unit clkgen.delay_100ns_2.genblk1\[269\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[270\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[262\].delay_unit edgedetect.delay_200ns.genblk1\[262\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[263\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[59\].delay_unit clkgen.delay_100ns_3.genblk1\[59\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[60\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[117\].delay_unit clkgen.delay_100ns_1.genblk1\[117\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[118\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_56_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[61\].delay_unit clkgen.delay_100ns_3.genblk1\[61\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[62\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[439\].delay_unit edgedetect.delay_200ns.genblk1\[439\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[440\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_191 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_1.genblk1\[63\].delay_unit clkgen.delay_100ns_1.genblk1\[63\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[64\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[115\].delay_unit clkgen.delay_100ns_3.genblk1\[115\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[116\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[149\].delay_unit clkgen.delay_100ns_2.genblk1\[149\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[150\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[142\].delay_unit edgedetect.delay_200ns.genblk1\[142\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[143\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_38_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[441\].delay_unit edgedetect.delay_200ns.genblk1\[441\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[442\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[95\].delay_unit clkgen.delay_100ns_2.genblk1\[95\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[96\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[19\].delay_unit edgedetect.delay_200ns.genblk1\[19\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[20\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[151\].delay_unit clkgen.delay_100ns_2.genblk1\[151\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[152\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_1.genblk1\[185\].delay_unit clkgen.delay_100ns_1.genblk1\[185\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[186\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[319\].delay_unit edgedetect.delay_200ns.genblk1\[319\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[320\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_60_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[21\].delay_unit edgedetect.delay_200ns.genblk1\[21\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[22\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_62_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[321\].delay_unit edgedetect.delay_200ns.genblk1\[321\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[322\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_100ns_3.genblk1\[183\].delay_unit clkgen.delay_100ns_3.genblk1\[183\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[184\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_53_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[87\].delay_unit edgedetect.delay_200ns.genblk1\[87\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[88\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[208\].delay_unit clkgen.delay_100ns_2.genblk1\[208\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[209\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[387\].delay_unit edgedetect.delay_200ns.genblk1\[387\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[388\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[201\].delay_unit edgedetect.delay_200ns.genblk1\[201\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[202\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[500\].delay_unit edgedetect.delay_200ns.genblk1\[500\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[501\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_50_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk1\[210\].delay_unit clkgen.delay_100ns_2.genblk1\[210\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[211\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_1.genblk1\[244\].delay_unit clkgen.delay_100ns_1.genblk1\[244\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[245\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[267\].delay_unit edgedetect.delay_200ns.genblk1\[267\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[268\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_2.genblk1\[34\].delay_unit clkgen.delay_100ns_2.genblk1\[34\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[35\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_3.genblk1\[242\].delay_unit clkgen.delay_100ns_3.genblk1\[242\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[243\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_23_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_3.genblk1\[66\].delay_unit clkgen.delay_100ns_3.genblk1\[66\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[67\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[124\].delay_unit clkgen.delay_100ns_1.genblk1\[124\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[125\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_1.genblk1\[68\].delay_unit clkgen.delay_100ns_1.genblk1\[68\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[69\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_36_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_200ns.genblk1\[147\].delay_unit edgedetect.delay_200ns.genblk1\[147\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[148\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_52_218 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[446\].delay_unit edgedetect.delay_200ns.genblk1\[446\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[447\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_60_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_3.genblk1\[122\].delay_unit clkgen.delay_100ns_3.genblk1\[122\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[123\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[70\].delay_unit clkgen.delay_100ns_1.genblk1\[70\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[71\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[156\].delay_unit clkgen.delay_100ns_2.genblk1\[156\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[157\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_51_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_2.genblk1\[4\].delay_unit clkgen.delay_100ns_2.genblk1\[4\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[5\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[26\].delay_unit edgedetect.delay_200ns.genblk1\[26\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[27\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_13 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_1.genblk1\[192\].delay_unit clkgen.delay_100ns_1.genblk1\[192\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[193\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[326\].delay_unit edgedetect.delay_200ns.genblk1\[326\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[327\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[188\].delay_unit clkgen.delay_100ns_3.genblk1\[188\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[189\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_26_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[190\].delay_unit clkgen.delay_100ns_3.genblk1\[190\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[191\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_24_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[206\].delay_unit edgedetect.delay_200ns.genblk1\[206\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[207\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[505\].delay_unit edgedetect.delay_200ns.genblk1\[505\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[506\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_15_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[94\].delay_unit edgedetect.delay_200ns.genblk1\[94\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[95\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_53_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_2.genblk1\[215\].delay_unit clkgen.delay_100ns_2.genblk1\[215\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[216\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[394\].delay_unit edgedetect.delay_200ns.genblk1\[394\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[395\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[249\].delay_unit clkgen.delay_100ns_1.genblk1\[249\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[250\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_3.genblk1\[247\].delay_unit clkgen.delay_100ns_3.genblk1\[247\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[248\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[251\].delay_unit clkgen.delay_100ns_1.genblk1\[251\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[252\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[39\].delay_unit clkgen.delay_100ns_2.genblk1\[39\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[40\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_62_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_200ns.genblk1\[274\].delay_unit edgedetect.delay_200ns.genblk1\[274\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[275\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[129\].delay_unit clkgen.delay_100ns_1.genblk1\[129\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[130\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_26_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_2.genblk1\[41\].delay_unit clkgen.delay_100ns_2.genblk1\[41\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[42\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_184 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[73\].delay_unit clkgen.delay_100ns_3.genblk1\[73\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[74\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[131\].delay_unit clkgen.delay_100ns_1.genblk1\[131\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[132\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[127\].delay_unit clkgen.delay_100ns_3.genblk1\[127\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[128\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[75\].delay_unit clkgen.delay_100ns_1.genblk1\[75\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[76\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[154\].delay_unit edgedetect.delay_200ns.genblk1\[154\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[155\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[453\].delay_unit edgedetect.delay_200ns.genblk1\[453\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[454\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[9\].delay_unit clkgen.delay_100ns_2.genblk1\[9\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[9\].delay_unit/X sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk1\[163\].delay_unit clkgen.delay_100ns_2.genblk1\[163\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[164\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[197\].delay_unit clkgen.delay_100ns_1.genblk1\[197\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[198\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[33\].delay_unit edgedetect.delay_200ns.genblk1\[33\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[34\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[333\].delay_unit edgedetect.delay_200ns.genblk1\[333\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[334\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_3.genblk1\[195\].delay_unit clkgen.delay_100ns_3.genblk1\[195\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[196\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_31_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[99\].delay_unit edgedetect.delay_200ns.genblk1\[99\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[99\].delay_unit/X sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_45_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[399\].delay_unit edgedetect.delay_200ns.genblk1\[399\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[400\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[213\].delay_unit edgedetect.delay_200ns.genblk1\[213\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[214\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[512\].delay_unit edgedetect.delay_200ns.genblk1\[512\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[513\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_20 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_3.genblk1\[12\].delay_unit clkgen.delay_100ns_3.genblk1\[12\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[13\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[222\].delay_unit clkgen.delay_100ns_2.genblk1\[222\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[223\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[256\].delay_unit clkgen.delay_100ns_1.genblk1\[256\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[257\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_27_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_1.genblk1\[14\].delay_unit clkgen.delay_100ns_1.genblk1\[14\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[15\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[279\].delay_unit edgedetect.delay_200ns.genblk1\[279\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[280\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_3.genblk1\[254\].delay_unit clkgen.delay_100ns_3.genblk1\[254\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[255\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[46\].delay_unit clkgen.delay_100ns_2.genblk1\[46\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[47\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[78\].delay_unit clkgen.delay_100ns_3.genblk1\[78\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[79\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[281\].delay_unit edgedetect.delay_200ns.genblk1\[281\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[282\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[102\].delay_unit clkgen.delay_100ns_2.genblk1\[102\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[103\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[136\].delay_unit clkgen.delay_100ns_1.genblk1\[136\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[137\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_178 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[80\].delay_unit clkgen.delay_100ns_3.genblk1\[80\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[81\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[159\].delay_unit edgedetect.delay_200ns.genblk1\[159\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[160\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[458\].delay_unit edgedetect.delay_200ns.genblk1\[458\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[459\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[134\].delay_unit clkgen.delay_100ns_3.genblk1\[134\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[135\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_53_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_344 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_1.genblk1\[82\].delay_unit clkgen.delay_100ns_1.genblk1\[82\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[83\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[168\].delay_unit clkgen.delay_100ns_2.genblk1\[168\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[169\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_56_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_200ns.genblk1\[161\].delay_unit edgedetect.delay_200ns.genblk1\[161\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[162\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[460\].delay_unit edgedetect.delay_200ns.genblk1\[460\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[461\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_60_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[38\].delay_unit edgedetect.delay_200ns.genblk1\[38\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[39\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[170\].delay_unit clkgen.delay_100ns_2.genblk1\[170\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[171\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[338\].delay_unit edgedetect.delay_200ns.genblk1\[338\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[339\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_62_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_200ns.genblk1\[40\].delay_unit edgedetect.delay_200ns.genblk1\[40\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[41\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[340\].delay_unit edgedetect.delay_200ns.genblk1\[340\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[341\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[218\].delay_unit edgedetect.delay_200ns.genblk1\[218\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[219\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[517\].delay_unit edgedetect.delay_200ns.genblk1\[517\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[518\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_50_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_100ns_2.genblk1\[227\].delay_unit clkgen.delay_100ns_2.genblk1\[227\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[228\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_3.genblk1\[17\].delay_unit clkgen.delay_100ns_3.genblk1\[17\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[18\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[220\].delay_unit edgedetect.delay_200ns.genblk1\[220\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[221\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_1.genblk1\[19\].delay_unit clkgen.delay_100ns_1.genblk1\[19\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[20\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_3.genblk1\[259\].delay_unit clkgen.delay_100ns_3.genblk1\[259\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[260\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_1.genblk1\[263\].delay_unit clkgen.delay_100ns_1.genblk1\[263\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[264\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[21\].delay_unit clkgen.delay_100ns_1.genblk1\[21\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[22\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_23_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[286\].delay_unit edgedetect.delay_200ns.genblk1\[286\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[287\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[107\].delay_unit clkgen.delay_100ns_2.genblk1\[107\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[108\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[100\].delay_unit edgedetect.delay_200ns.genblk1\[99\].delay_unit/X
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[101\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_100ns_2.genblk1\[53\].delay_unit clkgen.delay_100ns_2.genblk1\[53\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[54\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[261\].delay_unit clkgen.delay_100ns_3.genblk1\[261\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[262\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[85\].delay_unit clkgen.delay_100ns_3.genblk1\[85\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[86\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_3.genblk1\[139\].delay_unit clkgen.delay_100ns_3.genblk1\[139\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[140\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[143\].delay_unit clkgen.delay_100ns_1.genblk1\[143\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[144\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[87\].delay_unit clkgen.delay_100ns_1.genblk1\[87\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[88\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[3\].delay_unit clkgen.delay_100ns_1.genblk1\[3\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[4\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[166\].delay_unit edgedetect.delay_200ns.genblk1\[166\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[167\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[465\].delay_unit edgedetect.delay_200ns.genblk1\[465\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[466\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[141\].delay_unit clkgen.delay_100ns_3.genblk1\[141\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[142\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_32 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[175\].delay_unit clkgen.delay_100ns_2.genblk1\[175\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[176\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[45\].delay_unit edgedetect.delay_200ns.genblk1\[45\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[46\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[345\].delay_unit edgedetect.delay_200ns.genblk1\[345\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[346\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_56_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_1.genblk1\[202\].delay_unit clkgen.delay_100ns_1.genblk1\[202\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[203\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[225\].delay_unit edgedetect.delay_200ns.genblk1\[225\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[226\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_38_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_200ns.genblk1\[524\].delay_unit edgedetect.delay_200ns.genblk1\[524\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[525\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[200\].delay_unit clkgen.delay_100ns_3.genblk1\[200\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[201\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[234\].delay_unit clkgen.delay_100ns_2.genblk1\[234\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[235\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[24\].delay_unit clkgen.delay_100ns_3.genblk1\[24\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[25\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[268\].delay_unit clkgen.delay_100ns_1.genblk1\[268\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[269\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_62_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_1.genblk1\[26\].delay_unit clkgen.delay_100ns_1.genblk1\[26\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[27\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_200ns.genblk1\[105\].delay_unit edgedetect.delay_200ns.genblk1\[105\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[106\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_38_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[404\].delay_unit edgedetect.delay_200ns.genblk1\[404\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[405\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[58\].delay_unit clkgen.delay_100ns_2.genblk1\[58\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[59\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[266\].delay_unit clkgen.delay_100ns_3.genblk1\[266\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[267\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[270\].delay_unit clkgen.delay_100ns_1.genblk1\[270\].delay_unit/A
+ VGND VGND VPWR VPWR _1_/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[293\].delay_unit edgedetect.delay_200ns.genblk1\[293\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[294\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[114\].delay_unit clkgen.delay_100ns_2.genblk1\[114\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[115\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_44_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[148\].delay_unit clkgen.delay_100ns_1.genblk1\[148\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[149\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk1\[60\].delay_unit clkgen.delay_100ns_2.genblk1\[60\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[61\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[8\].delay_unit clkgen.delay_100ns_1.genblk1\[8\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[9\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[92\].delay_unit clkgen.delay_100ns_3.genblk1\[92\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[93\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_3.genblk1\[146\].delay_unit clkgen.delay_100ns_3.genblk1\[146\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[147\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[94\].delay_unit clkgen.delay_100ns_1.genblk1\[94\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[95\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[150\].delay_unit clkgen.delay_100ns_1.genblk1\[150\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[151\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_200ns.genblk1\[173\].delay_unit edgedetect.delay_200ns.genblk1\[173\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[174\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[472\].delay_unit edgedetect.delay_200ns.genblk1\[472\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[473\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_2.genblk1\[182\].delay_unit clkgen.delay_100ns_2.genblk1\[182\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[183\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[52\].delay_unit edgedetect.delay_200ns.genblk1\[52\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[53\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_240 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[352\].delay_unit edgedetect.delay_200ns.genblk1\[352\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[353\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_52_44 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_1.genblk1\[207\].delay_unit clkgen.delay_100ns_1.genblk1\[207\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[208\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[529\].delay_unit edgedetect.delay_200ns.genblk1\[529\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[530\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[205\].delay_unit clkgen.delay_100ns_3.genblk1\[205\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[206\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_36_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[239\].delay_unit clkgen.delay_100ns_2.genblk1\[239\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[240\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[232\].delay_unit edgedetect.delay_200ns.genblk1\[232\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[233\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[29\].delay_unit clkgen.delay_100ns_3.genblk1\[29\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[30\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_44 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[531\].delay_unit edgedetect.delay_200ns.genblk1\[531\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[532\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[241\].delay_unit clkgen.delay_100ns_2.genblk1\[241\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[242\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[409\].delay_unit edgedetect.delay_200ns.genblk1\[409\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[410\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_240 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[31\].delay_unit clkgen.delay_100ns_3.genblk1\[31\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[32\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[33\].delay_unit clkgen.delay_100ns_1.genblk1\[33\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[34\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[298\].delay_unit edgedetect.delay_200ns.genblk1\[298\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[299\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[119\].delay_unit clkgen.delay_100ns_2.genblk1\[119\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[120\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_17_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[112\].delay_unit edgedetect.delay_200ns.genblk1\[112\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[113\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[411\].delay_unit edgedetect.delay_200ns.genblk1\[411\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[412\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[65\].delay_unit clkgen.delay_100ns_2.genblk1\[65\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[66\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_3.genblk1\[97\].delay_unit clkgen.delay_100ns_3.genblk1\[97\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[98\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[121\].delay_unit clkgen.delay_100ns_2.genblk1\[121\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[122\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[99\].delay_unit clkgen.delay_100ns_1.genblk1\[99\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[99\].delay_unit/X sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[155\].delay_unit clkgen.delay_100ns_1.genblk1\[155\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[156\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_24_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[178\].delay_unit edgedetect.delay_200ns.genblk1\[178\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[179\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[477\].delay_unit edgedetect.delay_200ns.genblk1\[477\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[478\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_3.genblk1\[153\].delay_unit clkgen.delay_100ns_3.genblk1\[153\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[154\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_44_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_66 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_28 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_2.genblk1\[187\].delay_unit clkgen.delay_100ns_2.genblk1\[187\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[188\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[180\].delay_unit edgedetect.delay_200ns.genblk1\[180\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[181\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_316 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[57\].delay_unit edgedetect.delay_200ns.genblk1\[57\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[58\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_38_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[357\].delay_unit edgedetect.delay_200ns.genblk1\[357\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[358\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_55_99 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_1.genblk1\[214\].delay_unit clkgen.delay_100ns_1.genblk1\[214\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[215\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_58_216 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xedgedetect.delay_200ns.genblk1\[237\].delay_unit edgedetect.delay_200ns.genblk1\[237\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[238\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_200ns.genblk1\[536\].delay_unit edgedetect.delay_200ns.genblk1\[536\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[537\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_3.genblk1\[212\].delay_unit clkgen.delay_100ns_3.genblk1\[212\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[213\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_2.genblk1\[246\].delay_unit clkgen.delay_100ns_2.genblk1\[246\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[247\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_17_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[36\].delay_unit clkgen.delay_100ns_3.genblk1\[36\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[37\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[38\].delay_unit clkgen.delay_100ns_1.genblk1\[38\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[39\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_23_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[117\].delay_unit edgedetect.delay_200ns.genblk1\[117\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[118\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[416\].delay_unit edgedetect.delay_200ns.genblk1\[416\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[417\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_100ns_1.genblk1\[40\].delay_unit clkgen.delay_100ns_1.genblk1\[40\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[41\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_52_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[126\].delay_unit clkgen.delay_100ns_2.genblk1\[126\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[127\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_37_208 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_2.genblk1\[72\].delay_unit clkgen.delay_100ns_2.genblk1\[72\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[73\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_60_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_1.genblk1\[162\].delay_unit clkgen.delay_100ns_1.genblk1\[162\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[163\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[158\].delay_unit clkgen.delay_100ns_3.genblk1\[158\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[159\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[185\].delay_unit edgedetect.delay_200ns.genblk1\[185\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[186\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[2\].delay_unit edgedetect.delay_200ns.genblk1\[2\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[3\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[484\].delay_unit edgedetect.delay_200ns.genblk1\[484\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[485\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_3.genblk1\[160\].delay_unit clkgen.delay_100ns_3.genblk1\[160\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[161\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk1\[194\].delay_unit clkgen.delay_100ns_2.genblk1\[194\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[195\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[64\].delay_unit edgedetect.delay_200ns.genblk1\[64\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[65\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[364\].delay_unit edgedetect.delay_200ns.genblk1\[364\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[365\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[219\].delay_unit clkgen.delay_100ns_1.genblk1\[219\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[220\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_40 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[221\].delay_unit clkgen.delay_100ns_1.genblk1\[221\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[222\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[217\].delay_unit clkgen.delay_100ns_3.genblk1\[217\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[218\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[244\].delay_unit edgedetect.delay_200ns.genblk1\[244\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[245\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_2.genblk1\[11\].delay_unit clkgen.delay_100ns_2.genblk1\[11\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[12\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[253\].delay_unit clkgen.delay_100ns_2.genblk1\[253\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[254\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_100ns_3.genblk1\[43\].delay_unit clkgen.delay_100ns_3.genblk1\[43\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[44\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_53_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[101\].delay_unit clkgen.delay_100ns_1.genblk1\[101\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[102\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_41_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[45\].delay_unit clkgen.delay_100ns_1.genblk1\[45\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[46\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_200ns.genblk1\[124\].delay_unit edgedetect.delay_200ns.genblk1\[124\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[125\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_44_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[423\].delay_unit edgedetect.delay_200ns.genblk1\[423\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[424\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_25_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[77\].delay_unit clkgen.delay_100ns_2.genblk1\[77\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[78\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_2.genblk1\[133\].delay_unit clkgen.delay_100ns_2.genblk1\[133\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[134\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[167\].delay_unit clkgen.delay_100ns_1.genblk1\[167\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[168\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_228 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_200ns.genblk1\[7\].delay_unit edgedetect.delay_200ns.genblk1\[7\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[8\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[489\].delay_unit edgedetect.delay_200ns.genblk1\[489\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[490\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[303\].delay_unit edgedetect.delay_200ns.genblk1\[303\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[304\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[1\].delay_unit _3_/X VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[2\].delay_unit/A
+ sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_3.genblk1\[165\].delay_unit clkgen.delay_100ns_3.genblk1\[165\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[166\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_17_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_2.genblk1\[199\].delay_unit clkgen.delay_100ns_2.genblk1\[199\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[200\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[192\].delay_unit edgedetect.delay_200ns.genblk1\[192\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[193\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[491\].delay_unit edgedetect.delay_200ns.genblk1\[491\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[492\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[69\].delay_unit edgedetect.delay_200ns.genblk1\[69\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[70\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_200ns.genblk1\[369\].delay_unit edgedetect.delay_200ns.genblk1\[369\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[370\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_54_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[71\].delay_unit edgedetect.delay_200ns.genblk1\[71\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[72\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_26_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[371\].delay_unit edgedetect.delay_200ns.genblk1\[371\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[372\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_154 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_1.genblk1\[226\].delay_unit clkgen.delay_100ns_1.genblk1\[226\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[227\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_36_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[249\].delay_unit edgedetect.delay_200ns.genblk1\[249\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[250\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk1\[16\].delay_unit clkgen.delay_100ns_2.genblk1\[16\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[17\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[224\].delay_unit clkgen.delay_100ns_3.genblk1\[224\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[225\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_2.genblk1\[258\].delay_unit clkgen.delay_100ns_2.genblk1\[258\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[259\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[251\].delay_unit edgedetect.delay_200ns.genblk1\[251\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[252\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[48\].delay_unit clkgen.delay_100ns_3.genblk1\[48\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[49\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[106\].delay_unit clkgen.delay_100ns_1.genblk1\[106\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[107\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[129\].delay_unit edgedetect.delay_200ns.genblk1\[129\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[130\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_24_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[260\].delay_unit clkgen.delay_100ns_2.genblk1\[260\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[261\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[428\].delay_unit edgedetect.delay_200ns.genblk1\[428\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[429\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[50\].delay_unit clkgen.delay_100ns_3.genblk1\[50\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[51\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[52\].delay_unit clkgen.delay_100ns_1.genblk1\[52\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[53\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[104\].delay_unit clkgen.delay_100ns_3.genblk1\[104\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[105\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_62_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[138\].delay_unit clkgen.delay_100ns_2.genblk1\[138\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[139\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[131\].delay_unit edgedetect.delay_200ns.genblk1\[131\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[132\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[430\].delay_unit edgedetect.delay_200ns.genblk1\[430\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[431\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[84\].delay_unit clkgen.delay_100ns_2.genblk1\[84\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[85\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_53_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[140\].delay_unit clkgen.delay_100ns_2.genblk1\[140\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[141\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_56_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[174\].delay_unit clkgen.delay_100ns_1.genblk1\[174\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[175\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_3.genblk1\[6\].delay_unit clkgen.delay_100ns_3.genblk1\[6\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[7\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[308\].delay_unit edgedetect.delay_200ns.genblk1\[308\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[309\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_52_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_13 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[197\].delay_unit edgedetect.delay_200ns.genblk1\[197\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[198\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[10\].delay_unit edgedetect.delay_200ns.genblk1\[9\].delay_unit/X
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[11\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[496\].delay_unit edgedetect.delay_200ns.genblk1\[496\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[497\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[310\].delay_unit edgedetect.delay_200ns.genblk1\[310\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[311\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[172\].delay_unit clkgen.delay_100ns_3.genblk1\[172\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[173\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[76\].delay_unit edgedetect.delay_200ns.genblk1\[76\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[77\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_17_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[376\].delay_unit edgedetect.delay_200ns.genblk1\[376\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[377\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_1.genblk1\[233\].delay_unit clkgen.delay_100ns_1.genblk1\[233\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[234\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_3.genblk1\[229\].delay_unit clkgen.delay_100ns_3.genblk1\[229\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[230\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_41_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[256\].delay_unit edgedetect.delay_200ns.genblk1\[256\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[257\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[23\].delay_unit clkgen.delay_100ns_2.genblk1\[23\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[24\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_3.genblk1\[231\].delay_unit clkgen.delay_100ns_3.genblk1\[231\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[232\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[265\].delay_unit clkgen.delay_100ns_2.genblk1\[265\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[266\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_16_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[55\].delay_unit clkgen.delay_100ns_3.genblk1\[55\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[56\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[113\].delay_unit clkgen.delay_100ns_1.genblk1\[113\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[114\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_100ns_1.genblk1\[57\].delay_unit clkgen.delay_100ns_1.genblk1\[57\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[58\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[109\].delay_unit clkgen.delay_100ns_3.genblk1\[109\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[110\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[136\].delay_unit edgedetect.delay_200ns.genblk1\[136\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[137\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_200ns.genblk1\[435\].delay_unit edgedetect.delay_200ns.genblk1\[435\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[436\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[89\].delay_unit clkgen.delay_100ns_2.genblk1\[89\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[90\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_13_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[111\].delay_unit clkgen.delay_100ns_3.genblk1\[111\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[112\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_195 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[145\].delay_unit clkgen.delay_100ns_2.genblk1\[145\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[146\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[179\].delay_unit clkgen.delay_100ns_1.genblk1\[179\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[180\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_36_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_2.genblk1\[91\].delay_unit clkgen.delay_100ns_2.genblk1\[91\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[92\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[15\].delay_unit edgedetect.delay_200ns.genblk1\[15\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[16\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[181\].delay_unit clkgen.delay_100ns_1.genblk1\[181\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[182\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[315\].delay_unit edgedetect.delay_200ns.genblk1\[315\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[316\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[177\].delay_unit clkgen.delay_100ns_3.genblk1\[177\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[178\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_191 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[83\].delay_unit edgedetect.delay_200ns.genblk1\[83\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[84\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_23_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[204\].delay_unit clkgen.delay_100ns_2.genblk1\[204\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[205\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[383\].delay_unit edgedetect.delay_200ns.genblk1\[383\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[384\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[238\].delay_unit clkgen.delay_100ns_1.genblk1\[238\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[239\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_56_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_3.genblk1\[236\].delay_unit clkgen.delay_100ns_3.genblk1\[236\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[237\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk1\[28\].delay_unit clkgen.delay_100ns_2.genblk1\[28\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[29\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[240\].delay_unit clkgen.delay_100ns_1.genblk1\[240\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[241\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[263\].delay_unit edgedetect.delay_200ns.genblk1\[263\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[264\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_100ns_1.genblk1\[118\].delay_unit clkgen.delay_100ns_1.genblk1\[118\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[119\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_38_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_2.genblk1\[30\].delay_unit clkgen.delay_100ns_2.genblk1\[30\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[31\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[62\].delay_unit clkgen.delay_100ns_3.genblk1\[62\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[63\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_1.genblk1\[120\].delay_unit clkgen.delay_100ns_1.genblk1\[120\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[121\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[64\].delay_unit clkgen.delay_100ns_1.genblk1\[64\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[65\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[116\].delay_unit clkgen.delay_100ns_3.genblk1\[116\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[117\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[442\].delay_unit edgedetect.delay_200ns.genblk1\[442\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[443\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[143\].delay_unit edgedetect.delay_200ns.genblk1\[143\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[144\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_16_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_2.genblk1\[96\].delay_unit clkgen.delay_100ns_2.genblk1\[96\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[97\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[152\].delay_unit clkgen.delay_100ns_2.genblk1\[152\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[153\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[186\].delay_unit clkgen.delay_100ns_1.genblk1\[186\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[187\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[22\].delay_unit edgedetect.delay_200ns.genblk1\[22\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[23\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_31_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[322\].delay_unit edgedetect.delay_200ns.genblk1\[322\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[323\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_3.genblk1\[184\].delay_unit clkgen.delay_100ns_3.genblk1\[184\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[185\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_23_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[88\].delay_unit edgedetect.delay_200ns.genblk1\[88\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[89\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_26_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkgen.delay_100ns_2.genblk1\[209\].delay_unit clkgen.delay_100ns_2.genblk1\[209\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[210\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[388\].delay_unit edgedetect.delay_200ns.genblk1\[388\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[389\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[202\].delay_unit edgedetect.delay_200ns.genblk1\[202\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[203\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[501\].delay_unit edgedetect.delay_200ns.genblk1\[501\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[502\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_36_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[90\].delay_unit edgedetect.delay_200ns.genblk1\[90\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[91\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_51_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk1\[211\].delay_unit clkgen.delay_100ns_2.genblk1\[211\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[212\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[390\].delay_unit edgedetect.delay_200ns.genblk1\[390\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[391\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[245\].delay_unit clkgen.delay_100ns_1.genblk1\[245\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[246\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[268\].delay_unit edgedetect.delay_200ns.genblk1\[268\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[269\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[243\].delay_unit clkgen.delay_100ns_3.genblk1\[243\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[244\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_53_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[35\].delay_unit clkgen.delay_100ns_2.genblk1\[35\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[36\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_52_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_3.genblk1\[67\].delay_unit clkgen.delay_100ns_3.genblk1\[67\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[68\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[270\].delay_unit edgedetect.delay_200ns.genblk1\[270\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[271\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[125\].delay_unit clkgen.delay_100ns_1.genblk1\[125\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[126\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[69\].delay_unit clkgen.delay_100ns_1.genblk1\[69\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[70\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_62_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[447\].delay_unit edgedetect.delay_200ns.genblk1\[447\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[448\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[148\].delay_unit edgedetect.delay_200ns.genblk1\[148\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[149\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_15_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[123\].delay_unit clkgen.delay_100ns_3.genblk1\[123\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[124\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_1.genblk1\[71\].delay_unit clkgen.delay_100ns_1.genblk1\[71\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[72\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_2.genblk1\[157\].delay_unit clkgen.delay_100ns_2.genblk1\[157\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[158\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[150\].delay_unit edgedetect.delay_200ns.genblk1\[150\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[151\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[5\].delay_unit clkgen.delay_100ns_2.genblk1\[5\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[6\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_56_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_114 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[27\].delay_unit edgedetect.delay_200ns.genblk1\[27\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[28\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[327\].delay_unit edgedetect.delay_200ns.genblk1\[327\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[328\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_62_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_3.genblk1\[189\].delay_unit clkgen.delay_100ns_3.genblk1\[189\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[190\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[193\].delay_unit clkgen.delay_100ns_1.genblk1\[193\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[194\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_331 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_3.genblk1\[191\].delay_unit clkgen.delay_100ns_3.genblk1\[191\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[192\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[207\].delay_unit edgedetect.delay_200ns.genblk1\[207\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[208\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[506\].delay_unit edgedetect.delay_200ns.genblk1\[506\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[507\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[95\].delay_unit edgedetect.delay_200ns.genblk1\[95\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[96\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_31_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[395\].delay_unit edgedetect.delay_200ns.genblk1\[395\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[396\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[216\].delay_unit clkgen.delay_100ns_2.genblk1\[216\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[217\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[248\].delay_unit clkgen.delay_100ns_3.genblk1\[248\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[249\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_1.genblk1\[252\].delay_unit clkgen.delay_100ns_1.genblk1\[252\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[253\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_15_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[10\].delay_unit clkgen.delay_100ns_1.genblk1\[9\].delay_unit/X
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[11\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[275\].delay_unit edgedetect.delay_200ns.genblk1\[275\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[276\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_31_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[42\].delay_unit clkgen.delay_100ns_2.genblk1\[42\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[43\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[250\].delay_unit clkgen.delay_100ns_3.genblk1\[250\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[251\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_3.genblk1\[74\].delay_unit clkgen.delay_100ns_3.genblk1\[74\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[75\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[128\].delay_unit clkgen.delay_100ns_3.genblk1\[128\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[129\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[132\].delay_unit clkgen.delay_100ns_1.genblk1\[132\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[133\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_45_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_1.genblk1\[76\].delay_unit clkgen.delay_100ns_1.genblk1\[76\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[77\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[454\].delay_unit edgedetect.delay_200ns.genblk1\[454\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[455\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[155\].delay_unit edgedetect.delay_200ns.genblk1\[155\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[156\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_43 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_3.genblk1\[130\].delay_unit clkgen.delay_100ns_3.genblk1\[130\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[131\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_2.genblk1\[164\].delay_unit clkgen.delay_100ns_2.genblk1\[164\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[165\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[198\].delay_unit clkgen.delay_100ns_1.genblk1\[198\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[199\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[34\].delay_unit edgedetect.delay_200ns.genblk1\[34\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[35\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[334\].delay_unit edgedetect.delay_200ns.genblk1\[334\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[335\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[196\].delay_unit clkgen.delay_100ns_3.genblk1\[196\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[197\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_45_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_163 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[214\].delay_unit edgedetect.delay_200ns.genblk1\[214\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[215\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_38_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[513\].delay_unit edgedetect.delay_200ns.genblk1\[513\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[514\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_2.genblk1\[223\].delay_unit clkgen.delay_100ns_2.genblk1\[223\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[224\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_52_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_3.genblk1\[13\].delay_unit clkgen.delay_100ns_3.genblk1\[13\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[14\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[257\].delay_unit clkgen.delay_100ns_1.genblk1\[257\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[258\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_1.genblk1\[15\].delay_unit clkgen.delay_100ns_1.genblk1\[15\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[16\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_100ns_2.genblk1\[47\].delay_unit clkgen.delay_100ns_2.genblk1\[47\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[48\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[255\].delay_unit clkgen.delay_100ns_3.genblk1\[255\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[256\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_34_343 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_3.genblk1\[79\].delay_unit clkgen.delay_100ns_3.genblk1\[79\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[80\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[282\].delay_unit edgedetect.delay_200ns.genblk1\[282\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[283\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[103\].delay_unit clkgen.delay_100ns_2.genblk1\[103\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[104\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_100ns_1.genblk1\[137\].delay_unit clkgen.delay_100ns_1.genblk1\[137\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[138\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk1\[81\].delay_unit clkgen.delay_100ns_3.genblk1\[81\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[82\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[459\].delay_unit edgedetect.delay_200ns.genblk1\[459\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[460\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_43_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_3.genblk1\[135\].delay_unit clkgen.delay_100ns_3.genblk1\[135\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[136\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[83\].delay_unit clkgen.delay_100ns_1.genblk1\[83\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[84\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_100ns_2.genblk1\[169\].delay_unit clkgen.delay_100ns_2.genblk1\[169\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[170\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[162\].delay_unit edgedetect.delay_200ns.genblk1\[162\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[163\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[461\].delay_unit edgedetect.delay_200ns.genblk1\[461\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[462\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_200ns.genblk1\[39\].delay_unit edgedetect.delay_200ns.genblk1\[39\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[40\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_346 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_2.genblk1\[171\].delay_unit clkgen.delay_100ns_2.genblk1\[171\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[172\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_31_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[339\].delay_unit edgedetect.delay_200ns.genblk1\[339\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[340\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[41\].delay_unit edgedetect.delay_200ns.genblk1\[41\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[42\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_200ns.genblk1\[341\].delay_unit edgedetect.delay_200ns.genblk1\[341\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[342\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[219\].delay_unit edgedetect.delay_200ns.genblk1\[219\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[220\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_53_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[518\].delay_unit edgedetect.delay_200ns.genblk1\[518\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[519\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_2.genblk1\[228\].delay_unit clkgen.delay_100ns_2.genblk1\[228\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[229\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[221\].delay_unit edgedetect.delay_200ns.genblk1\[221\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[222\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[18\].delay_unit clkgen.delay_100ns_3.genblk1\[18\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[19\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_200ns.genblk1\[520\].delay_unit edgedetect.delay_200ns.genblk1\[520\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[521\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk1\[230\].delay_unit clkgen.delay_100ns_2.genblk1\[230\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[231\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_12_42 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[264\].delay_unit clkgen.delay_100ns_1.genblk1\[264\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[265\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[20\].delay_unit clkgen.delay_100ns_3.genblk1\[20\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[21\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_41_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[22\].delay_unit clkgen.delay_100ns_1.genblk1\[22\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[23\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_53_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_200ns.genblk1\[287\].delay_unit edgedetect.delay_200ns.genblk1\[287\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[288\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_2.genblk1\[108\].delay_unit clkgen.delay_100ns_2.genblk1\[108\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[109\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[101\].delay_unit edgedetect.delay_200ns.genblk1\[101\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[102\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_17_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[54\].delay_unit clkgen.delay_100ns_2.genblk1\[54\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[55\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[400\].delay_unit edgedetect.delay_200ns.genblk1\[400\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[401\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[262\].delay_unit clkgen.delay_100ns_3.genblk1\[262\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[263\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_3.genblk1\[86\].delay_unit clkgen.delay_100ns_3.genblk1\[86\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[87\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk1\[110\].delay_unit clkgen.delay_100ns_2.genblk1\[110\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[111\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_23_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[88\].delay_unit clkgen.delay_100ns_1.genblk1\[88\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[89\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[144\].delay_unit clkgen.delay_100ns_1.genblk1\[144\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[145\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_175 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_200ns.genblk1\[167\].delay_unit edgedetect.delay_200ns.genblk1\[167\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[168\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_208 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_100ns_1.genblk1\[4\].delay_unit clkgen.delay_100ns_1.genblk1\[4\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[5\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_200ns.genblk1\[466\].delay_unit edgedetect.delay_200ns.genblk1\[466\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[467\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[142\].delay_unit clkgen.delay_100ns_3.genblk1\[142\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[143\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_52_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk1\[90\].delay_unit clkgen.delay_100ns_1.genblk1\[90\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[91\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[176\].delay_unit clkgen.delay_100ns_2.genblk1\[176\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[177\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_267 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_200ns.genblk1\[46\].delay_unit edgedetect.delay_200ns.genblk1\[46\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[47\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_34_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_200ns.genblk1\[346\].delay_unit edgedetect.delay_200ns.genblk1\[346\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[347\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_1.genblk1\[203\].delay_unit clkgen.delay_100ns_1.genblk1\[203\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[204\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[226\].delay_unit edgedetect.delay_200ns.genblk1\[226\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[227\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_200ns.genblk1\[525\].delay_unit edgedetect.delay_200ns.genblk1\[525\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[526\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_3.genblk1\[201\].delay_unit clkgen.delay_100ns_3.genblk1\[201\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[202\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_2.genblk1\[235\].delay_unit clkgen.delay_100ns_2.genblk1\[235\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[236\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[25\].delay_unit clkgen.delay_100ns_3.genblk1\[25\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[26\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_1.genblk1\[269\].delay_unit clkgen.delay_100ns_1.genblk1\[269\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[270\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_17_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_1.genblk1\[27\].delay_unit clkgen.delay_100ns_1.genblk1\[27\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_1.genblk1\[28\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_31_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_200ns.genblk1\[106\].delay_unit edgedetect.delay_200ns.genblk1\[106\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[107\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_16_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_200ns.genblk1\[405\].delay_unit edgedetect.delay_200ns.genblk1\[405\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_200ns.genblk1\[406\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk1\[59\].delay_unit clkgen.delay_100ns_2.genblk1\[59\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_2.genblk1\[60\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_100ns_3.genblk1\[267\].delay_unit clkgen.delay_100ns_3.genblk1\[267\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_100ns_3.genblk1\[268\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
.ends
