* NGSPICE file created from adc_clkgen_with_edgedetect.ext - technology: sky130A

.subckt sky130_fd_sc_hd__decap_3 VPWR VGND VNB VPB
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=590000u
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=590000u
.ends

.subckt sky130_fd_sc_hd__conb_1 LO HI VPB VNB VGND VPWR
R0 HI VPWR sky130_fd_pr__res_generic_po w=480000u l=45000u
R1 VGND LO sky130_fd_pr__res_generic_po w=480000u l=45000u
.ends

.subckt sky130_fd_sc_hd__decap_6 VPWR VGND VNB VPB
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=1.97e+06u
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.97e+06u
.ends

.subckt sky130_fd_sc_hd__decap_4 VGND VPWR VNB VPB
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=1.05e+06u
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
.ends

.subckt sky130_fd_sc_hd__mux2_1 VGND VPWR S A1 A0 X VNB VPB
X0 VPWR a_505_21# a_535_374# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X1 a_505_21# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X2 a_218_374# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 VGND a_505_21# a_439_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X4 a_76_199# A0 a_218_374# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X5 a_505_21# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X6 a_439_47# A0 a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X7 a_535_374# A1 a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X8 a_76_199# A1 a_218_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X9 a_218_47# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X10 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_mm_sc_hd_dlyPoly5ns VPWR in out VGND VNB VPB
X0 a_851_95# in VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=3.83e+06u
X1 a_1724_71# a_851_95# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X2 VPWR out a_1724_71# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 VGND out a_1783_329# VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=800000u l=150000u
X4 a_1783_329# out VGND VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=800000u l=150000u
X5 a_1724_71# out VPWR VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X6 VGND a_851_95# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=1.375e+06u l=2.25e+06u
X7 a_1783_329# a_851_95# VPWR VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=800000u l=150000u
X8 out a_851_95# a_1783_329# VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=800000u l=150000u
X9 a_851_95# in VPWR VPB sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=800000u l=3.83e+06u
X10 out a_851_95# a_1724_71# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__and2_1 VPWR VGND X B A VNB VPB
X0 VPWR B a_59_75# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X1 X a_59_75# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 VGND B a_145_75# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 a_59_75# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X4 X a_59_75# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 a_145_75# A a_59_75# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VPWR VPB VNB
D0 VNB DIODE sky130_fd_pr__diode_pw2nd_05v5 pj=2.64e+06u area=4.347e+11p
.ends

.subckt sky130_fd_sc_hd__decap_8 VPWR VGND VNB VPB
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=2.89e+06u
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=2.89e+06u
.ends

.subckt sky130_fd_sc_hd__buf_1 VGND VPWR X A VNB VPB
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=790000u l=150000u
X1 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=520000u l=150000u
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=790000u l=150000u
X3 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=520000u l=150000u
.ends

.subckt sky130_fd_sc_hd__buf_4 VPWR VGND X A VNB VPB
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__inv_2 A Y VPWR VGND VNB VPB
X0 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__a211o_2 X A2 A1 B1 C1 VGND VPWR VNB VPB
X0 a_79_21# A1 a_348_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 a_79_21# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 a_79_21# C1 a_585_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 VPWR A2 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_299_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 a_585_297# B1 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_348_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 VGND B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt adc_clkgen_with_edgedetect VGND VPWR clk_comp clk_dig dlycontrol1[0] dlycontrol1[1]
+ dlycontrol1[2] dlycontrol1[3] dlycontrol1[4] dlycontrol2[0] dlycontrol2[1] dlycontrol2[2]
+ dlycontrol2[3] dlycontrol2[4] dlycontrol3[0] dlycontrol3[1] dlycontrol3[2] dlycontrol3[3]
+ dlycontrol3[4] dlycontrol4[0] dlycontrol4[1] dlycontrol4[2] dlycontrol4[3] dlycontrol4[4]
+ dlycontrol4[5] ena_in enable_dlycontrol ndecision_finish nsample_n nsample_n_buf
+ nsample_p nsample_p_buf sample_n sample_n_buf sample_p sample_p_buf start_conv
XFILLER_5_354 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_294_ _294_/LO _294_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_363_ _363_/LO _363_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_12_43 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_346_ _346_/LO _346_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_18_203 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_277_ _277_/LO _277_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xedgedetect.dly200cell.genblk2\[9\].mux1 VGND VPWR _405_/LO edgedetect.dly200cell.genblk2\[9\].and1/B
+ edgedetect.dly200cell.genblk2\[9\].mux1/A0 edgedetect.dly200cell.genblk2\[9\].mux1/X
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_9_55 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_329_ _329_/LO _329_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_14_272 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.dly200cell.genblk2\[17\].delay_unit VPWR edgedetect.dly200cell.genblk2\[17\].and1/X
+ edgedetect.dly200cell.genblk2\[17\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_20_275 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_286 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[29\].mux1 VGND VPWR _387_/LO edgedetect.dly200cell.genblk2\[29\].and1/B
+ edgedetect.dly200cell.genblk2\[29\].mux1/A0 edgedetect.dly200cell.genblk2\[30\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_18_75 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk2\[14\].mux1 VGND VPWR _331_/LO clkgen.delay_100ns_2.genblk2\[14\].and1/B
+ clkgen.delay_100ns_2.genblk2\[14\].mux1/A0 clkgen.delay_100ns_2.genblk2\[15\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
Xedgedetect.dly200cell.genblk2\[12\].mux1 VGND VPWR _369_/LO edgedetect.dly200cell.genblk2\[12\].and1/B
+ edgedetect.dly200cell.genblk2\[12\].mux1/A0 edgedetect.dly200cell.genblk2\[13\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
Xclkgen.delay_100ns_2.genblk2\[18\].and1 VPWR VGND clkgen.delay_100ns_2.genblk2\[18\].and1/X
+ clkgen.delay_100ns_2.genblk2\[18\].and1/B _235_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_13_3 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_5 _238_/HI VGND VPWR VPWR VGND sky130_fd_sc_hd__diode_2
XFILLER_15_32 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_54 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.dly200cell.genblk2\[16\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[16\].and1/X
+ edgedetect.dly200cell.genblk2\[16\].and1/B _273_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_16_164 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_8 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_13 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_362_ _362_/LO _362_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_293_ _293_/LO _293_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_10_148 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_55 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_237 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.dly200cell.genblk2\[24\].delay_unit VPWR edgedetect.dly200cell.genblk2\[24\].and1/X
+ edgedetect.dly200cell.genblk2\[24\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
X_345_ _345_/LO _345_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_276_ _276_/LO _276_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_17_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_207 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_1.genblk2\[1\].mux1 VGND VPWR _317_/LO clkgen.delay_100ns_1.genblk2\[1\].and1/B
+ clkgen.delay_100ns_1.genblk2\[1\].mux1/A0 clkgen.delay_100ns_1.genblk2\[2\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
X_328_ _328_/LO _328_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_259_ _259_/LO _259_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_20_254 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk2\[5\].and1 VPWR VGND clkgen.delay_100ns_1.genblk2\[5\].and1/X
+ clkgen.delay_100ns_1.genblk2\[5\].and1/B _221_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_11_243 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_54 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[35\].mux1 VGND VPWR _394_/LO edgedetect.dly200cell.genblk2\[35\].and1/B
+ edgedetect.dly200cell.genblk2\[35\].mux1/A0 edgedetect.dly200cell.genblk2\[36\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
Xedgedetect.dly200cell.genblk2\[3\].delay_unit VPWR edgedetect.dly200cell.genblk2\[3\].and1/X
+ edgedetect.dly200cell.genblk2\[3\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_3.genblk2\[1\].delay_unit VPWR clkgen.delay_100ns_3.genblk2\[1\].and1/X
+ clkgen.delay_100ns_3.genblk2\[1\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_2.genblk2\[10\].delay_unit VPWR clkgen.delay_100ns_2.genblk2\[10\].and1/X
+ clkgen.delay_100ns_2.genblk2\[10\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_20_99 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_22 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_6 _246_/HI VGND VPWR VPWR VGND sky130_fd_sc_hd__diode_2
Xedgedetect.dly200cell.genblk2\[39\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[39\].and1/X
+ edgedetect.dly200cell.genblk2\[39\].and1/B _298_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_16_335 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_173 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk2\[8\].mux1 VGND VPWR _364_/LO clkgen.delay_100ns_3.genblk2\[8\].and1/B
+ clkgen.delay_100ns_3.genblk2\[8\].mux1/A0 clkgen.delay_100ns_3.genblk2\[9\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
Xclkgen.delay_100ns_1.genblk2\[19\].mux1 VGND VPWR _316_/LO clkgen.delay_100ns_1.genblk2\[19\].and1/B
+ clkgen.delay_100ns_1.genblk2\[19\].mux1/A0 _205_/A VGND VPWR sky130_fd_sc_hd__mux2_1
Xedgedetect.dly200cell.genblk2\[29\].delay_unit VPWR edgedetect.dly200cell.genblk2\[29\].and1/X
+ edgedetect.dly200cell.genblk2\[29\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_15_88 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[2\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[2\].and1/X
+ edgedetect.dly200cell.genblk2\[2\].and1/B _288_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_16_121 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_187 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_198 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[31\].delay_unit VPWR edgedetect.dly200cell.genblk2\[31\].and1/X
+ edgedetect.dly200cell.genblk2\[31\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_8_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk2\[15\].mux1 VGND VPWR _352_/LO clkgen.delay_100ns_3.genblk2\[15\].and1/B
+ clkgen.delay_100ns_3.genblk2\[15\].mux1/A0 clkgen.delay_100ns_3.genblk2\[16\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
Xedgedetect.dly200cell.genblk2\[22\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[22\].and1/X
+ edgedetect.dly200cell.genblk2\[22\].and1/B _280_/HI VGND VPWR sky130_fd_sc_hd__and2_1
Xclkgen.delay_100ns_3.genblk2\[19\].and1 VPWR VGND clkgen.delay_100ns_3.genblk2\[19\].and1/X
+ clkgen.delay_100ns_3.genblk2\[19\].and1/B _256_/HI VGND VPWR sky130_fd_sc_hd__and2_1
X_361_ _361_/LO _361_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_292_ _292_/LO _292_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_13_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_146 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_150 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_161 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_275_ _275_/LO _275_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_344_ _344_/LO _344_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_18_249 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[8\].delay_unit VPWR edgedetect.dly200cell.genblk2\[8\].and1/X
+ edgedetect.dly200cell.genblk2\[8\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_3.genblk2\[6\].delay_unit VPWR clkgen.delay_100ns_3.genblk2\[6\].and1/X
+ clkgen.delay_100ns_3.genblk2\[6\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_2.genblk2\[15\].delay_unit VPWR clkgen.delay_100ns_2.genblk2\[15\].and1/X
+ clkgen.delay_100ns_2.genblk2\[15\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_17_260 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_134 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_167 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_13 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk2\[3\].and1 VPWR VGND clkgen.delay_100ns_2.genblk2\[3\].and1/X
+ clkgen.delay_100ns_2.genblk2\[3\].and1/B _239_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_14_252 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_263 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_258_ _258_/LO _258_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_327_ _327_/LO _327_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_18_99 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.dly200cell.genblk2\[36\].delay_unit VPWR edgedetect.dly200cell.genblk2\[36\].and1/X
+ edgedetect.dly200cell.genblk2\[36\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_19_344 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_89 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_240 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_7 _266_/HI VGND VPWR VPWR VGND sky130_fd_sc_hd__diode_2
XFILLER_19_130 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_276 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_45 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_360_ _360_/LO _360_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_291_ _291_/LO _291_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_7_90 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_136 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_26 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_302 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_106 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_343_ _343_/LO _343_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_274_ _274_/LO _274_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xedgedetect.dly200cell.genblk2\[18\].mux1 VGND VPWR _375_/LO edgedetect.dly200cell.genblk2\[18\].and1/B
+ edgedetect.dly200cell.genblk2\[18\].mux1/A0 edgedetect.dly200cell.genblk2\[19\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
Xclkgen.delay_100ns_1.genblk2\[12\].and1 VPWR VGND clkgen.delay_100ns_1.genblk2\[12\].and1/X
+ clkgen.delay_100ns_1.genblk2\[12\].and1/B _209_/HI VGND VPWR sky130_fd_sc_hd__and2_1
Xclkgen.delay_100ns_3.genblk2\[1\].and1 VPWR VGND clkgen.delay_100ns_3.genblk2\[1\].and1/X
+ clkgen.delay_100ns_3.genblk2\[1\].and1/B _257_/HI VGND VPWR sky130_fd_sc_hd__and2_1
X_326_ _326_/LO _326_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_257_ _257_/LO _257_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_9_290 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_245 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_309_ _309_/LO _309_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xclkgen.delay_100ns_2.genblk2\[0\].delay_unit VPWR clkgen.delay_100ns_2.genblk2\[0\].and1/X
+ clkgen.delay_100ns_2.genblk2\[0\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XANTENNA_8 _272_/HI VGND VPWR VPWR VGND sky130_fd_sc_hd__diode_2
XFILLER_20_68 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_46 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_307 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_300 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_3 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_1.genblk2\[7\].mux1 VGND VPWR _323_/LO clkgen.delay_100ns_1.genblk2\[7\].and1/B
+ clkgen.delay_100ns_1.genblk2\[7\].mux1/A0 clkgen.delay_100ns_1.genblk2\[8\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_16_156 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_347 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_290_ _290_/LO _290_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_5_155 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_342_ _342_/LO _342_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_273_ _273_/LO _273_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xclkgen.delay_100ns_2.genblk2\[5\].delay_unit VPWR clkgen.delay_100ns_2.genblk2\[5\].and1/X
+ clkgen.delay_100ns_2.genblk2\[5\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_17_295 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_240 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.dly200cell.genblk2\[4\].mux1 VGND VPWR _400_/LO edgedetect.dly200cell.genblk2\[4\].and1/B
+ edgedetect.dly200cell.genblk2\[4\].mux1/A0 edgedetect.dly200cell.genblk2\[5\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_2_147 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.dly200cell.genblk2\[24\].mux1 VGND VPWR _382_/LO edgedetect.dly200cell.genblk2\[24\].and1/B
+ edgedetect.dly200cell.genblk2\[24\].mux1/A0 edgedetect.dly200cell.genblk2\[25\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_14_298 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[8\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[8\].and1/X
+ edgedetect.dly200cell.genblk2\[8\].and1/B _304_/HI VGND VPWR sky130_fd_sc_hd__and2_1
X_325_ _325_/LO _325_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_256_ _256_/LO _256_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xedgedetect.dly200cell.genblk2\[28\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[28\].and1/X
+ edgedetect.dly200cell.genblk2\[28\].and1/B _286_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_20_213 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_268 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_68 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_335 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_93 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk2\[13\].and1 VPWR VGND clkgen.delay_100ns_2.genblk2\[13\].and1/X
+ clkgen.delay_100ns_2.genblk2\[13\].and1/B _230_/HI VGND VPWR sky130_fd_sc_hd__and2_1
X_308_ _308_/LO _308_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_239_ _239_/LO _239_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_6_16 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_9 _272_/HI VGND VPWR VPWR VGND sky130_fd_sc_hd__diode_2
Xedgedetect.dly200cell.genblk2\[11\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[11\].and1/X
+ edgedetect.dly200cell.genblk2\[11\].and1/B _268_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_20_8 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk2\[5\].mux1 VGND VPWR _341_/LO clkgen.delay_100ns_2.genblk2\[5\].and1/B
+ clkgen.delay_100ns_2.genblk2\[5\].mux1/A0 clkgen.delay_100ns_2.genblk2\[6\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_0_245 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk2\[9\].and1 VPWR VGND clkgen.delay_100ns_2.genblk2\[9\].and1/X
+ clkgen.delay_100ns_2.genblk2\[9\].and1/B _245_/HI VGND VPWR sky130_fd_sc_hd__and2_1
X_272_ _272_/LO _272_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_341_ _341_/LO _341_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_1_340 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_274 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk2\[0\].and1 VPWR VGND clkgen.delay_100ns_1.genblk2\[0\].and1/X
+ inbuf_3/X _206_/HI VGND VPWR sky130_fd_sc_hd__and2_1
X_324_ _324_/LO _324_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_255_ _255_/LO _255_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_1_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[30\].mux1 VGND VPWR _389_/LO edgedetect.dly200cell.genblk2\[30\].and1/B
+ edgedetect.dly200cell.genblk2\[30\].mux1/A0 edgedetect.dly200cell.genblk2\[31\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_19_303 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_47 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[34\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[34\].and1/X
+ edgedetect.dly200cell.genblk2\[34\].and1/B _293_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_10_280 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_238_ _238_/LO _238_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_307_ _307_/LO _307_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xclkgen.delay_100ns_1.genblk2\[14\].delay_unit VPWR clkgen.delay_100ns_1.genblk2\[14\].and1/X
+ clkgen.delay_100ns_1.genblk2\[14\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_3.genblk2\[12\].delay_unit VPWR clkgen.delay_100ns_3.genblk2\[12\].and1/X
+ clkgen.delay_100ns_3.genblk2\[12\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_16_306 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_37 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk2\[3\].mux1 VGND VPWR _359_/LO clkgen.delay_100ns_3.genblk2\[3\].and1/B
+ clkgen.delay_100ns_3.genblk2\[3\].mux1/A0 clkgen.delay_100ns_3.genblk2\[4\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_3_276 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk2\[14\].mux1 VGND VPWR _311_/LO clkgen.delay_100ns_1.genblk2\[14\].and1/B
+ clkgen.delay_100ns_1.genblk2\[14\].mux1/A0 clkgen.delay_100ns_1.genblk2\[15\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_19_199 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_166 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_144 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_100 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_90 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_3.genblk2\[7\].and1 VPWR VGND clkgen.delay_100ns_3.genblk2\[7\].and1/X
+ clkgen.delay_100ns_3.genblk2\[7\].and1/B _263_/HI VGND VPWR sky130_fd_sc_hd__and2_1
Xclkgen.delay_100ns_1.genblk2\[18\].and1 VPWR VGND clkgen.delay_100ns_1.genblk2\[18\].and1/X
+ clkgen.delay_100ns_1.genblk2\[18\].and1/B _215_/HI VGND VPWR sky130_fd_sc_hd__and2_1
Xclkgen.delay_100ns_3.genblk2\[10\].mux1 VGND VPWR _347_/LO clkgen.delay_100ns_3.genblk2\[9\].mux1/X
+ clkgen.delay_100ns_3.genblk2\[10\].mux1/A0 clkgen.delay_100ns_3.genblk2\[11\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_12_331 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_0 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_3.genblk2\[14\].and1 VPWR VGND clkgen.delay_100ns_3.genblk2\[14\].and1/X
+ clkgen.delay_100ns_3.genblk2\[14\].and1/B _251_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_13_106 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_194 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_308 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_16 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_271_ _271_/LO _271_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_340_ _340_/LO _340_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_4_94 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_1.genblk2\[19\].delay_unit VPWR clkgen.delay_100ns_1.genblk2\[19\].and1/X
+ clkgen.delay_100ns_1.genblk2\[19\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_3.genblk2\[17\].delay_unit VPWR clkgen.delay_100ns_3.genblk2\[17\].and1/X
+ clkgen.delay_100ns_3.genblk2\[17\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_1.genblk2\[4\].delay_unit VPWR clkgen.delay_100ns_1.genblk2\[4\].and1/X
+ clkgen.delay_100ns_1.genblk2\[4\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_2_105 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_245 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_254_ _254_/LO _254_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_323_ _323_/LO _323_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_20_226 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_263 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_237_ _237_/LO _237_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_306_ _306_/LO _306_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_19_156 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_214 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_336 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_1 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_1.genblk2\[9\].delay_unit VPWR clkgen.delay_100ns_1.genblk2\[9\].and1/X
+ clkgen.delay_100ns_1.genblk2\[9\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_15_170 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_192 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_2.genblk2\[15\].mux1 VGND VPWR _332_/LO clkgen.delay_100ns_2.genblk2\[15\].and1/B
+ clkgen.delay_100ns_2.genblk2\[15\].mux1/A0 clkgen.delay_100ns_2.genblk2\[16\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_12_162 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xinbuf_1 VGND VPWR _204_/B1 ena_in VGND VPWR sky130_fd_sc_hd__buf_1
Xclkgen.delay_100ns_2.genblk2\[19\].and1 VPWR VGND clkgen.delay_100ns_2.genblk2\[19\].and1/X
+ clkgen.delay_100ns_2.genblk2\[19\].and1/B _236_/HI VGND VPWR sky130_fd_sc_hd__and2_1
Xedgedetect.dly200cell.genblk2\[13\].mux1 VGND VPWR _370_/LO edgedetect.dly200cell.genblk2\[13\].and1/B
+ edgedetect.dly200cell.genblk2\[13\].mux1/A0 edgedetect.dly200cell.genblk2\[14\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
Xedgedetect.dly200cell.genblk2\[13\].delay_unit VPWR edgedetect.dly200cell.genblk2\[13\].and1/X
+ edgedetect.dly200cell.genblk2\[13\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_5_103 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_125 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_270_ _270_/LO _270_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xedgedetect.dly200cell.genblk2\[17\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[17\].and1/X
+ edgedetect.dly200cell.genblk2\[17\].and1/B _274_/HI VGND VPWR sky130_fd_sc_hd__and2_1
X_399_ _399_/LO _399_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_322_ _322_/LO _322_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_1_183 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_93 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_253_ _253_/LO _253_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_20_238 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_216 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_27 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_236_ _236_/LO _236_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_19_316 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
X_305_ _305_/LO _305_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_1_63 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_94 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_219_ _219_/LO _219_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xedgedetect.dly200cell.genblk2\[18\].delay_unit VPWR edgedetect.dly200cell.genblk2\[18\].and1/X
+ edgedetect.dly200cell.genblk2\[18\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_1.genblk2\[2\].mux1 VGND VPWR _318_/LO clkgen.delay_100ns_1.genblk2\[2\].and1/B
+ clkgen.delay_100ns_1.genblk2\[2\].mux1/A0 clkgen.delay_100ns_1.genblk2\[3\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_18_190 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.dly200cell.genblk2\[20\].delay_unit VPWR edgedetect.dly200cell.genblk2\[20\].and1/X
+ edgedetect.dly200cell.genblk2\[20\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_12_322 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk2\[6\].and1 VPWR VGND clkgen.delay_100ns_1.genblk2\[6\].and1/X
+ clkgen.delay_100ns_1.genblk2\[6\].and1/B _222_/HI VGND VPWR sky130_fd_sc_hd__and2_1
Xedgedetect.dly200cell.genblk2\[36\].mux1 VGND VPWR _395_/LO edgedetect.dly200cell.genblk2\[36\].and1/B
+ edgedetect.dly200cell.genblk2\[36\].mux1/A0 edgedetect.dly200cell.genblk2\[37\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_5_318 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xinbuf_2 VGND VPWR _204_/A1 start_conv VGND VPWR sky130_fd_sc_hd__buf_1
Xclkgen.delay_100ns_3.genblk2\[9\].mux1 VGND VPWR _365_/LO clkgen.delay_100ns_3.genblk2\[9\].and1/B
+ clkgen.delay_100ns_3.genblk2\[9\].mux1/A0 clkgen.delay_100ns_3.genblk2\[9\].mux1/X
+ VGND VPWR sky130_fd_sc_hd__mux2_1
Xedgedetect.dly200cell.genblk2\[3\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[3\].and1/X
+ edgedetect.dly200cell.genblk2\[3\].and1/B _299_/HI VGND VPWR sky130_fd_sc_hd__and2_1
X_398_ _398_/LO _398_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_17_288 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[23\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[23\].and1/X
+ edgedetect.dly200cell.genblk2\[23\].and1/B _281_/HI VGND VPWR sky130_fd_sc_hd__and2_1
Xclkgen.delay_100ns_3.genblk2\[16\].mux1 VGND VPWR _353_/LO clkgen.delay_100ns_3.genblk2\[16\].and1/B
+ clkgen.delay_100ns_3.genblk2\[16\].mux1/A0 clkgen.delay_100ns_3.genblk2\[17\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
X_321_ _321_/LO _321_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_252_ _252_/LO _252_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_20_206 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[25\].delay_unit VPWR edgedetect.dly200cell.genblk2\[25\].and1/X
+ edgedetect.dly200cell.genblk2\[25\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_19_328 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_304_ _304_/LO _304_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_235_ _235_/LO _235_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_6_276 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk2\[0\].mux1 VGND VPWR _326_/LO _205_/Y clkgen.delay_100ns_2.genblk2\[0\].mux1/A0
+ clkgen.delay_100ns_2.genblk2\[1\].and1/B VGND VPWR sky130_fd_sc_hd__mux2_1
Xclkgen.delay_100ns_2.genblk2\[4\].and1 VPWR VGND clkgen.delay_100ns_2.genblk2\[4\].and1/X
+ clkgen.delay_100ns_2.genblk2\[4\].and1/B _240_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_19_114 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_218_ _218_/LO _218_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_12_301 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_139 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.dly200cell.genblk2\[4\].delay_unit VPWR edgedetect.dly200cell.genblk2\[4\].and1/X
+ edgedetect.dly200cell.genblk2\[4\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XPHY_3 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_3.genblk2\[2\].delay_unit VPWR clkgen.delay_100ns_3.genblk2\[2\].and1/X
+ clkgen.delay_100ns_3.genblk2\[2\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_2.genblk2\[11\].delay_unit VPWR clkgen.delay_100ns_2.genblk2\[11\].and1/X
+ clkgen.delay_100ns_2.genblk2\[11\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xinbuf_3 VGND VPWR inbuf_3/X ndecision_finish VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_12_175 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.dly200cell.genblk2\[32\].delay_unit VPWR edgedetect.dly200cell.genblk2\[32\].and1/X
+ edgedetect.dly200cell.genblk2\[32\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
X_397_ _397_/LO _397_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_17_267 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_51 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_251_ _251_/LO _251_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_320_ _320_/LO _320_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_18_18 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[9\].delay_unit VPWR edgedetect.dly200cell.genblk2\[9\].and1/X
+ edgedetect.dly200cell.genblk2\[9\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_3.genblk2\[7\].delay_unit VPWR clkgen.delay_100ns_3.genblk2\[7\].and1/X
+ clkgen.delay_100ns_3.genblk2\[7\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
X_303_ _303_/LO _303_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_234_ _234_/LO _234_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xclkgen.delay_100ns_2.genblk2\[16\].delay_unit VPWR clkgen.delay_100ns_2.genblk2\[16\].and1/X
+ clkgen.delay_100ns_2.genblk2\[16\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_3.genblk2\[2\].and1 VPWR VGND clkgen.delay_100ns_3.genblk2\[2\].and1/X
+ clkgen.delay_100ns_3.genblk2\[2\].and1/B _258_/HI VGND VPWR sky130_fd_sc_hd__and2_1
Xedgedetect.dly200cell.genblk2\[19\].mux1 VGND VPWR _376_/LO edgedetect.dly200cell.genblk2\[19\].and1/B
+ edgedetect.dly200cell.genblk2\[19\].mux1/A0 edgedetect.dly200cell.genblk2\[20\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
Xclkgen.delay_100ns_1.genblk2\[13\].and1 VPWR VGND clkgen.delay_100ns_1.genblk2\[13\].and1/X
+ clkgen.delay_100ns_1.genblk2\[13\].and1/B _210_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_15_354 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_137 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_83 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_217_ _217_/LO _217_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_2_280 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.dly200cell.genblk2\[37\].delay_unit VPWR edgedetect.dly200cell.genblk2\[37\].and1/X
+ edgedetect.dly200cell.genblk2\[37\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XPHY_4 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_9 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_396_ _396_/LO _396_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_4_161 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_183 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_63 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk2\[8\].mux1 VGND VPWR _324_/LO clkgen.delay_100ns_1.genblk2\[8\].and1/B
+ clkgen.delay_100ns_1.genblk2\[8\].mux1/A0 clkgen.delay_100ns_1.genblk2\[9\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
X_250_ _250_/LO _250_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_9_242 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_293 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_379_ _379_/LO _379_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_1_33 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_302_ _302_/LO _302_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_233_ _233_/LO _233_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xedgedetect.dly200cell.genblk2\[5\].mux1 VGND VPWR _401_/LO edgedetect.dly200cell.genblk2\[5\].and1/B
+ edgedetect.dly200cell.genblk2\[5\].mux1/A0 edgedetect.dly200cell.genblk2\[6\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_19_40 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.dly200cell.genblk2\[9\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[9\].and1/X
+ edgedetect.dly200cell.genblk2\[9\].and1/B _305_/HI VGND VPWR sky130_fd_sc_hd__and2_1
Xedgedetect.dly200cell.genblk2\[25\].mux1 VGND VPWR _383_/LO edgedetect.dly200cell.genblk2\[25\].and1/B
+ edgedetect.dly200cell.genblk2\[25\].mux1/A0 edgedetect.dly200cell.genblk2\[26\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
X_216_ _216_/LO _216_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_8_307 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_108 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_5 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk2\[1\].delay_unit VPWR clkgen.delay_100ns_2.genblk2\[1\].and1/X
+ clkgen.delay_100ns_2.genblk2\[1\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xedgedetect.dly200cell.genblk2\[29\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[29\].and1/X
+ edgedetect.dly200cell.genblk2\[29\].and1/B _287_/HI VGND VPWR sky130_fd_sc_hd__and2_1
Xclkgen.delay_100ns_2.genblk2\[10\].mux1 VGND VPWR _327_/LO clkgen.delay_100ns_2.genblk2\[9\].mux1/X
+ clkgen.delay_100ns_2.genblk2\[10\].mux1/A0 clkgen.delay_100ns_2.genblk2\[11\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
Xclkgen.delay_100ns_2.genblk2\[14\].and1 VPWR VGND clkgen.delay_100ns_2.genblk2\[14\].and1/X
+ clkgen.delay_100ns_2.genblk2\[14\].and1/B _231_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_8_137 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_85 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.dly200cell.genblk2\[12\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[12\].and1/X
+ edgedetect.dly200cell.genblk2\[12\].and1/B _269_/HI VGND VPWR sky130_fd_sc_hd__and2_1
Xclkgen.delay_100ns_2.genblk2\[6\].mux1 VGND VPWR _342_/LO clkgen.delay_100ns_2.genblk2\[6\].and1/B
+ clkgen.delay_100ns_2.genblk2\[6\].mux1/A0 clkgen.delay_100ns_2.genblk2\[7\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_4_140 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_395_ _395_/LO _395_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_1_154 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_187 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_378_ _378_/LO _378_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xclkgen.delay_100ns_2.genblk2\[6\].delay_unit VPWR clkgen.delay_100ns_2.genblk2\[6\].and1/X
+ clkgen.delay_100ns_2.genblk2\[6\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
X_301_ _301_/LO _301_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_232_ _232_/LO _232_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_18_320 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_227 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_74 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_63 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_52 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_271 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_1.genblk2\[1\].and1 VPWR VGND clkgen.delay_100ns_1.genblk2\[1\].and1/X
+ clkgen.delay_100ns_1.genblk2\[1\].and1/B _217_/HI VGND VPWR sky130_fd_sc_hd__and2_1
X_215_ _215_/LO _215_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_18_183 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_315 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_6 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.dly200cell.genblk2\[31\].mux1 VGND VPWR _390_/LO edgedetect.dly200cell.genblk2\[31\].and1/B
+ edgedetect.dly200cell.genblk2\[31\].mux1/A0 edgedetect.dly200cell.genblk2\[32\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
Xedgedetect.dly200cell.genblk2\[35\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[35\].and1/X
+ edgedetect.dly200cell.genblk2\[35\].and1/B _294_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_12_134 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_156 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_3.genblk2\[4\].mux1 VGND VPWR _360_/LO clkgen.delay_100ns_3.genblk2\[4\].and1/B
+ clkgen.delay_100ns_3.genblk2\[4\].mux1/A0 clkgen.delay_100ns_3.genblk2\[5\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
Xclkgen.delay_100ns_1.genblk2\[15\].mux1 VGND VPWR _312_/LO clkgen.delay_100ns_1.genblk2\[15\].and1/B
+ clkgen.delay_100ns_1.genblk2\[15\].mux1/A0 clkgen.delay_100ns_1.genblk2\[16\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
Xclkgen.delay_100ns_3.genblk2\[8\].and1 VPWR VGND clkgen.delay_100ns_3.genblk2\[8\].and1/X
+ clkgen.delay_100ns_3.genblk2\[8\].and1/B _264_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_17_226 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_174 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_196 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_3.genblk2\[11\].mux1 VGND VPWR _348_/LO clkgen.delay_100ns_3.genblk2\[11\].and1/B
+ clkgen.delay_100ns_3.genblk2\[11\].mux1/A0 clkgen.delay_100ns_3.genblk2\[12\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
Xclkgen.delay_100ns_1.genblk2\[19\].and1 VPWR VGND clkgen.delay_100ns_1.genblk2\[19\].and1/X
+ clkgen.delay_100ns_1.genblk2\[19\].and1/B _216_/HI VGND VPWR sky130_fd_sc_hd__and2_1
X_394_ _394_/LO _394_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xclkgen.delay_100ns_3.genblk2\[15\].and1 VPWR VGND clkgen.delay_100ns_3.genblk2\[15\].and1/X
+ clkgen.delay_100ns_3.genblk2\[15\].and1/B _252_/HI VGND VPWR sky130_fd_sc_hd__and2_1
Xclkgen.delay_100ns_1.genblk2\[10\].delay_unit VPWR clkgen.delay_100ns_1.genblk2\[10\].and1/X
+ clkgen.delay_100ns_1.genblk2\[10\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_16_292 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_3 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_43 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_377_ _377_/LO _377_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_9_299 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_231_ _231_/LO _231_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_300_ _300_/LO _300_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_18_354 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_107 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_214_ _214_/LO _214_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_18_151 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_162 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_7 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_338 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_349 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_110 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_121 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_132 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk2\[15\].delay_unit VPWR clkgen.delay_100ns_1.genblk2\[15\].and1/X
+ clkgen.delay_100ns_1.genblk2\[15\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_3.genblk2\[13\].delay_unit VPWR clkgen.delay_100ns_3.genblk2\[13\].and1/X
+ clkgen.delay_100ns_3.genblk2\[13\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_1.genblk2\[0\].delay_unit VPWR clkgen.delay_100ns_1.genblk2\[0\].and1/X
+ clkgen.delay_100ns_1.genblk2\[0\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_4_323 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_76 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_393_ _393_/LO _393_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_17_216 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_260 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_2.genblk2\[16\].mux1 VGND VPWR _333_/LO clkgen.delay_100ns_2.genblk2\[16\].and1/B
+ clkgen.delay_100ns_2.genblk2\[16\].mux1/A0 clkgen.delay_100ns_2.genblk2\[17\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_9_256 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_263 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_376_ _376_/LO _376_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_10_200 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_230_ _230_/LO _230_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_1_47 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[14\].mux1 VGND VPWR _371_/LO edgedetect.dly200cell.genblk2\[14\].and1/B
+ edgedetect.dly200cell.genblk2\[14\].mux1/A0 edgedetect.dly200cell.genblk2\[15\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
Xclkgen.delay_100ns_3.genblk2\[18\].delay_unit VPWR clkgen.delay_100ns_3.genblk2\[18\].and1/X
+ clkgen.delay_100ns_3.genblk2\[18\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_1.genblk2\[5\].delay_unit VPWR clkgen.delay_100ns_1.genblk2\[5\].and1/X
+ clkgen.delay_100ns_1.genblk2\[5\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
X_359_ _359_/LO _359_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xedgedetect.dly200cell.genblk2\[18\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[18\].and1/X
+ edgedetect.dly200cell.genblk2\[18\].and1/B _275_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_15_347 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_213_ _213_/LO _213_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XPHY_8 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_46 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_147 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_22 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_99 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_349 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
X_392_ _392_/LO _392_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xclkgen.delay_100ns_1.genblk2\[3\].mux1 VGND VPWR _319_/LO clkgen.delay_100ns_1.genblk2\[3\].and1/B
+ clkgen.delay_100ns_1.genblk2\[3\].mux1/A0 clkgen.delay_100ns_1.genblk2\[4\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_17_206 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_1.genblk2\[7\].and1 VPWR VGND clkgen.delay_100ns_1.genblk2\[7\].and1/X
+ clkgen.delay_100ns_1.genblk2\[7\].and1/B _223_/HI VGND VPWR sky130_fd_sc_hd__and2_1
Xedgedetect.dly200cell.genblk2\[37\].mux1 VGND VPWR _396_/LO edgedetect.dly200cell.genblk2\[37\].and1/B
+ edgedetect.dly200cell.genblk2\[37\].mux1/A0 edgedetect.dly200cell.genblk2\[38\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
X_375_ _375_/LO _375_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xedgedetect.dly200cell.genblk2\[14\].delay_unit VPWR edgedetect.dly200cell.genblk2\[14\].and1/X
+ edgedetect.dly200cell.genblk2\[14\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xedgedetect.dly200cell.genblk2\[0\].mux1 VGND VPWR _366_/LO _204_/A1 edgedetect.dly200cell.genblk2\[0\].mux1/A0
+ edgedetect.dly200cell.genblk2\[1\].and1/B VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_10_245 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_358_ _358_/LO _358_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_5_293 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_289_ _289_/LO _289_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xedgedetect.dly200cell.genblk2\[20\].mux1 VGND VPWR _378_/LO edgedetect.dly200cell.genblk2\[20\].and1/B
+ edgedetect.dly200cell.genblk2\[20\].mux1/A0 edgedetect.dly200cell.genblk2\[21\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
Xedgedetect.dly200cell.genblk2\[4\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[4\].and1/X
+ edgedetect.dly200cell.genblk2\[4\].and1/B _300_/HI VGND VPWR sky130_fd_sc_hd__and2_1
X_212_ _212_/LO _212_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_19_33 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk2\[17\].mux1 VGND VPWR _354_/LO clkgen.delay_100ns_3.genblk2\[17\].and1/B
+ clkgen.delay_100ns_3.genblk2\[17\].mux1/A0 clkgen.delay_100ns_3.genblk2\[18\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
Xedgedetect.dly200cell.genblk2\[24\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[24\].and1/X
+ edgedetect.dly200cell.genblk2\[24\].and1/B _282_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_18_131 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_9 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_311 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_314 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_108 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_67 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[19\].delay_unit VPWR edgedetect.dly200cell.genblk2\[19\].and1/X
+ edgedetect.dly200cell.genblk2\[19\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_2.genblk2\[1\].mux1 VGND VPWR _337_/LO clkgen.delay_100ns_2.genblk2\[1\].and1/B
+ clkgen.delay_100ns_2.genblk2\[1\].mux1/A0 clkgen.delay_100ns_2.genblk2\[2\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_7_152 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_391_ _391_/LO _391_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xedgedetect.dly200cell.genblk2\[21\].delay_unit VPWR edgedetect.dly200cell.genblk2\[21\].and1/X
+ edgedetect.dly200cell.genblk2\[21\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_2.genblk2\[5\].and1 VPWR VGND clkgen.delay_100ns_2.genblk2\[5\].and1/X
+ clkgen.delay_100ns_2.genblk2\[5\].and1/B _241_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_4_59 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_100 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_125 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_221 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_243 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_374_ _374_/LO _374_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_8_291 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_313 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[0\].delay_unit VPWR edgedetect.dly200cell.genblk2\[0\].and1/X
+ edgedetect.dly200cell.genblk2\[0\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_5_261 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_288_ _288_/LO _288_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_357_ _357_/LO _357_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_15_338 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_12 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_211_ _211_/LO _211_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_18_176 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[26\].delay_unit VPWR edgedetect.dly200cell.genblk2\[26\].and1/X
+ edgedetect.dly200cell.genblk2\[26\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xedgedetect.dly200cell.genblk2\[30\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[30\].and1/X
+ edgedetect.dly200cell.genblk2\[30\].and1/B _289_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_11_90 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_105 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk2\[10\].mux1 VGND VPWR _307_/LO clkgen.delay_100ns_1.genblk2\[9\].mux1/X
+ clkgen.delay_100ns_1.genblk2\[10\].mux1/A0 clkgen.delay_100ns_1.genblk2\[11\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_20_182 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk2\[14\].and1 VPWR VGND clkgen.delay_100ns_1.genblk2\[14\].and1/X
+ clkgen.delay_100ns_1.genblk2\[14\].and1/B _211_/HI VGND VPWR sky130_fd_sc_hd__and2_1
Xclkgen.delay_100ns_3.genblk2\[3\].and1 VPWR VGND clkgen.delay_100ns_3.genblk2\[3\].and1/X
+ clkgen.delay_100ns_3.genblk2\[3\].and1/B _259_/HI VGND VPWR sky130_fd_sc_hd__and2_1
X_390_ _390_/LO _390_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xclkgen.delay_100ns_3.genblk2\[10\].and1 VPWR VGND clkgen.delay_100ns_3.genblk2\[10\].and1/X
+ clkgen.delay_100ns_3.genblk2\[9\].mux1/X _247_/HI VGND VPWR sky130_fd_sc_hd__and2_1
Xedgedetect.dly200cell.genblk2\[5\].delay_unit VPWR edgedetect.dly200cell.genblk2\[5\].and1/X
+ edgedetect.dly200cell.genblk2\[5\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_3.genblk2\[3\].delay_unit VPWR clkgen.delay_100ns_3.genblk2\[3\].and1/X
+ clkgen.delay_100ns_3.genblk2\[3\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_4_16 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_285 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk2\[12\].delay_unit VPWR clkgen.delay_100ns_2.genblk2\[12\].and1/X
+ clkgen.delay_100ns_2.genblk2\[12\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_13_14 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_373_ _373_/LO _373_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xedgedetect.dly200cell.genblk2\[33\].delay_unit VPWR edgedetect.dly200cell.genblk2\[33\].and1/X
+ edgedetect.dly200cell.genblk2\[33\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_6_229 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
X_287_ _287_/LO _287_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_356_ _356_/LO _356_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_18_347 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_59 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_1.genblk2\[9\].mux1 VGND VPWR _325_/LO clkgen.delay_100ns_1.genblk2\[9\].and1/B
+ clkgen.delay_100ns_1.genblk2\[9\].mux1/A0 clkgen.delay_100ns_1.genblk2\[9\].mux1/X
+ VGND VPWR sky130_fd_sc_hd__mux2_1
X_210_ _210_/LO _210_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_18_144 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_122 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_339_ _339_/LO _339_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_10 _277_/HI VGND VPWR VPWR VGND sky130_fd_sc_hd__diode_2
Xclkgen.delay_100ns_3.genblk2\[8\].delay_unit VPWR clkgen.delay_100ns_3.genblk2\[8\].and1/X
+ clkgen.delay_100ns_3.genblk2\[8\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_2.genblk2\[17\].delay_unit VPWR clkgen.delay_100ns_2.genblk2\[17\].and1/X
+ clkgen.delay_100ns_2.genblk2\[17\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_4_305 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_58 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_161 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[6\].mux1 VGND VPWR _402_/LO edgedetect.dly200cell.genblk2\[6\].and1/B
+ edgedetect.dly200cell.genblk2\[6\].mux1/A0 edgedetect.dly200cell.genblk2\[7\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_7_198 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_3 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.dly200cell.genblk2\[38\].delay_unit VPWR edgedetect.dly200cell.genblk2\[38\].and1/X
+ edgedetect.dly200cell.genblk2\[38\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_19_261 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[26\].mux1 VGND VPWR _384_/LO edgedetect.dly200cell.genblk2\[26\].and1/B
+ edgedetect.dly200cell.genblk2\[26\].mux1/A0 edgedetect.dly200cell.genblk2\[27\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
Xclkgen.delay_100ns_2.genblk2\[11\].mux1 VGND VPWR _328_/LO clkgen.delay_100ns_2.genblk2\[11\].and1/B
+ clkgen.delay_100ns_2.genblk2\[11\].mux1/A0 clkgen.delay_100ns_2.genblk2\[12\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_13_201 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_234 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_256 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_372_ _372_/LO _372_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xclkgen.delay_100ns_2.genblk2\[15\].and1 VPWR VGND clkgen.delay_100ns_2.genblk2\[15\].and1/X
+ clkgen.delay_100ns_2.genblk2\[15\].and1/B _232_/HI VGND VPWR sky130_fd_sc_hd__and2_1
Xedgedetect.dly200cell.genblk2\[13\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[13\].and1/X
+ edgedetect.dly200cell.genblk2\[13\].and1/B _270_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_6_208 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_286_ _286_/LO _286_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_355_ _355_/LO _355_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_10_16 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk2\[7\].mux1 VGND VPWR _343_/LO clkgen.delay_100ns_2.genblk2\[7\].and1/B
+ clkgen.delay_100ns_2.genblk2\[7\].mux1/A0 clkgen.delay_100ns_2.genblk2\[8\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_18_156 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_269_ _269_/LO _269_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_338_ _338_/LO _338_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_11 _302_/HI VGND VPWR VPWR VGND sky130_fd_sc_hd__diode_2
XFILLER_15_148 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_17 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_354 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_173 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_1.genblk2\[2\].and1 VPWR VGND clkgen.delay_100ns_1.genblk2\[2\].and1/X
+ clkgen.delay_100ns_1.genblk2\[2\].and1/B _218_/HI VGND VPWR sky130_fd_sc_hd__and2_1
Xclkgen.delay_100ns_2.genblk2\[2\].delay_unit VPWR clkgen.delay_100ns_2.genblk2\[2\].and1/X
+ clkgen.delay_100ns_2.genblk2\[2\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xedgedetect.dly200cell.genblk2\[32\].mux1 VGND VPWR _391_/LO edgedetect.dly200cell.genblk2\[32\].and1/B
+ edgedetect.dly200cell.genblk2\[32\].mux1/A0 edgedetect.dly200cell.genblk2\[33\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
X_371_ _371_/LO _371_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_0_183 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.dly200cell.genblk2\[36\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[36\].and1/X
+ edgedetect.dly200cell.genblk2\[36\].and1/B _295_/HI VGND VPWR sky130_fd_sc_hd__and2_1
Xclkgen.delay_100ns_3.genblk2\[5\].mux1 VGND VPWR _361_/LO clkgen.delay_100ns_3.genblk2\[5\].and1/B
+ clkgen.delay_100ns_3.genblk2\[5\].mux1/A0 clkgen.delay_100ns_3.genblk2\[6\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
Xclkgen.delay_100ns_1.genblk2\[16\].mux1 VGND VPWR _313_/LO clkgen.delay_100ns_1.genblk2\[16\].and1/B
+ clkgen.delay_100ns_1.genblk2\[16\].mux1/A0 clkgen.delay_100ns_1.genblk2\[17\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
X_285_ _285_/LO _285_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_354_ _354_/LO _354_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_18_338 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_3.genblk2\[9\].and1 VPWR VGND clkgen.delay_100ns_3.genblk2\[9\].and1/X
+ clkgen.delay_100ns_3.genblk2\[9\].and1/B _265_/HI VGND VPWR sky130_fd_sc_hd__and2_1
Xclkgen.delay_100ns_3.genblk2\[12\].mux1 VGND VPWR _349_/LO clkgen.delay_100ns_3.genblk2\[12\].and1/B
+ clkgen.delay_100ns_3.genblk2\[12\].mux1/A0 clkgen.delay_100ns_3.genblk2\[13\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_4_3 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_3.genblk2\[16\].and1 VPWR VGND clkgen.delay_100ns_3.genblk2\[16\].and1/X
+ clkgen.delay_100ns_3.genblk2\[16\].and1/B _253_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_19_59 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_26 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_268_ _268_/LO _268_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_337_ _337_/LO _337_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_12 _388_/LO VGND VPWR VPWR VGND sky130_fd_sc_hd__diode_2
XFILLER_7_326 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk2\[7\].delay_unit VPWR clkgen.delay_100ns_2.genblk2\[7\].and1/X
+ clkgen.delay_100ns_2.genblk2\[7\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_16_49 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_130 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_2.genblk2\[0\].and1 VPWR VGND clkgen.delay_100ns_2.genblk2\[0\].and1/X
+ _205_/Y _226_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_19_296 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_299 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_229 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_214 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_370_ _370_/LO _370_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_284_ _284_/LO _284_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_18_306 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_353_ _353_/LO _353_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_5_221 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_243 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk2\[11\].delay_unit VPWR clkgen.delay_100ns_1.genblk2\[11\].and1/X
+ clkgen.delay_100ns_1.genblk2\[11\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
X_267_ _267_/LO _267_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_336_ _336_/LO _336_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_405_ _405_/LO _405_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_18_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_85 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_13 _366_/LO VGND VPWR VPWR VGND sky130_fd_sc_hd__diode_2
Xclkgen.delay_100ns_2.genblk2\[17\].mux1 VGND VPWR _334_/LO clkgen.delay_100ns_2.genblk2\[17\].and1/B
+ clkgen.delay_100ns_2.genblk2\[17\].mux1/A0 clkgen.delay_100ns_2.genblk2\[18\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_15_139 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[15\].mux1 VGND VPWR _372_/LO edgedetect.dly200cell.genblk2\[15\].and1/B
+ edgedetect.dly200cell.genblk2\[15\].mux1/A0 edgedetect.dly200cell.genblk2\[16\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
X_319_ _319_/LO _319_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_20_175 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_142 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_120 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[19\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[19\].and1/X
+ edgedetect.dly200cell.genblk2\[19\].and1/B _276_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_19_220 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_275 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk2\[14\].delay_unit VPWR clkgen.delay_100ns_3.genblk2\[14\].and1/X
+ clkgen.delay_100ns_3.genblk2\[14\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_1.genblk2\[1\].delay_unit VPWR clkgen.delay_100ns_1.genblk2\[1\].and1/X
+ clkgen.delay_100ns_1.genblk2\[1\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_16_212 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_93 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_1.genblk2\[16\].delay_unit VPWR clkgen.delay_100ns_1.genblk2\[16\].and1/X
+ clkgen.delay_100ns_1.genblk2\[16\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_12_3 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_152 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_74 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_230 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_329 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_283_ _283_/LO _283_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xclkgen.delay_100ns_1.genblk2\[4\].mux1 VGND VPWR _320_/LO clkgen.delay_100ns_1.genblk2\[4\].and1/B
+ clkgen.delay_100ns_1.genblk2\[4\].mux1/A0 clkgen.delay_100ns_1.genblk2\[5\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
X_352_ _352_/LO _352_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_17_351 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_1.genblk2\[8\].and1 VPWR VGND clkgen.delay_100ns_1.genblk2\[8\].and1/X
+ clkgen.delay_100ns_1.genblk2\[8\].and1/B _224_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_2_258 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_354 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_266_ _266_/LO _266_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_335_ _335_/LO _335_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_18_115 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_404_ _404_/LO _404_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_14 _366_/LO VGND VPWR VPWR VGND sky130_fd_sc_hd__diode_2
Xedgedetect.dly200cell.genblk2\[38\].mux1 VGND VPWR _397_/LO edgedetect.dly200cell.genblk2\[38\].and1/B
+ edgedetect.dly200cell.genblk2\[38\].mux1/A0 edgedetect.dly200cell.genblk2\[39\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_17_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk2\[19\].delay_unit VPWR clkgen.delay_100ns_3.genblk2\[19\].and1/X
+ clkgen.delay_100ns_3.genblk2\[19\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_1.genblk2\[6\].delay_unit VPWR clkgen.delay_100ns_1.genblk2\[6\].and1/X
+ clkgen.delay_100ns_1.genblk2\[6\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_14_140 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
X_249_ _249_/LO _249_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_318_ _318_/LO _318_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xedgedetect.dly200cell.genblk2\[1\].mux1 VGND VPWR _377_/LO edgedetect.dly200cell.genblk2\[1\].and1/B
+ edgedetect.dly200cell.genblk2\[1\].mux1/A0 edgedetect.dly200cell.genblk2\[2\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
Xedgedetect.dly200cell.genblk2\[21\].mux1 VGND VPWR _379_/LO edgedetect.dly200cell.genblk2\[21\].and1/B
+ edgedetect.dly200cell.genblk2\[21\].mux1/A0 edgedetect.dly200cell.genblk2\[22\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_7_103 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_121 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_187 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[5\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[5\].and1/X
+ edgedetect.dly200cell.genblk2\[5\].and1/B _301_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_19_254 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[10\].delay_unit VPWR edgedetect.dly200cell.genblk2\[10\].and1/X
+ edgedetect.dly200cell.genblk2\[10\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_3.genblk2\[18\].mux1 VGND VPWR _355_/LO clkgen.delay_100ns_3.genblk2\[18\].and1/B
+ clkgen.delay_100ns_3.genblk2\[18\].mux1/A0 clkgen.delay_100ns_3.genblk2\[19\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
Xedgedetect.dly200cell.genblk2\[25\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[25\].and1/X
+ edgedetect.dly200cell.genblk2\[25\].and1/B _283_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_3_183 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk2\[10\].and1 VPWR VGND clkgen.delay_100ns_2.genblk2\[10\].and1/X
+ clkgen.delay_100ns_2.genblk2\[9\].mux1/X _227_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_5_31 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk2\[2\].mux1 VGND VPWR _338_/LO clkgen.delay_100ns_2.genblk2\[2\].and1/B
+ clkgen.delay_100ns_2.genblk2\[2\].mux1/A0 clkgen.delay_100ns_2.genblk2\[3\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_5_234 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk2\[6\].and1 VPWR VGND clkgen.delay_100ns_2.genblk2\[6\].and1/X
+ clkgen.delay_100ns_2.genblk2\[6\].and1/B _242_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_14_62 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_282_ _282_/LO _282_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_351_ _351_/LO _351_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_17_330 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_334_ _334_/LO _334_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_403_ _403_/LO _403_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xedgedetect.dly200cell.genblk2\[15\].delay_unit VPWR edgedetect.dly200cell.genblk2\[15\].and1/X
+ edgedetect.dly200cell.genblk2\[15\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_2_43 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_347 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
X_265_ _265_/LO _265_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_11_347 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_248_ _248_/LO _248_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_317_ _317_/LO _317_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_20_199 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_354 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_144 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_244 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_129 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.dly200cell.genblk2\[31\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[31\].and1/X
+ edgedetect.dly200cell.genblk2\[31\].and1/B _290_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_0_121 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_3.genblk2\[0\].mux1 VGND VPWR _346_/LO _204_/X clkgen.delay_100ns_3.genblk2\[0\].mux1/A0
+ clkgen.delay_100ns_3.genblk2\[1\].and1/B VGND VPWR sky130_fd_sc_hd__mux2_1
Xclkgen.delay_100ns_1.genblk2\[11\].mux1 VGND VPWR _308_/LO clkgen.delay_100ns_1.genblk2\[11\].and1/B
+ clkgen.delay_100ns_1.genblk2\[11\].mux1/A0 clkgen.delay_100ns_1.genblk2\[12\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_12_294 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[22\].delay_unit VPWR edgedetect.dly200cell.genblk2\[22\].and1/X
+ edgedetect.dly200cell.genblk2\[22\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_1.genblk2\[15\].and1 VPWR VGND clkgen.delay_100ns_1.genblk2\[15\].and1/X
+ clkgen.delay_100ns_1.genblk2\[15\].and1/B _212_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_10_209 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_3.genblk2\[4\].and1 VPWR VGND clkgen.delay_100ns_3.genblk2\[4\].and1/X
+ clkgen.delay_100ns_3.genblk2\[4\].and1/B _260_/HI VGND VPWR sky130_fd_sc_hd__and2_1
X_350_ _350_/LO _350_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_281_ _281_/LO _281_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xclkgen.delay_100ns_3.genblk2\[11\].and1 VPWR VGND clkgen.delay_100ns_3.genblk2\[11\].and1/X
+ clkgen.delay_100ns_3.genblk2\[11\].and1/B _248_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_19_19 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_205 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_264_ _264_/LO _264_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_402_ _402_/LO _402_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_333_ _333_/LO _333_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XPHY_40 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_304 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_326 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.dly200cell.genblk2\[1\].delay_unit VPWR edgedetect.dly200cell.genblk2\[1\].and1/X
+ edgedetect.dly200cell.genblk2\[1\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
X_247_ _247_/LO _247_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_14_186 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_316_ _316_/LO _316_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_11_112 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[27\].delay_unit VPWR edgedetect.dly200cell.genblk2\[27\].and1/X
+ edgedetect.dly200cell.genblk2\[27\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_17_63 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_74 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_292 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_3 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.dly200cell.genblk2\[6\].delay_unit VPWR edgedetect.dly200cell.genblk2\[6\].and1/X
+ edgedetect.dly200cell.genblk2\[6\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xedgedetect.dly200cell.genblk2\[7\].mux1 VGND VPWR _403_/LO edgedetect.dly200cell.genblk2\[7\].and1/B
+ edgedetect.dly200cell.genblk2\[7\].mux1/A0 edgedetect.dly200cell.genblk2\[8\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
X_280_ _280_/LO _280_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xclkgen.delay_100ns_3.genblk2\[4\].delay_unit VPWR clkgen.delay_100ns_3.genblk2\[4\].and1/X
+ clkgen.delay_100ns_3.genblk2\[4\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_4_280 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk2\[13\].delay_unit VPWR clkgen.delay_100ns_2.genblk2\[13\].and1/X
+ clkgen.delay_100ns_2.genblk2\[13\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xedgedetect.dly200cell.genblk2\[27\].mux1 VGND VPWR _385_/LO edgedetect.dly200cell.genblk2\[27\].and1/B
+ edgedetect.dly200cell.genblk2\[27\].mux1/A0 edgedetect.dly200cell.genblk2\[28\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_2_56 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk2\[12\].mux1 VGND VPWR _329_/LO clkgen.delay_100ns_2.genblk2\[12\].and1/B
+ clkgen.delay_100ns_2.genblk2\[12\].mux1/A0 clkgen.delay_100ns_2.genblk2\[13\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_14_335 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_30 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_41 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_401_ _401_/LO _401_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_332_ _332_/LO _332_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_263_ _263_/LO _263_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xedgedetect.dly200cell.genblk2\[34\].delay_unit VPWR edgedetect.dly200cell.genblk2\[34\].and1/X
+ edgedetect.dly200cell.genblk2\[34\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_2.genblk2\[16\].and1 VPWR VGND clkgen.delay_100ns_2.genblk2\[16\].and1/X
+ clkgen.delay_100ns_2.genblk2\[16\].and1/B _233_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_20_338 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.dly200cell.genblk2\[10\].mux1 VGND VPWR _367_/LO edgedetect.dly200cell.genblk2\[9\].mux1/X
+ edgedetect.dly200cell.genblk2\[10\].mux1/A0 edgedetect.dly200cell.genblk2\[11\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_11_338 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[14\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[14\].and1/X
+ edgedetect.dly200cell.genblk2\[14\].and1/B _271_/HI VGND VPWR sky130_fd_sc_hd__and2_1
X_315_ _315_/LO _315_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_6_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_246_ _246_/LO _246_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_20_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk2\[8\].mux1 VGND VPWR _344_/LO clkgen.delay_100ns_2.genblk2\[8\].and1/B
+ clkgen.delay_100ns_2.genblk2\[8\].mux1/A0 clkgen.delay_100ns_2.genblk2\[9\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_20_168 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_183 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_99 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_229_ _229_/LO _229_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_19_213 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_268 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk2\[18\].delay_unit VPWR clkgen.delay_100ns_2.genblk2\[18\].and1/X
+ clkgen.delay_100ns_2.genblk2\[18\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_3.genblk2\[9\].delay_unit VPWR clkgen.delay_100ns_3.genblk2\[9\].and1/X
+ clkgen.delay_100ns_3.genblk2\[9\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_16_205 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_53 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_86 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_156 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[39\].delay_unit VPWR edgedetect.dly200cell.genblk2\[39\].and1/X
+ edgedetect.dly200cell.genblk2\[39\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_14_32 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk2\[3\].and1 VPWR VGND clkgen.delay_100ns_1.genblk2\[3\].and1/X
+ clkgen.delay_100ns_1.genblk2\[3\].and1/B _219_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_17_344 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_229 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_292 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[33\].mux1 VGND VPWR _392_/LO edgedetect.dly200cell.genblk2\[33\].and1/B
+ edgedetect.dly200cell.genblk2\[33\].mux1/A0 edgedetect.dly200cell.genblk2\[34\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XPHY_20 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_347 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_31 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_331_ _331_/LO _331_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_262_ _262_/LO _262_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_18_108 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_400_ _400_/LO _400_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xedgedetect.dly200cell.genblk2\[37\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[37\].and1/X
+ edgedetect.dly200cell.genblk2\[37\].and1/B _296_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_17_152 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_306 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk2\[6\].mux1 VGND VPWR _362_/LO clkgen.delay_100ns_3.genblk2\[6\].and1/B
+ clkgen.delay_100ns_3.genblk2\[6\].mux1/A0 clkgen.delay_100ns_3.genblk2\[7\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
Xclkgen.delay_100ns_1.genblk2\[17\].mux1 VGND VPWR _314_/LO clkgen.delay_100ns_1.genblk2\[17\].and1/B
+ clkgen.delay_100ns_1.genblk2\[17\].mux1/A0 clkgen.delay_100ns_1.genblk2\[18\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_14_111 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[0\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[0\].and1/X
+ _204_/A1 _266_/HI VGND VPWR sky130_fd_sc_hd__and2_1
X_314_ _314_/LO _314_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_245_ _245_/LO _245_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xedgedetect.dly200cell.genblk2\[20\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[20\].and1/X
+ edgedetect.dly200cell.genblk2\[20\].and1/B _278_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_11_103 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk2\[13\].mux1 VGND VPWR _350_/LO clkgen.delay_100ns_3.genblk2\[13\].and1/B
+ clkgen.delay_100ns_3.genblk2\[13\].mux1/A0 clkgen.delay_100ns_3.genblk2\[14\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_11_136 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk2\[17\].and1 VPWR VGND clkgen.delay_100ns_3.genblk2\[17\].and1/X
+ clkgen.delay_100ns_3.genblk2\[17\].and1/B _254_/HI VGND VPWR sky130_fd_sc_hd__and2_1
X_228_ _228_/LO _228_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_0_349 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_154 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_228 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_21 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_198 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_268 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_275 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk2\[1\].and1 VPWR VGND clkgen.delay_100ns_2.genblk2\[1\].and1/X
+ clkgen.delay_100ns_2.genblk2\[1\].and1/B _237_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_5_249 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk2\[3\].delay_unit VPWR clkgen.delay_100ns_2.genblk2\[3\].and1/X
+ clkgen.delay_100ns_2.genblk2\[3\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_17_323 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_10 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_21 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_32 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_261_ _261_/LO _261_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_330_ _330_/LO _330_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_9_352 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_142 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
Xoutbuf_1 VPWR VGND clk_dig _205_/Y VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_14_101 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_156 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_313_ _313_/LO _313_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_244_ _244_/LO _244_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_3_90 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_347 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_237 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_227_ _227_/LO _227_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_18_292 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_270 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_328 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk2\[8\].delay_unit VPWR clkgen.delay_100ns_2.genblk2\[8\].and1/X
+ clkgen.delay_100ns_2.genblk2\[8\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_16_218 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk2\[18\].mux1 VGND VPWR _335_/LO clkgen.delay_100ns_2.genblk2\[18\].and1/B
+ clkgen.delay_100ns_2.genblk2\[18\].mux1/A0 clkgen.delay_100ns_2.genblk2\[19\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_0_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[16\].mux1 VGND VPWR _373_/LO edgedetect.dly200cell.genblk2\[16\].and1/B
+ edgedetect.dly200cell.genblk2\[16\].mux1/A0 edgedetect.dly200cell.genblk2\[17\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_8_203 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_287 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk2\[10\].and1 VPWR VGND clkgen.delay_100ns_1.genblk2\[10\].and1/X
+ clkgen.delay_100ns_1.genblk2\[9\].mux1/X _207_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_17_302 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_11 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_22 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_33 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_260_ _260_/LO _260_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_1_231 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_286 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_389_ _389_/LO _389_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_20_319 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xoutbuf_2 VPWR VGND clk_comp outbuf_2/A VGND VPWR sky130_fd_sc_hd__buf_4
Xclkgen.delay_100ns_3.genblk2\[10\].delay_unit VPWR clkgen.delay_100ns_3.genblk2\[10\].and1/X
+ clkgen.delay_100ns_3.genblk2\[10\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
X_312_ _312_/LO _312_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_243_ _243_/LO _243_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_9_183 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_1.genblk2\[12\].delay_unit VPWR clkgen.delay_100ns_1.genblk2\[12\].and1/X
+ clkgen.delay_100ns_1.genblk2\[12\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_20_149 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_1.genblk2\[5\].mux1 VGND VPWR _321_/LO clkgen.delay_100ns_1.genblk2\[5\].and1/B
+ clkgen.delay_100ns_1.genblk2\[5\].mux1/A0 clkgen.delay_100ns_1.genblk2\[6\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_10_171 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk2\[9\].and1 VPWR VGND clkgen.delay_100ns_1.genblk2\[9\].and1/X
+ clkgen.delay_100ns_1.genblk2\[9\].and1/B _225_/HI VGND VPWR sky130_fd_sc_hd__and2_1
X_226_ _226_/LO _226_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_19_3 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_12 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[39\].mux1 VGND VPWR _398_/LO edgedetect.dly200cell.genblk2\[39\].and1/B
+ edgedetect.dly200cell.genblk2\[39\].mux1/A0 _202_/A VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_15_241 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_285 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_90 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_209_ _209_/LO _209_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xedgedetect.dly200cell.genblk2\[2\].mux1 VGND VPWR _388_/LO edgedetect.dly200cell.genblk2\[2\].and1/B
+ edgedetect.dly200cell.genblk2\[2\].mux1/A0 edgedetect.dly200cell.genblk2\[3\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_8_259 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[6\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[6\].and1/X
+ edgedetect.dly200cell.genblk2\[6\].and1/B _302_/HI VGND VPWR sky130_fd_sc_hd__and2_1
Xedgedetect.dly200cell.genblk2\[22\].mux1 VGND VPWR _380_/LO edgedetect.dly200cell.genblk2\[22\].and1/B
+ edgedetect.dly200cell.genblk2\[22\].mux1/A0 edgedetect.dly200cell.genblk2\[23\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
Xclkgen.delay_100ns_3.genblk2\[15\].delay_unit VPWR clkgen.delay_100ns_3.genblk2\[15\].and1/X
+ clkgen.delay_100ns_3.genblk2\[15\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_1.genblk2\[2\].delay_unit VPWR clkgen.delay_100ns_1.genblk2\[2\].and1/X
+ clkgen.delay_100ns_1.genblk2\[2\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_3.genblk2\[19\].mux1 VGND VPWR _356_/LO clkgen.delay_100ns_3.genblk2\[19\].and1/B
+ clkgen.delay_100ns_3.genblk2\[19\].mux1/A0 outbuf_2/A VGND VPWR sky130_fd_sc_hd__mux2_1
Xclkgen.delay_100ns_1.genblk2\[17\].delay_unit VPWR clkgen.delay_100ns_1.genblk2\[17\].and1/X
+ clkgen.delay_100ns_1.genblk2\[17\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xedgedetect.dly200cell.genblk2\[26\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[26\].and1/X
+ edgedetect.dly200cell.genblk2\[26\].and1/B _284_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XPHY_12 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk2\[11\].and1 VPWR VGND clkgen.delay_100ns_2.genblk2\[11\].and1/X
+ clkgen.delay_100ns_2.genblk2\[11\].and1/B _228_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XPHY_23 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_328 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_34 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_177 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_199 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_343 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xoutbuf_3 VPWR VGND sample_p_buf sample_p VGND VPWR sky130_fd_sc_hd__buf_4
X_388_ _388_/LO _388_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xclkgen.delay_100ns_2.genblk2\[3\].mux1 VGND VPWR _339_/LO clkgen.delay_100ns_2.genblk2\[3\].and1/B
+ clkgen.delay_100ns_2.genblk2\[3\].mux1/A0 clkgen.delay_100ns_2.genblk2\[4\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_10_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_47 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
X_311_ _311_/LO _311_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_242_ _242_/LO _242_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xclkgen.delay_100ns_2.genblk2\[7\].and1 VPWR VGND clkgen.delay_100ns_2.genblk2\[7\].and1/X
+ clkgen.delay_100ns_2.genblk2\[7\].and1/B _243_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_20_106 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_305 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_59 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_225_ _225_/LO _225_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_19_206 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_319 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk2\[7\].delay_unit VPWR clkgen.delay_100ns_1.genblk2\[7\].and1/X
+ clkgen.delay_100ns_1.genblk2\[7\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_17_46 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_208_ _208_/LO _208_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xedgedetect.dly200cell.genblk2\[11\].delay_unit VPWR edgedetect.dly200cell.genblk2\[11\].and1/X
+ edgedetect.dly200cell.genblk2\[11\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_7_260 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_274 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[32\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[32\].and1/X
+ edgedetect.dly200cell.genblk2\[32\].and1/B _291_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_1_299 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_13 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_24 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_112 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_35 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_3.genblk2\[1\].mux1 VGND VPWR _357_/LO clkgen.delay_100ns_3.genblk2\[1\].and1/B
+ clkgen.delay_100ns_3.genblk2\[1\].mux1/A0 clkgen.delay_100ns_3.genblk2\[2\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_9_311 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_1.genblk2\[12\].mux1 VGND VPWR _309_/LO clkgen.delay_100ns_1.genblk2\[12\].and1/B
+ clkgen.delay_100ns_1.genblk2\[12\].mux1/A0 clkgen.delay_100ns_1.genblk2\[13\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
X_387_ _387_/LO _387_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_17_167 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
Xoutbuf_4 VPWR VGND sample_n_buf sample_n VGND VPWR sky130_fd_sc_hd__buf_4
Xclkgen.delay_100ns_3.genblk2\[5\].and1 VPWR VGND clkgen.delay_100ns_3.genblk2\[5\].and1/X
+ clkgen.delay_100ns_3.genblk2\[5\].and1/B _261_/HI VGND VPWR sky130_fd_sc_hd__and2_1
X_310_ _310_/LO _310_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_9_152 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_1.genblk2\[16\].and1 VPWR VGND clkgen.delay_100ns_1.genblk2\[16\].and1/X
+ clkgen.delay_100ns_1.genblk2\[16\].and1/B _213_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_13_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_241_ _241_/LO _241_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xclkgen.delay_100ns_3.genblk2\[12\].and1 VPWR VGND clkgen.delay_100ns_3.genblk2\[12\].and1/X
+ clkgen.delay_100ns_3.genblk2\[12\].and1/B _249_/HI VGND VPWR sky130_fd_sc_hd__and2_1
Xedgedetect.dly200cell.genblk2\[16\].delay_unit VPWR edgedetect.dly200cell.genblk2\[16\].and1/X
+ edgedetect.dly200cell.genblk2\[16\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_6_199 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_16 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_224_ _224_/LO _224_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_19_229 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_350 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_125 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_207_ _207_/LO _207_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_12_246 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_90 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_316 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_256 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_14 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_25 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.dly200cell.genblk2\[23\].delay_unit VPWR edgedetect.dly200cell.genblk2\[23\].and1/X
+ edgedetect.dly200cell.genblk2\[23\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
X_386_ _386_/LO _386_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_17_135 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xoutbuf_5 VPWR VGND nsample_p_buf nsample_p VGND VPWR sky130_fd_sc_hd__buf_4
Xedgedetect.dly200cell.genblk2\[8\].mux1 VGND VPWR _404_/LO edgedetect.dly200cell.genblk2\[8\].and1/B
+ edgedetect.dly200cell.genblk2\[8\].mux1/A0 edgedetect.dly200cell.genblk2\[9\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
X_240_ _240_/LO _240_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xedgedetect.dly200cell.genblk2\[28\].mux1 VGND VPWR _386_/LO edgedetect.dly200cell.genblk2\[28\].and1/B
+ edgedetect.dly200cell.genblk2\[28\].mux1/A0 edgedetect.dly200cell.genblk2\[29\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
X_369_ _369_/LO _369_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_3_318 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_223_ _223_/LO _223_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_6_134 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk2\[13\].mux1 VGND VPWR _330_/LO clkgen.delay_100ns_2.genblk2\[13\].and1/B
+ clkgen.delay_100ns_2.genblk2\[13\].mux1/A0 clkgen.delay_100ns_2.genblk2\[14\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_18_285 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_263 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_230 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[2\].delay_unit VPWR edgedetect.dly200cell.genblk2\[2\].and1/X
+ edgedetect.dly200cell.genblk2\[2\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_2.genblk2\[17\].and1 VPWR VGND clkgen.delay_100ns_2.genblk2\[17\].and1/X
+ clkgen.delay_100ns_2.genblk2\[17\].and1/B _234_/HI VGND VPWR sky130_fd_sc_hd__and2_1
Xclkgen.delay_100ns_3.genblk2\[0\].delay_unit VPWR clkgen.delay_100ns_3.genblk2\[0\].and1/X
+ clkgen.delay_100ns_3.genblk2\[0\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xedgedetect.dly200cell.genblk2\[11\].mux1 VGND VPWR _368_/LO edgedetect.dly200cell.genblk2\[11\].and1/B
+ edgedetect.dly200cell.genblk2\[11\].mux1/A0 edgedetect.dly200cell.genblk2\[12\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_15_299 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_206_ _206_/LO _206_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xedgedetect.dly200cell.genblk2\[15\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[15\].and1/X
+ edgedetect.dly200cell.genblk2\[15\].and1/B _272_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_17_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_218 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.dly200cell.genblk2\[28\].delay_unit VPWR edgedetect.dly200cell.genblk2\[28\].and1/X
+ edgedetect.dly200cell.genblk2\[28\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_2.genblk2\[9\].mux1 VGND VPWR _345_/LO clkgen.delay_100ns_2.genblk2\[9\].and1/B
+ clkgen.delay_100ns_2.genblk2\[9\].mux1/A0 clkgen.delay_100ns_2.genblk2\[9\].mux1/X
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_7_295 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[30\].delay_unit VPWR edgedetect.dly200cell.genblk2\[30\].and1/X
+ edgedetect.dly200cell.genblk2\[30\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_14_16 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_15 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_26 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_37 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_202 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_385_ _385_/LO _385_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_17_125 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.dly200cell.genblk2\[7\].delay_unit VPWR edgedetect.dly200cell.genblk2\[7\].and1/X
+ edgedetect.dly200cell.genblk2\[7\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xoutbuf_6 VPWR VGND nsample_n_buf nsample_n VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_16_180 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk2\[5\].delay_unit VPWR clkgen.delay_100ns_3.genblk2\[5\].and1/X
+ clkgen.delay_100ns_3.genblk2\[5\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_2.genblk2\[14\].delay_unit VPWR clkgen.delay_100ns_2.genblk2\[14\].and1/X
+ clkgen.delay_100ns_2.genblk2\[14\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_10_312 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk2\[0\].mux1 VGND VPWR _306_/LO inbuf_3/X clkgen.delay_100ns_1.genblk2\[0\].mux1/A0
+ clkgen.delay_100ns_1.genblk2\[1\].and1/B VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_9_198 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_1.genblk2\[4\].and1 VPWR VGND clkgen.delay_100ns_1.genblk2\[4\].and1/X
+ clkgen.delay_100ns_1.genblk2\[4\].and1/B _220_/HI VGND VPWR sky130_fd_sc_hd__and2_1
X_368_ _368_/LO _368_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_299_ _299_/LO _299_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_2_330 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[34\].mux1 VGND VPWR _393_/LO edgedetect.dly200cell.genblk2\[34\].and1/B
+ edgedetect.dly200cell.genblk2\[34\].mux1/A0 edgedetect.dly200cell.genblk2\[35\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
X_222_ _222_/LO _222_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xedgedetect.dly200cell.genblk2\[35\].delay_unit VPWR edgedetect.dly200cell.genblk2\[35\].and1/X
+ edgedetect.dly200cell.genblk2\[35\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xedgedetect.dly200cell.genblk2\[38\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[38\].and1/X
+ edgedetect.dly200cell.genblk2\[38\].and1/B _297_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_15_256 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_205_ _205_/A _205_/Y VPWR VGND VGND VPWR sky130_fd_sc_hd__inv_2
Xclkgen.delay_100ns_1.genblk2\[18\].mux1 VGND VPWR _315_/LO clkgen.delay_100ns_1.genblk2\[18\].and1/B
+ clkgen.delay_100ns_1.genblk2\[18\].mux1/A0 clkgen.delay_100ns_1.genblk2\[19\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
Xclkgen.delay_100ns_3.genblk2\[7\].mux1 VGND VPWR _363_/LO clkgen.delay_100ns_3.genblk2\[7\].and1/B
+ clkgen.delay_100ns_3.genblk2\[7\].mux1/A0 clkgen.delay_100ns_3.genblk2\[8\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
Xedgedetect.dly200cell.genblk2\[1\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[1\].and1/X
+ edgedetect.dly200cell.genblk2\[1\].and1/B _277_/HI VGND VPWR sky130_fd_sc_hd__and2_1
Xedgedetect.dly200cell.genblk2\[21\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[21\].and1/X
+ edgedetect.dly200cell.genblk2\[21\].and1/B _279_/HI VGND VPWR sky130_fd_sc_hd__and2_1
Xclkgen.delay_100ns_3.genblk2\[14\].mux1 VGND VPWR _351_/LO clkgen.delay_100ns_3.genblk2\[14\].and1/B
+ clkgen.delay_100ns_3.genblk2\[14\].mux1/A0 clkgen.delay_100ns_3.genblk2\[15\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
Xclkgen.delay_100ns_2.genblk2\[19\].delay_unit VPWR clkgen.delay_100ns_2.genblk2\[19\].and1/X
+ clkgen.delay_100ns_2.genblk2\[19\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_3.genblk2\[18\].and1 VPWR VGND clkgen.delay_100ns_3.genblk2\[18\].and1/X
+ clkgen.delay_100ns_3.genblk2\[18\].and1/B _255_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_20_82 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_16 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_384_ _384_/LO _384_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_17_159 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_280 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_18 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk2\[2\].and1 VPWR VGND clkgen.delay_100ns_2.genblk2\[2\].and1/X
+ clkgen.delay_100ns_2.genblk2\[2\].and1/B _238_/HI VGND VPWR sky130_fd_sc_hd__and2_1
X_367_ _367_/LO _367_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_298_ _298_/LO _298_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_6_147 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_94 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_221_ _221_/LO _221_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_18_210 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_204_ _204_/X _202_/Y _204_/A1 _204_/B1 _203_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__a211o_2
XFILLER_11_260 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_245 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk2\[19\].mux1 VGND VPWR _336_/LO clkgen.delay_100ns_2.genblk2\[19\].and1/B
+ clkgen.delay_100ns_2.genblk2\[19\].mux1/A0 _203_/A VGND VPWR sky130_fd_sc_hd__mux2_1
XPHY_17 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_28 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_1 ena_in VGND VPWR VPWR VGND sky130_fd_sc_hd__diode_2
XFILLER_13_300 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_311 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_322 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_100ns_3.genblk2\[0\].and1 VPWR VGND clkgen.delay_100ns_3.genblk2\[0\].and1/X
+ _204_/X _246_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_17_105 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_39 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_383_ _383_/LO _383_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xedgedetect.dly200cell.genblk2\[17\].mux1 VGND VPWR _374_/LO edgedetect.dly200cell.genblk2\[17\].and1/B
+ edgedetect.dly200cell.genblk2\[17\].mux1/A0 edgedetect.dly200cell.genblk2\[18\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
Xclkgen.delay_100ns_1.genblk2\[11\].and1 VPWR VGND clkgen.delay_100ns_1.genblk2\[11\].and1/X
+ clkgen.delay_100ns_1.genblk2\[11\].and1/B _208_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_16_171 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_307 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_2.genblk2\[4\].delay_unit VPWR clkgen.delay_100ns_2.genblk2\[4\].and1/X
+ clkgen.delay_100ns_2.genblk2\[4\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_10_325 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_297_ _297_/LO _297_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_366_ _366_/LO _366_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_2_321 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_220_ _220_/LO _220_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_5_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_349_ _349_/LO _349_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_18_299 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_203_ _203_/A _203_/Y VPWR VGND VGND VPWR sky130_fd_sc_hd__inv_2
XFILLER_14_291 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_232 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_261 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_83 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_61 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk2\[6\].mux1 VGND VPWR _322_/LO clkgen.delay_100ns_1.genblk2\[6\].and1/B
+ clkgen.delay_100ns_1.genblk2\[6\].mux1/A0 clkgen.delay_100ns_1.genblk2\[7\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
Xclkgen.delay_100ns_2.genblk2\[9\].delay_unit VPWR clkgen.delay_100ns_2.genblk2\[9\].and1/X
+ clkgen.delay_100ns_2.genblk2\[9\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_15_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_86 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_2 _226_/HI VGND VPWR VPWR VGND sky130_fd_sc_hd__diode_2
XPHY_18 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_29 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_180 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.dly200cell.genblk2\[3\].mux1 VGND VPWR _399_/LO edgedetect.dly200cell.genblk2\[3\].and1/B
+ edgedetect.dly200cell.genblk2\[3\].mux1/A0 edgedetect.dly200cell.genblk2\[4\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
X_382_ _382_/LO _382_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_16_150 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[23\].mux1 VGND VPWR _381_/LO edgedetect.dly200cell.genblk2\[23\].and1/B
+ edgedetect.dly200cell.genblk2\[23\].mux1/A0 edgedetect.dly200cell.genblk2\[24\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_13_175 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[7\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[7\].and1/X
+ edgedetect.dly200cell.genblk2\[7\].and1/B _303_/HI VGND VPWR sky130_fd_sc_hd__and2_1
X_296_ _296_/LO _296_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_365_ _365_/LO _365_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_8_190 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[27\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[27\].and1/X
+ edgedetect.dly200cell.genblk2\[27\].and1/B _285_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_6_105 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_156 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_100ns_2.genblk2\[12\].and1 VPWR VGND clkgen.delay_100ns_2.genblk2\[12\].and1/X
+ clkgen.delay_100ns_2.genblk2\[12\].and1/B _229_/HI VGND VPWR sky130_fd_sc_hd__and2_1
X_279_ _279_/LO _279_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_348_ _348_/LO _348_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_18_256 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_223 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.dly200cell.genblk2\[10\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[10\].and1/X
+ edgedetect.dly200cell.genblk2\[9\].mux1/X _267_/HI VGND VPWR sky130_fd_sc_hd__and2_1
Xclkgen.delay_100ns_3.genblk2\[11\].delay_unit VPWR clkgen.delay_100ns_3.genblk2\[11\].and1/X
+ clkgen.delay_100ns_3.genblk2\[11\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_1.genblk2\[13\].delay_unit VPWR clkgen.delay_100ns_1.genblk2\[13\].and1/X
+ clkgen.delay_100ns_1.genblk2\[13\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
X_202_ _202_/A _202_/Y VPWR VGND VGND VPWR sky130_fd_sc_hd__inv_2
XFILLER_9_42 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_2.genblk2\[4\].mux1 VGND VPWR _340_/LO clkgen.delay_100ns_2.genblk2\[4\].and1/B
+ clkgen.delay_100ns_2.genblk2\[4\].mux1/A0 clkgen.delay_100ns_2.genblk2\[5\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_12_218 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_100ns_2.genblk2\[8\].and1 VPWR VGND clkgen.delay_100ns_2.genblk2\[8\].and1/X
+ clkgen.delay_100ns_2.genblk2\[8\].and1/B _244_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_11_273 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_295 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_351 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_32 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_3 _236_/HI VGND VPWR VPWR VGND sky130_fd_sc_hd__diode_2
XPHY_19 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_74 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_381_ _381_/LO _381_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xclkgen.delay_100ns_3.genblk2\[16\].delay_unit VPWR clkgen.delay_100ns_3.genblk2\[16\].and1/X
+ clkgen.delay_100ns_3.genblk2\[16\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_1.genblk2\[3\].delay_unit VPWR clkgen.delay_100ns_1.genblk2\[3\].and1/X
+ clkgen.delay_100ns_1.genblk2\[3\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
Xclkgen.delay_100ns_1.genblk2\[18\].delay_unit VPWR clkgen.delay_100ns_1.genblk2\[18\].and1/X
+ clkgen.delay_100ns_1.genblk2\[18\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_3_55 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_103 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
X_364_ _364_/LO _364_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
X_295_ _295_/LO _295_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xedgedetect.dly200cell.genblk2\[33\].and1 VPWR VGND edgedetect.dly200cell.genblk2\[33\].and1/X
+ edgedetect.dly200cell.genblk2\[33\].and1/B _292_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_10_135 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_3 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_347_ _347_/LO _347_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_12_64 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_86 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_278_ _278_/LO _278_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
Xclkgen.delay_100ns_3.genblk2\[2\].mux1 VGND VPWR _358_/LO clkgen.delay_100ns_3.genblk2\[2\].and1/B
+ clkgen.delay_100ns_3.genblk2\[2\].mux1/A0 clkgen.delay_100ns_3.genblk2\[3\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_2_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk2\[13\].mux1 VGND VPWR _310_/LO clkgen.delay_100ns_1.genblk2\[13\].and1/B
+ clkgen.delay_100ns_1.genblk2\[13\].mux1/A0 clkgen.delay_100ns_1.genblk2\[14\].and1/B
+ VGND VPWR sky130_fd_sc_hd__mux2_1
Xclkgen.delay_100ns_3.genblk2\[6\].and1 VPWR VGND clkgen.delay_100ns_3.genblk2\[6\].and1/X
+ clkgen.delay_100ns_3.genblk2\[6\].and1/B _262_/HI VGND VPWR sky130_fd_sc_hd__and2_1
Xclkgen.delay_100ns_1.genblk2\[17\].and1 VPWR VGND clkgen.delay_100ns_1.genblk2\[17\].and1/X
+ clkgen.delay_100ns_1.genblk2\[17\].and1/B _214_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_12_208 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_3.genblk2\[13\].and1 VPWR VGND clkgen.delay_100ns_3.genblk2\[13\].and1/X
+ clkgen.delay_100ns_3.genblk2\[13\].and1/B _250_/HI VGND VPWR sky130_fd_sc_hd__and2_1
XFILLER_7_245 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_230 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_100ns_1.genblk2\[8\].delay_unit VPWR clkgen.delay_100ns_1.genblk2\[8\].and1/X
+ clkgen.delay_100ns_1.genblk2\[8\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_16_322 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_75 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_53 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_44 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_4 _237_/HI VGND VPWR VPWR VGND sky130_fd_sc_hd__diode_2
Xedgedetect.dly200cell.genblk2\[12\].delay_unit VPWR edgedetect.dly200cell.genblk2\[12\].and1/X
+ edgedetect.dly200cell.genblk2\[12\].mux1/A0 VGND VGND VPWR sky130_mm_sc_hd_dlyPoly5ns
XFILLER_15_97 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_119 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_380_ _380_/LO _380_/HI VPWR VGND VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_16_130 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
.ends
