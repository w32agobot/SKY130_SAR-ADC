* NGSPICE file created from adc_edge_detect_circuit.ext - technology: sky130A

.subckt sky130_fd_sc_hd__decap_6 VGND VPWR VNB VPB
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=4.524e+11p pd=4.52e+06u as=0p ps=0u w=870000u l=1.97e+06u
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=2.86e+11p pd=3.24e+06u as=0p ps=0u w=550000u l=1.97e+06u
.ends

.subckt sky130_fd_sc_hd__decap_4 VGND VPWR VNB VPB
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=4.524e+11p pd=4.52e+06u as=0p ps=0u w=870000u l=1.05e+06u
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=2.86e+11p pd=3.24e+06u as=0p ps=0u w=550000u l=1.05e+06u
.ends

.subckt sky130_fd_sc_hd__decap_3 VGND VPWR VNB VPB
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=4.524e+11p pd=4.52e+06u as=0p ps=0u w=870000u l=590000u
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=2.86e+11p pd=3.24e+06u as=0p ps=0u w=550000u l=590000u
.ends

.subckt sky130_fd_sc_hd__clkdlybuf4s50_2 A VGND VPWR X VNB VPB
X0 VPWR a_283_47# a_390_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.0458e+12p pd=8.16e+06u as=2.132e+11p ps=2.16e+06u w=820000u l=500000u
X1 a_283_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.173e+11p pd=2.17e+06u as=0p ps=0u w=820000u l=500000u
X2 VPWR a_390_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.75e+11p ps=2.55e+06u w=1e+06u l=150000u
X3 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X4 X a_390_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 VGND a_283_47# a_390_47# VNB sky130_fd_pr__nfet_01v8 ad=5.686e+11p pd=5.6e+06u as=1.69e+11p ps=1.82e+06u w=650000u l=500000u
X6 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X7 VGND a_390_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.155e+11p ps=1.39e+06u w=420000u l=150000u
X8 a_283_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.7225e+11p pd=1.83e+06u as=0p ps=0u w=650000u l=500000u
X9 X a_390_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__decap_8 VGND VPWR VNB VPB
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=4.524e+11p pd=4.52e+06u as=0p ps=0u w=870000u l=2.89e+06u
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=2.86e+11p pd=3.24e+06u as=0p ps=0u w=550000u l=2.89e+06u
.ends

.subckt sky130_fd_sc_hd__inv_1 A VGND VPWR Y VNB VPB
X0 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
.ends

.subckt sky130_ef_sc_hd__decap_12 VGND VPWR VNB VPB
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=4.524e+11p pd=4.52e+06u as=0p ps=0u w=870000u l=4.73e+06u
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=2.86e+11p pd=3.24e+06u as=0p ps=0u w=550000u l=4.73e+06u
.ends

.subckt sky130_fd_sc_hd__nor2_1 A B VGND VPWR Y VNB VPB
X0 VPWR A a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=2.1e+11p ps=2.42e+06u w=1e+06u l=150000u
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=3.38e+11p pd=3.64e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X2 a_109_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X3 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt adc_edge_detect_circuit VGND VPWR ena_in ena_out start_conv
XFILLER_22_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_236 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_155 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x15 x1_x15/A VGND VPWR x1_x16/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_27_214 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xx3_x1590 x3_x1590/A VGND VPWR x3_x1591/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_41_272 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xx3_x125 x3_x125/A VGND VPWR x3_x126/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x158 x3_x158/A VGND VPWR x3_x159/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x147 x3_x147/A VGND VPWR x3_x148/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x136 x3_x136/A VGND VPWR x3_x137/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x114 x3_x114/A VGND VPWR x3_x115/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x169 x3_x169/A VGND VPWR x3_x170/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_26_280 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xx1_x1405 x1_x1405/A VGND VPWR x1_x1406/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1416 x1_x1416/A VGND VPWR x1_x1417/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1427 x1_x1427/A VGND VPWR x1_x1428/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1438 x1_x1438/A VGND VPWR x1_x1439/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1449 x1_x1449/A VGND VPWR x1_x1450/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x1279 x1_x1279/A VGND VPWR x1_x1280/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1257 x1_x1257/A VGND VPWR x1_x1258/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1224 x1_x1224/A VGND VPWR x1_x1225/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1268 x1_x1268/A VGND VPWR x1_x1269/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1246 x1_x1246/A VGND VPWR x1_x1247/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1235 x1_x1235/A VGND VPWR x1_x1236/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1213 x1_x1213/A VGND VPWR x1_x1214/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1202 x1_x1202/A VGND VPWR x1_x1203/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_97 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_275 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_106 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_139 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_21 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1408 x3_x1408/A VGND VPWR x3_x1409/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1419 x3_x1419/A VGND VPWR x3_x1420/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_13_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_161 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_32 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_245 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1216 x3_x1216/A VGND VPWR x3_x1217/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1205 x3_x1205/A VGND VPWR x3_x1206/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1227 x3_x1227/A VGND VPWR x3_x1228/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1238 x3_x1238/A VGND VPWR x3_x1239/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1249 x3_x1249/A VGND VPWR x3_x1250/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x16 x1_x16/A VGND VPWR x1_x17/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1591 x3_x1591/A VGND VPWR x3_x1592/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1580 x3_x1580/A VGND VPWR x3_x1581/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x115 x3_x115/A VGND VPWR x3_x116/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x126 x3_x126/A VGND VPWR x3_x127/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x148 x3_x148/A VGND VPWR x3_x149/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x159 x3_x159/A VGND VPWR x3_x160/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x137 x3_x137/A VGND VPWR x3_x138/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_17_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x1406 x1_x1406/A VGND VPWR x1_x1407/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1417 x1_x1417/A VGND VPWR x1_x1418/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1428 x1_x1428/A VGND VPWR x1_x1429/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1439 x1_x1439/A VGND VPWR x1_x1440/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_15_218 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x1258 x1_x1258/A VGND VPWR x1_x1259/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1269 x1_x1269/A VGND VPWR x1_x1270/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1225 x1_x1225/A VGND VPWR x1_x1226/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1247 x1_x1247/A VGND VPWR x1_x1248/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1236 x1_x1236/A VGND VPWR x1_x1237/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1214 x1_x1214/A VGND VPWR x1_x1215/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1203 x1_x1203/A VGND VPWR x1_x1204/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_210 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_173 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1409 x3_x1409/A VGND VPWR x3_x1410/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_15_44 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_198 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xx3_x1228 x3_x1228/A VGND VPWR x3_x1229/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1217 x3_x1217/A VGND VPWR x3_x1218/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1206 x3_x1206/A VGND VPWR x3_x1207/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1239 x3_x1239/A VGND VPWR x3_x1240/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_45_249 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x17 x1_x17/A VGND VPWR x1_x18/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_150 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx3_x1592 x3_x1592/A VGND VPWR x3_x1593/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1581 x3_x1581/A VGND VPWR x3_x1582/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1570 x3_x1570/A VGND VPWR x3_x1571/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_219 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx3_x116 x3_x116/A VGND VPWR x3_x117/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x127 x3_x127/A VGND VPWR x3_x128/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx2 start_conv VGND VPWR x4/B VGND VPWR sky130_fd_sc_hd__inv_1
Xx3_x149 x3_x149/A VGND VPWR x3_x150/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x138 x3_x138/A VGND VPWR x3_x139/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_24_208 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xx1_x1407 x1_x1407/A VGND VPWR x1_x1408/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1418 x1_x1418/A VGND VPWR x1_x1419/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1429 x1_x1429/A VGND VPWR x1_x1430/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_167 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x1215 x1_x1215/A VGND VPWR x1_x1216/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1204 x1_x1204/A VGND VPWR x1_x1205/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1259 x1_x1259/A VGND VPWR x1_x1260/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1226 x1_x1226/A VGND VPWR x1_x1227/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1248 x1_x1248/A VGND VPWR x1_x1249/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1237 x1_x1237/A VGND VPWR x1_x1238/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_163 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_262 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x1590 x1_x1590/A VGND VPWR x1_x1591/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_25_122 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_66 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_169 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
Xx3_x1207 x3_x1207/A VGND VPWR x3_x1208/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1229 x3_x1229/A VGND VPWR x3_x1230/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1218 x3_x1218/A VGND VPWR x3_x1219/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_258 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_236 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x18 x1_x18/A VGND VPWR x1_x19/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1593 x3_x1593/A VGND VPWR x3_x1594/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1560 x3_x1560/A VGND VPWR x3_x1561/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1582 x3_x1582/A VGND VPWR x3_x1583/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1571 x3_x1571/A VGND VPWR x3_x1572/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x128 x3_x128/A VGND VPWR x3_x129/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x139 x3_x139/A VGND VPWR x3_x140/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x117 x3_x117/A VGND VPWR x3_x118/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_132 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_261 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx1_x1408 x1_x1408/A VGND VPWR x1_x1409/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1419 x1_x1419/A VGND VPWR x1_x1420/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_23_275 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx3_x1390 x3_x1390/A VGND VPWR x3_x1391/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x1227 x1_x1227/A VGND VPWR x1_x1228/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1216 x1_x1216/A VGND VPWR x1_x1217/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1238 x1_x1238/A VGND VPWR x1_x1239/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1205 x1_x1205/A VGND VPWR x1_x1206/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1249 x1_x1249/A VGND VPWR x1_x1250/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_33 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x1591 x1_x1591/A VGND VPWR x1_x1592/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1580 x1_x1580/A VGND VPWR x1_x1581/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_15_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_134 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1208 x3_x1208/A VGND VPWR x3_x1209/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1219 x3_x1219/A VGND VPWR x3_x1220/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_12 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_262 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x19 x1_x19/A VGND VPWR x1_x19/X VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1550 x3_x1550/A VGND VPWR x3_x1551/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1561 x3_x1561/A VGND VPWR x3_x1562/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_37_22 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1594 x3_x1594/A VGND VPWR x3_x1595/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_229 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx3_x1583 x3_x1583/A VGND VPWR x3_x1584/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1572 x3_x1572/A VGND VPWR x3_x1573/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x118 x3_x118/A VGND VPWR x3_x119/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x129 x3_x129/A VGND VPWR x3_x130/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx4 x4/A x4/B VGND VPWR x5/A VGND VPWR sky130_fd_sc_hd__nor2_1
XFILLER_5_100 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x1409 x1_x1409/A VGND VPWR x1_x1410/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_23_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_79 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1391 x3_x1391/A VGND VPWR x3_x1392/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1380 x3_x1380/A VGND VPWR x3_x1381/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1228 x1_x1228/A VGND VPWR x1_x1229/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1217 x1_x1217/A VGND VPWR x1_x1218/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1239 x1_x1239/A VGND VPWR x1_x1240/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1206 x1_x1206/A VGND VPWR x1_x1207/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_13 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_198 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_99 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_66 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_16 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x1592 x1_x1592/A VGND VPWR x1_x1593/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1570 x1_x1570/A VGND VPWR x1_x1571/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1581 x1_x1581/A VGND VPWR x1_x1582/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_25_135 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx3_x1209 x3_x1209/A VGND VPWR x3_x1210/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_38_271 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_12 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_160 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_193 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx3_x1595 x3_x1595/A VGND VPWR x3_x1596/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1540 x3_x1540/A VGND VPWR x3_x1541/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1551 x3_x1551/A VGND VPWR x3_x1552/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1562 x3_x1562/A VGND VPWR x3_x1563/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1584 x3_x1584/A VGND VPWR x3_x1585/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1573 x3_x1573/A VGND VPWR x3_x1574/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_26_230 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xx3_x119 x3_x119/A VGND VPWR x3_x120/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx5 x5/A ena_in VGND VPWR x6/A VGND VPWR sky130_fd_sc_hd__nor2_1
XFILLER_17_274 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_244 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xx3_x1370 x3_x1370/A VGND VPWR x3_x1371/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1392 x3_x1392/A VGND VPWR x3_x1393/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1381 x3_x1381/A VGND VPWR x3_x1382/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x1229 x1_x1229/A VGND VPWR x1_x1230/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1218 x1_x1218/A VGND VPWR x1_x1219/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1207 x1_x1207/A VGND VPWR x1_x1208/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_47 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_24 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_177 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x1560 x1_x1560/A VGND VPWR x1_x1561/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1593 x1_x1593/A VGND VPWR x1_x1594/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1571 x1_x1571/A VGND VPWR x1_x1572/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1582 x1_x1582/A VGND VPWR x1_x1583/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_25_147 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_128 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_206 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x1390 x1_x1390/A VGND VPWR x1_x1391/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_261 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_0 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_275 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx3_x1596 x3_x1596/A VGND VPWR x3_x1597/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1530 x3_x1530/A VGND VPWR x3_x1531/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1541 x3_x1541/A VGND VPWR x3_x1542/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1552 x3_x1552/A VGND VPWR x3_x1553/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1585 x3_x1585/A VGND VPWR x3_x1586/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1563 x3_x1563/A VGND VPWR x3_x1564/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1574 x3_x1574/A VGND VPWR x3_x1575/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_37_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xx6 x6/A VGND VPWR ena_out VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_17_220 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_26 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_234 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx3_x1371 x3_x1371/A VGND VPWR x3_x1372/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1393 x3_x1393/A VGND VPWR x3_x1394/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1360 x3_x1360/A VGND VPWR x3_x1361/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1382 x3_x1382/A VGND VPWR x3_x1383/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_39 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x1219 x1_x1219/A VGND VPWR x1_x1220/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1208 x1_x1208/A VGND VPWR x1_x1209/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_59 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1190 x3_x1190/A VGND VPWR x3_x1191/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_189 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_285 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_126 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_189 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_277 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x1594 x1_x1594/A VGND VPWR x1_x1595/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1561 x1_x1561/A VGND VPWR x1_x1562/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1583 x1_x1583/A VGND VPWR x1_x1584/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1572 x1_x1572/A VGND VPWR x1_x1573/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1550 x1_x1550/A VGND VPWR x1_x1551/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_247 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_218 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx1_x1391 x1_x1391/A VGND VPWR x1_x1392/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1380 x1_x1380/A VGND VPWR x1_x1381/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_273 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_1 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_72 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_151 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx3_x1597 x3_x1597/A VGND VPWR x3_x1598/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1520 x3_x1520/A VGND VPWR x3_x1521/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1531 x3_x1531/A VGND VPWR x3_x1532/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1542 x3_x1542/A VGND VPWR x3_x1543/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1553 x3_x1553/A VGND VPWR x3_x1554/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1586 x3_x1586/A VGND VPWR x3_x1587/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1564 x3_x1564/A VGND VPWR x3_x1565/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1575 x3_x1575/A VGND VPWR x3_x1576/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx3_x1350 x3_x1350/A VGND VPWR x3_x1351/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1361 x3_x1361/A VGND VPWR x3_x1362/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_13 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx3_x1372 x3_x1372/A VGND VPWR x3_x1373/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1394 x3_x1394/A VGND VPWR x3_x1395/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1383 x3_x1383/A VGND VPWR x3_x1384/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1209 x1_x1209/A VGND VPWR x1_x1210/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_34_59 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx3_x1180 x3_x1180/A VGND VPWR x3_x1181/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1191 x3_x1191/A VGND VPWR x3_x1192/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_14 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_190 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x1595 x1_x1595/A VGND VPWR x1_x1596/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1562 x1_x1562/A VGND VPWR x1_x1563/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1584 x1_x1584/A VGND VPWR x1_x1585/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1573 x1_x1573/A VGND VPWR x1_x1574/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1551 x1_x1551/A VGND VPWR x1_x1552/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1540 x1_x1540/A VGND VPWR x1_x1541/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_124 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x1392 x1_x1392/A VGND VPWR x1_x1393/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1381 x1_x1381/A VGND VPWR x1_x1382/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1370 x1_x1370/A VGND VPWR x1_x1371/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_2 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_285 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_196 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_152 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx3_x1510 x3_x1510/A VGND VPWR x3_x1511/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1521 x3_x1521/A VGND VPWR x3_x1522/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1532 x3_x1532/A VGND VPWR x3_x1533/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1543 x3_x1543/A VGND VPWR x3_x1544/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1598 x3_x1598/A VGND VPWR x3_x1599/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1554 x3_x1554/A VGND VPWR x3_x1555/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1565 x3_x1565/A VGND VPWR x3_x1566/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1587 x3_x1587/A VGND VPWR x3_x1588/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1576 x3_x1576/A VGND VPWR x3_x1577/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_43_80 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1340 x3_x1340/A VGND VPWR x3_x1341/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1351 x3_x1351/A VGND VPWR x3_x1352/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1373 x3_x1373/A VGND VPWR x3_x1374/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1395 x3_x1395/A VGND VPWR x3_x1396/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1384 x3_x1384/A VGND VPWR x3_x1385/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1362 x3_x1362/A VGND VPWR x3_x1363/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_34_38 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx3_x1181 x3_x1181/A VGND VPWR x3_x1182/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1170 x3_x1170/A VGND VPWR x3_x1171/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1192 x3_x1192/A VGND VPWR x3_x1193/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_283 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_125 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx1_x1596 x1_x1596/A VGND VPWR x1_x1597/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1563 x1_x1563/A VGND VPWR x1_x1564/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1585 x1_x1585/A VGND VPWR x1_x1586/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1574 x1_x1574/A VGND VPWR x1_x1575/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1552 x1_x1552/A VGND VPWR x1_x1553/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1541 x1_x1541/A VGND VPWR x1_x1542/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1530 x1_x1530/A VGND VPWR x1_x1531/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_161 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx1_x1360 x1_x1360/A VGND VPWR x1_x1361/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1393 x1_x1393/A VGND VPWR x1_x1394/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1382 x1_x1382/A VGND VPWR x1_x1383/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1371 x1_x1371/A VGND VPWR x1_x1372/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_120 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xx1_x1190 x1_x1190/A VGND VPWR x1_x1191/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_234 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx3_x1511 x3_x1511/A VGND VPWR x3_x1512/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1500 x3_x1500/A VGND VPWR x3_x1501/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1522 x3_x1522/A VGND VPWR x3_x1523/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1533 x3_x1533/A VGND VPWR x3_x1534/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1544 x3_x1544/A VGND VPWR x3_x1545/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1555 x3_x1555/A VGND VPWR x3_x1556/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1566 x3_x1566/A VGND VPWR x3_x1567/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1577 x3_x1577/A VGND VPWR x3_x1578/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1599 x3_x1599/A VGND VPWR x3_x1600/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1588 x3_x1588/A VGND VPWR x3_x1589/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_31_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1341 x3_x1341/A VGND VPWR x3_x1342/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1330 x3_x1330/A VGND VPWR x3_x1331/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1352 x3_x1352/A VGND VPWR x3_x1353/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1374 x3_x1374/A VGND VPWR x3_x1375/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1363 x3_x1363/A VGND VPWR x3_x1364/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1385 x3_x1385/A VGND VPWR x3_x1386/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1396 x3_x1396/A VGND VPWR x3_x1397/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_13_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_104 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1160 x3_x1160/A VGND VPWR x3_x1161/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1182 x3_x1182/A VGND VPWR x3_x1183/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1171 x3_x1171/A VGND VPWR x3_x1172/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1193 x3_x1193/A VGND VPWR x3_x1194/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_24_72 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_63 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x1542 x1_x1542/A VGND VPWR x1_x1543/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1520 x1_x1520/A VGND VPWR x1_x1521/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1531 x1_x1531/A VGND VPWR x1_x1532/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1597 x1_x1597/A VGND VPWR x1_x1598/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1564 x1_x1564/A VGND VPWR x1_x1565/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1586 x1_x1586/A VGND VPWR x1_x1587/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1553 x1_x1553/A VGND VPWR x1_x1554/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1575 x1_x1575/A VGND VPWR x1_x1576/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1394 x1_x1394/A VGND VPWR x1_x1395/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1350 x1_x1350/A VGND VPWR x1_x1351/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1383 x1_x1383/A VGND VPWR x1_x1384/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1361 x1_x1361/A VGND VPWR x1_x1362/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1372 x1_x1372/A VGND VPWR x1_x1373/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_4 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx3_x11 x3_x11/A VGND VPWR x3_x12/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_44_246 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_165 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xx1_x1180 x1_x1180/A VGND VPWR x1_x1181/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1191 x1_x1191/A VGND VPWR x1_x1192/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1512 x3_x1512/A VGND VPWR x3_x1513/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1501 x3_x1501/A VGND VPWR x3_x1502/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1523 x3_x1523/A VGND VPWR x3_x1524/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1534 x3_x1534/A VGND VPWR x3_x1535/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1545 x3_x1545/A VGND VPWR x3_x1546/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1556 x3_x1556/A VGND VPWR x3_x1557/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1567 x3_x1567/A VGND VPWR x3_x1568/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1578 x3_x1578/A VGND VPWR x3_x1579/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1589 x3_x1589/A VGND VPWR x3_x1590/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1320 x3_x1320/A VGND VPWR x3_x1321/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1331 x3_x1331/A VGND VPWR x3_x1332/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1342 x3_x1342/A VGND VPWR x3_x1343/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1375 x3_x1375/A VGND VPWR x3_x1376/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1364 x3_x1364/A VGND VPWR x3_x1365/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1353 x3_x1353/A VGND VPWR x3_x1354/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1397 x3_x1397/A VGND VPWR x3_x1398/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1386 x3_x1386/A VGND VPWR x3_x1387/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_249 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_271 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_264 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x190 x1_x190/A VGND VPWR x1_x191/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1150 x3_x1150/A VGND VPWR x3_x1151/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1161 x3_x1161/A VGND VPWR x3_x1162/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1183 x3_x1183/A VGND VPWR x3_x1184/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1172 x3_x1172/A VGND VPWR x3_x1173/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1194 x3_x1194/A VGND VPWR x3_x1195/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_190 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_105 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_42 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x1565 x1_x1565/A VGND VPWR x1_x1566/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1554 x1_x1554/A VGND VPWR x1_x1555/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1576 x1_x1576/A VGND VPWR x1_x1577/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1521 x1_x1521/A VGND VPWR x1_x1522/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1543 x1_x1543/A VGND VPWR x1_x1544/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1532 x1_x1532/A VGND VPWR x1_x1533/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1510 x1_x1510/A VGND VPWR x1_x1511/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1598 x1_x1598/A VGND VPWR x1_x1599/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1587 x1_x1587/A VGND VPWR x1_x1588/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_152 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_160 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_193 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x1340 x1_x1340/A VGND VPWR x1_x1341/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1395 x1_x1395/A VGND VPWR x1_x1396/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1351 x1_x1351/A VGND VPWR x1_x1352/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1384 x1_x1384/A VGND VPWR x1_x1385/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1362 x1_x1362/A VGND VPWR x1_x1363/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1373 x1_x1373/A VGND VPWR x1_x1374/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_5 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x12 x3_x12/A VGND VPWR x3_x13/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_115 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_137 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx1_x1170 x1_x1170/A VGND VPWR x1_x1171/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1181 x1_x1181/A VGND VPWR x1_x1182/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1192 x1_x1192/A VGND VPWR x1_x1193/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1513 x3_x1513/A VGND VPWR x3_x1514/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1502 x3_x1502/A VGND VPWR x3_x1503/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1524 x3_x1524/A VGND VPWR x3_x1525/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1535 x3_x1535/A VGND VPWR x3_x1536/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1546 x3_x1546/A VGND VPWR x3_x1547/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1557 x3_x1557/A VGND VPWR x3_x1558/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1579 x3_x1579/A VGND VPWR x3_x1580/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1568 x3_x1568/A VGND VPWR x3_x1569/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_26_247 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_280 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_280 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xx3_x1332 x3_x1332/A VGND VPWR x3_x1333/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1310 x3_x1310/A VGND VPWR x3_x1311/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1321 x3_x1321/A VGND VPWR x3_x1322/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1343 x3_x1343/A VGND VPWR x3_x1344/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1365 x3_x1365/A VGND VPWR x3_x1366/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1354 x3_x1354/A VGND VPWR x3_x1355/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1387 x3_x1387/A VGND VPWR x3_x1388/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1376 x3_x1376/A VGND VPWR x3_x1377/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1398 x3_x1398/A VGND VPWR x3_x1399/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_221 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x180 x1_x180/A VGND VPWR x1_x181/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x191 x1_x191/A VGND VPWR x1_x192/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1162 x3_x1162/A VGND VPWR x3_x1163/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1184 x3_x1184/A VGND VPWR x3_x1185/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1173 x3_x1173/A VGND VPWR x3_x1174/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1140 x3_x1140/A VGND VPWR x3_x1141/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1151 x3_x1151/A VGND VPWR x3_x1152/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1195 x3_x1195/A VGND VPWR x3_x1196/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1599 x1_x1599/A VGND VPWR x1_x1600/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1566 x1_x1566/A VGND VPWR x1_x1567/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1588 x1_x1588/A VGND VPWR x1_x1589/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1555 x1_x1555/A VGND VPWR x1_x1556/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1544 x1_x1544/A VGND VPWR x1_x1545/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1577 x1_x1577/A VGND VPWR x1_x1578/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1522 x1_x1522/A VGND VPWR x1_x1523/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1533 x1_x1533/A VGND VPWR x1_x1534/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1500 x1_x1500/A VGND VPWR x1_x1501/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1511 x1_x1511/A VGND VPWR x1_x1512/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_139 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_42 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx1_x1330 x1_x1330/A VGND VPWR x1_x1331/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1341 x1_x1341/A VGND VPWR x1_x1342/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1396 x1_x1396/A VGND VPWR x1_x1397/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1352 x1_x1352/A VGND VPWR x1_x1353/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1385 x1_x1385/A VGND VPWR x1_x1386/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1363 x1_x1363/A VGND VPWR x1_x1364/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1374 x1_x1374/A VGND VPWR x1_x1375/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_6 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx3_x13 x3_x13/A VGND VPWR x3_x14/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x1160 x1_x1160/A VGND VPWR x1_x1161/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1171 x1_x1171/A VGND VPWR x1_x1172/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1182 x1_x1182/A VGND VPWR x1_x1183/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1193 x1_x1193/A VGND VPWR x1_x1194/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_204 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1514 x3_x1514/A VGND VPWR x3_x1515/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1503 x3_x1503/A VGND VPWR x3_x1504/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1525 x3_x1525/A VGND VPWR x3_x1526/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1536 x3_x1536/A VGND VPWR x3_x1537/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1547 x3_x1547/A VGND VPWR x3_x1548/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1558 x3_x1558/A VGND VPWR x3_x1559/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1569 x3_x1569/A VGND VPWR x3_x1570/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_262 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_96 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_95 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_12 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1300 x3_x1300/A VGND VPWR x3_x1301/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1333 x3_x1333/A VGND VPWR x3_x1334/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1311 x3_x1311/A VGND VPWR x3_x1312/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1322 x3_x1322/A VGND VPWR x3_x1323/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1344 x3_x1344/A VGND VPWR x3_x1345/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1355 x3_x1355/A VGND VPWR x3_x1356/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1366 x3_x1366/A VGND VPWR x3_x1367/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1377 x3_x1377/A VGND VPWR x3_x1378/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1388 x3_x1388/A VGND VPWR x3_x1389/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1399 x3_x1399/A VGND VPWR x3_x1400/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_284 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_273 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x170 x1_x170/A VGND VPWR x1_x171/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x181 x1_x181/A VGND VPWR x1_x182/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x192 x1_x192/A VGND VPWR x1_x193/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1174 x3_x1174/A VGND VPWR x3_x1175/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1163 x3_x1163/A VGND VPWR x3_x1164/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1185 x3_x1185/A VGND VPWR x3_x1186/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1196 x3_x1196/A VGND VPWR x3_x1197/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1141 x3_x1141/A VGND VPWR x3_x1142/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1152 x3_x1152/A VGND VPWR x3_x1153/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1130 x3_x1130/A VGND VPWR x3_x1131/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x1589 x1_x1589/A VGND VPWR x1_x1590/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1567 x1_x1567/A VGND VPWR x1_x1568/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1556 x1_x1556/A VGND VPWR x1_x1557/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1545 x1_x1545/A VGND VPWR x1_x1546/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1578 x1_x1578/A VGND VPWR x1_x1579/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1523 x1_x1523/A VGND VPWR x1_x1524/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1534 x1_x1534/A VGND VPWR x1_x1535/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1512 x1_x1512/A VGND VPWR x1_x1513/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1501 x1_x1501/A VGND VPWR x1_x1502/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_272 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x1320 x1_x1320/A VGND VPWR x1_x1321/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1331 x1_x1331/A VGND VPWR x1_x1332/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1342 x1_x1342/A VGND VPWR x1_x1343/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1397 x1_x1397/A VGND VPWR x1_x1398/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1353 x1_x1353/A VGND VPWR x1_x1354/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1386 x1_x1386/A VGND VPWR x1_x1387/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1364 x1_x1364/A VGND VPWR x1_x1365/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1375 x1_x1375/A VGND VPWR x1_x1376/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_7 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx3_x14 x3_x14/A VGND VPWR x3_x15/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_16_76 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_98 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x1172 x1_x1172/A VGND VPWR x1_x1173/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1183 x1_x1183/A VGND VPWR x1_x1184/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1161 x1_x1161/A VGND VPWR x1_x1162/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1150 x1_x1150/A VGND VPWR x1_x1151/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1194 x1_x1194/A VGND VPWR x1_x1195/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_216 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xx3_x1515 x3_x1515/A VGND VPWR x3_x1516/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1504 x3_x1504/A VGND VPWR x3_x1505/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1526 x3_x1526/A VGND VPWR x3_x1527/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1537 x3_x1537/A VGND VPWR x3_x1538/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1548 x3_x1548/A VGND VPWR x3_x1549/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1559 x3_x1559/A VGND VPWR x3_x1560/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_41_219 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_79 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_46 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_274 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1334 x3_x1334/A VGND VPWR x3_x1335/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1301 x3_x1301/A VGND VPWR x3_x1302/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1323 x3_x1323/A VGND VPWR x3_x1324/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1312 x3_x1312/A VGND VPWR x3_x1313/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1345 x3_x1345/A VGND VPWR x3_x1346/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1367 x3_x1367/A VGND VPWR x3_x1368/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1378 x3_x1378/A VGND VPWR x3_x1379/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1389 x3_x1389/A VGND VPWR x3_x1390/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1356 x3_x1356/A VGND VPWR x3_x1357/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_13_99 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx1_x193 x1_x193/A VGND VPWR x1_x194/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x160 x1_x160/A VGND VPWR x1_x161/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_234 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x171 x1_x171/A VGND VPWR x1_x172/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x182 x1_x182/A VGND VPWR x1_x183/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1164 x3_x1164/A VGND VPWR x3_x1165/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1175 x3_x1175/A VGND VPWR x3_x1176/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1186 x3_x1186/A VGND VPWR x3_x1187/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1120 x3_x1120/A VGND VPWR x3_x1121/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1197 x3_x1197/A VGND VPWR x3_x1198/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1153 x3_x1153/A VGND VPWR x3_x1154/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1131 x3_x1131/A VGND VPWR x3_x1132/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1142 x3_x1142/A VGND VPWR x3_x1143/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_233 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_218 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x1524 x1_x1524/A VGND VPWR x1_x1525/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1513 x1_x1513/A VGND VPWR x1_x1514/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1502 x1_x1502/A VGND VPWR x1_x1503/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1568 x1_x1568/A VGND VPWR x1_x1569/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1557 x1_x1557/A VGND VPWR x1_x1558/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1579 x1_x1579/A VGND VPWR x1_x1580/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1546 x1_x1546/A VGND VPWR x1_x1547/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1535 x1_x1535/A VGND VPWR x1_x1536/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_27_163 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_155 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx1_x1310 x1_x1310/A VGND VPWR x1_x1311/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1321 x1_x1321/A VGND VPWR x1_x1322/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1332 x1_x1332/A VGND VPWR x1_x1333/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1343 x1_x1343/A VGND VPWR x1_x1344/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1354 x1_x1354/A VGND VPWR x1_x1355/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1365 x1_x1365/A VGND VPWR x1_x1366/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1376 x1_x1376/A VGND VPWR x1_x1377/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1398 x1_x1398/A VGND VPWR x1_x1399/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1387 x1_x1387/A VGND VPWR x1_x1388/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_8 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x15 x3_x15/A VGND VPWR x3_x16/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1173 x1_x1173/A VGND VPWR x1_x1174/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1162 x1_x1162/A VGND VPWR x1_x1163/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1184 x1_x1184/A VGND VPWR x1_x1185/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1151 x1_x1151/A VGND VPWR x1_x1152/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1140 x1_x1140/A VGND VPWR x1_x1141/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1195 x1_x1195/A VGND VPWR x1_x1196/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_43_261 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_280 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_140 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx3_x1516 x3_x1516/A VGND VPWR x3_x1517/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1505 x3_x1505/A VGND VPWR x3_x1506/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1527 x3_x1527/A VGND VPWR x3_x1528/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1538 x3_x1538/A VGND VPWR x3_x1539/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1549 x3_x1549/A VGND VPWR x3_x1550/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_43_42 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_58 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx3_x1313 x3_x1313/A VGND VPWR x3_x1314/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1335 x3_x1335/A VGND VPWR x3_x1336/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1302 x3_x1302/A VGND VPWR x3_x1303/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1324 x3_x1324/A VGND VPWR x3_x1325/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1346 x3_x1346/A VGND VPWR x3_x1347/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1368 x3_x1368/A VGND VPWR x3_x1369/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1379 x3_x1379/A VGND VPWR x3_x1380/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1357 x3_x1357/A VGND VPWR x3_x1358/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x150 x1_x150/A VGND VPWR x1_x151/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x194 x1_x194/A VGND VPWR x1_x195/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x172 x1_x172/A VGND VPWR x1_x173/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x183 x1_x183/A VGND VPWR x1_x184/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x161 x1_x161/A VGND VPWR x1_x162/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1110 x3_x1110/A VGND VPWR x3_x1111/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1121 x3_x1121/A VGND VPWR x3_x1122/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1132 x3_x1132/A VGND VPWR x3_x1133/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1176 x3_x1176/A VGND VPWR x3_x1177/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1165 x3_x1165/A VGND VPWR x3_x1166/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1187 x3_x1187/A VGND VPWR x3_x1188/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1198 x3_x1198/A VGND VPWR x3_x1199/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1154 x3_x1154/A VGND VPWR x3_x1155/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1143 x3_x1143/A VGND VPWR x3_x1144/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_43 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_164 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xx1_x1558 x1_x1558/A VGND VPWR x1_x1559/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1547 x1_x1547/A VGND VPWR x1_x1548/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1525 x1_x1525/A VGND VPWR x1_x1526/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1536 x1_x1536/A VGND VPWR x1_x1537/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1514 x1_x1514/A VGND VPWR x1_x1515/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1503 x1_x1503/A VGND VPWR x1_x1504/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1569 x1_x1569/A VGND VPWR x1_x1570/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_12 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x1300 x1_x1300/A VGND VPWR x1_x1301/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1311 x1_x1311/A VGND VPWR x1_x1312/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1322 x1_x1322/A VGND VPWR x1_x1323/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1333 x1_x1333/A VGND VPWR x1_x1334/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1344 x1_x1344/A VGND VPWR x1_x1345/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1399 x1_x1399/A VGND VPWR x1_x1400/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1388 x1_x1388/A VGND VPWR x1_x1389/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1355 x1_x1355/A VGND VPWR x1_x1356/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1377 x1_x1377/A VGND VPWR x1_x1378/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1366 x1_x1366/A VGND VPWR x1_x1367/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_9 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx3_x16 x3_x16/A VGND VPWR x3_x17/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_37_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_137 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx1_x1174 x1_x1174/A VGND VPWR x1_x1175/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1163 x1_x1163/A VGND VPWR x1_x1164/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1185 x1_x1185/A VGND VPWR x1_x1186/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1152 x1_x1152/A VGND VPWR x1_x1153/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1141 x1_x1141/A VGND VPWR x1_x1142/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1196 x1_x1196/A VGND VPWR x1_x1197/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1130 x1_x1130/A VGND VPWR x1_x1131/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_152 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx3_x1517 x3_x1517/A VGND VPWR x3_x1518/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1528 x3_x1528/A VGND VPWR x3_x1529/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1506 x3_x1506/A VGND VPWR x3_x1507/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1539 x3_x1539/A VGND VPWR x3_x1540/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1303 x3_x1303/A VGND VPWR x3_x1304/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1314 x3_x1314/A VGND VPWR x3_x1315/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1325 x3_x1325/A VGND VPWR x3_x1326/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1336 x3_x1336/A VGND VPWR x3_x1337/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1347 x3_x1347/A VGND VPWR x3_x1348/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1369 x3_x1369/A VGND VPWR x3_x1370/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1358 x3_x1358/A VGND VPWR x3_x1359/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_13_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_76 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_54 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx1_x140 x1_x140/A VGND VPWR x1_x141/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x151 x1_x151/A VGND VPWR x1_x152/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x195 x1_x195/A VGND VPWR x1_x196/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x173 x1_x173/A VGND VPWR x1_x174/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x184 x1_x184/A VGND VPWR x1_x185/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x162 x1_x162/A VGND VPWR x1_x163/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1100 x3_x199/X VGND VPWR x3_x1101/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1122 x3_x1122/A VGND VPWR x3_x1123/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1166 x3_x1166/A VGND VPWR x3_x1167/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1111 x3_x1111/A VGND VPWR x3_x1112/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1155 x3_x1155/A VGND VPWR x3_x1156/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1133 x3_x1133/A VGND VPWR x3_x1134/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1144 x3_x1144/A VGND VPWR x3_x1145/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1177 x3_x1177/A VGND VPWR x3_x1178/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1188 x3_x1188/A VGND VPWR x3_x1189/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1199 x3_x1199/A VGND VPWR x3_x1200/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_24_56 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_14 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx1_x1559 x1_x1559/A VGND VPWR x1_x1560/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1548 x1_x1548/A VGND VPWR x1_x1549/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1537 x1_x1537/A VGND VPWR x1_x1538/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1526 x1_x1526/A VGND VPWR x1_x1527/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1515 x1_x1515/A VGND VPWR x1_x1516/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1504 x1_x1504/A VGND VPWR x1_x1505/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_190 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xx1_x1301 x1_x1301/A VGND VPWR x1_x1302/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1312 x1_x1312/A VGND VPWR x1_x1313/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1323 x1_x1323/A VGND VPWR x1_x1324/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1334 x1_x1334/A VGND VPWR x1_x1335/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1345 x1_x1345/A VGND VPWR x1_x1346/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1389 x1_x1389/A VGND VPWR x1_x1390/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1356 x1_x1356/A VGND VPWR x1_x1357/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1378 x1_x1378/A VGND VPWR x1_x1379/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1367 x1_x1367/A VGND VPWR x1_x1368/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_15_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_249 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx3_x17 x3_x17/A VGND VPWR x3_x18/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_205 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xx1_x1120 x1_x1120/A VGND VPWR x1_x1121/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1131 x1_x1131/A VGND VPWR x1_x1132/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1175 x1_x1175/A VGND VPWR x1_x1176/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1164 x1_x1164/A VGND VPWR x1_x1165/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1153 x1_x1153/A VGND VPWR x1_x1154/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1186 x1_x1186/A VGND VPWR x1_x1187/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1142 x1_x1142/A VGND VPWR x1_x1143/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1197 x1_x1197/A VGND VPWR x1_x1198/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1507 x3_x1507/A VGND VPWR x3_x1508/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1518 x3_x1518/A VGND VPWR x3_x1519/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1529 x3_x1529/A VGND VPWR x3_x1530/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1304 x3_x1304/A VGND VPWR x3_x1305/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1315 x3_x1315/A VGND VPWR x3_x1316/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1326 x3_x1326/A VGND VPWR x3_x1327/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1337 x3_x1337/A VGND VPWR x3_x1338/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1348 x3_x1348/A VGND VPWR x3_x1349/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1359 x3_x1359/A VGND VPWR x3_x1360/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x130 x1_x130/A VGND VPWR x1_x131/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x141 x1_x141/A VGND VPWR x1_x142/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x152 x1_x152/A VGND VPWR x1_x153/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x174 x1_x174/A VGND VPWR x1_x175/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x185 x1_x185/A VGND VPWR x1_x186/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x163 x1_x163/A VGND VPWR x1_x164/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x196 x1_x196/A VGND VPWR x1_x197/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_163 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx3_x1178 x3_x1178/A VGND VPWR x3_x1179/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1101 x3_x1101/A VGND VPWR x3_x1102/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1167 x3_x1167/A VGND VPWR x3_x1168/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1123 x3_x1123/A VGND VPWR x3_x1124/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1112 x3_x1112/A VGND VPWR x3_x1113/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1189 x3_x1189/A VGND VPWR x3_x1190/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1134 x3_x1134/A VGND VPWR x3_x1135/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1156 x3_x1156/A VGND VPWR x3_x1157/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1145 x3_x1145/A VGND VPWR x3_x1146/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_152 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x1549 x1_x1549/A VGND VPWR x1_x1550/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1527 x1_x1527/A VGND VPWR x1_x1528/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1538 x1_x1538/A VGND VPWR x1_x1539/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1516 x1_x1516/A VGND VPWR x1_x1517/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1505 x1_x1505/A VGND VPWR x1_x1506/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xx1_x1324 x1_x1324/A VGND VPWR x1_x1325/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1302 x1_x1302/A VGND VPWR x1_x1303/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1313 x1_x1313/A VGND VPWR x1_x1314/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1335 x1_x1335/A VGND VPWR x1_x1336/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1346 x1_x1346/A VGND VPWR x1_x1347/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1357 x1_x1357/A VGND VPWR x1_x1358/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1379 x1_x1379/A VGND VPWR x1_x1380/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1368 x1_x1368/A VGND VPWR x1_x1369/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_91 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_206 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x18 x3_x18/A VGND VPWR x3_x19/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1165 x1_x1165/A VGND VPWR x1_x1166/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1154 x1_x1154/A VGND VPWR x1_x1155/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1143 x1_x1143/A VGND VPWR x1_x1144/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1132 x1_x1132/A VGND VPWR x1_x1133/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1121 x1_x1121/A VGND VPWR x1_x1122/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1110 x1_x1110/A VGND VPWR x1_x1111/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1176 x1_x1176/A VGND VPWR x1_x1177/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1187 x1_x1187/A VGND VPWR x1_x1188/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1198 x1_x1198/A VGND VPWR x1_x1199/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_43_275 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_165 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx3_x1519 x3_x1519/A VGND VPWR x3_x1520/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1508 x3_x1508/A VGND VPWR x3_x1509/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_27_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_220 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_79 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_234 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx3_x1305 x3_x1305/A VGND VPWR x3_x1306/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1327 x3_x1327/A VGND VPWR x3_x1328/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1338 x3_x1338/A VGND VPWR x3_x1339/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1316 x3_x1316/A VGND VPWR x3_x1317/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1349 x3_x1349/A VGND VPWR x3_x1350/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_245 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x120 x1_x120/A VGND VPWR x1_x121/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x153 x1_x153/A VGND VPWR x1_x154/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x197 x1_x197/A VGND VPWR x1_x198/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_13_234 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x175 x1_x175/A VGND VPWR x1_x176/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x131 x1_x131/A VGND VPWR x1_x132/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x164 x1_x164/A VGND VPWR x1_x165/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x186 x1_x186/A VGND VPWR x1_x187/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x142 x1_x142/A VGND VPWR x1_x143/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_271 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx3_x1157 x3_x1157/A VGND VPWR x3_x1158/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1179 x3_x1179/A VGND VPWR x3_x1180/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1124 x3_x1124/A VGND VPWR x3_x1125/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1113 x3_x1113/A VGND VPWR x3_x1114/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1102 x3_x1102/A VGND VPWR x3_x1103/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1168 x3_x1168/A VGND VPWR x3_x1169/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1135 x3_x1135/A VGND VPWR x3_x1136/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1146 x3_x1146/A VGND VPWR x3_x1147/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_45_178 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_252 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_134 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x1506 x1_x1506/A VGND VPWR x1_x1507/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1539 x1_x1539/A VGND VPWR x1_x1540/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1528 x1_x1528/A VGND VPWR x1_x1529/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1517 x1_x1517/A VGND VPWR x1_x1518/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_90 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx1_x1303 x1_x1303/A VGND VPWR x1_x1304/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1314 x1_x1314/A VGND VPWR x1_x1315/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1325 x1_x1325/A VGND VPWR x1_x1326/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1336 x1_x1336/A VGND VPWR x1_x1337/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1347 x1_x1347/A VGND VPWR x1_x1348/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1358 x1_x1358/A VGND VPWR x1_x1359/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1369 x1_x1369/A VGND VPWR x1_x1370/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_15_137 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_181 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx3_x19 x3_x19/A VGND VPWR x3_x19/X VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_162 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
Xx1_x1166 x1_x1166/A VGND VPWR x1_x1167/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1177 x1_x1177/A VGND VPWR x1_x1178/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1155 x1_x1155/A VGND VPWR x1_x1156/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1188 x1_x1188/A VGND VPWR x1_x1189/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1144 x1_x1144/A VGND VPWR x1_x1145/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1133 x1_x1133/A VGND VPWR x1_x1134/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1122 x1_x1122/A VGND VPWR x1_x1123/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1199 x1_x1199/A VGND VPWR x1_x1200/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1111 x1_x1111/A VGND VPWR x1_x1112/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1100 x1_x199/X VGND VPWR x1_x1101/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1509 x3_x1509/A VGND VPWR x3_x1510/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_195 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_235 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xx3_x1339 x3_x1339/A VGND VPWR x3_x1340/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1306 x3_x1306/A VGND VPWR x3_x1307/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1317 x3_x1317/A VGND VPWR x3_x1318/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1328 x3_x1328/A VGND VPWR x3_x1329/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x110 x1_x19/X VGND VPWR x1_x111/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x143 x1_x143/A VGND VPWR x1_x144/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x121 x1_x121/A VGND VPWR x1_x122/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x154 x1_x154/A VGND VPWR x1_x155/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x198 x1_x198/A VGND VPWR x1_x199/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x176 x1_x176/A VGND VPWR x1_x177/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x165 x1_x165/A VGND VPWR x1_x166/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x187 x1_x187/A VGND VPWR x1_x188/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x132 x1_x132/A VGND VPWR x1_x133/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_150 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1103 x3_x1103/A VGND VPWR x3_x1104/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1114 x3_x1114/A VGND VPWR x3_x1115/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_283 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx3_x1136 x3_x1136/A VGND VPWR x3_x1137/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1125 x3_x1125/A VGND VPWR x3_x1126/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1169 x3_x1169/A VGND VPWR x3_x1170/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1158 x3_x1158/A VGND VPWR x3_x1159/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1147 x3_x1147/A VGND VPWR x3_x1148/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_249 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_220 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_81 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x1529 x1_x1529/A VGND VPWR x1_x1530/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1518 x1_x1518/A VGND VPWR x1_x1519/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1507 x1_x1507/A VGND VPWR x1_x1508/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_27_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_91 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_80 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_91 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_171 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xx1_x1304 x1_x1304/A VGND VPWR x1_x1305/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1326 x1_x1326/A VGND VPWR x1_x1327/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1315 x1_x1315/A VGND VPWR x1_x1316/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1337 x1_x1337/A VGND VPWR x1_x1338/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1348 x1_x1348/A VGND VPWR x1_x1349/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1359 x1_x1359/A VGND VPWR x1_x1360/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_13 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_160 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x1167 x1_x1167/A VGND VPWR x1_x1168/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1156 x1_x1156/A VGND VPWR x1_x1157/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1178 x1_x1178/A VGND VPWR x1_x1179/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1145 x1_x1145/A VGND VPWR x1_x1146/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1189 x1_x1189/A VGND VPWR x1_x1190/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1123 x1_x1123/A VGND VPWR x1_x1124/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1134 x1_x1134/A VGND VPWR x1_x1135/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1101 x1_x1101/A VGND VPWR x1_x1102/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1112 x1_x1112/A VGND VPWR x1_x1113/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_34_244 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_94 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_48 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_233 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1307 x3_x1307/A VGND VPWR x3_x1308/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1318 x3_x1318/A VGND VPWR x3_x1319/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1329 x3_x1329/A VGND VPWR x3_x1330/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x122 x1_x122/A VGND VPWR x1_x123/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x111 x1_x111/A VGND VPWR x1_x112/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x133 x1_x133/A VGND VPWR x1_x134/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x144 x1_x144/A VGND VPWR x1_x145/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x199 x1_x199/A VGND VPWR x1_x199/X VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x155 x1_x155/A VGND VPWR x1_x156/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x177 x1_x177/A VGND VPWR x1_x178/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x166 x1_x166/A VGND VPWR x1_x167/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x188 x1_x188/A VGND VPWR x1_x189/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_12_280 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xx3_x1137 x3_x1137/A VGND VPWR x3_x1138/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1104 x3_x1104/A VGND VPWR x3_x1105/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1115 x3_x1115/A VGND VPWR x3_x1116/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1126 x3_x1126/A VGND VPWR x3_x1127/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1148 x3_x1148/A VGND VPWR x3_x1149/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1159 x3_x1159/A VGND VPWR x3_x1160/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx1_x1519 x1_x1519/A VGND VPWR x1_x1520/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1508 x1_x1508/A VGND VPWR x1_x1509/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx3_x1490 x3_x1490/A VGND VPWR x3_x1491/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_92 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_81 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_70 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x1327 x1_x1327/A VGND VPWR x1_x1328/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1305 x1_x1305/A VGND VPWR x1_x1306/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1316 x1_x1316/A VGND VPWR x1_x1317/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1338 x1_x1338/A VGND VPWR x1_x1339/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1349 x1_x1349/A VGND VPWR x1_x1350/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_19 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_50 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_172 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx1_x1102 x1_x1102/A VGND VPWR x1_x1103/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1113 x1_x1113/A VGND VPWR x1_x1114/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1157 x1_x1157/A VGND VPWR x1_x1158/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1168 x1_x1168/A VGND VPWR x1_x1169/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1179 x1_x1179/A VGND VPWR x1_x1180/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1146 x1_x1146/A VGND VPWR x1_x1147/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1124 x1_x1124/A VGND VPWR x1_x1125/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1135 x1_x1135/A VGND VPWR x1_x1136/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_248 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx3_x1308 x3_x1308/A VGND VPWR x3_x1309/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1319 x3_x1319/A VGND VPWR x3_x1320/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_12_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x145 x1_x145/A VGND VPWR x1_x146/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x123 x1_x123/A VGND VPWR x1_x124/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x112 x1_x112/A VGND VPWR x1_x113/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x156 x1_x156/A VGND VPWR x1_x157/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x134 x1_x134/A VGND VPWR x1_x135/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x167 x1_x167/A VGND VPWR x1_x168/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x178 x1_x178/A VGND VPWR x1_x179/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x189 x1_x189/A VGND VPWR x1_x190/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_70 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx3_x1138 x3_x1138/A VGND VPWR x3_x1139/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1116 x3_x1116/A VGND VPWR x3_x1117/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1105 x3_x1105/A VGND VPWR x3_x1106/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1127 x3_x1127/A VGND VPWR x3_x1128/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1149 x3_x1149/A VGND VPWR x3_x1150/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1509 x1_x1509/A VGND VPWR x1_x1510/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1491 x3_x1491/A VGND VPWR x3_x1492/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1480 x3_x1480/A VGND VPWR x3_x1481/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_82 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_71 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_60 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_93 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x1306 x1_x1306/A VGND VPWR x1_x1307/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1328 x1_x1328/A VGND VPWR x1_x1329/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1317 x1_x1317/A VGND VPWR x1_x1318/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1339 x1_x1339/A VGND VPWR x1_x1340/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_37_221 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x1147 x1_x1147/A VGND VPWR x1_x1148/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1125 x1_x1125/A VGND VPWR x1_x1126/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1136 x1_x1136/A VGND VPWR x1_x1137/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1114 x1_x1114/A VGND VPWR x1_x1115/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1103 x1_x1103/A VGND VPWR x1_x1104/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1169 x1_x1169/A VGND VPWR x1_x1170/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1158 x1_x1158/A VGND VPWR x1_x1159/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_27_17 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_161 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1309 x3_x1309/A VGND VPWR x3_x1310/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_271 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x124 x1_x124/A VGND VPWR x1_x125/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x146 x1_x146/A VGND VPWR x1_x147/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x113 x1_x113/A VGND VPWR x1_x114/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x157 x1_x157/A VGND VPWR x1_x158/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x179 x1_x179/A VGND VPWR x1_x180/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x168 x1_x168/A VGND VPWR x1_x169/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x135 x1_x135/A VGND VPWR x1_x136/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1139 x3_x1139/A VGND VPWR x3_x1140/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1117 x3_x1117/A VGND VPWR x3_x1118/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1106 x3_x1106/A VGND VPWR x3_x1107/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1128 x3_x1128/A VGND VPWR x3_x1129/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_193 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_160 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_138 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1470 x3_x1470/A VGND VPWR x3_x1471/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1492 x3_x1492/A VGND VPWR x3_x1493/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1481 x3_x1481/A VGND VPWR x3_x1482/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_94 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_83 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_72 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_61 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_50 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_193 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x1307 x1_x1307/A VGND VPWR x1_x1308/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1329 x1_x1329/A VGND VPWR x1_x1330/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1318 x1_x1318/A VGND VPWR x1_x1319/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_266 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx1_x1159 x1_x1159/A VGND VPWR x1_x1160/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1148 x1_x1148/A VGND VPWR x1_x1149/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1137 x1_x1137/A VGND VPWR x1_x1138/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1126 x1_x1126/A VGND VPWR x1_x1127/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1115 x1_x1115/A VGND VPWR x1_x1116/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1104 x1_x1104/A VGND VPWR x1_x1105/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_233 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_155 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_53 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_40 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_140 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x1490 x1_x1490/A VGND VPWR x1_x1491/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_206 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x125 x1_x125/A VGND VPWR x1_x126/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x147 x1_x147/A VGND VPWR x1_x148/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x114 x1_x114/A VGND VPWR x1_x115/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x158 x1_x158/A VGND VPWR x1_x159/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x169 x1_x169/A VGND VPWR x1_x170/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x136 x1_x136/A VGND VPWR x1_x137/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_165 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx3_x1107 x3_x1107/A VGND VPWR x3_x1108/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_32 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1118 x3_x1118/A VGND VPWR x3_x1119/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1129 x3_x1129/A VGND VPWR x3_x1130/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_51 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_180 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_109 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx3_x1493 x3_x1493/A VGND VPWR x3_x1494/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1482 x3_x1482/A VGND VPWR x3_x1483/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1471 x3_x1471/A VGND VPWR x3_x1472/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1460 x3_x1460/A VGND VPWR x3_x1461/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_95 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_84 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_164 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_62 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_40 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_51 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_161 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_44 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x1308 x1_x1308/A VGND VPWR x1_x1309/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1319 x1_x1319/A VGND VPWR x1_x1320/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1290 x3_x1290/A VGND VPWR x3_x1291/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx1_x1149 x1_x1149/A VGND VPWR x1_x1150/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1138 x1_x1138/A VGND VPWR x1_x1139/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1127 x1_x1127/A VGND VPWR x1_x1128/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1105 x1_x1105/A VGND VPWR x1_x1106/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1116 x1_x1116/A VGND VPWR x1_x1117/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_234 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_270 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_248 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx1_x1491 x1_x1491/A VGND VPWR x1_x1492/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1480 x1_x1480/A VGND VPWR x1_x1481/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_15_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x115 x1_x115/A VGND VPWR x1_x116/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x126 x1_x126/A VGND VPWR x1_x127/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x148 x1_x148/A VGND VPWR x1_x149/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x137 x1_x137/A VGND VPWR x1_x138/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x159 x1_x159/A VGND VPWR x1_x160/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1119 x3_x1119/A VGND VPWR x3_x1120/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1108 x3_x1108/A VGND VPWR x3_x1109/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_88 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx3_x1494 x3_x1494/A VGND VPWR x3_x1495/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1483 x3_x1483/A VGND VPWR x3_x1484/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1472 x3_x1472/A VGND VPWR x3_x1473/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1450 x3_x1450/A VGND VPWR x3_x1451/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1461 x3_x1461/A VGND VPWR x3_x1462/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_30 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_96 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_74 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_63 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_52 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_12 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_261 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_132 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xx1_x1309 x1_x1309/A VGND VPWR x1_x1310/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_23_132 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_224 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1291 x3_x1291/A VGND VPWR x3_x1292/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1280 x3_x1280/A VGND VPWR x3_x1281/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1139 x1_x1139/A VGND VPWR x1_x1140/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1128 x1_x1128/A VGND VPWR x1_x1129/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1117 x1_x1117/A VGND VPWR x1_x1118/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1106 x1_x1106/A VGND VPWR x1_x1107/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_22 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx3_x190 x3_x190/A VGND VPWR x3_x191/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_31_219 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xx1_x1492 x1_x1492/A VGND VPWR x1_x1493/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1481 x1_x1481/A VGND VPWR x1_x1482/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1470 x1_x1470/A VGND VPWR x1_x1471/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x138 x1_x138/A VGND VPWR x1_x139/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x127 x1_x127/A VGND VPWR x1_x128/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x116 x1_x116/A VGND VPWR x1_x117/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x149 x1_x149/A VGND VPWR x1_x150/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_252 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_189 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1109 x3_x1109/A VGND VPWR x3_x1110/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_21 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_40 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1495 x3_x1495/A VGND VPWR x3_x1496/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1484 x3_x1484/A VGND VPWR x3_x1485/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1473 x3_x1473/A VGND VPWR x3_x1474/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1462 x3_x1462/A VGND VPWR x3_x1463/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1451 x3_x1451/A VGND VPWR x3_x1452/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1440 x3_x1440/A VGND VPWR x3_x1441/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_41_122 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_64 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_20 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_31 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_42 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_53 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_97 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_86 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_75 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx3_x1270 x3_x1270/A VGND VPWR x3_x1271/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1292 x3_x1292/A VGND VPWR x3_x1293/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1281 x3_x1281/A VGND VPWR x3_x1282/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_36_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx1_x1129 x1_x1129/A VGND VPWR x1_x1130/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1118 x1_x1118/A VGND VPWR x1_x1119/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1107 x1_x1107/A VGND VPWR x1_x1108/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_43_217 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_214 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xx3_x180 x3_x180/A VGND VPWR x3_x181/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x191 x3_x191/A VGND VPWR x3_x192/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_31 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_187 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx1_x1493 x1_x1493/A VGND VPWR x1_x1494/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1482 x1_x1482/A VGND VPWR x1_x1483/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1471 x1_x1471/A VGND VPWR x1_x1472/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1460 x1_x1460/A VGND VPWR x1_x1461/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x139 x1_x139/A VGND VPWR x1_x140/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x128 x1_x128/A VGND VPWR x1_x129/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x117 x1_x117/A VGND VPWR x1_x118/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_128 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx1_x1290 x1_x1290/A VGND VPWR x1_x1291/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1600 x3_x1600/A VGND VPWR x4/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_38_183 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_150 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx3_x1441 x3_x1441/A VGND VPWR x3_x1442/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1452 x3_x1452/A VGND VPWR x3_x1453/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1430 x3_x1430/A VGND VPWR x3_x1431/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1496 x3_x1496/A VGND VPWR x3_x1497/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1485 x3_x1485/A VGND VPWR x3_x1486/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1474 x3_x1474/A VGND VPWR x3_x1475/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_109 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx3_x1463 x3_x1463/A VGND VPWR x3_x1464/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_87 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_76 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_65 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_10 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_21 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_32 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_43 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_54 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_178 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_131 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_164 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx3_x1260 x3_x1260/A VGND VPWR x3_x1261/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1282 x3_x1282/A VGND VPWR x3_x1283/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1293 x3_x1293/A VGND VPWR x3_x1294/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1271 x3_x1271/A VGND VPWR x3_x1272/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_45_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x1119 x1_x1119/A VGND VPWR x1_x1120/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1108 x1_x1108/A VGND VPWR x1_x1109/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_44 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_79 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx3_x181 x3_x181/A VGND VPWR x3_x182/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x170 x3_x170/A VGND VPWR x3_x171/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x192 x3_x192/A VGND VPWR x3_x193/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_17_88 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx1_x1450 x1_x1450/A VGND VPWR x1_x1451/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1494 x1_x1494/A VGND VPWR x1_x1495/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1483 x1_x1483/A VGND VPWR x1_x1484/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1472 x1_x1472/A VGND VPWR x1_x1473/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1461 x1_x1461/A VGND VPWR x1_x1462/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x129 x1_x129/A VGND VPWR x1_x130/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x118 x1_x118/A VGND VPWR x1_x119/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_276 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_236 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x1291 x1_x1291/A VGND VPWR x1_x1292/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1280 x1_x1280/A VGND VPWR x1_x1281/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_75 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1486 x3_x1486/A VGND VPWR x3_x1487/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1464 x3_x1464/A VGND VPWR x3_x1465/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1475 x3_x1475/A VGND VPWR x3_x1476/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1442 x3_x1442/A VGND VPWR x3_x1443/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1453 x3_x1453/A VGND VPWR x3_x1454/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1431 x3_x1431/A VGND VPWR x3_x1432/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1420 x3_x1420/A VGND VPWR x3_x1421/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1497 x3_x1497/A VGND VPWR x3_x1498/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_88 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_77 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_66 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_11 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_22 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_33 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_44 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_55 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_98 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_275 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_146 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1250 x3_x1250/A VGND VPWR x3_x1251/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1261 x3_x1261/A VGND VPWR x3_x1262/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1294 x3_x1294/A VGND VPWR x3_x1295/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1283 x3_x1283/A VGND VPWR x3_x1284/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1272 x3_x1272/A VGND VPWR x3_x1273/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_249 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x1109 x1_x1109/A VGND VPWR x1_x1110/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_249 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xx3_x182 x3_x182/A VGND VPWR x3_x183/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x160 x3_x160/A VGND VPWR x3_x161/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x193 x3_x193/A VGND VPWR x3_x194/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x171 x3_x171/A VGND VPWR x3_x172/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1451 x1_x1451/A VGND VPWR x1_x1452/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1440 x1_x1440/A VGND VPWR x1_x1441/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1484 x1_x1484/A VGND VPWR x1_x1485/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1495 x1_x1495/A VGND VPWR x1_x1496/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1473 x1_x1473/A VGND VPWR x1_x1474/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1462 x1_x1462/A VGND VPWR x1_x1463/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x119 x1_x119/A VGND VPWR x1_x120/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1292 x1_x1292/A VGND VPWR x1_x1293/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1270 x1_x1270/A VGND VPWR x1_x1271/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1281 x1_x1281/A VGND VPWR x1_x1282/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_273 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx3_x1410 x3_x1410/A VGND VPWR x3_x1411/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1498 x3_x1498/A VGND VPWR x3_x1499/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1487 x3_x1487/A VGND VPWR x3_x1488/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1465 x3_x1465/A VGND VPWR x3_x1466/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1476 x3_x1476/A VGND VPWR x3_x1477/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1454 x3_x1454/A VGND VPWR x3_x1455/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1443 x3_x1443/A VGND VPWR x3_x1444/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1432 x3_x1432/A VGND VPWR x3_x1433/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1421 x3_x1421/A VGND VPWR x3_x1422/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_12 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_12 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_89 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_78 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_67 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_23 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_34 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_45 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_56 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_169 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
Xx3_x1251 x3_x1251/A VGND VPWR x3_x1252/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1262 x3_x1262/A VGND VPWR x3_x1263/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1240 x3_x1240/A VGND VPWR x3_x1241/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1295 x3_x1295/A VGND VPWR x3_x1296/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1284 x3_x1284/A VGND VPWR x3_x1285/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1273 x3_x1273/A VGND VPWR x3_x1274/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_36_55 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_151 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_139 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x1600 x1_x1600/A VGND VPWR x3_x11/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_79 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xx3_x183 x3_x183/A VGND VPWR x3_x184/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x161 x3_x161/A VGND VPWR x3_x162/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x150 x3_x150/A VGND VPWR x3_x151/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x194 x3_x194/A VGND VPWR x3_x195/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x172 x3_x172/A VGND VPWR x3_x173/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_24_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx1_x1452 x1_x1452/A VGND VPWR x1_x1453/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1441 x1_x1441/A VGND VPWR x1_x1442/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x1485 x1_x1485/A VGND VPWR x1_x1486/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1474 x1_x1474/A VGND VPWR x1_x1475/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1463 x1_x1463/A VGND VPWR x1_x1464/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1430 x1_x1430/A VGND VPWR x1_x1431/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1496 x1_x1496/A VGND VPWR x1_x1497/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_31_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_56 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx1_x1271 x1_x1271/A VGND VPWR x1_x1272/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1293 x1_x1293/A VGND VPWR x1_x1294/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1260 x1_x1260/A VGND VPWR x1_x1261/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_109 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x1282 x1_x1282/A VGND VPWR x1_x1283/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_285 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx3_x1400 x3_x1400/A VGND VPWR x3_x1401/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1411 x3_x1411/A VGND VPWR x3_x1412/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1499 x3_x1499/A VGND VPWR x3_x1500/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1488 x3_x1488/A VGND VPWR x3_x1489/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1466 x3_x1466/A VGND VPWR x3_x1467/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1455 x3_x1455/A VGND VPWR x3_x1456/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1477 x3_x1477/A VGND VPWR x3_x1478/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1444 x3_x1444/A VGND VPWR x3_x1445/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1433 x3_x1433/A VGND VPWR x3_x1434/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1422 x3_x1422/A VGND VPWR x3_x1423/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_13 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_24 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_46 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_79 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_68 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_67 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_159 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1230 x3_x1230/A VGND VPWR x3_x1231/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1252 x3_x1252/A VGND VPWR x3_x1253/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1241 x3_x1241/A VGND VPWR x3_x1242/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1285 x3_x1285/A VGND VPWR x3_x1286/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1296 x3_x1296/A VGND VPWR x3_x1297/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1263 x3_x1263/A VGND VPWR x3_x1264/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1274 x3_x1274/A VGND VPWR x3_x1275/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_67 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_159 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_163 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_14 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx3_x140 x3_x140/A VGND VPWR x3_x141/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_284 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx3_x195 x3_x195/A VGND VPWR x3_x196/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x184 x3_x184/A VGND VPWR x3_x185/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x151 x3_x151/A VGND VPWR x3_x152/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x162 x3_x162/A VGND VPWR x3_x163/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x173 x3_x173/A VGND VPWR x3_x174/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1431 x1_x1431/A VGND VPWR x1_x1432/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1420 x1_x1420/A VGND VPWR x1_x1421/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1453 x1_x1453/A VGND VPWR x1_x1454/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1442 x1_x1442/A VGND VPWR x1_x1443/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1486 x1_x1486/A VGND VPWR x1_x1487/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1497 x1_x1497/A VGND VPWR x1_x1498/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1475 x1_x1475/A VGND VPWR x1_x1476/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1464 x1_x1464/A VGND VPWR x1_x1465/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_24_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_67 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_45 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx1_x1294 x1_x1294/A VGND VPWR x1_x1295/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1283 x1_x1283/A VGND VPWR x1_x1284/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1272 x1_x1272/A VGND VPWR x1_x1273/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1261 x1_x1261/A VGND VPWR x1_x1262/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1250 x1_x1250/A VGND VPWR x1_x1251/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_165 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_25 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_179 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1401 x3_x1401/A VGND VPWR x3_x1402/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1412 x3_x1412/A VGND VPWR x3_x1413/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1434 x3_x1434/A VGND VPWR x3_x1435/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1423 x3_x1423/A VGND VPWR x3_x1424/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1489 x3_x1489/A VGND VPWR x3_x1490/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1467 x3_x1467/A VGND VPWR x3_x1468/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1478 x3_x1478/A VGND VPWR x3_x1479/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1456 x3_x1456/A VGND VPWR x3_x1457/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1445 x3_x1445/A VGND VPWR x3_x1446/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_69 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_14 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_25 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_47 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_58 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1220 x3_x1220/A VGND VPWR x3_x1221/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1231 x3_x1231/A VGND VPWR x3_x1232/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1253 x3_x1253/A VGND VPWR x3_x1254/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1242 x3_x1242/A VGND VPWR x3_x1243/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1264 x3_x1264/A VGND VPWR x3_x1265/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1275 x3_x1275/A VGND VPWR x3_x1276/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_36_24 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx3_x1297 x3_x1297/A VGND VPWR x3_x1298/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1286 x3_x1286/A VGND VPWR x3_x1287/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_36_79 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_182 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_39 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x130 x3_x130/A VGND VPWR x3_x131/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x163 x3_x163/A VGND VPWR x3_x164/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x152 x3_x152/A VGND VPWR x3_x153/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x141 x3_x141/A VGND VPWR x3_x142/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x174 x3_x174/A VGND VPWR x3_x175/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x196 x3_x196/A VGND VPWR x3_x197/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x185 x3_x185/A VGND VPWR x3_x186/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1410 x1_x1410/A VGND VPWR x1_x1411/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1421 x1_x1421/A VGND VPWR x1_x1422/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1432 x1_x1432/A VGND VPWR x1_x1433/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1454 x1_x1454/A VGND VPWR x1_x1455/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1487 x1_x1487/A VGND VPWR x1_x1488/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1498 x1_x1498/A VGND VPWR x1_x1499/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1476 x1_x1476/A VGND VPWR x1_x1477/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1465 x1_x1465/A VGND VPWR x1_x1466/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1443 x1_x1443/A VGND VPWR x1_x1444/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_15_255 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_214 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_25 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x1251 x1_x1251/A VGND VPWR x1_x1252/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1240 x1_x1240/A VGND VPWR x1_x1241/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1295 x1_x1295/A VGND VPWR x1_x1296/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1273 x1_x1273/A VGND VPWR x1_x1274/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1262 x1_x1262/A VGND VPWR x1_x1263/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1284 x1_x1284/A VGND VPWR x1_x1285/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_155 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_125 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1402 x3_x1402/A VGND VPWR x3_x1403/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1413 x3_x1413/A VGND VPWR x3_x1414/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_94 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1468 x3_x1468/A VGND VPWR x3_x1469/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1457 x3_x1457/A VGND VPWR x3_x1458/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1446 x3_x1446/A VGND VPWR x3_x1447/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1435 x3_x1435/A VGND VPWR x3_x1436/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1424 x3_x1424/A VGND VPWR x3_x1425/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1479 x3_x1479/A VGND VPWR x3_x1480/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_41_139 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_26 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_37 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_48 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_59 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_161 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1232 x3_x1232/A VGND VPWR x3_x1233/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1221 x3_x1221/A VGND VPWR x3_x1222/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1210 x3_x1210/A VGND VPWR x3_x1211/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1254 x3_x1254/A VGND VPWR x3_x1255/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1243 x3_x1243/A VGND VPWR x3_x1244/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1265 x3_x1265/A VGND VPWR x3_x1266/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1298 x3_x1298/A VGND VPWR x3_x1299/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1287 x3_x1287/A VGND VPWR x3_x1288/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1276 x3_x1276/A VGND VPWR x3_x1277/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_264 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_212 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_275 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx3_x120 x3_x120/A VGND VPWR x3_x121/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x197 x3_x197/A VGND VPWR x3_x198/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x131 x3_x131/A VGND VPWR x3_x132/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x164 x3_x164/A VGND VPWR x3_x165/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x175 x3_x175/A VGND VPWR x3_x176/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x153 x3_x153/A VGND VPWR x3_x154/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x142 x3_x142/A VGND VPWR x3_x143/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x186 x3_x186/A VGND VPWR x3_x187/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_190 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_16 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_48 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xx1_x1411 x1_x1411/A VGND VPWR x1_x1412/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1400 x1_x1400/A VGND VPWR x1_x1401/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1422 x1_x1422/A VGND VPWR x1_x1423/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1433 x1_x1433/A VGND VPWR x1_x1434/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1455 x1_x1455/A VGND VPWR x1_x1456/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1444 x1_x1444/A VGND VPWR x1_x1445/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1488 x1_x1488/A VGND VPWR x1_x1489/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1499 x1_x1499/A VGND VPWR x1_x1500/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1477 x1_x1477/A VGND VPWR x1_x1478/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1466 x1_x1466/A VGND VPWR x1_x1467/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_182 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x1274 x1_x1274/A VGND VPWR x1_x1275/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1263 x1_x1263/A VGND VPWR x1_x1264/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1252 x1_x1252/A VGND VPWR x1_x1253/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1230 x1_x1230/A VGND VPWR x1_x1231/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1241 x1_x1241/A VGND VPWR x1_x1242/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1285 x1_x1285/A VGND VPWR x1_x1286/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1296 x1_x1296/A VGND VPWR x1_x1297/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_38 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx3_x1414 x3_x1414/A VGND VPWR x3_x1415/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1469 x3_x1469/A VGND VPWR x3_x1470/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1458 x3_x1458/A VGND VPWR x3_x1459/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1436 x3_x1436/A VGND VPWR x3_x1437/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1447 x3_x1447/A VGND VPWR x3_x1448/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1425 x3_x1425/A VGND VPWR x3_x1426/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1403 x3_x1403/A VGND VPWR x3_x1404/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_26_137 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_16 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_49 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_82 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_81 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_262 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx3_x1200 x3_x1200/A VGND VPWR x3_x1201/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1255 x3_x1255/A VGND VPWR x3_x1256/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1233 x3_x1233/A VGND VPWR x3_x1234/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1211 x3_x1211/A VGND VPWR x3_x1212/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1222 x3_x1222/A VGND VPWR x3_x1223/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1244 x3_x1244/A VGND VPWR x3_x1245/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1266 x3_x1266/A VGND VPWR x3_x1267/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1299 x3_x1299/A VGND VPWR x3_x1300/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1288 x3_x1288/A VGND VPWR x3_x1289/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1277 x3_x1277/A VGND VPWR x3_x1278/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x11 start_conv VGND VPWR x1_x12/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_27_243 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_257 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx3_x121 x3_x121/A VGND VPWR x3_x122/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x198 x3_x198/A VGND VPWR x3_x199/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x176 x3_x176/A VGND VPWR x3_x177/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x165 x3_x165/A VGND VPWR x3_x166/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x154 x3_x154/A VGND VPWR x3_x155/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x143 x3_x143/A VGND VPWR x3_x144/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x132 x3_x132/A VGND VPWR x3_x133/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x187 x3_x187/A VGND VPWR x3_x188/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x110 x3_x19/X VGND VPWR x3_x111/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_17_28 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x1412 x1_x1412/A VGND VPWR x1_x1413/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1401 x1_x1401/A VGND VPWR x1_x1402/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1423 x1_x1423/A VGND VPWR x1_x1424/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1456 x1_x1456/A VGND VPWR x1_x1457/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1445 x1_x1445/A VGND VPWR x1_x1446/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1467 x1_x1467/A VGND VPWR x1_x1468/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1434 x1_x1434/A VGND VPWR x1_x1435/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1489 x1_x1489/A VGND VPWR x1_x1490/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1478 x1_x1478/A VGND VPWR x1_x1479/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1297 x1_x1297/A VGND VPWR x1_x1298/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x1286 x1_x1286/A VGND VPWR x1_x1287/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1275 x1_x1275/A VGND VPWR x1_x1276/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1253 x1_x1253/A VGND VPWR x1_x1254/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1220 x1_x1220/A VGND VPWR x1_x1221/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1264 x1_x1264/A VGND VPWR x1_x1265/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1231 x1_x1231/A VGND VPWR x1_x1232/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1242 x1_x1242/A VGND VPWR x1_x1243/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_160 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xx3_x1415 x3_x1415/A VGND VPWR x3_x1416/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1404 x3_x1404/A VGND VPWR x3_x1405/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1459 x3_x1459/A VGND VPWR x3_x1460/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1448 x3_x1448/A VGND VPWR x3_x1449/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1437 x3_x1437/A VGND VPWR x3_x1438/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1426 x3_x1426/A VGND VPWR x3_x1427/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_17 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_28 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_182 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_39 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1223 x3_x1223/A VGND VPWR x3_x1224/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1234 x3_x1234/A VGND VPWR x3_x1235/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1212 x3_x1212/A VGND VPWR x3_x1213/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1201 x3_x1201/A VGND VPWR x3_x1202/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1256 x3_x1256/A VGND VPWR x3_x1257/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1245 x3_x1245/A VGND VPWR x3_x1246/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1267 x3_x1267/A VGND VPWR x3_x1268/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1289 x3_x1289/A VGND VPWR x3_x1290/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1278 x3_x1278/A VGND VPWR x3_x1279/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_200 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_178 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx1_x12 x1_x12/A VGND VPWR x1_x13/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_36_233 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_92 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx3_x111 x3_x111/A VGND VPWR x3_x112/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x199 x3_x199/A VGND VPWR x3_x199/X VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x122 x3_x122/A VGND VPWR x3_x123/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x144 x3_x144/A VGND VPWR x3_x145/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x155 x3_x155/A VGND VPWR x3_x156/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x177 x3_x177/A VGND VPWR x3_x178/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x166 x3_x166/A VGND VPWR x3_x167/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x133 x3_x133/A VGND VPWR x3_x134/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x188 x3_x188/A VGND VPWR x3_x189/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_24_247 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx1_x1402 x1_x1402/A VGND VPWR x1_x1403/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1413 x1_x1413/A VGND VPWR x1_x1414/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1424 x1_x1424/A VGND VPWR x1_x1425/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1457 x1_x1457/A VGND VPWR x1_x1458/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1446 x1_x1446/A VGND VPWR x1_x1447/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1479 x1_x1479/A VGND VPWR x1_x1480/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1468 x1_x1468/A VGND VPWR x1_x1469/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1435 x1_x1435/A VGND VPWR x1_x1436/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_15_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_206 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_217 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x1276 x1_x1276/A VGND VPWR x1_x1277/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1298 x1_x1298/A VGND VPWR x1_x1299/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1287 x1_x1287/A VGND VPWR x1_x1288/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1254 x1_x1254/A VGND VPWR x1_x1255/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1265 x1_x1265/A VGND VPWR x1_x1266/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1221 x1_x1221/A VGND VPWR x1_x1222/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1232 x1_x1232/A VGND VPWR x1_x1233/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1243 x1_x1243/A VGND VPWR x1_x1244/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1210 x1_x1210/A VGND VPWR x1_x1211/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_34_71 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_125 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_139 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx3_x1416 x3_x1416/A VGND VPWR x3_x1417/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1405 x3_x1405/A VGND VPWR x3_x1406/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1449 x3_x1449/A VGND VPWR x3_x1450/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1438 x3_x1438/A VGND VPWR x3_x1439/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1427 x3_x1427/A VGND VPWR x3_x1428/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_18 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_109 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_95 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1224 x3_x1224/A VGND VPWR x3_x1225/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1257 x3_x1257/A VGND VPWR x3_x1258/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1213 x3_x1213/A VGND VPWR x3_x1214/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1202 x3_x1202/A VGND VPWR x3_x1203/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1235 x3_x1235/A VGND VPWR x3_x1236/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1246 x3_x1246/A VGND VPWR x3_x1247/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1268 x3_x1268/A VGND VPWR x3_x1269/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1279 x3_x1279/A VGND VPWR x3_x1280/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x13 x1_x13/A VGND VPWR x1_x14/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_101 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x123 x3_x123/A VGND VPWR x3_x124/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x145 x3_x145/A VGND VPWR x3_x146/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x134 x3_x134/A VGND VPWR x3_x135/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x112 x3_x112/A VGND VPWR x3_x113/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_41_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x178 x3_x178/A VGND VPWR x3_x179/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x156 x3_x156/A VGND VPWR x3_x157/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x167 x3_x167/A VGND VPWR x3_x168/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x189 x3_x189/A VGND VPWR x3_x190/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_24_226 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x1414 x1_x1414/A VGND VPWR x1_x1415/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1403 x1_x1403/A VGND VPWR x1_x1404/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1425 x1_x1425/A VGND VPWR x1_x1426/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1447 x1_x1447/A VGND VPWR x1_x1448/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1436 x1_x1436/A VGND VPWR x1_x1437/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1458 x1_x1458/A VGND VPWR x1_x1459/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1469 x1_x1469/A VGND VPWR x1_x1470/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_229 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x1233 x1_x1233/A VGND VPWR x1_x1234/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1222 x1_x1222/A VGND VPWR x1_x1223/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1211 x1_x1211/A VGND VPWR x1_x1212/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1200 x1_x1200/A VGND VPWR x1_x1201/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1277 x1_x1277/A VGND VPWR x1_x1278/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1299 x1_x1299/A VGND VPWR x1_x1300/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1255 x1_x1255/A VGND VPWR x1_x1256/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1288 x1_x1288/A VGND VPWR x1_x1289/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1266 x1_x1266/A VGND VPWR x1_x1267/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1244 x1_x1244/A VGND VPWR x1_x1245/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_63 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_82 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xx3_x1417 x3_x1417/A VGND VPWR x3_x1418/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_43 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx3_x1439 x3_x1439/A VGND VPWR x3_x1440/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1428 x3_x1428/A VGND VPWR x3_x1429/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1406 x3_x1406/A VGND VPWR x3_x1407/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_19 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_276 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx3_x1225 x3_x1225/A VGND VPWR x3_x1226/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1214 x3_x1214/A VGND VPWR x3_x1215/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1203 x3_x1203/A VGND VPWR x3_x1204/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1258 x3_x1258/A VGND VPWR x3_x1259/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1236 x3_x1236/A VGND VPWR x3_x1237/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1247 x3_x1247/A VGND VPWR x3_x1248/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1269 x3_x1269/A VGND VPWR x3_x1270/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_36_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_94 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_77 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx1_x14 x1_x14/A VGND VPWR x1_x15/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_36_246 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_180 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_205 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx3_x113 x3_x113/A VGND VPWR x3_x114/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x179 x3_x179/A VGND VPWR x3_x180/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x124 x3_x124/A VGND VPWR x3_x125/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x135 x3_x135/A VGND VPWR x3_x136/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x157 x3_x157/A VGND VPWR x3_x158/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x146 x3_x146/A VGND VPWR x3_x147/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x168 x3_x168/A VGND VPWR x3_x169/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1404 x1_x1404/A VGND VPWR x1_x1405/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1415 x1_x1415/A VGND VPWR x1_x1416/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1426 x1_x1426/A VGND VPWR x1_x1427/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1448 x1_x1448/A VGND VPWR x1_x1449/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1437 x1_x1437/A VGND VPWR x1_x1438/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1459 x1_x1459/A VGND VPWR x1_x1460/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_67 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_274 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xx1_x1256 x1_x1256/A VGND VPWR x1_x1257/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1223 x1_x1223/A VGND VPWR x1_x1224/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1245 x1_x1245/A VGND VPWR x1_x1246/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1234 x1_x1234/A VGND VPWR x1_x1235/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1212 x1_x1212/A VGND VPWR x1_x1213/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1201 x1_x1201/A VGND VPWR x1_x1202/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1278 x1_x1278/A VGND VPWR x1_x1279/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx1_x1267 x1_x1267/A VGND VPWR x1_x1268/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx1_x1289 x1_x1289/A VGND VPWR x1_x1290/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_252 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_196 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xx3_x1418 x3_x1418/A VGND VPWR x3_x1419/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1407 x3_x1407/A VGND VPWR x3_x1408/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xx3_x1429 x3_x1429/A VGND VPWR x3_x1430/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_34_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_188 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xx3_x1215 x3_x1215/A VGND VPWR x3_x1216/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1204 x3_x1204/A VGND VPWR x3_x1205/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1226 x3_x1226/A VGND VPWR x3_x1227/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1237 x3_x1237/A VGND VPWR x3_x1238/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1248 x3_x1248/A VGND VPWR x3_x1249/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
Xx3_x1259 x3_x1259/A VGND VPWR x3_x1260/A VGND VPWR sky130_fd_sc_hd__clkdlybuf4s50_2
.ends
