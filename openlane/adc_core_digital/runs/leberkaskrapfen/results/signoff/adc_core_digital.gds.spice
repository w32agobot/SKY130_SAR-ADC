* NGSPICE file created from adc_core_digital.ext - technology: sky130A

.subckt sky130_fd_sc_hd__decap_4 VGND VPWR VNB VPB
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=1.05e+06u
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
.ends

.subckt sky130_fd_sc_hd__and2_2 VPWR VGND A X B VNB VPB
X0 X a_61_75# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 VPWR a_61_75# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 VPWR B a_61_75# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 VGND B a_147_75# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X4 X a_61_75# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 VGND a_61_75# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 a_61_75# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X7 a_147_75# A a_61_75# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__decap_6 VPWR VGND VNB VPB
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=1.97e+06u
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.97e+06u
.ends

.subckt sky130_fd_sc_hd__mux2_1 VGND VPWR S A1 A0 X VNB VPB
X0 VPWR a_505_21# a_535_374# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X1 a_505_21# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X2 a_218_374# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 VGND a_505_21# a_439_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X4 a_76_199# A0 a_218_374# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X5 a_505_21# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X6 a_439_47# A0 a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X7 a_535_374# A1 a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X8 a_76_199# A1 a_218_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X9 a_218_47# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X10 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__nor3_2 C Y A B VGND VPWR VNB VPB
X0 Y C a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 a_281_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 a_281_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_27_297# B a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__o2111a_2 D1 C1 A2 A1 B1 X VGND VPWR VNB VPB
X0 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 X a_80_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 a_80_21# D1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 VPWR C1 a_80_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 X a_80_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 a_80_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 a_674_297# A2 a_80_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_386_47# D1 a_80_21# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 VPWR A1 a_674_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 a_566_47# B1 a_458_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 VGND A2 a_566_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 a_566_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 a_458_47# C1 a_386_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o22ai_4 A1 Y A2 B1 B2 VGND VPWR VNB VPB
X0 a_33_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 VGND A1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 VGND A2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 a_33_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_797_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_797_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 Y B2 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 VPWR B1 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 a_33_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 VGND A1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 a_33_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 a_33_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X14 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 a_33_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X16 a_797_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X17 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X18 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X19 VPWR B1 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X20 VGND A2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X21 a_33_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X22 a_797_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X23 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X24 Y B2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X25 Y B2 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X26 Y B1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X27 Y B2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X28 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X29 Y B1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X30 a_33_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X31 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_ef_sc_hd__decap_12 VGND VPWR VNB VPB
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=4.73e+06u
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
.ends

.subckt sky130_fd_sc_hd__a21boi_2 VPWR VGND B1_N A2 A1 Y VNB VPB
X0 Y a_61_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 VPWR A2 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 a_217_297# a_61_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 a_479_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_217_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 Y a_61_47# a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 VPWR A1 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 a_61_47# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X8 VGND A2 a_637_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 VGND a_61_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 Y A1 a_479_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 VGND B1_N a_61_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X12 a_217_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 a_637_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__a31o_2 X B1 A3 A1 A2 VGND VPWR VNB VPB
X0 VPWR A2 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 a_277_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 a_79_21# B1 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 a_277_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 a_361_47# A2 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 a_277_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 VGND B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 a_79_21# A1 a_361_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__a21o_2 X B1 A1 A2 VGND VPWR VNB VPB
X0 VPWR a_80_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 X a_80_199# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 VGND a_80_199# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 a_386_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 X a_80_199# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 a_80_199# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 a_386_297# B1 a_80_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 a_458_47# A1 a_80_199# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 VPWR A1 a_386_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 VGND A2 a_458_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__buf_1 VGND VPWR X A VNB VPB
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=790000u l=150000u
X1 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=520000u l=150000u
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=790000u l=150000u
X3 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=520000u l=150000u
.ends

.subckt sky130_fd_sc_hd__a21bo_2 B1_N A2 X A1 VGND VPWR VNB VPB
X0 VPWR A1 a_485_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 a_485_297# a_297_93# a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 a_297_93# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 a_581_47# A1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 a_79_21# a_297_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 VGND A2 a_581_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_297_93# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X9 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 a_485_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__and3b_2 VGND VPWR B X A_N C VNB VPB
X0 a_109_53# A_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X1 X a_215_311# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 a_109_53# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 VGND C a_373_53# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X4 VGND a_215_311# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 VPWR C a_215_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X6 VPWR a_215_311# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 X a_215_311# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_301_53# a_109_53# a_215_311# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X9 a_215_311# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X10 a_373_53# B a_301_53# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X11 VPWR a_109_53# a_215_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__xor2_2 VPWR VGND X B A VNB VPB
X0 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 a_470_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 a_470_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 VPWR A a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 a_470_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 a_470_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 VPWR B a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X14 VGND A a_470_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X15 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X16 X a_112_47# a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X17 a_470_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X18 X B a_470_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X19 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__and3_2 B X A C VPWR VGND VNB VPB
X0 VPWR a_29_311# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 X a_29_311# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 VPWR A a_29_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 VGND a_29_311# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_184_53# B a_112_53# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X5 VPWR C a_29_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X6 X a_29_311# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 a_112_53# A a_29_311# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X8 a_29_311# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X9 VGND C a_184_53# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__nand2_2 Y A B VGND VPWR VNB VPB
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o31a_2 X A1 A2 B1 A3 VGND VPWR VNB VPB
X0 a_108_21# B1 a_346_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 a_346_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 X a_108_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 a_108_21# A3 a_430_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 a_430_297# A2 a_346_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 VPWR a_108_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_346_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 VGND A2 a_346_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 X a_108_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 VPWR B1 a_108_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 VGND a_108_21# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 a_346_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__a22o_2 A1 A2 X B2 B1 VPWR VGND VNB VPB
X0 VPWR a_27_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 VGND A2 a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 a_27_297# B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 a_27_297# B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 VGND a_27_297# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 a_381_47# A1 a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 a_109_297# B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_109_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__nor2_8 Y A B VGND VPWR VNB VPB
X0 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X14 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X16 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X17 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X18 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X19 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X20 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X21 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X22 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X23 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X24 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X25 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X26 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X27 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X28 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X29 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X30 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X31 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__and4b_2 VPWR VGND X A_N D C B VNB VPB
X0 VPWR a_193_413# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 a_297_47# a_27_413# a_193_413# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X2 a_369_47# B a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 X a_193_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 VPWR D a_193_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X5 VPWR A_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X6 VGND D a_469_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X7 VGND a_193_413# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 VPWR B a_193_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X9 a_193_413# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X10 X a_193_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_193_413# a_27_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X12 a_469_47# C a_369_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X13 a_27_413# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__or4b_2 C A X B D_N VPWR VGND VNB VPB
X0 a_176_21# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X1 VGND D_N a_27_53# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X2 VGND a_176_21# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 X a_176_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 VPWR a_176_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_555_297# C a_483_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X6 a_176_21# a_27_53# a_555_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X7 X a_176_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_387_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X9 a_483_297# B a_387_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X10 VGND B a_176_21# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X11 VGND a_27_53# a_176_21# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X12 VPWR D_N a_27_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X13 a_176_21# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__a22o_4 B1 B2 X A2 A1 VGND VPWR VNB VPB
X0 a_484_297# B2 a_96_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 VGND B2 a_566_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 X a_96_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 VPWR a_96_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 X a_96_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_96_21# B1 a_484_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 VPWR a_96_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 X a_96_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 VGND a_96_21# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 a_484_297# B1 a_96_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 a_484_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 VGND A2 a_918_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 a_96_21# B2 a_484_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 a_96_21# B1 a_566_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X14 a_484_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 VPWR A1 a_484_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X16 a_96_21# A1 a_918_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X17 VPWR A2 a_484_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X18 a_566_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X19 a_918_47# A1 a_96_21# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X20 a_566_47# B1 a_96_21# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X21 a_918_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X22 X a_96_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X23 VGND a_96_21# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__decap_3 VPWR VGND VNB VPB
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=590000u
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=590000u
.ends

.subckt sky130_fd_sc_hd__a32o_2 B2 X A2 A3 A1 B1 VGND VPWR VNB VPB
X0 VPWR A3 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 a_299_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 a_352_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 a_549_47# A1 a_21_199# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 X a_21_199# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 VGND a_21_199# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 a_665_47# A2 a_549_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 VPWR A1 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_299_297# B1 a_21_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 a_21_199# B2 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 VGND A3 a_665_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 VPWR a_21_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X12 X a_21_199# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 a_21_199# B1 a_352_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VPWR VPB VNB
D0 VNB DIODE sky130_fd_pr__diode_pw2nd_05v5 pj=2.64e+06u area=4.347e+11p
.ends

.subckt sky130_fd_sc_hd__or3_2 A B X C VGND VPWR VNB VPB
X0 VPWR a_30_53# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 VGND a_30_53# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 X a_30_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 a_112_297# C a_30_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X4 X a_30_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 VGND A a_30_53# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X6 a_30_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X7 VGND C a_30_53# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X8 a_184_297# B a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X9 VPWR A a_184_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__dfrtp_4 Q RESET_B D CLK VGND VPWR VNB VPB
X0 a_1217_47# a_27_47# a_1108_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=360000u l=150000u
X1 a_805_47# a_761_289# a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X2 a_1108_47# a_193_47# a_761_289# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=360000u l=150000u
X3 a_1283_21# a_1108_47# a_1462_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X4 a_651_413# a_27_47# a_543_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X5 VGND RESET_B a_805_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X6 VPWR a_1283_21# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X8 a_448_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X9 Q a_1283_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 VPWR a_1283_21# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_761_289# a_543_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X12 Q a_1283_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X14 a_1108_47# a_27_47# a_761_289# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X15 a_543_47# a_27_47# a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=360000u l=150000u
X16 a_1462_47# RESET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X17 a_543_47# a_193_47# a_448_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X18 a_448_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X19 VPWR a_1283_21# a_1270_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X20 VPWR a_1108_47# a_1283_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X21 Q a_1283_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X22 a_1270_413# a_193_47# a_1108_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X23 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X24 a_1283_21# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X25 VGND a_1283_21# Q VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X26 VGND a_1283_21# Q VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X27 VPWR a_761_289# a_651_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X28 a_639_47# a_193_47# a_543_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=360000u l=150000u
X29 VGND a_1283_21# a_1217_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X30 a_651_413# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X31 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X32 a_761_289# a_543_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=840000u l=150000u
X33 Q a_1283_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__buf_4 VPWR VGND X A VNB VPB
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__decap_8 VPWR VGND VNB VPB
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=2.89e+06u
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=2.89e+06u
.ends

.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 Y C1 VGND VPWR VNB VPB
X0 a_286_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 a_286_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 Y A2 a_487_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 VGND A1 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 Y C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 VGND A2 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 a_487_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_27_47# B1 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 VPWR A1 a_487_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_27_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 a_487_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 a_286_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X15 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__a21oi_2 B1 A2 A1 Y VGND VPWR VNB VPB
X0 VGND A2 a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 Y A1 a_114_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 a_114_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 a_285_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__inv_2 A Y VPWR VGND VNB VPB
X0 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__or2_2 B X A VPWR VGND VNB VPB
X0 a_121_297# B a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X1 X a_39_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 VPWR a_39_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 X a_39_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 VGND a_39_297# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 VPWR A a_121_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X6 VGND A a_39_297# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X7 a_39_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o32a_2 B1 B2 A3 A2 A1 X VGND VPWR VNB VPB
X0 a_429_297# A2 a_345_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 VGND A2 a_345_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_345_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 a_345_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_629_297# B2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 VPWR B1 a_629_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_79_21# B2 a_345_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 a_345_47# B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 a_79_21# A3 a_429_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X12 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 a_345_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__nand3_4 Y A B C VGND VPWR VNB VPB
X0 a_27_47# B a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 a_27_47# B a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 Y A a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 Y A a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_27_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 a_27_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 a_445_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X12 a_445_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 VGND C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X14 a_445_47# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X15 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X16 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X17 a_445_47# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X18 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X19 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X20 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X21 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X22 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X23 VGND C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__nor2_2 B Y A VGND VPWR VNB VPB
X0 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__xnor2_2 VGND VPWR Y A B VNB VPB
X0 a_27_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 a_560_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 VGND B a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 Y B a_474_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 Y a_27_297# a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 a_474_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 VGND A a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 a_27_47# B a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 a_27_297# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 a_27_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 VPWR B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X12 a_474_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 a_560_47# a_27_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X14 VPWR A a_474_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 Y a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X16 VPWR a_27_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X17 a_560_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X18 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X19 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__buf_12 A X VGND VPWR VNB VPB
X0 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 VPWR A a_109_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 a_109_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X12 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 VPWR A a_109_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 VGND A a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X16 VGND A a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X17 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X18 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X19 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X20 a_109_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X21 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X22 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X23 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X24 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X25 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X26 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X27 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X28 a_109_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X29 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X30 a_109_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X31 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__and4_2 X C A B D VGND VPWR VNB VPB
X0 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 VGND D a_304_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 a_198_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X4 a_27_47# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X5 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_304_47# C a_198_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X7 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X8 VPWR D a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X9 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X11 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__dfrtp_2 Q RESET_B D CLK VGND VPWR VNB VPB
X0 a_1217_47# a_27_47# a_1108_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=360000u l=150000u
X1 a_805_47# a_761_289# a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X2 VGND a_1283_21# Q VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 a_1108_47# a_193_47# a_761_289# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=360000u l=150000u
X4 a_1283_21# a_1108_47# a_1462_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X5 a_651_413# a_27_47# a_543_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X6 VPWR a_1283_21# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 VGND RESET_B a_805_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X8 Q a_1283_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X10 a_448_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X11 a_761_289# a_543_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X12 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X13 a_1108_47# a_27_47# a_761_289# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X14 a_543_47# a_27_47# a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=360000u l=150000u
X15 a_1462_47# RESET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X16 a_543_47# a_193_47# a_448_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X17 a_448_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X18 VPWR a_1283_21# a_1270_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X19 VPWR a_1108_47# a_1283_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X20 a_1270_413# a_193_47# a_1108_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X21 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X22 a_1283_21# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X23 VPWR a_761_289# a_651_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X24 Q a_1283_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X25 a_639_47# a_193_47# a_543_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=360000u l=150000u
X26 VGND a_1283_21# a_1217_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X27 a_651_413# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X28 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X29 a_761_289# a_543_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=840000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o21ai_2 B1 Y A2 A1 VGND VPWR VNB VPB
X0 VGND A2 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 Y B1 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 VPWR A1 a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 a_29_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 Y A2 a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 VGND A1 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 a_112_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_112_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 a_29_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_29_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__xor2_4 X B A VGND VPWR VNB VPB
X0 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 a_806_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 a_806_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_806_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 X B a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 X a_112_47# a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 a_806_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 VGND A a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 X B a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 VGND A a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X14 a_806_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X16 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X17 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X18 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X19 a_806_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X20 VPWR B a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X21 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X22 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X23 VPWR B a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X24 a_806_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X25 a_806_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X26 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X27 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X28 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X29 a_806_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X30 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X31 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X32 VPWR A a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X33 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X34 X a_112_47# a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X35 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X36 a_806_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X37 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X38 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X39 VPWR A a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__a211o_2 X A2 A1 B1 C1 VGND VPWR VNB VPB
X0 a_79_21# A1 a_348_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 a_79_21# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 a_79_21# C1 a_585_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 VPWR A2 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_299_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 a_585_297# B1 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_348_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 VGND B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__a31oi_4 Y B1 A1 A3 A2 VPWR VGND VNB VPB
X0 a_27_47# A2 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 a_27_47# A2 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_445_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 a_445_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X15 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X16 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X17 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X18 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X19 Y A1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X20 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X21 Y A1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X22 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X23 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X24 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X25 a_445_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X26 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X27 a_445_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X28 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X29 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X30 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X31 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__nand3b_2 Y C A_N B VGND VPWR VNB VPB
X0 a_408_47# B a_218_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 a_408_47# a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 Y a_27_47# a_408_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X4 VGND C a_218_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_218_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 VPWR a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 a_218_47# B a_408_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X12 Y a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o22a_2 A2 X B1 A1 B2 VGND VPWR VNB VPB
X0 a_301_47# B2 a_81_21# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 VGND A2 a_301_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 a_383_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 VPWR a_81_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 a_301_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 VGND a_81_21# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 X a_81_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 X a_81_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 VPWR A1 a_579_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 a_81_21# B1 a_301_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 a_579_297# A2 a_81_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_81_21# B2 a_383_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__or2_4 X A B VGND VPWR VNB VPB
X0 a_121_297# B a_35_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 VPWR a_35_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 X a_35_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 X a_35_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 X a_35_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 VPWR a_35_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 X a_35_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 VPWR A a_121_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 VGND A a_35_297# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 a_35_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__buf_8 A X VGND VPWR VNB VPB
X0 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 a_27_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X15 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X16 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X17 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X18 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X19 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X20 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X21 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o21ai_4 Y B1 A2 A1 VPWR VGND VNB VPB
X0 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 VGND A2 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 Y B1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 VGND A1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_32_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 Y B1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_32_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 a_32_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 a_32_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X14 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 a_32_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X16 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X17 a_32_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X18 VGND A2 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X19 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X20 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X21 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X22 VGND A1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X23 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__a221o_2 X B1 A1 B2 A2 VGND VPWR C1 VNB VPB
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 a_465_47# A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 a_109_297# B1 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 a_193_297# B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 a_205_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 VPWR A2 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_193_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 a_27_47# B1 a_205_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 a_109_297# C1 a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X12 VGND C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 VGND A2 a_465_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__xnor2_4 Y B A VGND VPWR VNB VPB
X0 VGND A a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 Y a_38_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 a_38_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 a_820_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 VPWR a_38_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 VGND A a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 VGND B a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 VGND B a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 Y B a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 a_38_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 a_38_297# B a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 VGND A a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 a_902_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 a_820_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 a_902_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X15 VPWR A a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X16 Y a_38_297# a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X17 Y a_38_297# a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X18 a_38_47# B a_38_297# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X19 a_38_47# B a_38_297# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X20 a_38_297# B a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X21 a_38_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X22 VPWR B a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X23 a_38_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X24 a_902_47# a_38_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X25 a_902_47# a_38_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X26 Y B a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X27 a_38_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X28 a_820_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X29 VPWR A a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X30 VGND A a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X31 VPWR A a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X32 a_902_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X33 a_820_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X34 Y a_38_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X35 a_902_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X36 a_38_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X37 VPWR A a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X38 VPWR a_38_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X39 VPWR B a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__buf_6 VPWR VGND X A VNB VPB
X0 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 a_161_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 VGND A a_161_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 VPWR A a_161_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X15 a_161_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__and3_4 A B C X VGND VPWR VNB VPB
X0 VPWR A a_94_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 a_294_47# B a_185_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 a_185_47# A a_94_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 VPWR a_94_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 VGND C a_294_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 a_94_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 X a_94_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 X a_94_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 VPWR C a_94_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 X a_94_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 VGND a_94_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 VPWR a_94_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X12 VGND a_94_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 X a_94_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__o21a_2 A1 B1 A2 X VGND VPWR VNB VPB
X0 VPWR A1 a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 VGND A2 a_384_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_470_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_384_47# B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 a_384_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o211a_2 C1 B1 A2 A1 X VPWR VGND VNB VPB
X0 a_27_47# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 VPWR C1 a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 VPWR A1 a_373_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 a_182_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_182_47# B1 a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 a_373_297# A2 a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 a_110_47# C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 VGND A1 a_182_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__a211oi_4 A2 A1 C1 Y B1 VPWR VGND VNB VPB
X0 Y A1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 VGND A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 a_949_297# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 Y C1 a_949_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 a_781_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_27_297# B1 a_781_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X12 VGND A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 Y A1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X14 a_781_297# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 a_1301_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X16 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X17 Y C1 a_781_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X18 a_109_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X19 a_109_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X20 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X21 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X22 a_109_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X23 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X24 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X25 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X26 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X27 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X28 a_27_297# B1 a_1301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X29 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X30 a_109_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X31 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__a2bb2o_2 VGND VPWR B1 A1_N A2_N X B2 VNB VPB
X0 VPWR a_82_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 a_646_47# B2 a_82_21# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X2 a_574_369# a_313_47# a_82_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X3 a_574_369# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X4 VGND a_82_21# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 VPWR B2 a_574_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X6 X a_82_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 X a_82_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_313_47# A2_N a_313_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X9 a_313_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X10 a_313_297# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X11 VGND A2_N a_313_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X12 a_82_21# a_313_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X13 VGND B1 a_646_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__buf_2 VPWR VGND X A VNB VPB
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X3 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__or3_4 A X B C VPWR VGND VNB VPB
X0 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 VPWR A a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_193_297# B a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X12 a_109_297# C a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 VGND C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__a221oi_4 A2 Y C1 A1 B2 B1 VPWR VGND VNB VPB
X0 Y A1 a_1241_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 a_453_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 Y B1 a_453_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 Y A1 a_1241_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 Y C1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_471_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 Y B1 a_453_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 VGND A2 a_1241_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 a_27_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 VPWR A2 a_471_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_453_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 a_471_297# B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 VGND B2 a_453_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X14 a_1241_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X15 a_27_297# B2 a_471_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X16 a_453_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X17 a_1241_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X18 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X19 a_1241_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X20 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X21 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X22 VPWR A2 a_471_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X23 a_471_297# B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X24 a_471_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X25 a_471_297# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X26 VPWR A1 a_471_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X27 Y C1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X28 a_27_297# B1 a_471_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X29 VGND A2 a_1241_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X30 a_471_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X31 a_27_297# B1 a_471_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X32 a_1241_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X33 a_471_297# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X34 VPWR A1 a_471_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X35 a_27_297# B2 a_471_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X36 a_471_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X37 a_27_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X38 a_453_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X39 VGND B2 a_453_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__or3b_2 A B C_N X VPWR VGND VNB VPB
X0 a_388_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X1 VPWR C_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X2 VGND a_176_21# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 X a_176_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 VPWR a_176_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 VGND B a_176_21# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X6 X a_176_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 a_176_21# a_27_47# a_472_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X8 a_472_297# B a_388_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X9 a_176_21# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X10 a_176_21# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X11 VGND C_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__nor3_4 A C B Y VGND VPWR VNB VPB
X0 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 a_449_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 a_27_297# B a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 Y C a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_449_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 Y C a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 a_449_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X16 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X17 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X18 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X19 a_27_297# B a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X20 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X21 a_449_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X22 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X23 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__o21ba_2 B1_N A1 X A2 VGND VPWR VNB VPB
X0 VGND B1_N a_27_93# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X1 VGND A2 a_478_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 a_478_47# a_27_93# a_174_21# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 a_478_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 X a_174_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 VPWR a_174_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 X a_174_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 VPWR A1 a_574_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 VGND a_174_21# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 VPWR B1_N a_27_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X10 a_574_297# A2 a_174_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_174_21# a_27_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__mux2_4 X S A0 A1 VPWR VGND VNB VPB
X0 a_204_297# A1 a_396_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 VPWR a_396_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 X a_396_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 VPWR S a_314_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 a_204_297# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_396_47# A0 a_314_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_206_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 X a_396_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 X a_396_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 VPWR a_396_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 a_490_47# A1 a_396_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 VGND S a_490_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 VGND a_396_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 a_396_47# A0 a_206_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X14 VGND a_396_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X15 VPWR S a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X16 X a_396_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X17 VGND S a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__or4_2 C A X B D VPWR VGND VNB VPB
X0 a_27_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X1 a_27_297# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X2 a_277_297# B a_205_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 VPWR A a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X4 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 a_205_297# C a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X6 VPWR a_27_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 VGND a_27_297# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 VGND C a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X10 a_109_297# D a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X11 VGND A a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__or2b_2 A B_N X VPWR VGND VNB VPB
X0 VPWR A a_300_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X1 a_218_297# a_27_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X2 VGND B_N a_27_53# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 a_300_297# a_27_53# a_218_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X4 X a_218_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 VPWR a_218_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 X a_218_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 VGND a_218_297# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 a_27_53# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X9 VGND A a_218_297# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__nor4_4 A C Y D B VGND VPWR VNB VPB
X0 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 a_807_297# D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 Y D a_807_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 Y D VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 Y D VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 a_27_297# B a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X12 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X14 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X15 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X16 a_449_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X17 a_807_297# C a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X18 VGND D Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X19 VGND D Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X20 a_807_297# C a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X21 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X22 a_449_297# C a_807_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X23 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X24 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X25 a_449_297# C a_807_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X26 a_27_297# B a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X27 a_807_297# D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X28 a_449_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X29 Y D a_807_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X30 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X31 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__nand2_4 Y A B VGND VPWR VNB VPB
X0 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X12 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__a21oi_4 B1 A2 A1 Y VGND VPWR VNB VPB
X0 a_28_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 a_462_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 Y B1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_462_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 a_28_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_462_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 Y B1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 Y A1 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 a_28_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X12 VPWR A2 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X14 VGND A2 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X15 a_28_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X16 VPWR A1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X17 a_28_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X18 VGND A2 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X19 VPWR A2 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X20 a_28_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X21 Y A1 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X22 a_462_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X23 VPWR A1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__or4_4 B C A D X VPWR VGND VNB VPB
X0 VPWR A a_304_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 a_304_297# B a_220_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 VGND C a_32_297# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 a_220_297# C a_114_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 a_32_297# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 a_32_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 VPWR a_32_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 X a_32_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 VGND A a_32_297# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 VPWR a_32_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 X a_32_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 X a_32_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 X a_32_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 a_114_297# D a_32_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 VGND a_32_297# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X15 VGND a_32_297# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o41a_4 A1 A2 A3 A4 B1 X VGND VPWR VNB VPB
X0 a_467_47# A4 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 a_467_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 VGND A1 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 a_467_47# B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_467_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 VPWR A1 a_1083_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_1083_297# A2 a_889_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 VGND A3 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 a_79_21# B1 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X12 a_889_297# A2 a_1083_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X15 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X16 a_639_297# A3 a_889_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X17 VGND A2 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X18 a_889_297# A3 a_639_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X19 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X20 a_639_297# A4 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X21 VPWR B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X22 VGND A4 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X23 a_1083_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X24 a_79_21# A4 a_639_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X25 a_467_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X26 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X27 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__conb_1 LO HI VPB VNB VGND VPWR
R0 HI VPWR sky130_fd_pr__res_generic_po w=480000u l=45000u
R1 VGND LO sky130_fd_pr__res_generic_po w=480000u l=45000u
.ends

.subckt sky130_fd_sc_hd__dfstp_4 Q D VPWR SET_B CLK VGND VNB VPB
X0 a_1178_261# a_1028_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=840000u l=150000u
X1 VGND a_652_21# a_586_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X2 VPWR a_1028_413# a_1598_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X3 a_1178_261# a_1028_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=540000u l=150000u
X4 VGND a_1598_47# Q VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 a_956_413# a_476_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X6 a_1136_413# a_193_47# a_1028_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X7 VPWR a_1598_47# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 VPWR a_476_47# a_652_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X9 a_586_47# a_193_47# a_476_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=360000u l=150000u
X10 VGND a_1598_47# Q VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X12 Q a_1598_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 a_476_47# a_27_47# a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=360000u l=150000u
X14 a_1056_47# a_476_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X15 a_381_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=840000u l=150000u
X16 a_652_21# SET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X17 a_1224_47# a_27_47# a_1028_413# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X18 a_562_413# a_27_47# a_476_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X19 a_1028_413# a_193_47# a_1056_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X20 a_476_47# a_193_47# a_381_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X21 Q a_1598_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X22 a_1296_47# a_1178_261# a_1224_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X23 VGND a_1028_413# a_1598_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X24 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X25 VPWR a_652_21# a_562_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X26 VPWR a_1598_47# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X27 VGND SET_B a_1296_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X28 Q a_1598_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X29 a_1028_413# a_27_47# a_956_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X30 VPWR a_1178_261# a_1136_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X31 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X32 Q a_1598_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X33 a_796_47# SET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X34 a_381_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X35 Q a_1598_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X36 Q a_1598_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X37 a_652_21# a_476_47# a_796_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X38 VPWR SET_B a_1028_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X39 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__nand2_8 A B Y VGND VPWR VNB VPB
X0 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X12 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X16 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X17 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X18 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X19 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X20 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X21 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X22 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X23 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X24 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X25 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X26 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X27 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X28 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X29 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X30 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X31 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o221a_2 B2 A2 X B1 C1 A1 VGND VPWR VNB VPB
X0 VPWR a_38_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 VPWR A1 a_497_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 X a_38_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 a_141_47# B2 a_225_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_497_297# A2 a_38_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 VGND A1 a_225_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 VPWR C1 a_38_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 a_237_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_38_47# B2 a_237_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 a_225_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 X a_38_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 a_141_47# C1 a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 VGND a_38_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 a_225_47# B1 a_141_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__a311o_2 VGND VPWR X C1 B1 A1 A2 A3 VNB VPB
X0 a_79_21# C1 a_635_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 VPWR A2 a_319_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 VGND B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 a_417_47# A2 a_319_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_79_21# A1 a_417_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 a_319_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 a_319_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 a_319_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 a_79_21# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 a_635_297# B1 a_319_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X12 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__nand4_2 B A Y D C VGND VPWR VNB VPB
X0 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 a_471_47# B a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 VPWR D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_27_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 a_27_47# C a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_277_47# B a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 Y A a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 a_277_47# C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 a_471_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X14 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 VGND D a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o22a_4 B2 B1 X A1 A2 VGND VPWR VNB VPB
X0 VPWR B1 a_566_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 a_484_47# B1 a_96_21# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 X a_96_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 VPWR a_96_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 X a_96_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_566_297# B2 a_96_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 VPWR a_96_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 X a_96_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 VGND a_96_21# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 a_96_21# B2 a_566_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 VPWR A1 a_918_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_484_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 a_566_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 a_484_47# B2 a_96_21# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X14 a_96_21# A2 a_918_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 a_918_297# A2 a_96_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X16 a_484_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X17 a_918_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X18 a_96_21# B1 a_484_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X19 VGND A2 a_484_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X20 a_96_21# B2 a_484_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X21 VGND A1 a_484_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X22 X a_96_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X23 VGND a_96_21# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__a2bb2o_4 B1 B2 X A1_N A2_N VGND VPWR VNB VPB
X0 VGND a_415_21# a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 a_415_21# A2_N a_717_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 a_717_297# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 VGND A2_N a_415_21# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_193_47# a_415_21# a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 VPWR a_193_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 X a_193_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 VPWR B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 X a_193_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 a_415_21# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 a_415_21# A2_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 X a_193_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 a_27_297# B2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 a_193_47# B2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X15 VGND B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X16 VGND a_193_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X17 VGND A1_N a_415_21# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X18 VGND a_193_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X19 a_109_47# B2 a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X20 a_193_47# a_415_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X21 VPWR a_193_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X22 a_27_297# a_415_21# a_193_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X23 X a_193_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X24 VPWR A1_N a_717_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X25 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X26 a_717_297# A2_N a_415_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X27 a_109_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__a21o_4 A2 A1 X B1 VGND VPWR VNB VPB
X0 VGND B1 a_84_21# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 a_741_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 a_84_21# A1 a_741_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 VGND A2 a_901_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 VPWR a_84_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 VPWR A2 a_483_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_483_297# B1 a_84_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 X a_84_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 a_84_21# B1 a_483_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 VGND a_84_21# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 VPWR a_84_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_483_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X12 VPWR A1 a_483_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 VGND a_84_21# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X14 X a_84_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 a_84_21# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X16 a_483_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X17 X a_84_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X18 a_901_47# A1 a_84_21# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X19 X a_84_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__and2b_2 VPWR VGND X B A_N VNB VPB
X0 VPWR a_212_413# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 a_297_47# a_27_413# a_212_413# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X2 X a_212_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 X a_212_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_212_413# a_27_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X5 VPWR A_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X6 VPWR B a_212_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X7 VGND B a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X8 VGND a_212_413# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 a_27_413# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o211ai_4 A1 B1 A2 C1 Y VGND VPWR VNB VPB
X0 VPWR A1 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 Y A2 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 a_806_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 a_110_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 a_110_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 a_110_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 VPWR A1 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_27_47# B1 a_1314_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X14 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X16 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X17 Y A2 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X18 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X19 Y C1 a_978_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X20 Y C1 a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X21 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X22 a_27_47# B1 a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X23 a_110_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X24 a_806_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X25 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X26 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X27 a_978_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X28 a_1314_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X29 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X30 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X31 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o31ai_4 A3 A2 A1 Y B1 VGND VPWR VNB VPB
X0 Y A3 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 a_449_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 Y A3 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 VGND A1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 Y B1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 a_449_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 Y B1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 a_31_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 a_27_297# A2 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 VGND A1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 a_31_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 a_31_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X15 a_31_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X16 a_449_297# A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X17 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X18 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X19 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X20 VGND A2 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X21 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X22 VGND A2 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X23 VGND A3 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X24 a_31_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X25 a_27_297# A2 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X26 VGND A3 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X27 a_31_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X28 a_449_297# A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X29 a_31_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X30 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X31 a_31_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__a22oi_4 A2 B2 A1 B1 Y VGND VPWR VNB VPB
X0 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 Y A1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 Y A1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 VGND A2 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X14 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X15 a_803_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X16 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X17 a_803_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X18 a_803_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X19 a_803_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X20 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X21 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X22 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X23 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X24 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X25 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X26 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X27 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X28 VGND A2 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X29 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X30 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X31 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__nor2_4 Y A B VGND VPWR VNB VPB
X0 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__o31a_4 X B1 A3 A2 A1 VGND VPWR VNB VPB
X0 VPWR A1 a_926_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 VGND A1 a_496_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 a_926_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 VGND A3 a_496_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 VGND a_102_21# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 VGND A2 a_496_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 a_926_297# A2 a_672_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 a_102_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_496_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 X a_102_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 a_102_21# B1 a_496_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 VPWR a_102_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X12 X a_102_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 X a_102_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 VPWR a_102_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 a_672_297# A3 a_102_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X16 a_496_47# B1 a_102_21# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X17 a_102_21# A3 a_672_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X18 VGND a_102_21# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X19 X a_102_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X20 a_496_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X21 VPWR B1 a_102_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X22 a_496_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X23 a_672_297# A2 a_926_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__nor4_2 C D Y A B VGND VPWR VNB VPB
X0 a_281_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 a_475_297# D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 Y D a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 VGND D Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 Y D VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X12 a_475_297# C a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 a_281_297# C a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 a_27_297# B a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o21a_4 A1 A2 B1 X VPWR VGND VNB VPB
X0 X a_80_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 a_475_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 X a_80_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_762_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_475_47# B1 a_80_21# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 VGND A2 a_475_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 X a_80_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 a_80_21# A2 a_762_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_80_21# B1 a_475_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 a_80_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 a_475_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X14 X a_80_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 VPWR A1 a_934_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X16 a_934_297# A2 a_80_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X17 VPWR B1 a_80_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X18 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X19 VGND A1 a_475_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o22ai_2 B2 B1 Y A1 A2 VGND VPWR VNB VPB
X0 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 Y B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 a_475_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 VPWR A1 a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X12 a_475_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 Y A2 a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o21bai_4 Y B1_N A1 A2 VGND VPWR VNB VPB
X0 Y a_33_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 a_225_47# a_33_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 VPWR a_33_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 a_33_297# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 Y a_33_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 Y A2 a_561_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 Y a_33_297# a_225_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 Y a_33_297# a_225_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 VGND A2 a_225_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 VGND A2 a_225_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 a_561_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_225_47# a_33_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 VPWR A1 a_561_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 a_225_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X14 a_225_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X15 a_225_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X16 a_225_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X17 VPWR A1 a_561_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X18 a_561_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X19 VPWR B1_N a_33_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X20 a_561_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X21 VGND A1 a_225_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X22 Y A2 a_561_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X23 VGND A1 a_225_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X24 a_561_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X25 VPWR a_33_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__a31o_4 B1 A2 A3 A1 X VGND VPWR VNB VPB
X0 VPWR a_277_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 X a_277_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 X a_277_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_277_47# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 VGND a_277_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 VGND a_277_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_193_47# A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 a_361_47# A1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 X a_277_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X14 VGND A3 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X15 X a_277_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X16 a_277_47# A1 a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X17 a_445_47# A2 a_361_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X18 VGND B1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X19 a_27_297# B1 a_277_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X20 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X21 VPWR a_277_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X22 a_109_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X23 a_277_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__mux2_2 VGND VPWR A1 A0 S X VNB VPB
X0 VPWR S a_591_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X1 a_591_369# A0 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X2 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 a_79_21# A1 a_306_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X4 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 VGND S a_578_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X6 a_306_369# a_257_199# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X7 a_79_21# A0 a_288_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X8 a_288_47# a_257_199# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X9 a_257_199# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X10 a_578_47# A1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X11 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X12 a_257_199# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X13 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__or3b_4 A B C_N X VGND VPWR VNB VPB
X0 a_176_21# a_27_47# a_626_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 a_626_297# B a_542_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 VPWR C_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 VGND a_176_21# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_542_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 VPWR a_176_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 X a_176_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 X a_176_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 X a_176_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 a_176_21# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 VPWR a_176_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 X a_176_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X12 a_176_21# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 VGND a_176_21# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X14 VGND B a_176_21# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X15 VGND C_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__inv_4 Y A VPWR VGND VNB VPB
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o2111a_4 X A1 A2 C1 B1 D1 VPWR VGND VNB VPB
X0 VGND A1 a_361_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 a_27_297# A2 a_852_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 VPWR a_27_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 VGND a_27_297# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_852_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_361_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 VPWR C1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 VGND A2 a_361_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 a_27_297# D1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X12 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 a_27_47# D1 a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X15 a_361_47# B1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X16 a_361_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X17 a_277_47# C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X18 a_445_47# B1 a_361_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X19 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X20 a_27_297# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X21 a_681_297# A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X22 a_27_47# C1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X23 VGND a_27_297# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X24 VPWR D1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X25 VPWR a_27_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X26 VPWR A1 a_681_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X27 a_27_297# D1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__a311o_4 VGND VPWR C1 A1 A2 A3 X B1 VNB VPB
X0 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 a_277_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 a_861_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_27_297# B1 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_1059_47# A2 a_861_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 a_1059_47# A1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 a_277_297# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 a_27_297# C1 a_109_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 VGND A3 a_861_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 VGND C1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 VGND B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X14 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 a_109_47# A1 a_1059_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X16 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X17 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X18 a_109_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X19 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X20 VPWR A3 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X21 VPWR A2 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X22 a_109_47# C1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X23 VPWR A1 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X24 a_277_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X25 a_277_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X26 a_109_47# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X27 a_861_47# A2 a_1059_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o31ai_2 A1 Y B1 A3 A2 VGND VPWR VNB VPB
X0 a_281_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 a_281_297# A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 Y A3 a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 a_27_297# A2 a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__o41a_2 A1 A2 A3 A4 B1 X VGND VPWR VNB VPB
X0 VGND A2 a_393_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 a_496_297# A4 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 a_393_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 VPWR A1 a_697_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 VGND A4 a_393_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 a_697_297# A2 a_597_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 a_393_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_393_47# B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 a_597_297# A3 a_496_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o2bb2a_2 A1_N X A2_N B2 B1 VGND VPWR VNB VPB
X0 a_294_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X1 VPWR A2_N a_295_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X2 VPWR B1 a_665_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X3 VGND a_84_21# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 X a_84_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 a_581_47# a_295_369# a_84_21# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X6 VPWR a_84_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 a_665_369# B2 a_84_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X8 VGND B2 a_581_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X9 a_295_369# A2_N a_294_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X10 X a_84_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_84_21# a_295_369# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X12 a_295_369# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X13 a_581_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__nand3_2 A Y B C VGND VPWR VNB VPB
X0 VGND C a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 a_277_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 a_27_47# B a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 a_277_47# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__a21boi_4 Y A1 B1_N A2 VGND VPWR VNB VPB
X0 a_223_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 Y A1 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 VPWR B1_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 a_223_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 Y a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 VGND A2 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 a_223_297# a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 Y a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 VPWR A2 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 a_658_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 VPWR A1 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_223_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X12 a_658_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 Y a_27_47# a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 a_223_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 VPWR A2 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X16 VPWR A1 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X17 a_658_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X18 VGND B1_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X19 a_223_297# a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X20 a_658_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X21 VGND A2 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X22 VGND a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X23 VGND a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X24 Y A1 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X25 Y a_27_47# a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__a221oi_2 B2 C1 A2 A1 B1 Y VGND VPWR VNB VPB
X0 Y B1 a_383_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 a_301_297# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 a_301_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 VGND B2 a_383_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 Y A1 a_735_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 a_27_297# B2 a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 VPWR A1 a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 VGND A2 a_735_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 a_301_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 Y C1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 VPWR A2 a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 a_383_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X14 a_383_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X15 a_735_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X16 a_27_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X17 a_301_297# B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X18 a_735_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X19 a_27_297# B1 a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__nand3b_4 A_N Y B C VGND VPWR VNB VPB
X0 VGND C a_633_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 Y a_27_47# a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 Y a_27_47# a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_633_47# B a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 a_633_47# B a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 a_215_47# a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_215_47# B a_633_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 a_215_47# B a_633_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 VPWR a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 Y a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X16 a_633_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X17 a_633_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X18 VPWR a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X19 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X20 a_215_47# a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X21 Y a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X22 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X23 VGND C a_633_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X24 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X25 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__nor3b_4 A C_N B Y VGND VPWR VNB VPB
X0 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X1 VPWR A a_197_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 Y a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_555_297# a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_197_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 VGND a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 a_197_297# B a_555_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 VGND a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 VGND C_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 Y a_27_47# a_555_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 Y a_27_47# a_555_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 VPWR C_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X16 a_555_297# a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X17 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X18 a_555_297# B a_197_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X19 a_197_297# B a_555_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X20 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X21 a_555_297# B a_197_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X22 VPWR A a_197_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X23 a_197_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X24 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X25 Y a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o32ai_4 A1 A2 A3 B1 Y B2 VGND VPWR VNB VPB
X0 a_1224_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X1 VPWR A1 a_1224_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_806_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_806_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X12 Y A3 a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X14 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X16 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X17 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X18 Y A3 a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X19 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X20 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X21 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X22 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X23 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X24 a_806_297# A2 a_1224_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X25 Y B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X26 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X27 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X28 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X29 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X30 a_1224_297# A2 a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X31 a_1224_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X32 a_806_297# A2 a_1224_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X33 VPWR A1 a_1224_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X34 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X35 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X36 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X37 a_1224_297# A2 a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X38 Y B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X39 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt adc_core_digital VGND VPWR clk_dig_in comparator_in
+ config_1_in[0] config_1_in[1] config_1_in[2] config_1_in[3] config_1_in[4]
+ config_1_in[5] config_1_in[6] config_1_in[7] config_1_in[8] config_1_in[9]
+ config_1_in[10] config_1_in[11] config_1_in[12] config_1_in[13] config_1_in[14]
+ config_1_in[15]
+ config_2_in[0] config_2_in[1] config_2_in[2] config_2_in[3] config_2_in[4]
+ config_2_in[5] config_2_in[6] config_2_in[7] config_2_in[8] config_2_in[9]
+ config_2_in[10] config_2_in[11] config_2_in[12] config_2_in[13] config_2_in[14]
+ config_2_in[15]
+ conv_finished_out enable_loop_out
+ nmatrix_bincap_out_n[0] nmatrix_bincap_out_n[1] nmatrix_bincap_out_n[2]
+ nmatrix_c0_out_n
+ nmatrix_col_out_n[0] nmatrix_col_out_n[1] nmatrix_col_out_n[2] nmatrix_col_out_n[3] nmatrix_col_out_n[4]
+ nmatrix_col_out_n[5] nmatrix_col_out_n[6] nmatrix_col_out_n[7] nmatrix_col_out_n[8] nmatrix_col_out_n[9]
+ nmatrix_col_out_n[10] nmatrix_col_out_n[11] nmatrix_col_out_n[12] nmatrix_col_out_n[13] nmatrix_col_out_n[14]
+ nmatrix_col_out_n[15] nmatrix_col_out_n[16] nmatrix_col_out_n[17] nmatrix_col_out_n[18] nmatrix_col_out_n[19]
+ nmatrix_col_out_n[20] nmatrix_col_out_n[21] nmatrix_col_out_n[22] nmatrix_col_out_n[23] nmatrix_col_out_n[24]
+ nmatrix_col_out_n[25] nmatrix_col_out_n[26] nmatrix_col_out_n[27] nmatrix_col_out_n[28] nmatrix_col_out_n[29]
+ nmatrix_col_out_n[30] nmatrix_col_out_n[31]
+ nmatrix_row_out_n[0] nmatrix_row_out_n[1] nmatrix_row_out_n[2] nmatrix_row_out_n[3] nmatrix_row_out_n[4]
+ nmatrix_row_out_n[5] nmatrix_row_out_n[6] nmatrix_row_out_n[7] nmatrix_row_out_n[8] nmatrix_row_out_n[9]
+ nmatrix_row_out_n[10] nmatrix_row_out_n[11] nmatrix_row_out_n[12] nmatrix_row_out_n[13] nmatrix_row_out_n[14]
+ nmatrix_row_out_n[15]
+ nmatrix_rowon_out_n[0] nmatrix_rowon_out_n[1] nmatrix_rowon_out_n[2] nmatrix_rowon_out_n[3] nmatrix_rowon_out_n[4]
+ nmatrix_rowon_out_n[5] nmatrix_rowon_out_n[6] nmatrix_rowon_out_n[7] nmatrix_rowon_out_n[8] nmatrix_rowon_out_n[9]
+ nmatrix_rowon_out_n[10] nmatrix_rowon_out_n[11] nmatrix_rowon_out_n[12] nmatrix_rowon_out_n[13] nmatrix_rowon_out_n[14]
+ nmatrix_rowon_out_n[15]
+ pmatrix_bincap_out_n[0] pmatrix_bincap_out_n[1] pmatrix_bincap_out_n[2]
+ pmatrix_c0_out_n
+ pmatrix_col_out_n[0] pmatrix_col_out_n[1] pmatrix_col_out_n[2] pmatrix_col_out_n[3] pmatrix_col_out_n[4]
+ pmatrix_col_out_n[5] pmatrix_col_out_n[6] pmatrix_col_out_n[7] pmatrix_col_out_n[8] pmatrix_col_out_n[9]
+ matrix_col_out_n[10] pmatrix_col_out_n[11] pmatrix_col_out_n[12] pmatrix_col_out_n[13] pmatrix_col_out_n[14]
+ pmatrix_col_out_n[15] pmatrix_col_out_n[16] pmatrix_col_out_n[17] pmatrix_col_out_n[18] pmatrix_col_out_n[19]
+ pmatrix_col_out_n[20] pmatrix_col_out_n[21] pmatrix_col_out_n[22] pmatrix_col_out_n[23] pmatrix_col_out_n[24]
+ pmatrix_col_out_n[25] pmatrix_col_out_n[26] pmatrix_col_out_n[27] pmatrix_col_out_n[28] pmatrix_col_out_n[29]
+ pmatrix_col_out_n[30] pmatrix_col_out_n[31]
+ pmatrix_row_out_n[0] pmatrix_row_out_n[1] pmatrix_row_out_n[2] pmatrix_row_out_n[3] pmatrix_row_out_n[4]
+ pmatrix_row_out_n[5] pmatrix_row_out_n[6] pmatrix_row_out_n[7] pmatrix_row_out_n[8] pmatrix_row_out_n[9]
+ pmatrix_row_out_n[10] pmatrix_row_out_n[11] pmatrix_row_out_n[12] pmatrix_row_out_n[13] pmatrix_row_out_n[14]
+ pmatrix_row_out_n[15]
+ pmatrix_rowon_out_n[0] pmatrix_rowon_out_n[1] pmatrix_rowon_out_n[2] pmatrix_rowon_out_n[3] pmatrix_rowon_out_n[4]
+ pmatrix_rowon_out_n[5] pmatrix_rowon_out_n[6] pmatrix_rowon_out_n[7] pmatrix_rowon_out_n[8] pmatrix_rowon_out_n[9]
+ pmatrix_rowon_out_n[10] pmatrix_rowon_out_n[11] pmatrix_rowon_out_n[12] pmatrix_rowon_out_n[13] pmatrix_rowon_out_n[14]
+ pmatrix_rowon_out_n[15]
+ result_out[0] result_out[1] result_out[2] result_out[3] result_out[4] result_out[5] result_out[6] result_out[7]
+ result_out[8] result_out[9] result_out[10] result_out[11] result_out[12] result_out[13] result_out[14] result_out[15]
+ rst_n sample_matrix_out sample_matrix_out_n sample_switch_out sample_switch_out_n
XFILLER_52_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1270_ VPWR VGND _1535_/A _1271_/A _1270_/B VGND VPWR sky130_fd_sc_hd__and2_2
XFILLER_51_217 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1606_ VGND VPWR _1606_/S input4/X _1713_/Q _1607_/A VGND VPWR sky130_fd_sc_hd__mux2_1
X_0985_ _0985_/C _1390_/B _0985_/A _0985_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nor3_2
X_1537_ _1351_/B _1536_/Y _1549_/B _1667_/D _1533_/X _1537_/X VGND VPWR VGND VPWR
+ sky130_fd_sc_hd__o2111a_2
X_1399_ _1427_/A _1725_/A _1397_/B _1415_/A _1398_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o22ai_4
X_1468_ VGND VPWR _1468_/S _1653_/Q _1606_/S _1469_/A VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_12_10 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_0770_ VPWR VGND _1694_/Q _0771_/C _1693_/Q _0770_/Y VGND VPWR sky130_fd_sc_hd__a21boi_2
X_1322_ _1673_/D _1321_/Y _1319_/Y _1672_/Q _1317_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
X_1253_ _1253_/X _1708_/Q _1535_/A _1270_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__a21o_2
X_1184_ VGND VPWR _1184_/X _1184_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_0968_ _0967_/X _0966_/Y _0968_/X _0945_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__a21bo_2
XFILLER_32_272 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_0899_ VGND VPWR _0899_/B _0899_/X _0869_/B _0899_/C VGND VPWR sky130_fd_sc_hd__and3b_2
XFILLER_38_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0822_ VGND VPWR _1714_/Q input2/X _0821_/X _0822_/X VGND VPWR sky130_fd_sc_hd__mux2_1
X_0753_ VPWR VGND _0754_/B _0758_/C _1698_/Q VGND VPWR sky130_fd_sc_hd__xor2_2
X_1305_ _1667_/Q _1309_/C _1666_/Q _1668_/Q VPWR VGND VGND VPWR sky130_fd_sc_hd__and3_2
X_1236_ _1237_/B _1567_/A _1236_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_1098_ _1098_/X _1157_/A _1046_/A _1044_/A _1089_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__o31a_2
X_1167_ _1081_/X _1164_/Y _1167_/X _1097_/X _1166_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__a22o_2
X_1021_ _1171_/A _1021_/A _1021_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_8
X_0805_ VPWR VGND _0806_/B _0782_/Y _0805_/D _0805_/C _0805_/B VGND VPWR sky130_fd_sc_hd__and4b_2
X_0736_ _0771_/C _1714_/Q _0736_/X _1693_/Q _1713_/Q VPWR VGND VGND VPWR sky130_fd_sc_hd__or4b_2
X_1219_ _1218_/X _1209_/B _1246_/B _1214_/X _1218_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__a22o_4
XFILLER_37_161 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_249 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_301 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_142 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_293 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1570_ _1670_/D _1570_/X _1485_/B _1567_/B _1668_/D _1539_/C VGND VPWR VGND VPWR
+ sky130_fd_sc_hd__a32o_2
XANTENNA_5 _1742_/A VGND VPWR VPWR VGND sky130_fd_sc_hd__diode_2
XFILLER_13_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1004_ _1004_/A _1004_/B _1005_/B _1004_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__or3_2
XFILLER_34_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1699_ _1699_/Q fanout179/X _1699_/D _1714_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_15_10 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_164 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_145 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_53 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xoutput31 VPWR VGND nmatrix_col_out_n[24] _1173_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput42 VPWR VGND nmatrix_col_out_n[5] _1140_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput75 VPWR VGND nmatrix_rowon_out_n[8] _1729_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput64 VPWR VGND nmatrix_rowon_out_n[11] _1732_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput20 VPWR VGND nmatrix_col_out_n[14] _1156_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput53 VPWR VGND nmatrix_row_out_n[1] _1721_/A VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput86 VPWR VGND pmatrix_col_out_n[15] _1094_/Y VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput97 VPWR VGND pmatrix_col_out_n[25] _1121_/Y VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_16_120 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1622_ _1622_/Q fanout183/X _1622_/D _1711_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_1484_ VGND VPWR _1567_/B _1482_/X _1660_/D _1484_/X VGND VPWR sky130_fd_sc_hd__mux2_1
X_1553_ _1553_/X _1552_/X _1530_/C _1685_/Q _1530_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
XFILLER_13_145 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0984_ _0957_/Y _0990_/B _0985_/C _0990_/A _0983_/Y VPWR VGND VGND VPWR sky130_fd_sc_hd__a22o_2
XFILLER_8_193 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1536_ _1534_/X _1535_/Y _1248_/B _1536_/Y _1248_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__o211ai_2
X_1605_ VGND VPWR _1712_/D _1605_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1398_ _1398_/X _1171_/B _1405_/B _1405_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__a21o_2
X_1467_ VGND VPWR _1652_/D _1467_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_12_55 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1321_ _1320_/Y _1317_/B _1672_/Q _1321_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__a21oi_2
X_1252_ _1488_/A _1661_/D VPWR VGND VGND VPWR sky130_fd_sc_hd__inv_2
XFILLER_17_281 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1183_ _1183_/B _1184_/A _1183_/A VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
X_0967_ _0940_/B _1617_/Q _0966_/C _0966_/B _1616_/Q _0967_/X VGND VPWR VGND VPWR
+ sky130_fd_sc_hd__o32a_2
X_1519_ _1519_/X _1518_/X _1530_/C _1681_/Q _1530_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
X_0898_ _0898_/Y _0898_/A _0898_/B _0898_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__nand3_4
X_0752_ VPWR VGND _1697_/Q _0758_/C _0752_/B VGND VPWR sky130_fd_sc_hd__and2_2
X_0821_ VGND VPWR _1712_/Q _1698_/Q _1697_/Q _0821_/X VGND VPWR sky130_fd_sc_hd__mux2_1
X_1304_ _1543_/A _1668_/D _1433_/S VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_1235_ VGND VPWR _1236_/B _1655_/Q _1235_/B VGND VPWR sky130_fd_sc_hd__xnor2_2
XFILLER_49_181 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1166_ _1061_/A _1046_/A _1166_/X _1093_/A _1089_/Y VPWR VGND VGND VPWR sky130_fd_sc_hd__a22o_2
X_1097_ VPWR VGND _1097_/X _1097_/A VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_18_65 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1020_ _1020_/A _1164_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__buf_12
XFILLER_46_173 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_0804_ _0909_/B _0926_/B _0805_/D _0810_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__or3_2
X_0735_ _1693_/Q _0771_/C _0735_/X _0728_/X _0734_/Y VPWR VGND VGND VPWR sky130_fd_sc_hd__a22o_2
X_1218_ _1218_/X _1218_/C _1218_/A _1218_/B _1218_/D VGND VPWR VGND VPWR sky130_fd_sc_hd__and4_2
X_1149_ _1061_/A _1392_/A _1149_/X _1093_/A _1089_/Y VPWR VGND VGND VPWR sky130_fd_sc_hd__a22o_2
XFILLER_29_64 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_154 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_6 _1679_/Q VGND VPWR VPWR VGND sky130_fd_sc_hd__diode_2
XFILLER_3_261 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_68 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_79 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1003_ _1003_/C _1638_/Q _1004_/C _1752_/A _1653_/Q VPWR VGND VGND VPWR sky130_fd_sc_hd__or4b_2
X_1698_ _1698_/Q fanout181/X _1698_/D _1714_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
XFILLER_31_10 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xoutput54 VPWR VGND nmatrix_row_out_n[2] _1722_/A VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput10 VPWR VGND conv_finished_out _1624_/Q VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput43 VPWR VGND nmatrix_col_out_n[6] _1142_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput21 VPWR VGND nmatrix_col_out_n[15] _1158_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput32 VPWR VGND nmatrix_col_out_n[25] _1174_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput65 VPWR VGND nmatrix_rowon_out_n[12] _1733_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput76 VPWR VGND nmatrix_rowon_out_n[9] _1730_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput87 VPWR VGND pmatrix_col_out_n[16] _1096_/Y VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput98 VPWR VGND pmatrix_col_out_n[26] _1122_/Y VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_48_279 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1552_ VPWR VGND _1707_/Q _1552_/X _1558_/B VGND VPWR sky130_fd_sc_hd__and2_2
X_1621_ _1621_/Q fanout183/X _1621_/D _1711_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_1483_ _1567_/B _1483_/A _1483_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_8
XFILLER_26_10 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_102 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_179 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_249 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_0983_ _1618_/Q _0983_/Y _0982_/A _0835_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ai_2
X_1535_ _1535_/B _1535_/Y _1535_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_1604_ VGND VPWR _1606_/S input3/X _1712_/Q _1605_/A VGND VPWR sky130_fd_sc_hd__mux2_1
X_1397_ _1397_/B _1724_/A _1397_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_1466_ VGND VPWR _1468_/S _0990_/A _1653_/Q _1467_/A VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_33_219 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1320_ _1320_/Y _1673_/Q _1567_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_1251_ _1488_/A _1515_/S _1707_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__xor2_4
X_1182_ _1046_/X _1135_/Y _1182_/X _1097_/X _1181_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__a22o_2
XFILLER_17_293 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_0966_ _0966_/C _0966_/Y _1615_/Q _0966_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nor3_2
X_0897_ _0898_/C _0859_/C _0859_/B _0859_/A _0878_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__a211o_2
X_1518_ VPWR VGND _1703_/Q _1518_/X _1558_/B VGND VPWR sky130_fd_sc_hd__and2_2
X_1449_ VGND VPWR _1643_/D _1449_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_2_189 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_57 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_0751_ VGND VPWR _1697_/D _0751_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_0820_ VGND VPWR _0820_/S _1699_/Q input2/X _0820_/X VGND VPWR sky130_fd_sc_hd__mux2_1
X_1303_ VGND VPWR _1543_/A _1668_/Q _1303_/B VGND VPWR sky130_fd_sc_hd__xnor2_2
X_1234_ _1235_/B _1654_/Q _1700_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
XFILLER_49_193 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1096_ _1096_/Y _1081_/X _1064_/X _1018_/X _1095_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__a31oi_4
X_1165_ _1081_/X _1164_/Y _1165_/X _1097_/X _1102_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__a22o_2
XFILLER_20_233 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_0949_ _0959_/C _0949_/X _0949_/A VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
X_0803_ VGND VPWR _0810_/B _1646_/Q _1645_/Q VGND VPWR sky130_fd_sc_hd__xnor2_2
X_0734_ _0734_/Y _1712_/Q _1714_/Q _1713_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__nand3b_2
X_1217_ _1658_/Q _1218_/D _1704_/Q VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
X_1079_ _1079_/B _1079_/Y _1413_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_1148_ _1146_/X _1148_/X _1147_/X _1064_/X _1093_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o22a_2
XFILLER_29_10 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_141 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_20 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_7 _1148_/X VGND VPWR VPWR VGND sky130_fd_sc_hd__diode_2
XFILLER_3_273 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1002_ VPWR VGND _1620_/Q _1386_/B _1002_/B VGND VPWR sky130_fd_sc_hd__and2_2
XFILLER_34_166 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
X_1697_ _1697_/Q fanout181/X _1697_/D _1714_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
XFILLER_40_136 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xoutput55 VPWR VGND nmatrix_row_out_n[3] _1723_/A VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput44 VPWR VGND nmatrix_col_out_n[7] _1143_/X VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_0_276 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xoutput99 VPWR VGND pmatrix_col_out_n[27] _1124_/Y VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput11 VPWR VGND enable_loop_out _1753_/A VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput77 VPWR VGND pmatrix_bincap_out_n[0] _0817_/A VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput33 VPWR VGND nmatrix_col_out_n[26] _1177_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput88 VPWR VGND pmatrix_col_out_n[17] _1100_/Y VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput66 VPWR VGND nmatrix_rowon_out_n[13] _1734_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput22 VPWR VGND nmatrix_col_out_n[16] _1159_/X VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_31_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1482_ VGND VPWR _1550_/A _1658_/D _1656_/D _1482_/X VGND VPWR sky130_fd_sc_hd__mux2_1
X_1551_ _1551_/X _1665_/D _1566_/A _1522_/B _1550_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__a211o_2
X_1620_ _1620_/Q fanout183/X _1620_/D _1711_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
XFILLER_10_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1749_ VGND VPWR _1749_/X _1749_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_26_22 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_15 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
X_0982_ _0990_/B _0982_/A _0982_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__or2_4
X_1534_ _1534_/X _1534_/C _1707_/Q _1661_/Q _1534_/D VGND VPWR VGND VPWR sky130_fd_sc_hd__and4_2
X_1603_ _1711_/Q _1602_/B _1711_/D _1014_/B _1602_/Y VPWR VGND VGND VPWR sky130_fd_sc_hd__a22o_2
X_1465_ VGND VPWR _1651_/D _1465_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1396_ _1429_/C _1397_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__buf_8
XFILLER_50_253 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_10 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1250_ _1515_/S _1567_/A _1249_/Y _1248_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__o21ai_4
X_1181_ _1181_/X _1046_/A _1089_/Y _1061_/A _1081_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
X_0965_ _0966_/B _0965_/Y _0966_/C _0962_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ai_2
X_0896_ _0898_/B _0878_/C _0859_/B _0878_/B _0859_/C VGND VPWR _0859_/A VGND VPWR
+ sky130_fd_sc_hd__a221o_2
X_1517_ _1516_/X _1515_/X _1535_/B _1659_/D _1351_/B _1517_/X VGND VPWR VGND VPWR
+ sky130_fd_sc_hd__o2111a_2
X_1448_ VGND VPWR _1460_/S _1643_/Q _1644_/Q _1449_/A VGND VPWR sky130_fd_sc_hd__mux2_1
X_1379_ _1379_/B _1636_/D _1382_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
XFILLER_2_124 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_253 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_0750_ VPWR VGND _0768_/A _0751_/A _0750_/B VGND VPWR sky130_fd_sc_hd__and2_2
X_1302_ _1667_/Q _1666_/Q _1290_/Y _1272_/S _1309_/B _1303_/B VGND VPWR VGND VPWR
+ sky130_fd_sc_hd__o2111a_2
X_1233_ _1662_/D _1233_/B _1708_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__xnor2_4
X_1164_ _1164_/Y _1164_/A _1413_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_1095_ VPWR VGND _1095_/X _1095_/A VGND VPWR sky130_fd_sc_hd__buf_6
X_0948_ _0948_/C _0951_/B _0948_/A _0959_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__nor3_2
X_0879_ _0898_/A _0878_/A _0878_/B _0878_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__a21o_2
XFILLER_28_301 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_238 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_304 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0802_ _1647_/Q _0909_/B _1648_/Q VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
X_0733_ _1692_/Q _1691_/Q _1690_/Q _0771_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__and3_4
X_1216_ _1218_/C _1704_/Q _1658_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
XFILLER_29_109 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1078_ _1044_/A _1087_/B _1171_/B _1078_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__a21oi_2
X_1147_ _1097_/A _1171_/B _1051_/X _1147_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o21a_2
XFILLER_31_307 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_8 _1150_/X VGND VPWR VPWR VGND sky130_fd_sc_hd__diode_2
XFILLER_19_142 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_164 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_186 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1001_ _1001_/B _1620_/D _1606_/S VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_1696_ _1696_/Q fanout181/X _1696_/D _1714_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_4
Xoutput23 VPWR VGND nmatrix_col_out_n[17] _1161_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput12 VPWR VGND nmatrix_bincap_out_n[0] _0817_/Y VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput34 VPWR VGND nmatrix_col_out_n[27] _1180_/Y VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput67 VPWR VGND nmatrix_rowon_out_n[14] _1735_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput45 VPWR VGND nmatrix_col_out_n[8] _1144_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput89 VPWR VGND pmatrix_col_out_n[18] _1103_/Y VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput78 VPWR VGND pmatrix_bincap_out_n[1] _1016_/Y VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput56 VPWR VGND nmatrix_row_out_n[4] _1724_/A VGND VPWR sky130_fd_sc_hd__buf_4
X_1481_ _1675_/D _1480_/X _1351_/B _1479_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__a21o_2
X_1550_ VPWR VGND _1550_/A _1550_/X _1667_/D VGND VPWR sky130_fd_sc_hd__and2_2
X_1748_ VGND VPWR _1748_/X _1748_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1679_ _1679_/Q fanout172/X _1679_/D _1679_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
XFILLER_36_229 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_0981_ _0980_/Y _0975_/S _0985_/B _0985_/A _1390_/A VPWR VGND VGND VPWR sky130_fd_sc_hd__o211a_2
XFILLER_12_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1602_ _1602_/B _1602_/Y _1606_/S VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_1533_ _1248_/B _1248_/C _1533_/X _1532_/X _1531_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__a22o_2
X_1395_ _1429_/D _1171_/B _1427_/A _1723_/A _1429_/C VPWR VGND VGND VPWR sky130_fd_sc_hd__a211oi_4
X_1464_ VGND VPWR _1468_/S _0979_/A _0990_/A _1465_/A VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_27_218 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_265 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_99 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_251 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1180_ _1179_/Y _1178_/Y _1164_/A _1180_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__a21oi_2
X_0964_ VGND VPWR _0931_/B _0962_/X _0966_/C _0964_/X _0931_/C VGND VPWR sky130_fd_sc_hd__a2bb2o_2
X_1516_ _1538_/C _1516_/X _1663_/D VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
X_0895_ VPWR VGND _0895_/A _0895_/X _0945_/A VGND VPWR sky130_fd_sc_hd__and2_2
X_1378_ VPWR VGND _1379_/B _1378_/B _1636_/Q VGND VPWR sky130_fd_sc_hd__xor2_2
X_1447_ VGND VPWR _1642_/D _1447_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_2_136 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_243 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_265 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1301_ VPWR VGND _1667_/D _1301_/A VGND VPWR sky130_fd_sc_hd__buf_2
X_1232_ _1531_/B _1233_/B _1232_/B _1232_/C VPWR VGND VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_49_162 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1163_ VGND VPWR _1163_/X _1163_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1094_ _1093_/X _1075_/Y _1018_/X _1094_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__a21oi_2
XFILLER_52_305 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_0947_ _0959_/C _0951_/A _0949_/A _0948_/C VPWR VGND VGND VPWR sky130_fd_sc_hd__and3_2
X_0878_ _0878_/B _0901_/C _0878_/A _0878_/C VPWR VGND VGND VPWR sky130_fd_sc_hd__and3_2
XFILLER_11_246 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_110 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_0801_ _0854_/B _0926_/B _0805_/C _0814_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__or3_2
X_0732_ _0732_/X _0731_/X _0730_/X _1693_/Q _1692_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__a211o_2
X_1215_ _1218_/B _1705_/Q _1659_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_1146_ _1392_/A _1036_/X _1076_/B _1146_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o21a_2
X_1077_ _1074_/Y _1077_/Y _1076_/X _1036_/X _1157_/B _1075_/Y VPWR VGND VGND VPWR
+ sky130_fd_sc_hd__a221oi_4
XFILLER_45_44 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_9 _1137_/X VGND VPWR VPWR VGND sky130_fd_sc_hd__diode_2
X_1000_ VGND VPWR _1001_/B _1620_/Q _1000_/B VGND VPWR sky130_fd_sc_hd__xnor2_2
XFILLER_34_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1695_ _1695_/Q fanout181/X _1695_/D _1695_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
XFILLER_25_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1129_ _1130_/B _1141_/A _1139_/C _1095_/X _1157_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__o31a_2
XFILLER_40_116 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_24 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xoutput24 VPWR VGND nmatrix_col_out_n[18] _1163_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput57 VPWR VGND nmatrix_row_out_n[5] _1725_/A VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput13 VPWR VGND nmatrix_bincap_out_n[1] _1016_/A VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput46 VPWR VGND nmatrix_col_out_n[9] _1145_/Y VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput35 VPWR VGND nmatrix_col_out_n[28] _1182_/X VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_48_249 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xoutput68 VPWR VGND nmatrix_rowon_out_n[1] _1722_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput79 VPWR VGND pmatrix_bincap_out_n[2] _0870_/A VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_16_135 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_301 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1480_ _1530_/B _1480_/X _1675_/Q _1530_/C VPWR VGND VGND VPWR sky130_fd_sc_hd__and3_2
XFILLER_30_182 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1678_ _1678_/Q fanout171/X _1678_/D _1689_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_7_92 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1747_ VGND VPWR _1747_/X _1747_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_26_35 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_120 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_0980_ _0992_/A _0980_/Y _1618_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_1532_ _1532_/A _1707_/Q _1661_/Q _1532_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__or3b_2
X_1601_ VGND VPWR _1602_/B _1001_/B _1600_/X _1710_/D _1710_/Q VGND VPWR sky130_fd_sc_hd__a2bb2o_2
X_1394_ _1427_/A _1415_/A _1429_/C _1722_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nor3_4
X_1463_ VGND VPWR _1650_/D _1463_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_35_252 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_277 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_208 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_123 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_263 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_0963_ _0966_/C _0963_/C _1617_/Q _0963_/B _0963_/D VGND VPWR VGND VPWR sky130_fd_sc_hd__and4_2
X_0894_ _0945_/A _0900_/A _0900_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__or2_4
X_1515_ VGND VPWR _1515_/S _1514_/X _1513_/X _1515_/X VGND VPWR sky130_fd_sc_hd__mux2_1
X_1377_ _1378_/B _1635_/Q _1377_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_1446_ VGND VPWR _1460_/S _1642_/Q _1643_/Q _1447_/A VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_23_277 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_277 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1300_ VGND VPWR _1565_/B _1298_/Y _1297_/X _1301_/A VGND VPWR sky130_fd_sc_hd__mux2_1
X_1231_ _1662_/Q _1270_/B _1535_/A _1232_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__a21oi_2
X_1162_ _1099_/X _1097_/A _1163_/A _1105_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ba_2
X_1093_ VPWR VGND _1093_/X _1093_/A VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_9_281 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_0946_ _1021_/A _0985_/A _0942_/Y _0945_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__mux2_4
X_0877_ _0854_/X _0878_/C _0875_/X _0926_/B _0876_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__o22a_2
X_1429_ _1429_/C _1429_/A _1430_/A _1429_/B _1429_/D VPWR VGND VGND VPWR sky130_fd_sc_hd__or4_2
XFILLER_7_207 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_258 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_46 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_24 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_34 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_0800_ _1648_/Q _1647_/Q _0814_/C VPWR VGND VGND VPWR sky130_fd_sc_hd__or2b_2
X_0731_ _0824_/S _0731_/X _1691_/Q VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
XFILLER_34_3 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1214_ _1704_/Q _1658_/Q _1214_/X _1659_/Q _1705_/Q VPWR VGND VGND VPWR sky130_fd_sc_hd__a22o_2
X_1145_ _1078_/Y _1071_/Y _1164_/A _1145_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__a21oi_2
X_1076_ VPWR VGND _1139_/C _1076_/X _1076_/B VGND VPWR sky130_fd_sc_hd__and2_2
XFILLER_20_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_0929_ _0932_/A _0929_/X _0933_/S VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
XFILLER_45_89 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_67 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_169 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1694_ _1694_/Q fanout179/X _1694_/D _1714_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_25_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1128_ _1412_/A _1044_/Y _1128_/X _1035_/X _1127_/Y VPWR VGND VGND VPWR sky130_fd_sc_hd__a22o_2
X_1059_ VPWR VGND _1061_/A _1101_/B VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput14 VPWR VGND nmatrix_bincap_out_n[2] _0871_/B VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput25 VPWR VGND nmatrix_col_out_n[19] _1165_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput47 VPWR VGND nmatrix_row_out_n[10] _1730_/A VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput36 VPWR VGND nmatrix_col_out_n[29] _1184_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput58 VPWR VGND nmatrix_row_out_n[6] _1726_/A VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput69 VPWR VGND nmatrix_rowon_out_n[2] _1723_/X VGND VPWR sky130_fd_sc_hd__buf_4
XPHY_0 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1746_ VGND VPWR _1746_/X _1746_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1677_ _1677_/Q fanout171/X _1677_/D _1683_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_29_294 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1531_ _1532_/A _1661_/Q _1531_/X _1531_/B _1707_/Q VPWR VGND VGND VPWR sky130_fd_sc_hd__or4b_2
X_1600_ _1602_/B _1600_/X _1637_/Q VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
X_1462_ VGND VPWR _1468_/S _0993_/B _0979_/A _1463_/A VGND VPWR sky130_fd_sc_hd__mux2_1
X_1393_ _1429_/D _1415_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__buf_8
X_1729_ VGND VPWR _1729_/X _1729_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_17_275 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0893_ _0895_/A _0900_/A _0900_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_0962_ _1616_/Q _0962_/X _1615_/Q VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
X_1514_ _1542_/B _1514_/X _1707_/Q VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
X_1445_ VGND VPWR _1641_/D _1445_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1376_ _1376_/B _1635_/D _1382_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
XFILLER_23_15 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_56 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_289 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1230_ _1535_/A _1232_/B _1662_/Q _1270_/B VPWR VGND VGND VPWR sky130_fd_sc_hd__and3_2
X_1092_ _1091_/X _1092_/Y _1090_/X _1054_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ai_2
X_1161_ _1093_/X _1101_/X _1161_/X _1097_/X _1160_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__a22o_2
XFILLER_20_248 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_293 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_0945_ _0945_/X _0949_/A _0945_/A _0948_/A _0959_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__and4_2
X_0876_ VGND VPWR _0876_/Y _1644_/Q _1643_/Q VGND VPWR sky130_fd_sc_hd__xnor2_2
X_1428_ VGND VPWR _1749_/A _1428_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_18_15 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1359_ VPWR VGND _1360_/B _1359_/B _1630_/Q VGND VPWR sky130_fd_sc_hd__xor2_2
XFILLER_50_46 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_80 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0730_ _0730_/X _1690_/Q _1691_/Q _0824_/S VGND VPWR VGND VPWR sky130_fd_sc_hd__a21o_2
X_1213_ _1659_/Q _1218_/A _1705_/Q VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
X_1144_ _1093_/X _1074_/Y _1144_/X _1157_/B _1075_/Y VPWR VGND VGND VPWR sky130_fd_sc_hd__a22o_2
X_1075_ _1075_/Y _1164_/A _1095_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_8
XFILLER_37_178 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_0928_ _0932_/A _0959_/B _1614_/Q _0927_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__a21o_2
X_0859_ _0859_/B _0901_/A _0859_/A _0859_/C VPWR VGND VGND VPWR sky130_fd_sc_hd__and3_2
XFILLER_28_134 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_181 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_93 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1693_ _1693_/Q fanout179/X _1693_/D _1712_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1127_ _1095_/X _1127_/Y _1087_/B _1036_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ai_2
X_1058_ _1141_/A _1058_/X _1139_/C _1079_/B VPWR VGND VGND VPWR sky130_fd_sc_hd__or3_4
Xoutput48 VPWR VGND nmatrix_row_out_n[11] _1731_/A VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput26 VPWR VGND nmatrix_col_out_n[1] _1133_/Y VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput15 VPWR VGND nmatrix_col_out_n[0] _1034_/B VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput59 VPWR VGND nmatrix_row_out_n[7] _1727_/A VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput37 VPWR VGND nmatrix_col_out_n[2] _1134_/X VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_16_148 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_218 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_159 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_1 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1745_ VGND VPWR _1745_/X _1745_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_15_181 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1676_ _1676_/Q fanout171/X _1676_/D _1689_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_1530_ _1530_/B _1530_/X _1683_/Q _1530_/C VPWR VGND VGND VPWR sky130_fd_sc_hd__and3_2
X_1392_ _1392_/A _1429_/C _1721_/A _1429_/D _1427_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nor4_4
X_1461_ VGND VPWR _1649_/D _1461_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_2_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1728_ VGND VPWR _1728_/X _1728_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1659_ _1659_/Q fanout173/X _1659_/D _1683_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
XFILLER_5_169 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_221 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_0961_ _0985_/A _0985_/B _0974_/A _1023_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nor3_4
X_0892_ _0856_/X _0900_/B _0926_/C _0857_/X _0926_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__o22a_2
X_1375_ VGND VPWR _1376_/B _1635_/Q _1377_/B VGND VPWR sky130_fd_sc_hd__xnor2_2
X_1513_ _1522_/B _1550_/A _1707_/Q _1513_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__or3b_2
X_1444_ VGND VPWR _1444_/S _1642_/Q _1641_/Q _1445_/A VGND VPWR sky130_fd_sc_hd__mux2_1
X_1091_ _1091_/X _1093_/A _1429_/A _1139_/A _1157_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
X_1160_ _1160_/X _1036_/X _1051_/X _1061_/A _1046_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
XFILLER_9_261 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_205 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_0944_ _0949_/A _1616_/Q _0966_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_0875_ _0875_/C _0875_/A _0875_/X _0875_/B _0875_/D VPWR VGND VGND VPWR sky130_fd_sc_hd__or4_2
X_1358_ _1359_/B _1628_/Q _1629_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_1427_ _1427_/A _1429_/C _1428_/A _1429_/D VGND VPWR VGND VPWR sky130_fd_sc_hd__or3_2
X_1289_ _1290_/B _1665_/Q _1711_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
XFILLER_46_124 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_220 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_253 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1212_ _1531_/B _1433_/S VGND VPWR VGND VPWR sky130_fd_sc_hd__buf_8
XFILLER_45_190 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1143_ _1093_/X _1049_/X _1143_/X _1064_/X _1065_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__a22o_2
X_1074_ _1074_/Y _1164_/A _1095_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_4
X_0927_ _0926_/X _0927_/Y _0856_/X _0857_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ai_2
X_0789_ _1003_/C _0875_/B _0789_/X _0833_/D VGND VPWR VGND VPWR sky130_fd_sc_hd__or3_2
X_0858_ _0854_/X _0859_/C _0856_/X _0926_/B _0857_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o22a_2
XFILLER_29_37 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_193 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1692_ _1692_/Q fanout179/X _1692_/D _1712_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_1126_ _1183_/B _1022_/Y _1054_/X _1126_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__a21oi_4
XFILLER_25_127 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1057_ _1049_/X _1057_/Y _1022_/Y _1056_/X _1054_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o22ai_4
XFILLER_0_248 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xoutput38 VPWR VGND nmatrix_col_out_n[30] _1186_/Y VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput49 VPWR VGND nmatrix_row_out_n[12] _1732_/A VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput27 VPWR VGND nmatrix_col_out_n[20] _1167_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput16 VPWR VGND nmatrix_col_out_n[10] _1148_/X VGND VPWR sky130_fd_sc_hd__buf_4
XPHY_100 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_93 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_2 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1744_ VGND VPWR _1744_/X _1744_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_30_163 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1675_ _1675_/Q fanout171/X _1675_/D _1689_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_38_263 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1109_ _1046_/A _1036_/X _1079_/B _1109_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o21a_2
XFILLER_29_274 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1460_ VGND VPWR _1460_/S _1649_/Q _0993_/B _1461_/A VGND VPWR sky130_fd_sc_hd__mux2_1
X_1391_ _1429_/D _1391_/B _1619_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__xor2_4
XFILLER_35_277 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1727_ VGND VPWR _1727_/X _1727_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_12_29 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1658_ _1658_/Q fanout173/X _1658_/D _1683_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1589_ VGND VPWR _1704_/D _1589_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_0960_ VPWR VGND _0985_/B _0960_/A VGND VPWR sky130_fd_sc_hd__buf_4
X_1512_ _1549_/B _1512_/X _1665_/D VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
X_0891_ _0909_/B _1646_/Q _1645_/Q _0926_/C VPWR VGND VGND VPWR sky130_fd_sc_hd__or3b_2
X_1374_ VPWR VGND _1634_/Q _1377_/B _1374_/B VGND VPWR sky130_fd_sc_hd__and2_2
X_1443_ VGND VPWR _1640_/D _1443_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_48_14 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1090_ _1090_/X _1157_/A _1429_/A _1036_/X _1089_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__o31a_2
XFILLER_9_273 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_0943_ _0943_/B _0948_/A _0943_/A VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
X_0874_ _0878_/B _0874_/A _0874_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_1357_ _1357_/B _1629_/D _1382_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_1288_ _1665_/D _1539_/B _1711_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__xor2_4
X_1426_ _1748_/A _1415_/A _1049_/X _1397_/B _1427_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__a211o_2
XFILLER_34_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_265 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1142_ _1142_/X _1061_/X _1412_/A _1141_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__a21o_2
X_1211_ _1658_/D _1211_/B _1704_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__xor2_4
XFILLER_52_117 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1073_ _1101_/C _1095_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__buf_8
X_0857_ _1003_/C _0857_/X _0875_/B _1004_/B VPWR VGND VGND VPWR sky130_fd_sc_hd__or3_4
X_0926_ _0943_/A _0926_/B _0926_/X _0926_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__or3_2
X_1409_ _1739_/A _1732_/A VPWR VGND VGND VPWR sky130_fd_sc_hd__inv_2
XFILLER_29_49 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_0788_ _1642_/Q _1644_/Q _1641_/Q _1649_/Q _0833_/D VPWR VGND VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_16_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_161 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1691_ _1691_/Q fanout179/X _1691_/D _1712_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1125_ _1053_/A _1101_/B _1141_/B _1051_/A _1095_/A _1183_/B VGND VPWR VGND VPWR
+ sky130_fd_sc_hd__o41a_4
X_1056_ _1139_/C _1056_/X _1429_/A _1141_/A _1051_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o22a_2
Xoutput17 VPWR VGND nmatrix_col_out_n[11] _1150_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput28 VPWR VGND nmatrix_col_out_n[21] _1169_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput39 VPWR VGND nmatrix_col_out_n[31] _1130_/B VGND VPWR sky130_fd_sc_hd__buf_4
X_0909_ _1645_/Q _0909_/B _1646_/Q _0909_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__or3b_2
XFILLER_12_301 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_101 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_3 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1674_ _1674_/Q fanout171/X _1674_/D _1689_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_1743_ VGND VPWR _1743_/X _1743_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1039_ VPWR VGND _1413_/A _1429_/A VGND VPWR sky130_fd_sc_hd__buf_6
X_1108_ _1104_/X _1108_/Y _1107_/X _1054_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ai_2
Xadc_core_digital_193 nmatrix_c0_out_n adc_core_digital_193/HI VPWR VGND VGND VPWR
+ sky130_fd_sc_hd__conb_1
XFILLER_44_223 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1390_ _1390_/A _1391_/B _1390_/B _1390_/C VPWR VGND VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_50_215 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_289 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1726_ VGND VPWR _1726_/X _1726_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1657_ _1657_/Q fanout172/X _1657_/D _1679_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1588_ VGND VPWR _1622_/D _1614_/D _1704_/Q _1589_/A VGND VPWR sky130_fd_sc_hd__mux2_1
X_0890_ _1614_/Q _0900_/A VPWR VGND VGND VPWR sky130_fd_sc_hd__inv_2
X_1511_ _1680_/D _1510_/X _1509_/X _1351_/B _1508_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
X_1442_ VGND VPWR _1444_/S _1641_/Q _1640_/Q _1443_/A VGND VPWR sky130_fd_sc_hd__mux2_1
X_1373_ _1373_/B _1634_/D _1382_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_1709_ _1709_/Q fanout177/X _1709_/D _1384_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
XFILLER_49_123 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_281 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_0942_ _0948_/C _0942_/Y _0959_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_0873_ _1613_/Q _0878_/A VPWR VGND VGND VPWR sky130_fd_sc_hd__inv_2
X_1425_ VPWR VGND _1747_/A _1425_/A VGND VPWR sky130_fd_sc_hd__buf_2
X_1356_ VGND VPWR _1357_/B _1628_/Q _1629_/Q VGND VPWR sky130_fd_sc_hd__xnor2_2
X_1287_ _1534_/C _1287_/B _1287_/C _1539_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__and3_4
XFILLER_18_29 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_277 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1210_ _1210_/B _1211_/B _1534_/C _1210_/C VPWR VGND VGND VPWR sky130_fd_sc_hd__and3_2
X_1141_ _1141_/A _1141_/B _1141_/X _1141_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__or3_2
XFILLER_49_91 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1072_ _1171_/A _1046_/X _1072_/X _1035_/X _1071_/Y VPWR VGND VGND VPWR sky130_fd_sc_hd__a22o_2
X_0787_ _0875_/D _1004_/A _0875_/C VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
X_0925_ _0933_/S _0925_/Y _0920_/X _0919_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ai_2
X_0856_ _0875_/D _1652_/Q _0856_/X _0993_/B _0856_/D VPWR VGND VGND VPWR sky130_fd_sc_hd__or4_2
X_1408_ _1739_/A _1405_/X _1415_/A _1731_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__a21oi_4
X_1339_ _1339_/X _1337_/X _1483_/A _1338_/Y _1634_/Q VGND VPWR _1632_/Q VGND VPWR
+ sky130_fd_sc_hd__a221o_2
XFILLER_28_126 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1690_ _1690_/Q _1690_/D VPWR fanout179/X _1712_/CLK VGND VGND VPWR sky130_fd_sc_hd__dfstp_4
X_1124_ _1046_/X _1124_/Y _1022_/Y _1123_/X _1054_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o22ai_4
X_1055_ _1049_/X _1055_/Y _1022_/Y _1052_/X _1054_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o22ai_4
Xoutput18 VPWR VGND nmatrix_col_out_n[12] _1152_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput29 VPWR VGND nmatrix_col_out_n[22] _1170_/Y VGND VPWR sky130_fd_sc_hd__buf_4
X_0839_ _0839_/B _0841_/B _1640_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_0908_ _0837_/B _0931_/B _0854_/X _0982_/A _0926_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__o22a_2
XFILLER_24_151 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_102 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_4 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1673_ _1673_/Q fanout175/X _1673_/D _1686_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_1742_ VGND VPWR _1742_/X _1742_/A VGND VPWR sky130_fd_sc_hd__buf_1
Xadc_core_digital_194 nmatrix_row_out_n[0] adc_core_digital_194/HI VPWR VGND VGND
+ VPWR sky130_fd_sc_hd__conb_1
X_1107_ _1046_/A _1107_/X _1051_/X _1157_/A _1093_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__o22a_2
X_1038_ VPWR VGND _1087_/B _1038_/A VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_50_227 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1725_ VGND VPWR _1725_/X _1725_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1656_ _1656_/Q fanout172/X _1656_/D _1679_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_1587_ VGND VPWR _1703_/D _1587_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_26_246 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_271 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_10 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1510_ _1702_/Q _1558_/B _1510_/X _1680_/Q _1352_/B VPWR VGND VGND VPWR sky130_fd_sc_hd__a22o_2
X_1441_ VGND VPWR _1639_/D _1441_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1372_ VGND VPWR _1373_/B _1634_/Q _1374_/B VGND VPWR sky130_fd_sc_hd__xnor2_2
X_1708_ _1708_/Q fanout177/X _1708_/D _1711_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1639_ _1639_/Q fanout181/X _1639_/D _1653_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_0941_ _0948_/C _0931_/Y _0966_/B _1616_/Q VPWR VGND VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_13_293 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_0872_ _1753_/A _0871_/Y _0999_/A _1612_/Q _1612_/D VPWR VGND VGND VPWR sky130_fd_sc_hd__o211a_2
X_1355_ _1530_/B _1530_/C _1382_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_8
X_1424_ _1429_/C _1425_/A _1427_/A VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
X_1286_ _1287_/C _1665_/Q _1285_/D _1285_/B _1285_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
XFILLER_40_61 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_289 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_7 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1071_ _1044_/A _1071_/Y _1018_/X _1171_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ai_2
X_1140_ _1097_/A _1022_/Y _1140_/X _1056_/X _1139_/X _1413_/A VGND VPWR VGND VPWR
+ sky130_fd_sc_hd__o221a_2
X_0924_ _0933_/S _0966_/B _1616_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__xor2_4
X_0855_ _1651_/Q _1649_/Q _0856_/D VPWR VGND VGND VPWR sky130_fd_sc_hd__or2b_2
X_0786_ _1641_/Q _1642_/Q _1644_/Q _0813_/A VPWR VGND VGND VPWR sky130_fd_sc_hd__or3b_2
X_1338_ _1338_/Y _1483_/B _1628_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_1407_ VPWR VGND _1413_/C _1407_/A VGND VPWR sky130_fd_sc_hd__buf_2
X_1269_ _1664_/Q _1531_/B _1274_/B _1269_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__or3b_2
XFILLER_36_182 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_182 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1054_ _1097_/A _1054_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__buf_12
X_1123_ _1081_/A _1123_/X _1046_/A _1157_/A _1051_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o22a_2
X_0907_ _1615_/Q _0943_/A VPWR VGND VGND VPWR sky130_fd_sc_hd__inv_2
X_0838_ VPWR VGND _0839_/B _1644_/Q _1642_/Q VGND VPWR sky130_fd_sc_hd__xor2_2
Xoutput19 VPWR VGND nmatrix_col_out_n[13] _1153_/X VGND VPWR sky130_fd_sc_hd__buf_4
X_0769_ VGND VPWR _1693_/D _0769_/A VGND VPWR sky130_fd_sc_hd__buf_1
XPHY_103 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_5 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_93 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_10 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1741_ VGND VPWR _1741_/X _1741_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1672_ _1672_/Q fanout175/X _1672_/D _1686_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1106_ _1105_/X _1104_/X _1054_/X _1106_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__a21oi_4
Xadc_core_digital_195 pmatrix_row_out_n[0] adc_core_digital_195/HI VPWR VGND VGND
+ VPWR sky130_fd_sc_hd__conb_1
X_1037_ _1053_/A _1038_/A _1139_/A VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
XFILLER_16_52 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_233 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_247 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_111 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_203 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_239 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1724_ VGND VPWR _1724_/X _1724_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1655_ _1655_/Q fanout172/X _1655_/D _1683_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1586_ VGND VPWR _1622_/D _1613_/D _1703_/Q _1587_/A VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_40_294 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1371_ _1633_/Q _1374_/B _1632_/Q _1371_/C VPWR VGND VGND VPWR sky130_fd_sc_hd__and3_2
XFILLER_4_22 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1440_ VGND VPWR _1444_/S _1640_/Q _1639_/Q _1441_/A VGND VPWR sky130_fd_sc_hd__mux2_1
X_1707_ _1707_/Q fanout180/X _1707_/D _1707_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1638_ _1638_/Q fanout180/X _1638_/D _1707_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_1569_ VGND VPWR _1687_/D _1568_/X _1563_/X _1671_/D _1522_/B _1567_/C VGND VPWR
+ sky130_fd_sc_hd__a311o_2
XFILLER_46_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_198 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_169 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_0940_ _0959_/C _0940_/B _1617_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__xnor2_4
X_0871_ _0871_/Y _0999_/A _0871_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_1354_ VPWR VGND _1530_/C _1497_/B VGND VPWR sky130_fd_sc_hd__buf_6
X_1285_ _1285_/B _1665_/Q _1287_/B _1285_/D _1285_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__nand4_2
X_1423_ _1398_/X _1412_/B _1746_/A _1427_/A _1397_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_48_191 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_253 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1070_ _1171_/A _1046_/X _1070_/X _1035_/X _1069_/Y VPWR VGND VGND VPWR sky130_fd_sc_hd__a22o_2
X_0854_ _1647_/Q _0854_/B _1648_/Q _0854_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__or3b_2
X_0923_ _0922_/X _0997_/A _0966_/B _0926_/B _0921_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__a2bb2o_4
X_0785_ _0875_/B _0785_/X _1003_/C VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
X_1337_ _1628_/Q _1337_/X _1483_/B VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
X_1268_ _1708_/Q _1274_/B _1663_/Q _1662_/Q _1709_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__o22a_2
X_1406_ _1406_/B _1407_/A _1406_/A _1406_/C VPWR VGND VGND VPWR sky130_fd_sc_hd__and3_2
X_1199_ _1199_/B _1201_/B _1656_/Q _1199_/C VPWR VGND VGND VPWR sky130_fd_sc_hd__and3_2
XFILLER_19_52 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_153 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_84 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_271 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1122_ _1061_/X _1058_/X _1046_/X _1122_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__a21oi_2
XFILLER_21_304 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1053_ VPWR VGND _1097_/A _1053_/A VGND VPWR sky130_fd_sc_hd__buf_6
X_0906_ _1753_/A _0905_/Y _0999_/A _1614_/Q _1614_/D VPWR VGND VGND VPWR sky130_fd_sc_hd__o211a_2
X_0837_ _0958_/B _0982_/A _0837_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_8
X_0768_ VPWR VGND _0768_/A _0769_/A _0768_/B VGND VPWR sky130_fd_sc_hd__and2_2
XFILLER_24_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_104 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_64 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_256 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XPHY_6 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_50 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1671_ _1671_/Q fanout175/X _1671_/D _1686_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_1740_ VGND VPWR _1740_/X _1740_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_30_3 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xadc_core_digital_196 adc_core_digital_196/LO nmatrix_rowon_out_n[15] VPWR VGND VGND
+ VPWR sky130_fd_sc_hd__conb_1
X_1105_ _1105_/X _1101_/B _1095_/A _1081_/A _1051_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__o31a_2
X_1036_ VPWR VGND _1036_/X _1139_/C VGND VPWR sky130_fd_sc_hd__buf_6
XFILLER_44_204 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_281 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1654_ _1654_/Q fanout172/X _1654_/D _1683_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1723_ VGND VPWR _1723_/X _1723_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1585_ VGND VPWR _1702_/D _1585_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1019_ VPWR VGND _1019_/A _1020_/A _1019_/B VGND VPWR sky130_fd_sc_hd__and2_2
XFILLER_34_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_303 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_52 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_281 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1370_ _1368_/Y _1352_/B _1369_/X _1633_/D VGND VPWR VGND VPWR sky130_fd_sc_hd__o21a_2
X_1706_ _1706_/Q fanout183/X _1706_/D _1711_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1637_ _1637_/Q _1637_/D VPWR fanout179/X _1714_/CLK VGND VGND VPWR sky130_fd_sc_hd__dfstp_4
X_1568_ VPWR VGND _1568_/X _1311_/B _1568_/D _1568_/C _1568_/B VGND VPWR sky130_fd_sc_hd__and4b_2
X_1499_ _1499_/X _1497_/Y _1678_/Q _1656_/D _1352_/B VGND VPWR _1498_/X VGND VPWR
+ sky130_fd_sc_hd__a221o_2
XFILLER_48_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_3 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_95 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_0870_ _0870_/A _0871_/B VPWR VGND VGND VPWR sky130_fd_sc_hd__inv_2
X_1422_ _1412_/B _1397_/B _1745_/A _1397_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__a21o_4
X_1353_ VPWR VGND _1530_/B _1353_/A VGND VPWR sky130_fd_sc_hd__buf_6
X_1284_ _1284_/A _1285_/D VPWR VGND VGND VPWR sky130_fd_sc_hd__inv_2
X_0999_ _1002_/B _1000_/B _0999_/A _1386_/A VPWR VGND VGND VPWR sky130_fd_sc_hd__and3_2
XFILLER_24_42 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_265 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_85 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_0922_ VPWR VGND _0979_/A _0922_/X _0963_/B VGND VPWR sky130_fd_sc_hd__and2_2
X_0853_ _0837_/B _0859_/B _0860_/B _0982_/A _0860_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__o22a_2
X_1405_ _1405_/B _1405_/X _1429_/A _1405_/C VPWR VGND VGND VPWR sky130_fd_sc_hd__and3_2
X_0784_ VPWR VGND _1003_/C _0784_/A VGND VPWR sky130_fd_sc_hd__buf_6
X_1336_ _1626_/Q _1483_/A VPWR VGND VGND VPWR sky130_fd_sc_hd__inv_2
X_1198_ _1199_/C _1655_/Q _1700_/Q _1701_/Q _1654_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
X_1267_ _1534_/C _1664_/Q _1267_/Y _1290_/C _1275_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand4_2
Xinput1 VGND VPWR input1/X clk_dig_in VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_3_217 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_173 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1052_ _1052_/X _1141_/A _1139_/C _1392_/A _1051_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o31a_2
X_1121_ _1120_/X _1121_/Y _1119_/X _1064_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ai_2
X_0905_ _0905_/Y _0999_/A _1139_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_0767_ VPWR VGND _0768_/B _0771_/C _1693_/Q VGND VPWR sky130_fd_sc_hd__xor2_2
X_0836_ _0837_/B _1652_/Q _0982_/B _0835_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__mux2_4
X_1319_ _1433_/S _1319_/Y _1673_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
XPHY_105 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_10 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_268 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_7 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1670_ _1670_/Q fanout175/X _1670_/D _1686_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
Xadc_core_digital_197 adc_core_digital_197/LO pmatrix_c0_out_n VPWR VGND VGND VPWR
+ sky130_fd_sc_hd__conb_1
X_1104_ _1104_/X _1093_/A _1061_/A _1095_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__a21o_2
X_1035_ VPWR VGND _1035_/X _1164_/A VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_21_113 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_0819_ VPWR VGND _0820_/S _1714_/Q _1712_/Q VGND VPWR sky130_fd_sc_hd__and2b_2
XFILLER_12_135 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_10 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_168 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_20 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
X_1584_ VGND VPWR _1622_/D _1612_/D _1702_/Q _1585_/A VGND VPWR sky130_fd_sc_hd__mux2_1
X_1722_ VGND VPWR _1722_/X _1722_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1653_ _1653_/Q fanout180/X _1653_/D _1653_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_1018_ _1141_/C _1018_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__buf_8
X_1705_ _1705_/Q fanout180/X _1705_/D _1707_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1567_ _1567_/B _1568_/D _1567_/A _1567_/C VPWR VGND VGND VPWR sky130_fd_sc_hd__and3_2
X_1636_ _1636_/Q fanout176/X _1636_/D _1688_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1498_ VPWR VGND _1700_/Q _1498_/X _1561_/B VGND VPWR sky130_fd_sc_hd__and2_2
X_1421_ _1744_/A _1397_/A _1415_/A _1412_/A _1397_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
X_1352_ _1628_/D _1628_/Q _1352_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_1283_ _1282_/X _1710_/Q _1664_/Q _1284_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__a21oi_4
X_0998_ _0985_/A _0975_/S _0985_/B _0997_/Y _1386_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__o211ai_4
X_1619_ _1619_/Q fanout183/X _1619_/D _1711_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
XFILLER_10_277 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_51 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0921_ _0921_/Y _0921_/A _0921_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_0852_ _0851_/Y _0860_/B _0839_/B _1641_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ai_2
X_0783_ _1639_/Q _1640_/Q _0784_/A _1643_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__or3_2
X_1335_ _1522_/B _1628_/Q _1634_/Q _1632_/Q _1626_/Q _1335_/X VGND VPWR VGND VPWR
+ sky130_fd_sc_hd__o32a_2
XFILLER_5_270 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_281 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1404_ _1730_/A _1397_/A _1412_/B _1397_/B VPWR VGND VGND VPWR sky130_fd_sc_hd__o21ai_4
X_1197_ _1199_/B _1701_/Q _1654_/Q _1700_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__a21o_2
X_1266_ _1290_/C _1662_/Q _1708_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
Xinput2 VPWR VGND input2/X comparator_in VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_10_67 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_163 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_8 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1051_ VPWR VGND _1051_/X _1051_/A VGND VPWR sky130_fd_sc_hd__buf_4
X_1120_ _1120_/X _1095_/X _1093_/A _1157_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__a21o_2
X_0904_ _0899_/X _0898_/Y _0895_/X _1139_/A _0985_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__o31ai_4
XFILLER_33_177 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0766_ _0764_/Y _0768_/A _0765_/X _1692_/D VGND VPWR VGND VPWR sky130_fd_sc_hd__o21a_2
X_0835_ _0993_/B _0835_/X _1651_/Q VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
X_1318_ _1318_/B _1672_/D _1433_/S VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_1249_ _1661_/Q _1248_/C _1248_/B _1249_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__a21oi_2
XPHY_8 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xadc_core_digital_198 adc_core_digital_198/LO pmatrix_rowon_out_n[15] VPWR VGND VGND
+ VPWR sky130_fd_sc_hd__conb_1
X_1103_ _1101_/X _1097_/A _1081_/X _1102_/X _1103_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__a22oi_4
X_1034_ _1034_/B _1034_/Y _1183_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
XFILLER_21_169 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_0818_ _1641_/Q _1639_/Q _0875_/A _1640_/Q _1642_/Q VPWR VGND VGND VPWR sky130_fd_sc_hd__or4_2
X_0749_ VPWR VGND _0750_/B _0752_/B _1697_/Q VGND VPWR sky130_fd_sc_hd__xor2_2
XFILLER_29_214 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_291 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_209 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_191 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1721_ VGND VPWR _1721_/X _1721_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_43_294 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1583_ VGND VPWR _1701_/D _1583_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1652_ _1652_/Q fanout180/X _1652_/D _1714_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
XFILLER_26_228 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_209 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1017_ VGND VPWR _1139_/A _1141_/C _1089_/A _1053_/A VGND VPWR sky130_fd_sc_hd__and3b_2
XFILLER_17_239 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_42 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1704_ _1704_/Q fanout173/X _1704_/D _1707_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1635_ _1635_/Q fanout176/X _1635_/D _1688_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1566_ _1568_/C _1566_/A _1566_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_1497_ _1497_/B _1497_/Y _1535_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
XFILLER_14_209 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_64 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1351_ _1352_/B _1561_/B _1351_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_4
X_1420_ _1742_/A _1397_/A _1415_/A _1397_/B _1413_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__o31a_4
X_1282_ _1710_/Q _1282_/X _1274_/A _1664_/Q _1274_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__o22a_2
X_0997_ _0997_/Y _0997_/A _0997_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_1618_ _1618_/Q fanout183/X _1618_/D _1711_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1549_ _1549_/B _1549_/X _1669_/D VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
XFILLER_42_304 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_249 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_245 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_289 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_10 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_301 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_153 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_142 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0920_ _0931_/B _0920_/X _1615_/Q _0931_/C VPWR VGND VGND VPWR sky130_fd_sc_hd__and3_2
X_0851_ _1641_/Q _0851_/Y _1644_/Q _1642_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ai_2
X_0782_ _0782_/C _0782_/D _0782_/Y _1640_/Q _0841_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nor4_2
X_1334_ _1471_/A _1634_/Q _1483_/B _1187_/X _1333_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__a211o_2
XFILLER_5_293 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1265_ _1275_/B _1663_/Q _1709_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_1403_ _1415_/A _1429_/C _1392_/A _1729_/A _1397_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__o31ai_4
Xinput3 VGND VPWR input3/X config_1_in[0] VGND VPWR sky130_fd_sc_hd__buf_1
X_1196_ VPWR VGND _1531_/B _1258_/C VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_18_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1050_ _1089_/B _1051_/A _1089_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_0903_ _0869_/B _0901_/X _0902_/X _0985_/A VPWR VGND VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_33_189 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_0834_ VGND VPWR _0982_/B _0979_/A _0993_/B VGND VPWR sky130_fd_sc_hd__xnor2_2
X_0765_ VGND VPWR _1691_/Q _0765_/X _1692_/Q _1690_/Q VGND VPWR sky130_fd_sc_hd__and3b_2
X_1317_ VGND VPWR _1318_/B _1672_/Q _1317_/B VGND VPWR sky130_fd_sc_hd__xnor2_2
X_1248_ _1248_/B _1248_/X _1661_/Q _1248_/C VPWR VGND VGND VPWR sky130_fd_sc_hd__and3_2
XFILLER_24_178 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_189 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1179_ _1095_/X _1044_/A _1097_/A _1179_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__a21oi_2
XPHY_9 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_64 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1102_ _1102_/X _1081_/A _1089_/Y _1157_/A _1095_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
X_1033_ _1034_/B _1171_/B _1157_/B _1139_/C _1141_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__o31a_4
X_0817_ _0817_/A _0817_/Y VPWR VGND VGND VPWR sky130_fd_sc_hd__inv_2
X_0748_ input2/X _0752_/B _1695_/Q _1696_/Q VPWR VGND VGND VPWR sky130_fd_sc_hd__and3_2
X_1651_ _1651_/Q fanout180/X _1651_/D _1714_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1582_ VGND VPWR _1622_/D _1611_/D _1701_/Q _1583_/A VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_19_281 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1016_ _1016_/A _1016_/Y VPWR VGND VGND VPWR sky130_fd_sc_hd__inv_2
XFILLER_27_66 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_10 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_76 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_254 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
X_1634_ _1634_/Q fanout176/X _1634_/D _1688_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1703_ _1703_/Q fanout173/X _1703_/D _1707_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1496_ VGND VPWR _1567_/B _1495_/X _1662_/D _1496_/X VGND VPWR sky130_fd_sc_hd__mux2_1
X_1565_ VGND VPWR _1566_/B _1667_/Q _1565_/B VGND VPWR sky130_fd_sc_hd__xnor2_2
XFILLER_13_57 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_276 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_232 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1350_ _1497_/B _1351_/B VPWR VGND VGND VPWR sky130_fd_sc_hd__inv_2
X_1281_ _1285_/C _1270_/B _1535_/A _1279_/X _1662_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__a211o_2
X_0996_ _0997_/B _0995_/X _0922_/X _1618_/Q _1619_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
XFILLER_5_91 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1617_ _1617_/Q fanout183/X _1617_/D _1711_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1479_ _1659_/D _1543_/B _1479_/X _1657_/D _1539_/C VPWR VGND VGND VPWR sky130_fd_sc_hd__a22o_2
X_1548_ _1663_/D _1525_/Y _1535_/B _1548_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o21a_2
XFILLER_45_165 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_0850_ _1612_/Q _0859_/A VPWR VGND VGND VPWR sky130_fd_sc_hd__inv_2
X_1402_ _1727_/A _1427_/A _1413_/A _1415_/A _1429_/C VPWR VGND VGND VPWR sky130_fd_sc_hd__a31oi_4
X_0781_ _1644_/Q _0782_/D _1642_/Q VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
X_1333_ _1550_/A _1331_/X _1333_/Y _1326_/X _1329_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o22ai_2
Xinput4 VGND VPWR input4/X config_1_in[1] VGND VPWR sky130_fd_sc_hd__buf_1
X_1264_ VPWR VGND _1663_/D _1264_/A VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_39_3 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1195_ _1189_/X _1187_/X _1636_/Q _1258_/C _1353_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__o31ai_4
XFILLER_24_305 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_0979_ _0982_/A _0979_/A _0992_/A _0993_/B _0990_/A VPWR VGND VGND VPWR sky130_fd_sc_hd__or4b_2
XFILLER_33_113 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_0833_ _0875_/B _0875_/D _1003_/C _0833_/D _0982_/A VPWR VGND VGND VPWR sky130_fd_sc_hd__or4_4
X_0902_ _0902_/X _0901_/D _0898_/C _0898_/A _0898_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
X_0764_ VPWR VGND _1692_/Q _1690_/Q _1691_/Q _0764_/Y VGND VPWR sky130_fd_sc_hd__a21boi_2
X_1316_ VPWR VGND _1671_/D _1316_/A VGND VPWR sky130_fd_sc_hd__buf_2
X_1247_ _1248_/C _1706_/Q _1246_/B _1660_/Q VPWR VGND VGND VPWR sky130_fd_sc_hd__o21ai_4
X_1178_ _1095_/X _1178_/Y _1079_/B _1044_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ai_2
Xoutput160 VPWR VGND sample_switch_out _1752_/X VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_46_10 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1032_ VPWR VGND _1157_/B _1032_/A VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_38_249 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1101_ _1139_/A _1101_/B _1101_/X _1101_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__or3_2
XFILLER_14_190 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_0747_ _0744_/Y _0768_/A _0745_/X _1696_/D VGND VPWR VGND VPWR sky130_fd_sc_hd__o21a_2
X_0816_ _0846_/A _0817_/A _0816_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
XFILLER_29_249 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
X_1581_ VGND VPWR _1700_/D _1581_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1650_ _1650_/Q fanout182/X _1650_/D _1714_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_19_293 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1015_ VGND VPWR _1621_/D _1015_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1633_ _1633_/Q fanout175/X _1633_/D _1686_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_1564_ _1566_/A _1669_/Q _1568_/B _1564_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__or3_2
X_1702_ _1702_/Q fanout172/X _1702_/D _1712_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1495_ VGND VPWR _1550_/A _1660_/D _1658_/D _1495_/X VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_9_237 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_244 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1280_ _1285_/B _1270_/B _1535_/A _1279_/X _1708_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__a211o_2
X_0995_ _0979_/A _0993_/X _0995_/X _0994_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ba_2
X_1547_ _1684_/D _1546_/X _1544_/X _1542_/X _1543_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
X_1616_ _1616_/Q fanout183/X _1616_/D _1384_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1478_ _1522_/B _1539_/C _1566_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
XFILLER_10_214 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_0780_ VGND VPWR _0782_/C _1639_/Q _1643_/Q VGND VPWR sky130_fd_sc_hd__xnor2_2
X_1401_ _1397_/A _1412_/B _1397_/B _1726_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__a21oi_4
X_1332_ VPWR VGND _1550_/A _1625_/Q VGND VPWR sky130_fd_sc_hd__buf_6
X_1194_ VGND VPWR _1654_/D _1700_/Q _1194_/B VGND VPWR sky130_fd_sc_hd__xnor2_2
X_1263_ _1263_/A _1263_/B _1264_/A _1263_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__or3_2
Xinput5 VGND VPWR input5/X config_1_in[2] VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_51_169 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_0978_ _0978_/B _1618_/D _1606_/S VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
XFILLER_50_180 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_77 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_177 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_0832_ _0921_/B _1647_/Q _1648_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__xor2_4
X_0901_ _0901_/C _0901_/A _0901_/X _0901_/B _0901_/D VPWR VGND VGND VPWR sky130_fd_sc_hd__or4_2
X_0763_ VGND VPWR _1691_/D _0763_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1315_ VGND VPWR _1315_/B _1316_/A _1317_/B _1567_/A VGND VPWR sky130_fd_sc_hd__and3b_2
X_1246_ _1248_/B _1660_/Q _1246_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_1177_ _1177_/X _1176_/X _1097_/A _1061_/A _1175_/X VGND VPWR _1171_/Y VGND VPWR
+ sky130_fd_sc_hd__a221o_2
XFILLER_12_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_10 _1088_/X VGND VPWR VPWR VGND sky130_fd_sc_hd__diode_2
Xoutput150 VPWR VGND result_out[2] _1676_/Q VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput161 VPWR VGND sample_switch_out_n _1753_/X VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_46_22 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1031_ _1139_/A _1053_/A _1089_/A _1032_/A VPWR VGND VGND VPWR sky130_fd_sc_hd__or3b_2
X_1100_ _1100_/Y _1099_/X _1097_/X _1098_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o21bai_4
X_0815_ _0782_/Y _0811_/X _0813_/Y _0814_/Y _1610_/Q _0846_/A VGND VPWR VGND VPWR
+ sky130_fd_sc_hd__o41a_4
X_0746_ VPWR VGND _0768_/A _1468_/S VGND VPWR sky130_fd_sc_hd__buf_4
X_1229_ _1228_/X _1218_/X _1226_/X _1209_/B _1270_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_4
XFILLER_7_165 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1580_ VGND VPWR _1622_/D _1610_/D _1700_/Q _1581_/A VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_14_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1014_ VPWR VGND _1753_/A _1015_/A _1014_/B VGND VPWR sky130_fd_sc_hd__and2_2
X_0729_ _1713_/Q _1714_/Q _1712_/Q _0824_/S VPWR VGND VGND VPWR sky130_fd_sc_hd__or3b_2
XFILLER_40_245 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_102 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_253 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1701_ _1701_/Q fanout172/X _1701_/D _1712_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1632_ _1632_/Q fanout176/X _1632_/D _1688_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1494_ _1677_/Q _1352_/B _1677_/D _1493_/X _1488_/Y VPWR VGND VGND VPWR sky130_fd_sc_hd__a22o_2
X_1563_ _1563_/X _1562_/X _1525_/Y _1665_/D _1534_/D VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
XFILLER_13_15 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_249 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_256 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_197 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
X_0994_ _0794_/C _0990_/A _1619_/Q _1618_/Q _0994_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__o211a_2
X_1477_ _1543_/B _1483_/B _1477_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__or2_4
X_1546_ _1546_/X _1545_/X _1530_/C _1684_/Q _1530_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
X_1615_ _1615_/Q fanout183/X _1615_/D _1695_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
XFILLER_45_178 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_123 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1331_ _1634_/Q _1632_/Q _1331_/X _1522_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ba_2
X_1400_ _1429_/D _1412_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__buf_8
X_1193_ _1194_/B _1654_/Q _1567_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_1262_ _1531_/B _1263_/C _1253_/X _1274_/A _1662_/Q _1709_/Q VGND VPWR VGND VPWR
+ sky130_fd_sc_hd__a32o_2
Xinput6 VPWR VGND input6/X config_1_in[3] VGND VPWR sky130_fd_sc_hd__buf_2
X_0977_ VGND VPWR _1101_/C _0957_/Y _0999_/A _0978_/B VGND VPWR sky130_fd_sc_hd__mux2_2
X_1529_ _1682_/D _1528_/X _1526_/X _1523_/Y _1524_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
XFILLER_50_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_90 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_0900_ VGND VPWR _0901_/D _0900_/A _0900_/B VGND VPWR sky130_fd_sc_hd__xnor2_2
X_0831_ _1645_/Q _0921_/A _1646_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_0762_ VPWR VGND _0768_/A _0763_/A _0762_/B VGND VPWR sky130_fd_sc_hd__and2_2
X_1314_ _1315_/B _1671_/Q _1670_/Q _1311_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__a21o_2
X_1245_ _1659_/D _1245_/B _1705_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__xnor2_4
XFILLER_49_281 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
X_1176_ _1176_/X _1095_/A _1139_/C _1051_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__a21o_2
XFILLER_32_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xoutput151 VPWR VGND result_out[3] _1677_/Q VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput140 VPWR VGND pmatrix_rowon_out_n[8] _1744_/X VGND VPWR sky130_fd_sc_hd__buf_4
X_1030_ VPWR VGND _1139_/C _1141_/B VGND VPWR sky130_fd_sc_hd__buf_6
X_0814_ _0814_/C _0814_/Y _0854_/B _0926_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nor3_2
X_0745_ VGND VPWR input2/X _0745_/X _1696_/Q _1695_/Q VGND VPWR sky130_fd_sc_hd__and3b_2
X_1228_ _1228_/X _1707_/Q _1706_/Q _1661_/Q _1660_/Q VGND VPWR _1227_/X VGND VPWR
+ sky130_fd_sc_hd__a221o_2
XFILLER_52_276 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_221 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1159_ _1046_/X _1093_/X _1157_/X _1159_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o21a_2
X_1013_ _1014_/B _1012_/X _1405_/C _0999_/A _1405_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
X_0728_ _1712_/Q _1713_/Q _1714_/Q _0728_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__or3b_2
XFILLER_40_224 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_265 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1631_ _1631_/Q fanout176/X _1631_/D _1688_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1700_ _1700_/Q fanout179/X _1700_/D _1712_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1562_ _1562_/X _1561_/X _1497_/B _1687_/Q _1353_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
X_1493_ _1657_/D _1538_/C _1493_/X _1542_/B _1492_/X _1659_/D VGND VPWR VGND VPWR
+ sky130_fd_sc_hd__o221a_2
XFILLER_38_24 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_268 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_0993_ VPWR VGND _0993_/X _0990_/A _1619_/Q _1618_/Q _0993_/B VGND VPWR sky130_fd_sc_hd__and4b_2
X_1614_ _1614_/Q fanout183/X _1614_/D _1711_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1476_ _1558_/B _1474_/X _1470_/Y _1674_/D VGND VPWR VGND VPWR sky130_fd_sc_hd__a21oi_2
X_1545_ VPWR VGND _1706_/Q _1545_/X _1558_/B VGND VPWR sky130_fd_sc_hd__and2_2
XFILLER_39_143 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_67 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1330_ _1626_/Q _1345_/B _1522_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_8
X_1261_ _1263_/B _1260_/X _1258_/Y _1662_/Q _1253_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
X_1192_ VPWR VGND _1567_/A _1534_/C VGND VPWR sky130_fd_sc_hd__buf_6
Xinput7 VPWR VGND input7/X config_1_in[4] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_44_190 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_0976_ _1023_/A _1023_/B _0975_/X _1101_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__or3b_4
X_1528_ _1528_/X _1527_/X _1530_/C _1682_/Q _1530_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
X_1459_ VGND VPWR _1648_/D _1459_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_51_57 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_0830_ _1753_/A _1752_/A VPWR VGND VGND VPWR sky130_fd_sc_hd__inv_4
XPHY_91 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_80 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_0761_ VPWR VGND _0762_/B _1690_/Q _1691_/Q VGND VPWR sky130_fd_sc_hd__xor2_2
X_1313_ _1317_/B _1272_/S _1290_/Y _1671_/Q _1309_/X _1670_/Q VPWR VGND VGND VPWR
+ sky130_fd_sc_hd__o2111a_4
X_1244_ _1244_/B _1245_/B _1531_/B VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
X_1175_ _1141_/A _1141_/B _1175_/X _1139_/A _1095_/A VPWR VGND VGND VPWR sky130_fd_sc_hd__a22o_2
X_0959_ _0959_/C _0959_/A _0960_/A _0959_/B _0933_/S VPWR VGND VGND VPWR sky130_fd_sc_hd__or4b_2
Xoutput141 VPWR VGND pmatrix_rowon_out_n[9] _1745_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput152 VPWR VGND result_out[4] _1678_/Q VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput130 VPWR VGND pmatrix_rowon_out_n[12] _1748_/X VGND VPWR sky130_fd_sc_hd__buf_4
X_0813_ _0860_/A _0813_/Y _0813_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_0744_ VPWR VGND _1696_/Q input2/X _1695_/Q _0744_/Y VGND VPWR sky130_fd_sc_hd__a21boi_2
X_1227_ _1214_/X _1218_/A _1660_/Q _1706_/Q _1227_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__o211a_2
X_1158_ _1412_/A _1093_/X _1157_/X _1158_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o21a_2
X_1089_ _1089_/Y _1089_/A _1089_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_4
X_1012_ VPWR VGND _1012_/X _1621_/Q _0954_/B VGND VPWR sky130_fd_sc_hd__and2b_2
XFILLER_34_266 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_277 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1630_ _1630_/Q fanout176/X _1630_/D _1688_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1492_ _1655_/D _1351_/B _1535_/B _1492_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o21a_2
X_1561_ VPWR VGND _1709_/Q _1561_/X _1561_/B VGND VPWR sky130_fd_sc_hd__and2_2
XFILLER_38_36 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_80 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0992_ _1002_/B _0992_/A _0992_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_1544_ _1666_/D _1535_/B _1544_/X _1538_/C _1525_/Y _1662_/D VGND VPWR VGND VPWR
+ sky130_fd_sc_hd__o221a_2
X_1613_ _1613_/Q fanout180/X _1613_/D _1707_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_1475_ VPWR VGND _1558_/B _1561_/B VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_39_177 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_188 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_57 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_93 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xinput8 VPWR VGND input8/X config_1_in[5] VGND VPWR sky130_fd_sc_hd__buf_2
X_1191_ _1534_/C _1353_/A _1189_/X _1187_/X _1636_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__o31a_4
X_1260_ _1270_/B _1535_/A _1274_/A _1258_/Y _1708_/Q _1260_/X VGND VPWR VGND VPWR
+ sky130_fd_sc_hd__o2111a_2
X_0975_ VGND VPWR _0975_/S _0974_/Y _0974_/A _0975_/X VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_10_29 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1527_ VPWR VGND _1704_/Q _1527_/X _1558_/B VGND VPWR sky130_fd_sc_hd__and2_2
X_1389_ _1389_/A _1429_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__buf_8
X_1458_ VGND VPWR _1460_/S _1648_/Q _1649_/Q _1459_/A VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_18_136 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0760_ _1690_/D _1690_/Q _0768_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
XPHY_92 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_81 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_70 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1312_ _1312_/B _1670_/D _1433_/S VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_1243_ VGND VPWR _1244_/B _1659_/Q _1243_/B VGND VPWR sky130_fd_sc_hd__xnor2_2
X_1174_ _1174_/X _1061_/X _1046_/X _1141_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__a21o_2
XFILLER_49_250 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_191 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_0889_ VGND VPWR _1613_/D _0889_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_0958_ _0974_/A _0958_/B _1618_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__xnor2_4
Xoutput142 VPWR VGND result_out[0] _1674_/Q VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput120 VPWR VGND pmatrix_row_out_n[3] _1738_/A VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput131 VPWR VGND pmatrix_rowon_out_n[13] _1749_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput153 VPWR VGND result_out[5] _1679_/Q VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_47_209 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_139 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_286 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_0743_ VGND VPWR _1695_/D input2/X _0743_/B VGND VPWR sky130_fd_sc_hd__xnor2_2
X_0812_ _0875_/B _0875_/C _1003_/C _0875_/D _0860_/A VPWR VGND VGND VPWR sky130_fd_sc_hd__or4_4
X_1226_ VPWR VGND _1226_/X _1660_/Q _1706_/Q VGND VPWR sky130_fd_sc_hd__xor2_2
X_1157_ _1157_/B _1157_/X _1157_/A VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
XFILLER_20_164 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1088_ _1086_/Y _1088_/X _1087_/Y _1035_/X _1171_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__o22a_2
XFILLER_32_49 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_164 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1011_ _1397_/A _1728_/A VPWR VGND VGND VPWR sky130_fd_sc_hd__inv_2
X_1209_ _1210_/C _1658_/Q _1209_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
XFILLER_16_289 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1560_ _1686_/D _1559_/X _1557_/X _1525_/Y _1556_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
X_1491_ VPWR VGND _1535_/B _1532_/A VGND VPWR sky130_fd_sc_hd__buf_4
X_1689_ _1689_/Q fanout174/X _1689_/D _1689_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
XFILLER_38_15 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0991_ _1619_/Q _0992_/B _0990_/Y _1618_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ai_2
X_1474_ _1525_/A _1549_/B _1658_/D _1474_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__or3b_2
X_1543_ _1543_/Y _1543_/A _1543_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_1612_ _1612_/Q fanout180/X _1612_/D _1707_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1190_ input8/X _1353_/A input7/X input6/X VPWR VGND VGND VPWR sky130_fd_sc_hd__or3_4
Xinput9 VGND VPWR input9/X rst_n VGND VPWR sky130_fd_sc_hd__buf_1
X_0974_ _0974_/Y _0974_/A _0985_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_1526_ _1660_/D _1666_/D _1526_/X _1535_/B _1525_/Y _1345_/B VGND VPWR VGND VPWR
+ sky130_fd_sc_hd__o221a_2
X_1457_ VGND VPWR _1647_/D _1457_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1388_ VPWR VGND _1406_/B _1389_/A _1406_/C VGND VPWR sky130_fd_sc_hd__and2_2
XFILLER_42_107 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_310 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_60 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_82 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_71 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_93 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1311_ VGND VPWR _1312_/B _1670_/Q _1311_/B VGND VPWR sky130_fd_sc_hd__xnor2_2
X_1242_ _1210_/C _1210_/B _1243_/B _1704_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__a21bo_2
XFILLER_49_262 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1173_ _1173_/X _1171_/Y _1064_/X _1120_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__a21o_2
XFILLER_17_181 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xoutput121 VPWR VGND pmatrix_row_out_n[4] _1739_/A VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput110 VPWR VGND pmatrix_col_out_n[8] _1072_/X VGND VPWR sky130_fd_sc_hd__buf_4
X_0888_ VPWR VGND _1753_/A _0889_/A _0888_/B VGND VPWR sky130_fd_sc_hd__and2_2
Xoutput132 VPWR VGND pmatrix_rowon_out_n[14] _1750_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput143 VPWR VGND result_out[10] _1684_/Q VGND VPWR sky130_fd_sc_hd__buf_4
X_0957_ _1618_/Q _0957_/Y VPWR VGND VGND VPWR sky130_fd_sc_hd__inv_2
Xoutput154 VPWR VGND result_out[6] _1680_/Q VGND VPWR sky130_fd_sc_hd__buf_4
X_1509_ _1535_/B _1509_/X _1658_/D VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
X_0742_ _0743_/B _1695_/Q _1460_/S VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_0811_ _0874_/B _0811_/X _0997_/A _0808_/Y _0993_/B _0874_/A VGND VPWR VGND VPWR
+ sky130_fd_sc_hd__a32o_2
XFILLER_42_3 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1225_ VPWR VGND _1535_/A _1225_/A VGND VPWR sky130_fd_sc_hd__buf_4
X_1087_ _1087_/B _1087_/Y _1413_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_1156_ _1097_/X _1155_/X _1154_/X _1156_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o21a_2
XFILLER_4_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_221 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1010_ VPWR VGND _1743_/A _1427_/A VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_19_265 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1208_ _1209_/B _1210_/B _1658_/Q VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
X_1139_ _1139_/A _1141_/A _1139_/X _1139_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__or3_2
XFILLER_16_235 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_50 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_238 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1490_ _1542_/B _1566_/A _1567_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_1688_ _1688_/Q fanout176/X _1688_/D _1688_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_9_209 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_179 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_253 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1611_ _1611_/Q fanout180/X _1611_/D _1712_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_0990_ _0990_/B _0990_/Y _0990_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_1473_ _1477_/B _1549_/B _1483_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_1542_ _1542_/B _1542_/X _1664_/D VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
XFILLER_24_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_105 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0973_ _0974_/A _1023_/B _0985_/A _0975_/S VPWR VGND VGND VPWR sky130_fd_sc_hd__and3_2
X_1525_ _1525_/A _1525_/Y VPWR VGND VGND VPWR sky130_fd_sc_hd__inv_2
X_1387_ _1406_/C _1620_/Q _1002_/B _1386_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__a21o_2
X_1456_ VGND VPWR _1460_/S _1647_/Q _1648_/Q _1457_/A VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_51_49 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_50 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_94 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_83 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_72 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_61 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_10 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1310_ _1272_/S _1309_/X _1290_/Y _1311_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__o21a_2
X_1241_ _1657_/D _1241_/B _1703_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__xnor2_4
XFILLER_49_274 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1172_ _1172_/X _1171_/Y _1064_/X _1113_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__a21o_2
XFILLER_21_19 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_0956_ VPWR VGND _1606_/S _1752_/A VGND VPWR sky130_fd_sc_hd__buf_6
Xoutput100 VPWR VGND pmatrix_col_out_n[28] _1126_/Y VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput111 VPWR VGND pmatrix_col_out_n[9] _1077_/Y VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput155 VPWR VGND result_out[7] _1681_/Q VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput122 VPWR VGND pmatrix_row_out_n[5] _1740_/A VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput144 VPWR VGND result_out[11] _1685_/Q VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput133 VPWR VGND pmatrix_rowon_out_n[1] _1737_/X VGND VPWR sky130_fd_sc_hd__buf_4
X_0887_ VGND VPWR _0954_/B _1089_/A _1613_/Q _0888_/B VGND VPWR sky130_fd_sc_hd__mux2_1
X_1508_ _1508_/X _1522_/B _1664_/D _1507_/X _1534_/D VGND VPWR VGND VPWR sky130_fd_sc_hd__a211o_2
X_1439_ _1638_/D _1622_/D _1638_/Q _0768_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__a21o_2
XFILLER_14_130 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0810_ _0810_/B _0874_/B _0909_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_0741_ VPWR VGND _1460_/S _1468_/S VGND VPWR sky130_fd_sc_hd__buf_6
X_1224_ _1661_/Q _1225_/A _1707_/Q VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
X_1086_ _1081_/X _1079_/B _1413_/A _1086_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__a21oi_2
X_1155_ _1155_/X _1044_/A _1051_/X _1061_/A _1171_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
XFILLER_37_277 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_0939_ _0963_/C _0940_/B _0963_/B _0963_/D VPWR VGND VGND VPWR sky130_fd_sc_hd__and3_2
XFILLER_43_258 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xfanout190 VPWR VGND _1653_/CLK _1695_/CLK VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_19_277 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_247 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_53 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_280 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1207_ _1206_/X _1238_/A _1238_/B _1203_/X _1209_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_4
X_1138_ _1054_/X _1022_/Y _1138_/X _1412_/A _1058_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__a22o_2
X_1069_ _1049_/X _1069_/Y _1018_/X _1044_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ai_2
XFILLER_4_118 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_247 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1687_ _1687_/Q fanout175/X _1687_/D _1687_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
XFILLER_45_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_71 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_243 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_265 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1610_ _1610_/Q fanout179/X _1610_/D _1712_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1472_ _1626_/Q _1477_/B _1550_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_1541_ _1683_/D _1558_/B _1705_/Q _1530_/X _1540_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__a211o_2
X_1739_ VGND VPWR _1739_/X _1739_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_49_27 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_246 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_14_52 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_150 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_0972_ VGND VPWR _0971_/X _0945_/A _0964_/X _0965_/Y _0975_/S _0968_/X VGND VPWR
+ sky130_fd_sc_hd__a311o_4
X_1524_ _1538_/C _1524_/X _1664_/D VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
X_1386_ _1406_/B _1386_/A _1386_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_1455_ VGND VPWR _1646_/D _1455_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_50_197 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_14_301 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_40 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_51 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_95 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_84 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_73 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_62 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1240_ _1240_/B _1241_/B _1433_/S VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
X_1171_ _1171_/B _1171_/Y _1171_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_0955_ _1141_/B _0954_/B _1752_/A _1617_/D _0954_/Y VPWR VGND VGND VPWR sky130_fd_sc_hd__a211oi_4
X_0886_ _1089_/A _0886_/B _0899_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__xor2_4
XFILLER_32_197 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
Xoutput145 VPWR VGND result_out[12] _1686_/Q VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput134 VPWR VGND pmatrix_rowon_out_n[2] _1738_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput101 VPWR VGND pmatrix_col_out_n[29] _1128_/X VGND VPWR sky130_fd_sc_hd__buf_4
X_1507_ _1506_/X _1566_/A _1507_/X _1662_/D VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ba_2
Xoutput112 VPWR VGND pmatrix_row_out_n[10] _1745_/A VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput123 VPWR VGND pmatrix_row_out_n[6] _1741_/A VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput156 VPWR VGND result_out[8] _1682_/Q VGND VPWR sky130_fd_sc_hd__buf_4
X_1369_ _1369_/B _1369_/X _1632_/Q _1371_/C VPWR VGND VGND VPWR sky130_fd_sc_hd__and3_2
X_1438_ VGND VPWR _1637_/D _1438_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_46_267 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_14_197 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_0740_ _1468_/S _1444_/S _0825_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_4
X_1223_ _1660_/D _1223_/A _1223_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_1154_ _1154_/X _1139_/A _1157_/A _1044_/A _1392_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__o31a_2
X_1085_ _1054_/X _1084_/X _1085_/Y _1081_/X _1075_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__o22ai_2
XFILLER_52_248 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0938_ _0875_/D _0937_/X _0856_/D _0963_/D VGND VPWR VGND VPWR sky130_fd_sc_hd__a21oi_2
X_0869_ _0870_/A _0869_/B _0899_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__xnor2_4
XFILLER_11_123 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_85 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xfanout191 VPWR VGND _1695_/CLK _1713_/CLK VGND VPWR sky130_fd_sc_hd__buf_2
Xfanout180 VPWR VGND fanout180/X fanout182/X VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_34_226 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1206_ VPWR VGND _1657_/Q _1206_/X _1703_/Q VGND VPWR sky130_fd_sc_hd__and2_2
X_1137_ _1412_/A _1135_/Y _1137_/X _1097_/X _1136_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__a22o_2
XFILLER_33_281 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1068_ _1067_/X _1065_/X _1064_/X _1068_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__a21oi_2
XFILLER_3_163 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_281 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_273 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1686_ _1686_/Q fanout175/X _1686_/D _1686_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_28_40 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_277 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1540_ _1539_/Y _1538_/X _1542_/B _1663_/D _1537_/X _1540_/X VGND VPWR VGND VPWR
+ sky130_fd_sc_hd__o2111a_2
XFILLER_5_77 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1471_ _1471_/A _1471_/B _1347_/Y _1525_/A VPWR VGND VGND VPWR sky130_fd_sc_hd__or3b_2
XFILLER_10_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1738_ VGND VPWR _1738_/X _1738_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1669_ _1669_/Q fanout175/X _1669_/D _1686_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
XFILLER_49_39 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_258 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_96 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_118 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0971_ _0971_/X _0969_/Y _0970_/X _0943_/B _0966_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__o31a_2
X_1523_ _1566_/A _1523_/Y _1522_/Y _1521_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ai_2
X_1454_ VGND VPWR _1460_/S _1646_/Q _1647_/Q _1455_/A VGND VPWR sky130_fd_sc_hd__mux2_1
X_1385_ VGND VPWR _1623_/D _1385_/A VGND VPWR sky130_fd_sc_hd__buf_1
XPHY_30 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_41 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_52 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_96 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_85 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_198 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_74 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_63 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1170_ VPWR VGND _1110_/X _1115_/Y _1035_/X _1170_/Y VGND VPWR sky130_fd_sc_hd__a21boi_2
X_0954_ _0954_/B _0954_/Y _1617_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_0885_ _0886_/B _0901_/B _0884_/Y _0899_/C _0883_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
Xoutput135 VPWR VGND pmatrix_rowon_out_n[3] _1739_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput102 VPWR VGND pmatrix_col_out_n[2] _1047_/X VGND VPWR sky130_fd_sc_hd__buf_4
X_1506_ _1506_/X _1522_/B _1223_/B _1566_/A _1223_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
Xoutput124 VPWR VGND pmatrix_row_out_n[7] _1742_/A VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput157 VPWR VGND result_out[9] _1683_/Q VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput146 VPWR VGND result_out[13] _1687_/Q VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput113 VPWR VGND pmatrix_row_out_n[11] _1746_/A VGND VPWR sky130_fd_sc_hd__buf_4
X_1437_ VGND VPWR _1460_/S _1606_/S _1638_/Q _1438_/A VGND VPWR sky130_fd_sc_hd__mux2_1
X_1368_ _1369_/B _1371_/C _1632_/Q _1368_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__a21oi_2
X_1299_ _1666_/Q _1309_/B _1290_/Y _1272_/S _1565_/B VPWR VGND VGND VPWR sky130_fd_sc_hd__o211a_2
XFILLER_46_29 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_10 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_95 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1222_ _1706_/Q _1531_/B _1223_/B _1222_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__or3_2
X_1153_ _1153_/X _1084_/X _1097_/X _1091_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__a21o_2
X_1084_ _1084_/X _1141_/A _1429_/A _1093_/A _1051_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o31a_2
X_0937_ _1649_/Q _0979_/A _0937_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__or2b_2
X_0799_ VPWR VGND _0926_/B _0799_/A VGND VPWR sky130_fd_sc_hd__buf_4
X_0868_ _0844_/X _1611_/Q _0846_/A _0842_/X _0869_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__a22oi_4
XFILLER_7_139 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
Xfanout170 VPWR VGND _1679_/CLK _1623_/Q VGND VPWR sky130_fd_sc_hd__buf_2
Xfanout192 VPWR VGND _1713_/CLK input1/X VGND VPWR sky130_fd_sc_hd__buf_2
Xfanout181 VPWR VGND fanout181/X fanout182/X VGND VPWR sky130_fd_sc_hd__buf_6
XFILLER_42_293 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_77 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1205_ _1238_/B _1656_/Q _1199_/C _1702_/Q _1199_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
X_1136_ _1136_/X _1171_/B _1089_/Y _1061_/A _1081_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
X_1067_ _1093_/A _1413_/A _1076_/B _1067_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o21a_2
XFILLER_0_304 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_153 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_308 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_293 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1685_ _1685_/Q fanout177/X _1685_/D _1687_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1119_ _1081_/A _1095_/X _1076_/B _1119_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o21a_2
X_1470_ _1470_/Y _1674_/Q _1530_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
XFILLER_8_289 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_311 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1668_ _1668_/Q fanout175/X _1668_/D _1686_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_1599_ _1606_/S _1709_/D _1598_/Y _1602_/B _0989_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__o31ai_2
X_1737_ VGND VPWR _1737_/X _1737_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_0970_ _1616_/Q _0900_/A _0970_/X _0900_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ba_2
X_1522_ _1522_/B _1522_/Y _1662_/D VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_1453_ VGND VPWR _1645_/D _1453_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1384_ VPWR VGND _1622_/Q _1385_/A _1384_/B VGND VPWR sky130_fd_sc_hd__and2_2
XFILLER_27_108 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_20 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_31 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_42 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_141 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_53 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_64 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_97 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_86 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_75 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xoutput114 VPWR VGND pmatrix_row_out_n[12] _1747_/A VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput125 VPWR VGND pmatrix_row_out_n[8] _1397_/A VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput103 VPWR VGND pmatrix_col_out_n[30] _1130_/Y VGND VPWR sky130_fd_sc_hd__buf_4
X_0953_ VPWR VGND _1141_/B _0953_/A VGND VPWR sky130_fd_sc_hd__buf_6
X_0884_ _0881_/Y _0884_/Y _0806_/B _0806_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ai_2
X_1367_ _1633_/Q _1369_/B VPWR VGND VGND VPWR sky130_fd_sc_hd__inv_2
Xoutput158 VPWR VGND sample_matrix_out _1637_/Q VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput136 VPWR VGND pmatrix_rowon_out_n[4] _1740_/X VGND VPWR sky130_fd_sc_hd__buf_4
X_1436_ VGND VPWR _1627_/D _1436_/A VGND VPWR sky130_fd_sc_hd__buf_1
Xoutput147 VPWR VGND result_out[14] _1688_/Q VGND VPWR sky130_fd_sc_hd__buf_4
X_1505_ _1679_/D _1504_/X _1501_/X _1502_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__a21o_2
X_1298_ _1433_/S _1298_/Y _1667_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_1221_ _1706_/Q _1223_/A _1222_/C _1433_/S VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ai_2
X_1083_ _1081_/X _1083_/Y _1075_/Y _1082_/X _1054_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o22ai_4
XFILLER_37_225 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1152_ _1093_/X _1074_/Y _1152_/X _1097_/X _1151_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__a22o_2
XFILLER_20_114 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0936_ _1101_/B _0954_/B _1752_/A _1616_/D _0935_/Y VPWR VGND VGND VPWR sky130_fd_sc_hd__a211oi_4
X_0867_ _0899_/C _0901_/A _0901_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_4
X_0798_ _0875_/C _1003_/C _0799_/A _0798_/B _1004_/B VPWR VGND VGND VPWR sky130_fd_sc_hd__or4_2
X_1419_ _1397_/B _1397_/A _1412_/B _1741_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__o21a_2
Xfanout171 VPWR VGND fanout171/X fanout174/X VGND VPWR sky130_fd_sc_hd__buf_4
Xfanout182 VPWR VGND fanout182/X fanout184/X VGND VPWR sky130_fd_sc_hd__buf_4
X_1204_ _1238_/A _1702_/Q _1199_/B _1199_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__a21o_2
X_1135_ _1135_/Y _1164_/A _1171_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_1066_ VPWR VGND _1093_/A _1141_/B VGND VPWR sky130_fd_sc_hd__buf_4
X_0919_ _0943_/B _0919_/Y _1615_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
XFILLER_17_32 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_261 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1753_ VGND VPWR _1753_/X _1753_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_30_286 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1684_ _1684_/Q fanout177/X _1684_/D _1687_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1049_ VPWR VGND _1049_/X _1392_/A VGND VPWR sky130_fd_sc_hd__buf_6
X_1118_ _1171_/A _1049_/X _1118_/X _1035_/X _1117_/Y VPWR VGND VGND VPWR sky130_fd_sc_hd__a22o_2
XFILLER_21_275 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_242 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_253 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_85 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_128 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1736_ VGND VPWR _1736_/X _1736_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1667_ _1667_/Q fanout176/X _1667_/D _1686_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1598_ _1598_/Y _1709_/Q _1602_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
XFILLER_38_150 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_271 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1521_ _1626_/Q _1295_/B _1567_/A _1521_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__a21oi_2
X_1383_ VGND VPWR _1624_/D _1383_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1452_ VGND VPWR _1460_/S _1645_/Q _1646_/Q _1453_/A VGND VPWR sky130_fd_sc_hd__mux2_1
XPHY_10 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_21 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_32 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_43 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_54 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_98 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_87 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_76 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_65 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_31 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_285 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_69 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0952_ _1021_/B _0953_/A _1021_/A VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
Xoutput159 VPWR VGND sample_matrix_out_n _1751_/X VGND VPWR sky130_fd_sc_hd__buf_4
X_1504_ _1504_/X _1503_/X _1530_/C _1679_/Q _1530_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
Xoutput115 VPWR VGND pmatrix_row_out_n[13] _1748_/A VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput126 VPWR VGND pmatrix_row_out_n[9] _1744_/A VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput104 VPWR VGND pmatrix_col_out_n[31] _1131_/Y VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput148 VPWR VGND result_out[15] _1689_/Q VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput137 VPWR VGND pmatrix_rowon_out_n[5] _1741_/X VGND VPWR sky130_fd_sc_hd__buf_4
X_0883_ _0806_/A _0883_/Y _0882_/Y _0881_/Y _0806_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__o31ai_2
X_1435_ VGND VPWR _1567_/A _1483_/B input8/X _1436_/A VGND VPWR sky130_fd_sc_hd__mux2_1
X_1366_ _1366_/B _1632_/D _1382_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_1297_ VPWR VGND _1667_/Q _1297_/X _1534_/C VGND VPWR sky130_fd_sc_hd__and2_2
XFILLER_23_123 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_89 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_248 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1220_ VGND VPWR _1222_/C _1660_/Q _1246_/B VGND VPWR sky130_fd_sc_hd__xnor2_2
X_1151_ _1151_/X _1036_/X _1089_/Y _1061_/A _1392_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
X_1082_ _1392_/A _1082_/X _1051_/X _1157_/A _1081_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__o22a_2
X_0866_ _0958_/B _0860_/Y _0864_/X _0865_/X _1612_/Q _0901_/B VGND VPWR VGND VPWR
+ sky130_fd_sc_hd__o41a_2
X_0935_ _0954_/B _0935_/Y _1616_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_0797_ _1641_/Q _1004_/B _1642_/Q _1644_/Q VPWR VGND VGND VPWR sky130_fd_sc_hd__or3_4
X_1349_ VPWR VGND _1497_/B _1349_/A VGND VPWR sky130_fd_sc_hd__buf_2
X_1418_ _1740_/A _1739_/A _1412_/B _1405_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__a21o_2
XFILLER_43_218 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
Xfanout172 VPWR VGND fanout172/X fanout174/X VGND VPWR sky130_fd_sc_hd__buf_6
Xfanout183 VPWR VGND fanout183/X fanout184/X VGND VPWR sky130_fd_sc_hd__buf_6
X_1203_ _1703_/Q _1203_/X _1657_/Q VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
X_1134_ _1134_/X _1049_/X _1097_/A _1183_/A _1052_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__a211o_2
X_1065_ _1065_/X _1392_/A _1081_/A _1157_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__a21o_2
X_0849_ _1753_/A _0848_/Y _0999_/A _1611_/Q _1611_/D VPWR VGND VGND VPWR sky130_fd_sc_hd__o211a_2
X_0918_ VPWR VGND _0931_/B _0943_/B _0931_/C VGND VPWR sky130_fd_sc_hd__and2_2
XFILLER_17_66 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_273 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1683_ _1683_/Q fanout172/X _1683_/D _1683_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1752_ VGND VPWR _1752_/X _1752_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1117_ _1046_/X _1117_/Y _1018_/X _1044_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ai_2
X_1048_ VPWR VGND _1392_/A _1429_/A VGND VPWR sky130_fd_sc_hd__buf_6
XFILLER_0_158 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_10 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_302 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_265 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_107 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_140 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1735_ VGND VPWR _1735_/X _1735_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1666_ _1666_/Q fanout175/X _1666_/D _1686_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1597_ _1606_/S _1708_/D _1596_/Y _1602_/B _0978_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__o31ai_2
XFILLER_39_53 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_305 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1520_ _1681_/D _1519_/X _1512_/X _1517_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__a21o_2
XFILLER_4_283 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1382_ VPWR VGND _1622_/Q _1383_/A _1382_/B VGND VPWR sky130_fd_sc_hd__and2_2
X_1451_ VGND VPWR _1644_/D _1451_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_50_168 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1649_ _1649_/Q fanout182/X _1649_/D _1695_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
XPHY_11 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_22 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_33 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_44 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_55 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_99 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_88 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_113 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_77 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_66 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_121 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_0951_ _0951_/A _0951_/B _0950_/X _1021_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__or3b_4
X_0882_ _1611_/Q _0882_/Y VPWR VGND VGND VPWR sky130_fd_sc_hd__inv_2
Xoutput116 VPWR VGND pmatrix_row_out_n[14] _1749_/A VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput149 VPWR VGND result_out[1] _1675_/Q VGND VPWR sky130_fd_sc_hd__buf_4
X_1503_ VPWR VGND _1701_/Q _1503_/X _1558_/B VGND VPWR sky130_fd_sc_hd__and2_2
Xoutput127 VPWR VGND pmatrix_rowon_out_n[0] _1736_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput105 VPWR VGND pmatrix_col_out_n[3] _1055_/Y VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput138 VPWR VGND pmatrix_rowon_out_n[6] _1742_/X VGND VPWR sky130_fd_sc_hd__buf_4
X_1365_ VGND VPWR _1366_/B _1632_/Q _1371_/C VGND VPWR sky130_fd_sc_hd__xnor2_2
X_1434_ VGND VPWR _1626_/D _1434_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1296_ VGND VPWR _1666_/D _1296_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_23_179 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_301 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1150_ _1093_/X _1074_/Y _1150_/X _1097_/X _1149_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__a22o_2
X_1081_ _1081_/A _1081_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__buf_8
X_0865_ VPWR VGND _0865_/X _1647_/Q _1648_/Q _0874_/A _0921_/A VGND VPWR sky130_fd_sc_hd__and4b_2
X_0934_ _1101_/B _1019_/A _1019_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_4
X_1417_ _1412_/A _1739_/A _1412_/B _1738_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__o21a_2
X_0796_ _1645_/Q _0854_/B _1646_/Q VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
X_1348_ _1471_/A _1471_/B _1347_/Y _1349_/A VPWR VGND VGND VPWR sky130_fd_sc_hd__or3b_2
X_1279_ _1279_/X _1274_/A _1664_/Q _1710_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__a21o_2
XFILLER_51_230 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
Xfanout162 _1743_/A _1397_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__buf_8
Xfanout173 VPWR VGND fanout173/X fanout174/X VGND VPWR sky130_fd_sc_hd__buf_2
Xfanout184 VPWR VGND fanout184/X input9/X VGND VPWR sky130_fd_sc_hd__buf_4
X_1202_ VGND VPWR _1656_/D _1702_/Q _1202_/B VGND VPWR sky130_fd_sc_hd__xnor2_2
X_1133_ _1132_/Y _1040_/Y _1035_/X _1133_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__a21oi_4
X_1064_ VPWR VGND _1064_/X _1157_/A VGND VPWR sky130_fd_sc_hd__buf_6
X_0848_ _0848_/Y _0999_/A _1016_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_0779_ _0875_/B _0875_/C _1641_/Q _0875_/D _0841_/A VPWR VGND VGND VPWR sky130_fd_sc_hd__or4_4
X_0917_ _0917_/B _1615_/D _1752_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_1682_ _1682_/Q fanout177/X _1682_/D _1687_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1751_ VGND VPWR _1751_/X _1753_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1047_ _1035_/X _1040_/Y _1047_/X _1046_/X _1044_/Y VPWR VGND VGND VPWR sky130_fd_sc_hd__a22o_2
X_1116_ _1171_/A _1412_/A _1116_/X _1035_/X _1115_/Y VPWR VGND VGND VPWR sky130_fd_sc_hd__a22o_2
XFILLER_5_15 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_277 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_281 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1665_ _1665_/Q fanout177/X _1665_/D _1687_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1596_ _1596_/Y _1708_/Q _1602_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_1734_ VGND VPWR _1734_/X _1734_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_5_218 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1450_ VGND VPWR _1460_/S _1644_/Q _1645_/Q _1451_/A VGND VPWR sky130_fd_sc_hd__mux2_1
XFILLER_4_295 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1381_ _1622_/D _1602_/B VPWR VGND VGND VPWR sky130_fd_sc_hd__inv_4
X_1579_ _1578_/Y _1689_/D _1576_/Y _1575_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ai_2
X_1648_ _1648_/Q fanout182/X _1648_/D _1653_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
XPHY_12 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_23 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_34 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_45 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_177 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_56 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_89 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_78 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_67 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_0950_ _0950_/X _0945_/A _0959_/C _0949_/X _0948_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__o31a_2
X_0881_ _0881_/C _0881_/Y _0881_/A _0958_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nor3_2
Xoutput117 VPWR VGND pmatrix_row_out_n[15] _1750_/A VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput128 VPWR VGND pmatrix_rowon_out_n[10] _1746_/X VGND VPWR sky130_fd_sc_hd__buf_4
X_1433_ VGND VPWR _1433_/S input7/X _1626_/Q _1434_/A VGND VPWR sky130_fd_sc_hd__mux2_1
X_1502_ _1488_/A _1502_/X _1539_/C _1663_/D _1549_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__o2bb2a_2
Xoutput106 VPWR VGND pmatrix_col_out_n[4] _1057_/Y VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput139 VPWR VGND pmatrix_rowon_out_n[7] _1743_/X VGND VPWR sky130_fd_sc_hd__buf_4
X_1364_ VPWR VGND _1631_/Q _1371_/C _1364_/B VGND VPWR sky130_fd_sc_hd__and2_2
X_1295_ VPWR VGND _1567_/A _1296_/A _1295_/B VGND VPWR sky130_fd_sc_hd__and2_2
XFILLER_48_291 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1080_ _1078_/Y _1080_/X _1079_/Y _1035_/X _1171_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__o22a_2
X_0864_ _0864_/X _0864_/C _1649_/Q _0963_/B _0963_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__and4_2
X_0795_ _0789_/X _0794_/X _1004_/A _0813_/A _0785_/X _0805_/B VGND VPWR VGND VPWR
+ sky130_fd_sc_hd__o32a_2
X_0933_ VGND VPWR _0932_/Y _0931_/Y _0933_/S _1019_/B VGND VPWR sky130_fd_sc_hd__mux2_2
X_1347_ _1636_/Q _1532_/A _1347_/Y _1630_/Q _1344_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o22ai_2
X_1416_ VPWR VGND _1737_/A _1416_/A VGND VPWR sky130_fd_sc_hd__buf_2
X_1278_ _1664_/D _1278_/B _1710_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__xnor2_4
XFILLER_28_206 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xfanout163 _1413_/C _1739_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__buf_8
Xfanout174 VPWR VGND fanout174/X fanout184/X VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_47_10 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
Xfanout185 VPWR VGND _1712_/CLK _1713_/CLK VGND VPWR sky130_fd_sc_hd__buf_4
X_1201_ _1531_/B _1201_/B _1202_/B _1201_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__or3_2
X_1132_ _1049_/X _1018_/X _1081_/X _1132_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__a21oi_2
X_1063_ VPWR VGND _1157_/A _1101_/B VGND VPWR sky130_fd_sc_hd__buf_4
X_0916_ VGND VPWR _0954_/B _1053_/A _0943_/A _0917_/B VGND VPWR sky130_fd_sc_hd__mux2_1
X_0847_ VPWR VGND _0999_/A _0954_/B VGND VPWR sky130_fd_sc_hd__buf_4
X_0778_ VPWR VGND _0875_/D _0778_/A VGND VPWR sky130_fd_sc_hd__buf_6
X_1750_ VGND VPWR _1750_/X _1750_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1681_ _1681_/Q fanout171/X _1681_/D _1689_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_1046_ _1046_/A _1046_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__buf_8
X_1115_ _1081_/X _1115_/Y _1018_/X _1095_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ai_2
XFILLER_5_49 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_289 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1733_ VGND VPWR _1733_/X _1733_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_7_293 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1664_ _1664_/Q fanout178/X _1664_/D _1687_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1595_ VGND VPWR _1707_/D _1595_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_38_197 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1029_ _1141_/B _1183_/A _1141_/A _1076_/B VPWR VGND VGND VPWR sky130_fd_sc_hd__and3_2
XFILLER_41_307 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1380_ _1639_/Q _1444_/S _1602_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_8
X_1578_ _1577_/X _1578_/Y _1530_/B _1711_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ai_2
X_1647_ _1647_/Q fanout182/X _1647_/D _1653_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
XPHY_13 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_24 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_46 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_57 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_79 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_68 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_215 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_90 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xoutput107 VPWR VGND pmatrix_col_out_n[5] _1062_/Y VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_40_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_181 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0880_ VPWR VGND _0899_/B _0898_/A _0901_/C VGND VPWR sky130_fd_sc_hd__and2b_2
X_1363_ _1363_/B _1631_/D _1382_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_1432_ VGND VPWR _1625_/D _1432_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1501_ _1659_/D _1535_/B _1501_/X _1542_/B _1351_/B _1657_/D VGND VPWR VGND VPWR
+ sky130_fd_sc_hd__o221a_2
Xoutput118 VPWR VGND pmatrix_row_out_n[1] _1736_/A VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput129 VPWR VGND pmatrix_rowon_out_n[11] _1747_/X VGND VPWR sky130_fd_sc_hd__buf_4
X_1294_ VGND VPWR _1295_/B _1666_/Q _1294_/B VGND VPWR sky130_fd_sc_hd__xnor2_2
XFILLER_52_44 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0932_ _0932_/A _0932_/Y VPWR VGND VGND VPWR sky130_fd_sc_hd__inv_2
XFILLER_9_163 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0863_ _1004_/B _0963_/C _1003_/C _0875_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nor3_2
X_0794_ _0794_/C _0990_/A _0794_/X _0979_/A _0875_/D VPWR VGND VGND VPWR sky130_fd_sc_hd__or4_2
XFILLER_3_93 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1346_ _1485_/B _1532_/A _1626_/Q VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
X_1415_ VPWR VGND _1415_/A _1416_/A _1739_/A VGND VPWR sky130_fd_sc_hd__and2_2
X_1277_ VPWR VGND _1277_/A _1278_/B _1277_/B VGND VPWR sky130_fd_sc_hd__and2_2
XFILLER_36_273 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
Xfanout175 VPWR VGND fanout175/X fanout178/X VGND VPWR sky130_fd_sc_hd__buf_6
XFILLER_19_229 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xfanout186 VPWR VGND _1707_/CLK _1713_/CLK VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_47_22 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
Xfanout164 _1637_/Q _1752_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__buf_8
X_1200_ _1656_/Q _1199_/C _1199_/B _1201_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__a21oi_2
X_1062_ _1061_/X _1058_/X _1049_/X _1062_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__a21oi_2
X_1131_ _1046_/X _1022_/Y _1018_/X _1131_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__a21oi_4
X_0915_ _1053_/A _0915_/B _0915_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__xnor2_4
X_0777_ _1648_/Q _1646_/Q _0778_/A _1645_/Q _1647_/Q VPWR VGND VGND VPWR sky130_fd_sc_hd__or4_2
X_0846_ _1016_/A _0846_/B _0846_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__xnor2_4
X_1329_ _1329_/X _1626_/Q _1628_/Q _1566_/A _1345_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
X_1680_ _1680_/Q fanout174/X _1680_/D _1683_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_24_3 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1114_ _1113_/X _1114_/Y _1112_/X _1064_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ai_2
X_1045_ VPWR VGND _1046_/A _1101_/C VGND VPWR sky130_fd_sc_hd__buf_4
X_0829_ _0829_/B _1610_/D _1752_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
XFILLER_7_250 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1663_ _1663_/Q fanout177/X _1663_/D _1687_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1732_ VGND VPWR _1732_/X _1732_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1594_ VGND VPWR _1622_/D _1617_/D _1707_/Q _1595_/A VGND VPWR sky130_fd_sc_hd__mux2_1
X_1028_ VPWR VGND _1139_/A _1076_/B _1053_/A VGND VPWR sky130_fd_sc_hd__and2_2
XFILLER_44_135 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1646_ _1646_/Q fanout184/X _1646_/D _1695_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1577_ _1577_/X _1497_/Y _1689_/Q _1667_/D _1497_/B VGND VPWR _1558_/B VGND VPWR
+ sky130_fd_sc_hd__a221o_2
XPHY_14 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_25 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_47 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_47 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_58 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_69 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_205 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_238 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
Xoutput119 VPWR VGND pmatrix_row_out_n[2] _1737_/A VGND VPWR sky130_fd_sc_hd__buf_4
X_1500_ _1678_/D _1499_/X _1567_/C _1496_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__a21o_2
Xoutput108 VPWR VGND pmatrix_col_out_n[6] _1068_/Y VGND VPWR sky130_fd_sc_hd__buf_4
X_1362_ VGND VPWR _1363_/B _1631_/Q _1364_/B VGND VPWR sky130_fd_sc_hd__xnor2_2
Xoutput90 VPWR VGND pmatrix_col_out_n[19] _1106_/Y VGND VPWR sky130_fd_sc_hd__buf_4
X_1431_ VGND VPWR _1433_/S input6/X _1550_/A _1432_/A VGND VPWR sky130_fd_sc_hd__mux2_1
X_1293_ _1309_/B _1294_/B _1290_/Y _1272_/S VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ai_2
X_1629_ _1629_/Q fanout176/X _1629_/D _1688_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_0862_ _0875_/D _0864_/C _0979_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_0931_ _0943_/A _0931_/Y _0931_/B _0931_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__nand3_2
X_0793_ _0993_/B _0794_/C VPWR VGND VGND VPWR sky130_fd_sc_hd__inv_2
X_1345_ _1485_/B _1625_/Q _1345_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_4
X_1276_ _1277_/B _1531_/B _1275_/X _1273_/X _1274_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
X_1414_ VPWR VGND _1736_/A _1414_/A VGND VPWR sky130_fd_sc_hd__buf_2
Xfanout165 VPWR VGND _1689_/CLK _1683_/CLK VGND VPWR sky130_fd_sc_hd__buf_4
Xfanout176 VPWR VGND fanout176/X fanout178/X VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_27_274 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
Xfanout187 VPWR VGND _1711_/CLK _1384_/B VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_47_34 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_189 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1130_ _1130_/B _1130_/Y _1183_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_1061_ _1081_/A _1061_/X _1061_/A _1087_/B VPWR VGND VGND VPWR sky130_fd_sc_hd__and3_2
XFILLER_33_277 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_0914_ _0945_/A _0902_/X _0901_/X _0869_/B _0915_/B VPWR VGND VGND VPWR sky130_fd_sc_hd__o211a_2
X_0845_ _0846_/B _1611_/Q _0844_/X _0842_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__a21boi_4
X_0776_ _1651_/Q _1649_/Q _1652_/Q _1650_/Q _0875_/C VPWR VGND VGND VPWR sky130_fd_sc_hd__or4_4
X_1328_ _1345_/B _1627_/Q VPWR VGND VGND VPWR sky130_fd_sc_hd__inv_4
X_1259_ VPWR VGND _1663_/Q _1274_/A _1709_/Q VGND VPWR sky130_fd_sc_hd__and2_2
X_1044_ _1044_/Y _1044_/A _1079_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
XFILLER_38_303 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1113_ _1113_/X _1036_/X _1046_/A _1157_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__a21o_2
X_0759_ _0757_/Y _0768_/A _0758_/X _1699_/D VGND VPWR VGND VPWR sky130_fd_sc_hd__o21a_2
X_0828_ VGND VPWR _0829_/B _1610_/Q _0828_/B VGND VPWR sky130_fd_sc_hd__xnor2_2
XFILLER_8_218 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_199 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1731_ VGND VPWR _1731_/X _1731_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_7_262 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1662_ _1662_/Q fanout177/X _1662_/D _1687_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1593_ VGND VPWR _1706_/D _1593_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1027_ VPWR VGND _1141_/A _1101_/B VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_35_136 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1576_ _1382_/B _1576_/Y _1542_/B _1669_/D VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ai_2
X_1645_ _1645_/Q fanout184/X _1645_/D _1695_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1714_ _1714_/Q fanout179/X _1714_/D _1714_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
XPHY_15 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_26 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_37 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_48 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_15 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_59 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_191 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_268 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1430_ VPWR VGND _1750_/A _1430_/A VGND VPWR sky130_fd_sc_hd__buf_2
Xoutput109 VPWR VGND pmatrix_col_out_n[7] _1070_/X VGND VPWR sky130_fd_sc_hd__buf_4
X_1361_ _1629_/Q _1364_/B _1628_/Q _1630_/Q VPWR VGND VGND VPWR sky130_fd_sc_hd__and3_2
X_1292_ _1309_/B _1290_/B _1291_/Y _1284_/A VPWR VGND VGND VPWR sky130_fd_sc_hd__o21ai_4
Xoutput80 VPWR VGND pmatrix_col_out_n[0] _1026_/Y VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput91 VPWR VGND pmatrix_col_out_n[1] _1034_/Y VGND VPWR sky130_fd_sc_hd__buf_4
X_1628_ _1628_/Q _1628_/D VPWR fanout171/X _1689_/CLK VGND VGND VPWR sky130_fd_sc_hd__dfstp_4
X_1559_ _1559_/X _1558_/X _1530_/C _1686_/Q _1530_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
XFILLER_10_301 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_106 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_297 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_132 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_0861_ _0993_/B _0963_/B _1652_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_0930_ VGND VPWR _0929_/X _0925_/Y _0985_/A _1019_/A VGND VPWR sky130_fd_sc_hd__mux2_2
X_0792_ VPWR VGND _0993_/B _1650_/Q VGND VPWR sky130_fd_sc_hd__buf_4
X_1413_ _1415_/A _1414_/A _1413_/A _1413_/C VPWR VGND VGND VPWR sky130_fd_sc_hd__and3_2
X_1344_ _1342_/X _1344_/X _1343_/Y _1625_/Q _1636_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__o22a_2
X_1275_ _1275_/B _1275_/X _1664_/Q VPWR VGND VGND VPWR sky130_fd_sc_hd__or2_2
XFILLER_36_253 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xfanout166 VPWR VGND _1683_/CLK _1679_/CLK VGND VPWR sky130_fd_sc_hd__buf_4
Xfanout177 VPWR VGND fanout177/X fanout178/X VGND VPWR sky130_fd_sc_hd__buf_6
XFILLER_47_46 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xfanout188 VPWR VGND _1384_/B _1713_/CLK VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_47_79 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_179 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_7 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1060_ VPWR VGND _1081_/A _1141_/B VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_18_253 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_0913_ _0915_/A _0959_/A _0959_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__or2_4
X_0775_ VPWR VGND _0875_/B _0798_/B VGND VPWR sky130_fd_sc_hd__buf_4
X_0844_ _0958_/B _1611_/Q _0844_/X _0881_/A _0881_/C VPWR VGND VGND VPWR sky130_fd_sc_hd__or4_2
X_1189_ _1630_/Q _1632_/Q _1189_/A _1634_/Q _1189_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__or4_4
X_1327_ _1566_/A _1625_/Q VPWR VGND VGND VPWR sky130_fd_sc_hd__inv_4
X_1258_ _1258_/C _1258_/Y _1663_/Q _1709_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__nor3_2
XFILLER_2_160 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1112_ _1095_/A _1036_/X _1076_/B _1112_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o21a_2
X_1043_ _1079_/B _1089_/A _1053_/A _1089_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__a21boi_4
XFILLER_21_204 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0827_ VPWR VGND _0828_/B _0954_/B _0806_/B VGND VPWR sky130_fd_sc_hd__and2b_2
X_0758_ _0758_/B _0758_/X _1698_/Q _0758_/C VPWR VGND VGND VPWR sky130_fd_sc_hd__and3_2
XFILLER_7_274 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_270 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_281 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1661_ _1661_/Q fanout173/X _1661_/D _1683_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1592_ VGND VPWR _1622_/D _1616_/D _1706_/Q _1593_/A VGND VPWR sky130_fd_sc_hd__mux2_1
X_1730_ VGND VPWR _1730_/X _1730_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1026_ _1412_/A _1022_/Y _1018_/X _1026_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__a21oi_4
XFILLER_44_115 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_107 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1713_ _1713_/Q fanout172/X _1713_/D _1713_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1575_ _1567_/B _1485_/B _1671_/D _1574_/X _1575_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__a22oi_4
XFILLER_6_51 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1644_ _1644_/Q fanout181/X _1644_/D _1653_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
XPHY_16 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1009_ _1429_/B _1427_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__buf_8
XPHY_49 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
Xoutput70 VPWR VGND nmatrix_rowon_out_n[3] _1724_/X VGND VPWR sky130_fd_sc_hd__buf_4
X_1360_ _1360_/B _1630_/D _1382_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
Xoutput92 VPWR VGND pmatrix_col_out_n[20] _1108_/Y VGND VPWR sky130_fd_sc_hd__buf_4
X_1291_ _1711_/Q _1291_/Y _1665_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
Xoutput81 VPWR VGND pmatrix_col_out_n[10] _1080_/X VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_23_107 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1627_ _1627_/Q fanout171/X _1627_/D _1689_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1489_ _1538_/C _1550_/A _1567_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_1558_ VPWR VGND _1708_/Q _1558_/X _1558_/B VGND VPWR sky130_fd_sc_hd__and2_2
XFILLER_14_118 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_265 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_243 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
X_0860_ _0860_/B _0860_/Y _0860_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_0791_ VPWR VGND _0979_/A _1651_/Q VGND VPWR sky130_fd_sc_hd__buf_4
X_1412_ _1412_/A _1735_/A _1412_/B _1739_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nand3_2
X_1343_ _1634_/Q _1343_/Y _1483_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_1274_ _1274_/A _1274_/B _1664_/Q _1274_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__or3b_2
XFILLER_22_39 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_0989_ _0989_/B _1619_/D _1606_/S VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
Xfanout167 VPWR VGND _1686_/CLK _1687_/CLK VGND VPWR sky130_fd_sc_hd__buf_4
Xfanout178 VPWR VGND fanout178/X fanout184/X VGND VPWR sky130_fd_sc_hd__buf_4
Xfanout189 VPWR VGND _1714_/CLK _1653_/CLK VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_18_265 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_0912_ _0943_/A _0931_/C _0931_/B _0959_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__a21oi_2
XFILLER_5_191 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_0843_ _0874_/A _0881_/C _0921_/A _0921_/B VPWR VGND VGND VPWR sky130_fd_sc_hd__and3_2
X_0774_ _1653_/Q _1638_/Q _0798_/B _1752_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__or3_2
X_1326_ _1326_/X _1325_/X _1636_/Q _1483_/B _1189_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
X_1188_ _1628_/Q _1189_/A VPWR VGND VGND VPWR sky130_fd_sc_hd__inv_2
X_1257_ _1255_/X _1256_/X _1253_/X _1662_/Q _1254_/X _1263_/A VGND VPWR VGND VPWR
+ sky130_fd_sc_hd__a221oi_2
XFILLER_24_213 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_117 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_93 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1042_ _1089_/B _0985_/A _0899_/X _0898_/Y _0895_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o31a_4
X_1111_ _1110_/X _1111_/Y _1109_/X _1064_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ai_2
XFILLER_9_40 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_0826_ _0825_/X _0875_/A _0824_/X _1444_/S _0954_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_4
X_0757_ _0758_/B _0758_/C _1698_/Q _0757_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__a21oi_2
X_1309_ _1309_/B _1309_/X _1669_/Q _1309_/C VPWR VGND VGND VPWR sky130_fd_sc_hd__and3_2
XFILLER_47_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_293 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1660_ _1660_/Q fanout173/X _1660_/D _1683_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1591_ VGND VPWR _1705_/D _1591_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_22_3 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_29 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1025_ VPWR VGND _1412_/A _1171_/B VGND VPWR sky130_fd_sc_hd__buf_6
X_0809_ _1003_/C _0875_/C _0874_/A _1004_/B _0875_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_52_193 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_190 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_1 _1126_/Y VGND VPWR VPWR VGND sky130_fd_sc_hd__diode_2
X_1712_ _1712_/Q fanout172/X _1712_/D _1712_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1643_ _1643_/Q fanout181/X _1643_/D _1653_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1574_ VGND VPWR _1574_/X _1321_/Y _1567_/B _1672_/Q _1317_/B _1319_/Y VGND VPWR
+ sky130_fd_sc_hd__a311o_2
XFILLER_6_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_17 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_28 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_39 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1008_ VPWR VGND _1405_/B _1429_/B _1405_/C VGND VPWR sky130_fd_sc_hd__and2_2
XFILLER_15_50 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
Xoutput93 VPWR VGND pmatrix_col_out_n[21] _1111_/Y VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput71 VPWR VGND nmatrix_rowon_out_n[4] _1725_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput82 VPWR VGND pmatrix_col_out_n[11] _1083_/Y VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput60 VPWR VGND nmatrix_row_out_n[8] _1728_/A VGND VPWR sky130_fd_sc_hd__buf_4
X_1290_ _1279_/X _1290_/Y _1290_/B _1290_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__nand3b_4
XFILLER_48_241 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
X_1626_ _1626_/Q fanout171/X _1626_/D _1689_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1488_ _1488_/Y _1488_/A _1543_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_1557_ _1535_/B _1557_/X _1549_/B _1664_/D _1670_/D VGND VPWR VGND VPWR sky130_fd_sc_hd__o22a_2
XFILLER_22_141 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_0790_ VPWR VGND _0990_/A _1652_/Q VGND VPWR sky130_fd_sc_hd__buf_4
X_1342_ _1626_/Q _1636_/Q _1345_/B _1342_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o21a_2
X_1273_ _1290_/C _1664_/Q _1274_/B _1273_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__or3b_2
X_1411_ _1734_/A _1412_/B _1739_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_0988_ VGND VPWR _0989_/B _1619_/Q _0988_/B VGND VPWR sky130_fd_sc_hd__xnor2_2
XFILLER_51_247 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_258 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
X_1609_ VGND VPWR _1714_/D _1609_/A VGND VPWR sky130_fd_sc_hd__buf_1
Xfanout168 VPWR VGND _1688_/CLK _1687_/CLK VGND VPWR sky130_fd_sc_hd__buf_2
Xfanout179 VPWR VGND fanout179/X fanout182/X VGND VPWR sky130_fd_sc_hd__buf_6
XFILLER_18_277 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_0911_ _0931_/B _0959_/A _0943_/A _0931_/C VPWR VGND VGND VPWR sky130_fd_sc_hd__and3_2
X_0842_ VGND VPWR _0881_/A _0921_/A _0874_/A _0921_/B _0842_/X _0958_/B VGND VPWR
+ sky130_fd_sc_hd__a311o_4
X_0773_ _1610_/Q _0806_/A VPWR VGND VGND VPWR sky130_fd_sc_hd__inv_2
X_1325_ _1483_/B _1625_/Q _1630_/Q _1325_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o21a_2
X_1256_ _1535_/A _1256_/X _1708_/Q _1270_/B VPWR VGND VGND VPWR sky130_fd_sc_hd__and3_2
X_1187_ _1631_/Q _1633_/Q _1629_/Q _1635_/Q _1187_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_23_291 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1110_ _1110_/X _1093_/A _1046_/A _1087_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__a21o_2
X_1041_ VPWR VGND _1044_/A _1139_/C VGND VPWR sky130_fd_sc_hd__buf_6
XFILLER_21_239 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0825_ VPWR VGND input2/X _0825_/X _0825_/B VGND VPWR sky130_fd_sc_hd__and2_2
X_0756_ _1699_/Q _0758_/B VPWR VGND VGND VPWR sky130_fd_sc_hd__inv_2
X_1308_ _1308_/B _1669_/D _1433_/S VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_1239_ VGND VPWR _1240_/B _1657_/Q _1239_/B VGND VPWR sky130_fd_sc_hd__xnor2_2
XFILLER_44_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_94 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_71 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1590_ VGND VPWR _1622_/D _1615_/D _1705_/Q _1591_/A VGND VPWR sky130_fd_sc_hd__mux2_1
X_1024_ _1429_/A _1171_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__buf_8
XFILLER_26_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0808_ _0979_/A _0808_/Y _0990_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
X_0739_ _1639_/Q _1641_/Q _0825_/B _1642_/Q _1640_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__nor4_4
XANTENNA_2 _1746_/A VGND VPWR VPWR VGND sky130_fd_sc_hd__diode_2
X_1711_ _1711_/Q fanout177/X _1711_/D _1711_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1642_ _1642_/Q fanout181/X _1642_/D _1653_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1573_ _1382_/B _1688_/D _1570_/X _1688_/Q _1572_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o22a_2
XPHY_18 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_29 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1007_ _1386_/A _1405_/C _1406_/A _1386_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand3_2
XFILLER_31_61 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
Xoutput61 VPWR VGND nmatrix_row_out_n[9] _1729_/A VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput72 VPWR VGND nmatrix_rowon_out_n[5] _1726_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput83 VPWR VGND pmatrix_col_out_n[12] _1085_/Y VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput94 VPWR VGND pmatrix_col_out_n[22] _1114_/Y VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput50 VPWR VGND nmatrix_row_out_n[13] _1733_/A VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_48_253 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1625_ _1625_/Q fanout171/X _1625_/D _1689_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1556_ _1556_/X _1555_/X _1550_/A _1668_/D VGND VPWR VGND VPWR sky130_fd_sc_hd__a21o_2
X_1487_ _1676_/Q _1352_/B _1676_/D _1567_/C _1484_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__a22o_2
XFILLER_13_131 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1410_ _1739_/A _1733_/A _1412_/B _1049_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ai_2
X_1341_ _1471_/B _1534_/C _1341_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nand2_2
X_1272_ VGND VPWR _1272_/S _1269_/X _1267_/Y _1277_/A VGND VPWR sky130_fd_sc_hd__mux2_1
X_0987_ _0988_/B _1390_/A _1390_/B _0999_/A _1390_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__o31a_2
X_1539_ _1711_/Q _1539_/Y _1539_/B _1539_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__nand3_2
X_1608_ VGND VPWR _1752_/A input5/X _1714_/Q _1609_/A VGND VPWR sky130_fd_sc_hd__mux2_1
Xfanout169 VPWR VGND _1687_/CLK _1679_/CLK VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_42_248 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_74 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_289 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_82 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_0841_ _0841_/A _0841_/C _0841_/B _0881_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nor3_4
X_0910_ _0856_/X _0931_/C _0909_/X _0857_/X _0926_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__o22a_2
X_0772_ _0770_/Y _0768_/A _0771_/X _1694_/D VGND VPWR VGND VPWR sky130_fd_sc_hd__o21a_2
X_1324_ VPWR VGND _1483_/B _1627_/Q VGND VPWR sky130_fd_sc_hd__buf_6
X_1255_ _1663_/Q _1709_/Q _1255_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__or2b_2
X_1186_ _1185_/Y _1127_/Y _1164_/A _1186_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__a21oi_2
XFILLER_15_237 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_7 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1040_ _1040_/Y _1413_/A _1087_/B _1036_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__o21ai_4
X_0755_ VGND VPWR _1698_/D _0755_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_0824_ VGND VPWR _0824_/S _0823_/X _1696_/Q _0824_/X VGND VPWR sky130_fd_sc_hd__mux2_1
X_1307_ VGND VPWR _1308_/B _1669_/Q _1564_/C VGND VPWR sky130_fd_sc_hd__xnor2_2
X_1238_ VPWR VGND _1238_/A _1239_/B _1238_/B VGND VPWR sky130_fd_sc_hd__and2_2
X_1169_ _1112_/X _1169_/X _1168_/X _1064_/X _1093_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o22a_2
XFILLER_20_273 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1023_ _1023_/A _0975_/X _1023_/B _1429_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nor3b_4
X_0807_ _1003_/C _0875_/D _0997_/A _0833_/D _0875_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nor4_4
X_0738_ _0732_/X _0737_/X _1444_/S _0728_/X _1694_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__a22o_4
XFILLER_43_195 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_3 _1747_/A VGND VPWR VPWR VGND sky130_fd_sc_hd__diode_2
XFILLER_6_10 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1572_ _1572_/X _1543_/B _1666_/D _1672_/D _1534_/D VGND VPWR _1571_/X VGND VPWR
+ sky130_fd_sc_hd__a221o_2
X_1710_ _1710_/Q fanout177/X _1710_/D _1384_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
X_1641_ _1641_/Q fanout181/X _1641_/D _1653_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
XPHY_19 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_302 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_6
X_1006_ _1405_/B _1406_/A _1386_/A _1386_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__a21o_2
Xoutput73 VPWR VGND nmatrix_rowon_out_n[6] _1727_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput95 VPWR VGND pmatrix_col_out_n[23] _1116_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput84 VPWR VGND pmatrix_col_out_n[13] _1088_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput51 VPWR VGND nmatrix_row_out_n[14] _1734_/A VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput40 VPWR VGND nmatrix_col_out_n[3] _1137_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput62 VPWR VGND nmatrix_rowon_out_n[0] _1721_/X VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_48_265 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
X_1555_ _1555_/X _1522_/B _1295_/B _1566_/A _1567_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
X_1624_ _1624_/Q fanout178/X _1624_/D _1384_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_1486_ _1525_/A _1567_/C _1534_/D VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
XFILLER_39_210 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_154 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1340_ _1339_/X _1341_/B _1335_/X _1550_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__o21ai_2
X_1271_ VPWR VGND _1272_/S _1271_/A VGND VPWR sky130_fd_sc_hd__buf_4
XFILLER_51_205 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_238 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_0986_ _0990_/A _0957_/Y _0990_/B _0985_/C _1390_/C _0975_/S VGND VPWR VGND VPWR
+ sky130_fd_sc_hd__o32ai_4
X_1538_ _1711_/Q _1539_/B _1538_/X _1538_/C VGND VPWR VGND VPWR sky130_fd_sc_hd__or3_2
X_1607_ VGND VPWR _1713_/D _1607_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_1469_ VGND VPWR _1653_/D _1469_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_27_257 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_106 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0840_ _0841_/C _0782_/D _1640_/Q _1643_/Q _1639_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__a211o_2
X_0771_ VGND VPWR _1693_/Q _0771_/X _1694_/Q _0771_/C VGND VPWR sky130_fd_sc_hd__and3b_2
X_1323_ input8/X input6/X input7/X _1561_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nor3_4
X_1254_ _1709_/Q _1531_/B _1663_/Q _1254_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__or3b_2
X_1185_ _1095_/X _1018_/X _1081_/X _1185_/Y VGND VPWR VGND VPWR sky130_fd_sc_hd__a21oi_2
X_0969_ _1616_/Q _0969_/Y _1615_/Q VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_2
XFILLER_15_249 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_0754_ VPWR VGND _0768_/A _0755_/A _0754_/B VGND VPWR sky130_fd_sc_hd__and2_2
X_0823_ VGND VPWR _1713_/Q _0822_/X _0820_/X _0823_/X VGND VPWR sky130_fd_sc_hd__mux2_1
X_1306_ _1309_/B _1309_/C _1290_/Y _1272_/S _1564_/C VPWR VGND VGND VPWR sky130_fd_sc_hd__o211a_2
X_1237_ VGND VPWR _1655_/D _1701_/Q _1237_/B VGND VPWR sky130_fd_sc_hd__xnor2_2
X_1168_ _1097_/A _1095_/X _1051_/X _1168_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o21a_2
X_1099_ _1099_/X _1089_/B _1164_/A _1171_/A _1429_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__o31a_2
XFILLER_20_285 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_95 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_127 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_116 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_3
X_1022_ _1022_/Y _1164_/A _1171_/A VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_8
X_0806_ VPWR VGND _0806_/A _0816_/A _0806_/B VGND VPWR sky130_fd_sc_hd__and2_2
X_0737_ _0736_/X _0735_/X _0728_/X _1694_/Q _0737_/X VPWR VGND VGND VPWR sky130_fd_sc_hd__o211a_2
XFILLER_52_185 VPWR VGND VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_163 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_259 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_108 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_281 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
X_1571_ _1710_/Q _1497_/B _1353_/A _1571_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__o21a_2
X_1640_ _1640_/Q fanout181/X _1640_/D _1653_/CLK VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_2
XANTENNA_4 _1737_/A VGND VPWR VPWR VGND sky130_fd_sc_hd__diode_2
X_1005_ VGND VPWR _1406_/A _1621_/Q _1005_/B VGND VPWR sky130_fd_sc_hd__xnor2_2
Xoutput52 VPWR VGND nmatrix_row_out_n[15] _1735_/A VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput41 VPWR VGND nmatrix_col_out_n[4] _1138_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput30 VPWR VGND nmatrix_col_out_n[23] _1172_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput63 VPWR VGND nmatrix_rowon_out_n[10] _1731_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput74 VPWR VGND nmatrix_rowon_out_n[7] _1728_/X VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput85 VPWR VGND pmatrix_col_out_n[14] _1092_/Y VGND VPWR sky130_fd_sc_hd__buf_4
Xoutput96 VPWR VGND pmatrix_col_out_n[24] _1118_/X VGND VPWR sky130_fd_sc_hd__buf_4
X_1485_ _1534_/D _1626_/Q _1485_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__nor2_4
X_1554_ _1685_/D _1553_/X _1551_/X _1548_/X _1549_/X VGND VPWR VGND VPWR sky130_fd_sc_hd__a31o_2
X_1623_ _1623_/Q fanout178/X _1623_/D _1384_/B VGND VPWR VGND VPWR sky130_fd_sc_hd__dfrtp_4
.ends
