* NGSPICE file created from adc_clkgen_with_edgedetect_native.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkdlybuf4s50_2 abstract view
.subckt sky130_fd_sc_hd__clkdlybuf4s50_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VGND VPWR VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_2 abstract view
.subckt sky130_fd_sc_hd__o21ba_2 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_2 abstract view
.subckt sky130_fd_sc_hd__and2b_2 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

.subckt adc_clkgen_with_edgedetect_native VGND VPWR clk_comp clk_dig comp_trig ena_in
+ start_conv
XFILLER_79_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_2.genblk1\[189\].delay_unit clkgen.delay_200ns_2.genblk1\[189\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[190\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[488\].delay_unit clkgen.delay_200ns_2.genblk1\[488\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[489\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_27_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[302\].delay_unit clkgen.delay_200ns_2.genblk1\[302\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[303\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[126\].delay_unit edgedetect.delay_400ns.genblk1\[126\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[127\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[425\].delay_unit edgedetect.delay_400ns.genblk1\[425\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[426\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[336\].delay_unit clkgen.delay_200ns_1.genblk1\[336\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[337\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[724\].delay_unit edgedetect.delay_400ns.genblk1\[724\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[725\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_58_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[191\].delay_unit clkgen.delay_200ns_2.genblk1\[191\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[192\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_41_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[490\].delay_unit clkgen.delay_200ns_2.genblk1\[490\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[491\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[44\].delay_unit edgedetect.delay_400ns.genblk1\[44\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[45\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_68_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_91 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[1009\].delay_unit edgedetect.delay_400ns.genblk1\[1009\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1010\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[334\].delay_unit clkgen.delay_200ns_3.genblk1\[334\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[335\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[6\].delay_unit clkgen.delay_200ns_2.genblk1\[6\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[7\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[368\].delay_unit clkgen.delay_200ns_2.genblk1\[368\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[369\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_67_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_331 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[305\].delay_unit edgedetect.delay_400ns.genblk1\[305\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[306\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[216\].delay_unit clkgen.delay_200ns_1.genblk1\[216\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[217\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_23_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[604\].delay_unit edgedetect.delay_400ns.genblk1\[604\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[605\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[515\].delay_unit clkgen.delay_200ns_1.genblk1\[515\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[516\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_107 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[903\].delay_unit edgedetect.delay_400ns.genblk1\[903\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[904\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1011\].delay_unit edgedetect.delay_400ns.genblk1\[1011\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1012\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_77_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[370\].delay_unit clkgen.delay_200ns_2.genblk1\[370\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[371\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_37_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[194\].delay_unit edgedetect.delay_400ns.genblk1\[194\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[195\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[493\].delay_unit edgedetect.delay_400ns.genblk1\[493\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[494\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[13\].delay_unit clkgen.delay_200ns_3.genblk1\[13\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[14\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[792\].delay_unit edgedetect.delay_400ns.genblk1\[792\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[793\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_78_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[214\].delay_unit clkgen.delay_200ns_3.genblk1\[214\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[215\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[15\].delay_unit clkgen.delay_200ns_1.genblk1\[15\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[16\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[513\].delay_unit clkgen.delay_200ns_3.genblk1\[513\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[514\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[248\].delay_unit clkgen.delay_200ns_2.genblk1\[248\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[249\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[47\].delay_unit clkgen.delay_200ns_2.genblk1\[47\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[48\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[969\].delay_unit edgedetect.delay_400ns.genblk1\[969\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[970\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[1077\].delay_unit edgedetect.delay_400ns.genblk1\[1077\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1078\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[250\].delay_unit clkgen.delay_200ns_2.genblk1\[250\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[251\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[79\].delay_unit clkgen.delay_200ns_3.genblk1\[79\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[80\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[373\].delay_unit edgedetect.delay_400ns.genblk1\[373\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[374\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[284\].delay_unit clkgen.delay_200ns_1.genblk1\[284\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[285\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[672\].delay_unit edgedetect.delay_400ns.genblk1\[672\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[673\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[971\].delay_unit edgedetect.delay_400ns.genblk1\[971\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[972\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_386 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[128\].delay_unit clkgen.delay_200ns_2.genblk1\[128\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[129\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[427\].delay_unit clkgen.delay_200ns_2.genblk1\[427\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[428\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[81\].delay_unit clkgen.delay_200ns_3.genblk1\[81\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[82\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_56_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[849\].delay_unit edgedetect.delay_400ns.genblk1\[849\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[850\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[282\].delay_unit clkgen.delay_200ns_3.genblk1\[282\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[283\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_1.genblk1\[83\].delay_unit clkgen.delay_200ns_1.genblk1\[83\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[84\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_69_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[130\].delay_unit clkgen.delay_200ns_2.genblk1\[130\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[131\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_43_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[253\].delay_unit edgedetect.delay_400ns.genblk1\[253\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[254\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[164\].delay_unit clkgen.delay_200ns_1.genblk1\[164\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[165\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[552\].delay_unit edgedetect.delay_400ns.genblk1\[552\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[553\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[463\].delay_unit clkgen.delay_200ns_1.genblk1\[463\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[464\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[851\].delay_unit edgedetect.delay_400ns.genblk1\[851\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[852\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_3.genblk1\[459\].delay_unit clkgen.delay_200ns_3.genblk1\[459\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[460\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[307\].delay_unit clkgen.delay_200ns_2.genblk1\[307\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[308\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_89_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[729\].delay_unit edgedetect.delay_400ns.genblk1\[729\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[730\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[162\].delay_unit clkgen.delay_200ns_3.genblk1\[162\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[163\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_52_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[461\].delay_unit clkgen.delay_200ns_3.genblk1\[461\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[462\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_71_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[196\].delay_unit clkgen.delay_200ns_2.genblk1\[196\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[197\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[495\].delay_unit clkgen.delay_200ns_2.genblk1\[495\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[496\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[49\].delay_unit edgedetect.delay_400ns.genblk1\[49\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[50\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[133\].delay_unit edgedetect.delay_400ns.genblk1\[133\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[134\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_16_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[432\].delay_unit edgedetect.delay_400ns.genblk1\[432\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[433\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_71_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[343\].delay_unit clkgen.delay_200ns_1.genblk1\[343\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[344\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_43_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[731\].delay_unit edgedetect.delay_400ns.genblk1\[731\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[732\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_31_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[339\].delay_unit clkgen.delay_200ns_3.genblk1\[339\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[340\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_407 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[51\].delay_unit edgedetect.delay_400ns.genblk1\[51\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[52\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_81_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xedgedetect.delay_400ns.genblk1\[609\].delay_unit edgedetect.delay_400ns.genblk1\[609\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[610\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[908\].delay_unit edgedetect.delay_400ns.genblk1\[908\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[909\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_89_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[341\].delay_unit clkgen.delay_200ns_3.genblk1\[341\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[342\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1016\].delay_unit edgedetect.delay_400ns.genblk1\[1016\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1017\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[375\].delay_unit clkgen.delay_200ns_2.genblk1\[375\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[376\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_15_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[199\].delay_unit edgedetect.delay_400ns.genblk1\[199\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[200\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_15_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[18\].delay_unit clkgen.delay_200ns_3.genblk1\[18\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[19\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[498\].delay_unit edgedetect.delay_400ns.genblk1\[498\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[499\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[797\].delay_unit edgedetect.delay_400ns.genblk1\[797\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[798\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[312\].delay_unit edgedetect.delay_400ns.genblk1\[312\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[313\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[223\].delay_unit clkgen.delay_200ns_1.genblk1\[223\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[224\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[611\].delay_unit edgedetect.delay_400ns.genblk1\[611\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[612\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[219\].delay_unit clkgen.delay_200ns_3.genblk1\[219\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[220\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[522\].delay_unit clkgen.delay_200ns_1.genblk1\[522\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[523\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[910\].delay_unit edgedetect.delay_400ns.genblk1\[910\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[911\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_56_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[518\].delay_unit clkgen.delay_200ns_3.genblk1\[518\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[519\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_56_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[20\].delay_unit clkgen.delay_200ns_3.genblk1\[20\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[21\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[221\].delay_unit clkgen.delay_200ns_3.genblk1\[221\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[222\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[22\].delay_unit clkgen.delay_200ns_1.genblk1\[22\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[23\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[520\].delay_unit clkgen.delay_200ns_3.genblk1\[520\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[521\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_77_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkgen.delay_200ns_2.genblk1\[255\].delay_unit clkgen.delay_200ns_2.genblk1\[255\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[256\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_77_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[378\].delay_unit edgedetect.delay_400ns.genblk1\[378\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[379\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[289\].delay_unit clkgen.delay_200ns_1.genblk1\[289\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[290\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[677\].delay_unit edgedetect.delay_400ns.genblk1\[677\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[678\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_45_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[976\].delay_unit edgedetect.delay_400ns.genblk1\[976\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[977\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_53_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[54\].delay_unit clkgen.delay_200ns_2.genblk1\[54\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[55\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[103\].delay_unit clkgen.delay_200ns_1.genblk1\[103\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[104\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_13_178 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_1.genblk1\[402\].delay_unit clkgen.delay_200ns_1.genblk1\[402\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[403\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_79 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[86\].delay_unit clkgen.delay_200ns_3.genblk1\[86\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[87\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_17_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[380\].delay_unit edgedetect.delay_400ns.genblk1\[380\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[381\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[291\].delay_unit clkgen.delay_200ns_1.genblk1\[291\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[292\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[287\].delay_unit clkgen.delay_200ns_3.genblk1\[287\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[288\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[88\].delay_unit clkgen.delay_200ns_1.genblk1\[88\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[89\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[101\].delay_unit clkgen.delay_200ns_3.genblk1\[101\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[102\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_82_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[400\].delay_unit clkgen.delay_200ns_3.genblk1\[400\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[401\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_2.genblk1\[135\].delay_unit clkgen.delay_200ns_2.genblk1\[135\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[136\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[434\].delay_unit clkgen.delay_200ns_2.genblk1\[434\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[435\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_119 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[258\].delay_unit edgedetect.delay_400ns.genblk1\[258\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[259\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[169\].delay_unit clkgen.delay_200ns_1.genblk1\[169\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[170\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[557\].delay_unit edgedetect.delay_400ns.genblk1\[557\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[558\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[468\].delay_unit clkgen.delay_200ns_1.genblk1\[468\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[469\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[856\].delay_unit edgedetect.delay_400ns.genblk1\[856\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[857\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[90\].delay_unit clkgen.delay_200ns_1.genblk1\[90\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[91\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[260\].delay_unit edgedetect.delay_400ns.genblk1\[260\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[261\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[171\].delay_unit clkgen.delay_200ns_1.genblk1\[171\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[172\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_76_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_1.genblk1\[470\].delay_unit clkgen.delay_200ns_1.genblk1\[470\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[471\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[167\].delay_unit clkgen.delay_200ns_3.genblk1\[167\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[168\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_64_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[466\].delay_unit clkgen.delay_200ns_3.genblk1\[466\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[467\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_58_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[314\].delay_unit clkgen.delay_200ns_2.genblk1\[314\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[315\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_67_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[138\].delay_unit edgedetect.delay_400ns.genblk1\[138\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[139\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[437\].delay_unit edgedetect.delay_400ns.genblk1\[437\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[438\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[348\].delay_unit clkgen.delay_200ns_1.genblk1\[348\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[349\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[736\].delay_unit edgedetect.delay_400ns.genblk1\[736\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[737\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_398 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[56\].delay_unit edgedetect.delay_400ns.genblk1\[56\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[57\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_61_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_71 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[140\].delay_unit edgedetect.delay_400ns.genblk1\[140\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[141\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_69_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_1.genblk1\[350\].delay_unit clkgen.delay_200ns_1.genblk1\[350\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[351\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[346\].delay_unit clkgen.delay_200ns_3.genblk1\[346\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[347\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_56_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[317\].delay_unit edgedetect.delay_400ns.genblk1\[317\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[318\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_87_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[228\].delay_unit clkgen.delay_200ns_1.genblk1\[228\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[229\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[616\].delay_unit edgedetect.delay_400ns.genblk1\[616\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[617\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[527\].delay_unit clkgen.delay_200ns_1.genblk1\[527\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[528\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_55_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[915\].delay_unit edgedetect.delay_400ns.genblk1\[915\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[916\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1023\].delay_unit edgedetect.delay_400ns.genblk1\[1023\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1024\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_34_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_2.genblk1\[382\].delay_unit clkgen.delay_200ns_2.genblk1\[382\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[383\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[25\].delay_unit clkgen.delay_200ns_3.genblk1\[25\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[26\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_75_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_1.genblk1\[230\].delay_unit clkgen.delay_200ns_1.genblk1\[230\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[231\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[226\].delay_unit clkgen.delay_200ns_3.genblk1\[226\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[227\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[27\].delay_unit clkgen.delay_200ns_1.genblk1\[27\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[28\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[525\].delay_unit clkgen.delay_200ns_3.genblk1\[525\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[526\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_69_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_279 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_90 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[59\].delay_unit clkgen.delay_200ns_2.genblk1\[59\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[60\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[108\].delay_unit clkgen.delay_200ns_1.genblk1\[108\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[109\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_1.genblk1\[407\].delay_unit clkgen.delay_200ns_1.genblk1\[407\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[408\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[262\].delay_unit clkgen.delay_200ns_2.genblk1\[262\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[263\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_31_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[385\].delay_unit edgedetect.delay_400ns.genblk1\[385\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[386\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[296\].delay_unit clkgen.delay_200ns_1.genblk1\[296\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[297\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_68 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[684\].delay_unit edgedetect.delay_400ns.genblk1\[684\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[685\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_2.genblk1\[61\].delay_unit clkgen.delay_200ns_2.genblk1\[61\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[62\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[983\].delay_unit edgedetect.delay_400ns.genblk1\[983\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[984\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[110\].delay_unit clkgen.delay_200ns_1.genblk1\[110\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[111\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_54_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[106\].delay_unit clkgen.delay_200ns_3.genblk1\[106\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[107\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_34_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[405\].delay_unit clkgen.delay_200ns_3.genblk1\[405\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[406\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[439\].delay_unit clkgen.delay_200ns_2.genblk1\[439\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[440\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[93\].delay_unit clkgen.delay_200ns_3.genblk1\[93\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[94\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_89_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[294\].delay_unit clkgen.delay_200ns_3.genblk1\[294\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[295\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_53_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_1.genblk1\[95\].delay_unit clkgen.delay_200ns_1.genblk1\[95\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[96\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[142\].delay_unit clkgen.delay_200ns_2.genblk1\[142\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[143\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[441\].delay_unit clkgen.delay_200ns_2.genblk1\[441\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[442\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[265\].delay_unit edgedetect.delay_400ns.genblk1\[265\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[266\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[176\].delay_unit clkgen.delay_200ns_1.genblk1\[176\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[177\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_16_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[564\].delay_unit edgedetect.delay_400ns.genblk1\[564\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[565\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_71_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_1.genblk1\[475\].delay_unit clkgen.delay_200ns_1.genblk1\[475\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[476\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[863\].delay_unit edgedetect.delay_400ns.genblk1\[863\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[864\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[319\].delay_unit clkgen.delay_200ns_2.genblk1\[319\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[320\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[174\].delay_unit clkgen.delay_200ns_3.genblk1\[174\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[175\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[473\].delay_unit clkgen.delay_200ns_3.genblk1\[473\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[474\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[321\].delay_unit clkgen.delay_200ns_2.genblk1\[321\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[322\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[145\].delay_unit edgedetect.delay_400ns.genblk1\[145\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[146\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[444\].delay_unit edgedetect.delay_400ns.genblk1\[444\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[445\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[355\].delay_unit clkgen.delay_200ns_1.genblk1\[355\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[356\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[743\].delay_unit edgedetect.delay_400ns.genblk1\[743\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[744\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_76_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[5\].delay_unit clkgen.delay_200ns_1.genblk1\[5\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[6\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[63\].delay_unit edgedetect.delay_400ns.genblk1\[63\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[64\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_67_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[353\].delay_unit clkgen.delay_200ns_3.genblk1\[353\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[354\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1028\].delay_unit edgedetect.delay_400ns.genblk1\[1028\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1029\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_12_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[387\].delay_unit clkgen.delay_200ns_2.genblk1\[387\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[388\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_77_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[201\].delay_unit clkgen.delay_200ns_2.genblk1\[201\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[202\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[500\].delay_unit clkgen.delay_200ns_2.genblk1\[500\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[501\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_53_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[324\].delay_unit edgedetect.delay_400ns.genblk1\[324\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[325\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[235\].delay_unit clkgen.delay_200ns_1.genblk1\[235\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[236\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[623\].delay_unit edgedetect.delay_400ns.genblk1\[623\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[624\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[534\].delay_unit clkgen.delay_200ns_1.genblk1\[534\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[535\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[922\].delay_unit edgedetect.delay_400ns.genblk1\[922\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[923\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1030\].delay_unit edgedetect.delay_400ns.genblk1\[1030\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1031\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_37_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[32\].delay_unit clkgen.delay_200ns_3.genblk1\[32\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[33\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[233\].delay_unit clkgen.delay_200ns_3.genblk1\[233\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[234\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_82_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[34\].delay_unit clkgen.delay_200ns_1.genblk1\[34\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[35\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[532\].delay_unit clkgen.delay_200ns_3.genblk1\[532\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[533\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_70_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[267\].delay_unit clkgen.delay_200ns_2.genblk1\[267\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[268\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_400ns.genblk1\[689\].delay_unit edgedetect.delay_400ns.genblk1\[689\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[690\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_78_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[66\].delay_unit clkgen.delay_200ns_2.genblk1\[66\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[67\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[988\].delay_unit edgedetect.delay_400ns.genblk1\[988\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[989\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[204\].delay_unit edgedetect.delay_400ns.genblk1\[204\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[205\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_65_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[115\].delay_unit clkgen.delay_200ns_1.genblk1\[115\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[116\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[503\].delay_unit edgedetect.delay_400ns.genblk1\[503\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[504\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[414\].delay_unit clkgen.delay_200ns_1.genblk1\[414\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[415\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[802\].delay_unit edgedetect.delay_400ns.genblk1\[802\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[803\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_3.genblk1\[98\].delay_unit clkgen.delay_200ns_3.genblk1\[98\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[99\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_36_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[392\].delay_unit edgedetect.delay_400ns.genblk1\[392\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[393\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_64_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[691\].delay_unit edgedetect.delay_400ns.genblk1\[691\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[692\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[299\].delay_unit clkgen.delay_200ns_3.genblk1\[299\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[300\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[990\].delay_unit edgedetect.delay_400ns.genblk1\[990\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[991\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[113\].delay_unit clkgen.delay_200ns_3.genblk1\[113\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[114\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[412\].delay_unit clkgen.delay_200ns_3.genblk1\[412\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[413\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_87_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[147\].delay_unit clkgen.delay_200ns_2.genblk1\[147\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[148\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[446\].delay_unit clkgen.delay_200ns_2.genblk1\[446\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[447\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[569\].delay_unit edgedetect.delay_400ns.genblk1\[569\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[570\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_51_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[868\].delay_unit edgedetect.delay_400ns.genblk1\[868\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[869\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[272\].delay_unit edgedetect.delay_400ns.genblk1\[272\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[273\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[183\].delay_unit clkgen.delay_200ns_1.genblk1\[183\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[184\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[571\].delay_unit edgedetect.delay_400ns.genblk1\[571\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[572\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[482\].delay_unit clkgen.delay_200ns_1.genblk1\[482\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[483\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[179\].delay_unit clkgen.delay_200ns_3.genblk1\[179\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[180\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[870\].delay_unit edgedetect.delay_400ns.genblk1\[870\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[871\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[478\].delay_unit clkgen.delay_200ns_3.genblk1\[478\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[479\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_52_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[326\].delay_unit clkgen.delay_200ns_2.genblk1\[326\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[327\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_88_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[449\].delay_unit edgedetect.delay_400ns.genblk1\[449\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[450\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_75_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[748\].delay_unit edgedetect.delay_400ns.genblk1\[748\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[749\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_16_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[181\].delay_unit clkgen.delay_200ns_3.genblk1\[181\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[182\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_71_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_3.genblk1\[480\].delay_unit clkgen.delay_200ns_3.genblk1\[480\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[481\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[68\].delay_unit edgedetect.delay_400ns.genblk1\[68\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[69\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_86_71 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[152\].delay_unit edgedetect.delay_400ns.genblk1\[152\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[153\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_34_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[451\].delay_unit edgedetect.delay_400ns.genblk1\[451\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[452\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[362\].delay_unit clkgen.delay_200ns_1.genblk1\[362\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[363\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[750\].delay_unit edgedetect.delay_400ns.genblk1\[750\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[751\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[358\].delay_unit clkgen.delay_200ns_3.genblk1\[358\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[359\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[206\].delay_unit clkgen.delay_200ns_2.genblk1\[206\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[207\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_13_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[70\].delay_unit edgedetect.delay_400ns.genblk1\[70\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[71\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_15_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[505\].delay_unit clkgen.delay_200ns_2.genblk1\[505\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[506\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[329\].delay_unit edgedetect.delay_400ns.genblk1\[329\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[330\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[628\].delay_unit edgedetect.delay_400ns.genblk1\[628\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[629\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[539\].delay_unit clkgen.delay_200ns_1.genblk1\[539\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[540\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[927\].delay_unit edgedetect.delay_400ns.genblk1\[927\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[928\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[1035\].delay_unit edgedetect.delay_400ns.genblk1\[1035\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1036\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[360\].delay_unit clkgen.delay_200ns_3.genblk1\[360\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[361\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[394\].delay_unit clkgen.delay_200ns_2.genblk1\[394\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[395\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[37\].delay_unit clkgen.delay_200ns_3.genblk1\[37\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[38\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_86_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_400ns.genblk1\[331\].delay_unit edgedetect.delay_400ns.genblk1\[331\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[332\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[242\].delay_unit clkgen.delay_200ns_1.genblk1\[242\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[243\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[630\].delay_unit edgedetect.delay_400ns.genblk1\[630\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[631\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[238\].delay_unit clkgen.delay_200ns_3.genblk1\[238\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[239\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[39\].delay_unit clkgen.delay_200ns_1.genblk1\[39\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[40\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[537\].delay_unit clkgen.delay_200ns_3.genblk1\[537\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[538\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[209\].delay_unit edgedetect.delay_400ns.genblk1\[209\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[210\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_38_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[508\].delay_unit edgedetect.delay_400ns.genblk1\[508\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[509\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_53_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[419\].delay_unit clkgen.delay_200ns_1.genblk1\[419\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[420\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[807\].delay_unit edgedetect.delay_400ns.genblk1\[807\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[808\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[240\].delay_unit clkgen.delay_200ns_3.genblk1\[240\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[241\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[41\].delay_unit clkgen.delay_200ns_1.genblk1\[41\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[42\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[274\].delay_unit clkgen.delay_200ns_2.genblk1\[274\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[275\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[397\].delay_unit edgedetect.delay_400ns.genblk1\[397\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[398\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_17_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[696\].delay_unit edgedetect.delay_400ns.genblk1\[696\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[697\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[73\].delay_unit clkgen.delay_200ns_2.genblk1\[73\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[74\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[995\].delay_unit edgedetect.delay_400ns.genblk1\[995\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[996\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[211\].delay_unit edgedetect.delay_400ns.genblk1\[211\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[212\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[122\].delay_unit clkgen.delay_200ns_1.genblk1\[122\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[123\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_66_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[510\].delay_unit edgedetect.delay_400ns.genblk1\[510\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[511\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[421\].delay_unit clkgen.delay_200ns_1.genblk1\[421\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[422\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[118\].delay_unit clkgen.delay_200ns_3.genblk1\[118\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[119\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[417\].delay_unit clkgen.delay_200ns_3.genblk1\[417\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[418\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_86_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[120\].delay_unit clkgen.delay_200ns_3.genblk1\[120\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[121\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[154\].delay_unit clkgen.delay_200ns_2.genblk1\[154\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[155\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[453\].delay_unit clkgen.delay_200ns_2.genblk1\[453\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[454\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[277\].delay_unit edgedetect.delay_400ns.genblk1\[277\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[278\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_78_94 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[188\].delay_unit clkgen.delay_200ns_1.genblk1\[188\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[189\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[576\].delay_unit edgedetect.delay_400ns.genblk1\[576\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[577\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[487\].delay_unit clkgen.delay_200ns_1.genblk1\[487\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[488\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[875\].delay_unit edgedetect.delay_400ns.genblk1\[875\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[876\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[301\].delay_unit clkgen.delay_200ns_1.genblk1\[301\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[302\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_1.genblk1\[190\].delay_unit clkgen.delay_200ns_1.genblk1\[190\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[191\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_70_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_12 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[186\].delay_unit clkgen.delay_200ns_3.genblk1\[186\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[187\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[485\].delay_unit clkgen.delay_200ns_3.genblk1\[485\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[486\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[333\].delay_unit clkgen.delay_200ns_2.genblk1\[333\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[334\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_64_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[157\].delay_unit edgedetect.delay_400ns.genblk1\[157\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[158\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[456\].delay_unit edgedetect.delay_400ns.genblk1\[456\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[457\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[367\].delay_unit clkgen.delay_200ns_1.genblk1\[367\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[368\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[755\].delay_unit edgedetect.delay_400ns.genblk1\[755\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[756\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_69_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[75\].delay_unit edgedetect.delay_400ns.genblk1\[75\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[76\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_3.genblk1\[365\].delay_unit clkgen.delay_200ns_3.genblk1\[365\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[366\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_83_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[399\].delay_unit clkgen.delay_200ns_2.genblk1\[399\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[400\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[213\].delay_unit clkgen.delay_200ns_2.genblk1\[213\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[214\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[512\].delay_unit clkgen.delay_200ns_2.genblk1\[512\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[513\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[336\].delay_unit edgedetect.delay_400ns.genblk1\[336\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[337\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_75_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[247\].delay_unit clkgen.delay_200ns_1.genblk1\[247\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[248\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[635\].delay_unit edgedetect.delay_400ns.genblk1\[635\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[636\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[12\].delay_unit clkgen.delay_200ns_2.genblk1\[12\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[13\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[934\].delay_unit edgedetect.delay_400ns.genblk1\[934\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[935\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1042\].delay_unit edgedetect.delay_400ns.genblk1\[1042\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1043\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_84_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[44\].delay_unit clkgen.delay_200ns_3.genblk1\[44\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[45\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_52_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_318 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[245\].delay_unit clkgen.delay_200ns_3.genblk1\[245\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[246\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[46\].delay_unit clkgen.delay_200ns_1.genblk1\[46\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[47\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[279\].delay_unit clkgen.delay_200ns_2.genblk1\[279\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[280\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[78\].delay_unit clkgen.delay_200ns_2.genblk1\[78\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[79\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[216\].delay_unit edgedetect.delay_400ns.genblk1\[216\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[217\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[127\].delay_unit clkgen.delay_200ns_1.genblk1\[127\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[128\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[515\].delay_unit edgedetect.delay_400ns.genblk1\[515\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[516\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_1.genblk1\[426\].delay_unit clkgen.delay_200ns_1.genblk1\[426\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[427\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[814\].delay_unit edgedetect.delay_400ns.genblk1\[814\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[815\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_86_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[281\].delay_unit clkgen.delay_200ns_2.genblk1\[281\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[282\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_2.genblk1\[80\].delay_unit clkgen.delay_200ns_2.genblk1\[80\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[81\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[125\].delay_unit clkgen.delay_200ns_3.genblk1\[125\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[126\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[424\].delay_unit clkgen.delay_200ns_3.genblk1\[424\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[425\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[159\].delay_unit clkgen.delay_200ns_2.genblk1\[159\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[160\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[458\].delay_unit clkgen.delay_200ns_2.genblk1\[458\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[459\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_76_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_1.genblk1\[306\].delay_unit clkgen.delay_200ns_1.genblk1\[306\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[307\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[161\].delay_unit clkgen.delay_200ns_2.genblk1\[161\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[162\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[460\].delay_unit clkgen.delay_200ns_2.genblk1\[460\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[461\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_432 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[284\].delay_unit edgedetect.delay_400ns.genblk1\[284\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[285\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[14\].delay_unit edgedetect.delay_400ns.genblk1\[14\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[15\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_50_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_1.genblk1\[195\].delay_unit clkgen.delay_200ns_1.genblk1\[195\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[196\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_50_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_295 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[583\].delay_unit edgedetect.delay_400ns.genblk1\[583\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[584\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[494\].delay_unit clkgen.delay_200ns_1.genblk1\[494\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[495\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[882\].delay_unit edgedetect.delay_400ns.genblk1\[882\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[883\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_89_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_3.genblk1\[304\].delay_unit clkgen.delay_200ns_3.genblk1\[304\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[305\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[338\].delay_unit clkgen.delay_200ns_2.genblk1\[338\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[339\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[193\].delay_unit clkgen.delay_200ns_3.genblk1\[193\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[194\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_67_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[492\].delay_unit clkgen.delay_200ns_3.genblk1\[492\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[493\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_76_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_295 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[340\].delay_unit clkgen.delay_200ns_2.genblk1\[340\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[341\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[164\].delay_unit edgedetect.delay_400ns.genblk1\[164\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[165\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_79_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[463\].delay_unit edgedetect.delay_400ns.genblk1\[463\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[464\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[374\].delay_unit clkgen.delay_200ns_1.genblk1\[374\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[375\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_55_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[762\].delay_unit edgedetect.delay_400ns.genblk1\[762\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[763\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_23_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[218\].delay_unit clkgen.delay_200ns_2.genblk1\[218\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[219\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[82\].delay_unit edgedetect.delay_400ns.genblk1\[82\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[83\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_58_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_2.genblk1\[517\].delay_unit clkgen.delay_200ns_2.genblk1\[517\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[518\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_58_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[939\].delay_unit edgedetect.delay_400ns.genblk1\[939\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[940\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[17\].delay_unit clkgen.delay_200ns_2.genblk1\[17\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[18\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1047\].delay_unit edgedetect.delay_400ns.genblk1\[1047\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1048\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[372\].delay_unit clkgen.delay_200ns_3.genblk1\[372\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[373\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[220\].delay_unit clkgen.delay_200ns_2.genblk1\[220\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[221\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[49\].delay_unit clkgen.delay_200ns_3.genblk1\[49\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[50\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[343\].delay_unit edgedetect.delay_400ns.genblk1\[343\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[344\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[254\].delay_unit clkgen.delay_200ns_1.genblk1\[254\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[255\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[642\].delay_unit edgedetect.delay_400ns.genblk1\[642\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[643\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_87_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[941\].delay_unit edgedetect.delay_400ns.genblk1\[941\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[942\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_87_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[51\].delay_unit clkgen.delay_200ns_3.genblk1\[51\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[52\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[819\].delay_unit edgedetect.delay_400ns.genblk1\[819\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[820\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[252\].delay_unit clkgen.delay_200ns_3.genblk1\[252\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[253\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[53\].delay_unit clkgen.delay_200ns_1.genblk1\[53\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[54\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_80_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[286\].delay_unit clkgen.delay_200ns_2.genblk1\[286\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[287\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[100\].delay_unit clkgen.delay_200ns_2.genblk1\[99\].delay_unit/X
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[101\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_84_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[85\].delay_unit clkgen.delay_200ns_2.genblk1\[85\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[86\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[223\].delay_unit edgedetect.delay_400ns.genblk1\[223\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[224\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[134\].delay_unit clkgen.delay_200ns_1.genblk1\[134\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[135\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[522\].delay_unit edgedetect.delay_400ns.genblk1\[522\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[523\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[433\].delay_unit clkgen.delay_200ns_1.genblk1\[433\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[434\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[821\].delay_unit edgedetect.delay_400ns.genblk1\[821\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[822\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[429\].delay_unit clkgen.delay_200ns_3.genblk1\[429\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[430\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_13 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_68 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[132\].delay_unit clkgen.delay_200ns_3.genblk1\[132\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[133\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_66_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[431\].delay_unit clkgen.delay_200ns_3.genblk1\[431\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[432\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[166\].delay_unit clkgen.delay_200ns_2.genblk1\[166\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[167\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_61_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[465\].delay_unit clkgen.delay_200ns_2.genblk1\[465\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[466\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[289\].delay_unit edgedetect.delay_400ns.genblk1\[289\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[290\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[19\].delay_unit edgedetect.delay_400ns.genblk1\[19\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[20\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[588\].delay_unit edgedetect.delay_400ns.genblk1\[588\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[589\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[499\].delay_unit clkgen.delay_200ns_1.genblk1\[499\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[500\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[887\].delay_unit edgedetect.delay_400ns.genblk1\[887\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[888\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[103\].delay_unit edgedetect.delay_400ns.genblk1\[103\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[104\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[402\].delay_unit edgedetect.delay_400ns.genblk1\[402\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[403\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[313\].delay_unit clkgen.delay_200ns_1.genblk1\[313\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[314\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[701\].delay_unit edgedetect.delay_400ns.genblk1\[701\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[702\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_77_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[309\].delay_unit clkgen.delay_200ns_3.genblk1\[309\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[310\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_25_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xedgedetect.delay_400ns.genblk1\[291\].delay_unit edgedetect.delay_400ns.genblk1\[291\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[292\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[21\].delay_unit edgedetect.delay_400ns.genblk1\[21\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[22\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_400ns.genblk1\[590\].delay_unit edgedetect.delay_400ns.genblk1\[590\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[591\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[198\].delay_unit clkgen.delay_200ns_3.genblk1\[198\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[199\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[497\].delay_unit clkgen.delay_200ns_3.genblk1\[497\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[498\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_43_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_3.genblk1\[311\].delay_unit clkgen.delay_200ns_3.genblk1\[311\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[312\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_2.genblk1\[345\].delay_unit clkgen.delay_200ns_2.genblk1\[345\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[346\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[169\].delay_unit edgedetect.delay_400ns.genblk1\[169\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[170\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[468\].delay_unit edgedetect.delay_400ns.genblk1\[468\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[469\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_62_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[379\].delay_unit clkgen.delay_200ns_1.genblk1\[379\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[380\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[767\].delay_unit edgedetect.delay_400ns.genblk1\[767\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[768\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_34_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_3.genblk1\[3\].delay_unit clkgen.delay_200ns_3.genblk1\[3\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[4\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[87\].delay_unit edgedetect.delay_400ns.genblk1\[87\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[88\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_25_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[171\].delay_unit edgedetect.delay_400ns.genblk1\[171\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[172\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[470\].delay_unit edgedetect.delay_400ns.genblk1\[470\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[471\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[381\].delay_unit clkgen.delay_200ns_1.genblk1\[381\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[382\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_3.genblk1\[377\].delay_unit clkgen.delay_200ns_3.genblk1\[377\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[378\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_88_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_400 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[225\].delay_unit clkgen.delay_200ns_2.genblk1\[225\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[226\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_12_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[524\].delay_unit clkgen.delay_200ns_2.genblk1\[524\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[525\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[348\].delay_unit edgedetect.delay_400ns.genblk1\[348\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[349\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_1.genblk1\[259\].delay_unit clkgen.delay_200ns_1.genblk1\[259\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[260\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[647\].delay_unit edgedetect.delay_400ns.genblk1\[647\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[648\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_79_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[24\].delay_unit clkgen.delay_200ns_2.genblk1\[24\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[25\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[946\].delay_unit edgedetect.delay_400ns.genblk1\[946\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[947\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_54_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[1054\].delay_unit edgedetect.delay_400ns.genblk1\[1054\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1055\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[56\].delay_unit clkgen.delay_200ns_3.genblk1\[56\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[57\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[350\].delay_unit edgedetect.delay_400ns.genblk1\[350\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[351\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_26_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[261\].delay_unit clkgen.delay_200ns_1.genblk1\[261\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[262\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_38_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[257\].delay_unit clkgen.delay_200ns_3.genblk1\[257\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[258\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_1.genblk1\[58\].delay_unit clkgen.delay_200ns_1.genblk1\[58\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[59\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_315 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[105\].delay_unit clkgen.delay_200ns_2.genblk1\[105\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[106\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_76_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkgen.delay_200ns_2.genblk1\[404\].delay_unit clkgen.delay_200ns_2.genblk1\[404\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[405\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[228\].delay_unit edgedetect.delay_400ns.genblk1\[228\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[229\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_44_274 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[139\].delay_unit clkgen.delay_200ns_1.genblk1\[139\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[140\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[527\].delay_unit edgedetect.delay_400ns.genblk1\[527\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[528\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_120 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[438\].delay_unit clkgen.delay_200ns_1.genblk1\[438\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[439\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[826\].delay_unit edgedetect.delay_400ns.genblk1\[826\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[827\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_1.genblk1\[60\].delay_unit clkgen.delay_200ns_1.genblk1\[60\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[61\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[293\].delay_unit clkgen.delay_200ns_2.genblk1\[293\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[294\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_23_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_400ns.genblk1\[230\].delay_unit edgedetect.delay_400ns.genblk1\[230\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[231\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[92\].delay_unit clkgen.delay_200ns_2.genblk1\[92\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[93\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[141\].delay_unit clkgen.delay_200ns_1.genblk1\[141\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[142\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[440\].delay_unit clkgen.delay_200ns_1.genblk1\[440\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[441\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[137\].delay_unit clkgen.delay_200ns_3.genblk1\[137\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[138\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_85_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_3.genblk1\[436\].delay_unit clkgen.delay_200ns_3.genblk1\[436\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[437\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_81_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[108\].delay_unit edgedetect.delay_400ns.genblk1\[108\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[109\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[407\].delay_unit edgedetect.delay_400ns.genblk1\[407\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[408\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[318\].delay_unit clkgen.delay_200ns_1.genblk1\[318\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[319\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[706\].delay_unit edgedetect.delay_400ns.genblk1\[706\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[707\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_17_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[173\].delay_unit clkgen.delay_200ns_2.genblk1\[173\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[174\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_87_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[472\].delay_unit clkgen.delay_200ns_2.genblk1\[472\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[473\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[296\].delay_unit edgedetect.delay_400ns.genblk1\[296\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[297\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[26\].delay_unit edgedetect.delay_400ns.genblk1\[26\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[27\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[595\].delay_unit edgedetect.delay_400ns.genblk1\[595\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[596\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_82_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[894\].delay_unit edgedetect.delay_400ns.genblk1\[894\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[895\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_55_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[110\].delay_unit edgedetect.delay_400ns.genblk1\[110\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[111\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[320\].delay_unit clkgen.delay_200ns_1.genblk1\[320\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[321\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[316\].delay_unit clkgen.delay_200ns_3.genblk1\[316\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[317\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_58_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[8\].delay_unit clkgen.delay_200ns_3.genblk1\[8\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[9\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_37_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[352\].delay_unit clkgen.delay_200ns_2.genblk1\[352\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[353\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_400ns.genblk1\[176\].delay_unit edgedetect.delay_400ns.genblk1\[176\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[177\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[475\].delay_unit edgedetect.delay_400ns.genblk1\[475\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[476\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[386\].delay_unit clkgen.delay_200ns_1.genblk1\[386\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[387\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[774\].delay_unit edgedetect.delay_400ns.genblk1\[774\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[775\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_87_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_1.genblk1\[200\].delay_unit clkgen.delay_200ns_1.genblk1\[200\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[201\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[94\].delay_unit edgedetect.delay_400ns.genblk1\[94\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[95\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_50_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[529\].delay_unit clkgen.delay_200ns_2.genblk1\[529\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[530\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[29\].delay_unit clkgen.delay_200ns_2.genblk1\[29\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[30\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[384\].delay_unit clkgen.delay_200ns_3.genblk1\[384\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[385\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1059\].delay_unit edgedetect.delay_400ns.genblk1\[1059\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1060\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_27_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[232\].delay_unit clkgen.delay_200ns_2.genblk1\[232\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[233\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[531\].delay_unit clkgen.delay_200ns_2.genblk1\[531\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[532\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[355\].delay_unit edgedetect.delay_400ns.genblk1\[355\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[356\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_65_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[266\].delay_unit clkgen.delay_200ns_1.genblk1\[266\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[267\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_372 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[654\].delay_unit edgedetect.delay_400ns.genblk1\[654\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[655\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[953\].delay_unit edgedetect.delay_400ns.genblk1\[953\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[954\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[31\].delay_unit clkgen.delay_200ns_2.genblk1\[31\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[32\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1061\].delay_unit edgedetect.delay_400ns.genblk1\[1061\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1062\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_88_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[409\].delay_unit clkgen.delay_200ns_2.genblk1\[409\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[410\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_12_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[63\].delay_unit clkgen.delay_200ns_3.genblk1\[63\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[64\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_43_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[264\].delay_unit clkgen.delay_200ns_3.genblk1\[264\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[265\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[65\].delay_unit clkgen.delay_200ns_1.genblk1\[65\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[66\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_272 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkgen.delay_200ns_2.genblk1\[298\].delay_unit clkgen.delay_200ns_2.genblk1\[298\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[299\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[112\].delay_unit clkgen.delay_200ns_2.genblk1\[112\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[113\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[411\].delay_unit clkgen.delay_200ns_2.genblk1\[411\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[412\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_89_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[235\].delay_unit edgedetect.delay_400ns.genblk1\[235\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[236\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[97\].delay_unit clkgen.delay_200ns_2.genblk1\[97\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[98\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_1.genblk1\[146\].delay_unit clkgen.delay_200ns_1.genblk1\[146\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[147\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[534\].delay_unit edgedetect.delay_400ns.genblk1\[534\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[535\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_1.genblk1\[445\].delay_unit clkgen.delay_200ns_1.genblk1\[445\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[446\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_72_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[833\].delay_unit edgedetect.delay_400ns.genblk1\[833\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[834\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_65_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_456 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_331 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[144\].delay_unit clkgen.delay_200ns_3.genblk1\[144\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[145\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[443\].delay_unit clkgen.delay_200ns_3.genblk1\[443\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[444\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[178\].delay_unit clkgen.delay_200ns_2.genblk1\[178\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[179\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[477\].delay_unit clkgen.delay_200ns_2.genblk1\[477\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[478\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[899\].delay_unit edgedetect.delay_400ns.genblk1\[899\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[900\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[115\].delay_unit edgedetect.delay_400ns.genblk1\[115\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[116\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_15_191 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[414\].delay_unit edgedetect.delay_400ns.genblk1\[414\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[415\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[325\].delay_unit clkgen.delay_200ns_1.genblk1\[325\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[326\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[713\].delay_unit edgedetect.delay_400ns.genblk1\[713\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[714\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_2.genblk1\[180\].delay_unit clkgen.delay_200ns_2.genblk1\[180\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[181\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_26_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[33\].delay_unit edgedetect.delay_400ns.genblk1\[33\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[34\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[323\].delay_unit clkgen.delay_200ns_3.genblk1\[323\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[324\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_44_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_2.genblk1\[357\].delay_unit clkgen.delay_200ns_2.genblk1\[357\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[358\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_86_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[779\].delay_unit edgedetect.delay_400ns.genblk1\[779\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[780\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_79_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_323 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[205\].delay_unit clkgen.delay_200ns_1.genblk1\[205\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[206\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[504\].delay_unit clkgen.delay_200ns_1.genblk1\[504\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[505\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_50_278 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[1000\].delay_unit edgedetect.delay_400ns.genblk1\[999\].delay_unit/X
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1001\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[99\].delay_unit edgedetect.delay_400ns.genblk1\[99\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[99\].delay_unit/X sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_58_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[183\].delay_unit edgedetect.delay_400ns.genblk1\[183\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[184\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_85_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[482\].delay_unit edgedetect.delay_400ns.genblk1\[482\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[483\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[393\].delay_unit clkgen.delay_200ns_1.genblk1\[393\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[394\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[781\].delay_unit edgedetect.delay_400ns.genblk1\[781\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[782\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_26_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[389\].delay_unit clkgen.delay_200ns_3.genblk1\[389\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[390\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[203\].delay_unit clkgen.delay_200ns_3.genblk1\[203\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[204\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[502\].delay_unit clkgen.delay_200ns_3.genblk1\[502\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[503\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[237\].delay_unit clkgen.delay_200ns_2.genblk1\[237\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[238\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_76_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[536\].delay_unit clkgen.delay_200ns_2.genblk1\[536\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[537\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[659\].delay_unit edgedetect.delay_400ns.genblk1\[659\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[660\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[36\].delay_unit clkgen.delay_200ns_2.genblk1\[36\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[37\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[958\].delay_unit edgedetect.delay_400ns.genblk1\[958\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[959\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_64_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[1066\].delay_unit edgedetect.delay_400ns.genblk1\[1066\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1067\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[391\].delay_unit clkgen.delay_200ns_3.genblk1\[391\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[392\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_87_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_94 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_3.genblk1\[68\].delay_unit clkgen.delay_200ns_3.genblk1\[68\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[69\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[362\].delay_unit edgedetect.delay_400ns.genblk1\[362\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[363\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[273\].delay_unit clkgen.delay_200ns_1.genblk1\[273\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[274\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[661\].delay_unit edgedetect.delay_400ns.genblk1\[661\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[662\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[269\].delay_unit clkgen.delay_200ns_3.genblk1\[269\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[270\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[960\].delay_unit edgedetect.delay_400ns.genblk1\[960\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[961\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_54_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_400 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[117\].delay_unit clkgen.delay_200ns_2.genblk1\[117\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[118\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_89_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_2.genblk1\[416\].delay_unit clkgen.delay_200ns_2.genblk1\[416\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[417\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[70\].delay_unit clkgen.delay_200ns_3.genblk1\[70\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[71\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[539\].delay_unit edgedetect.delay_400ns.genblk1\[539\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[540\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[838\].delay_unit edgedetect.delay_400ns.genblk1\[838\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[839\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_37_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[271\].delay_unit clkgen.delay_200ns_3.genblk1\[271\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[272\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[72\].delay_unit clkgen.delay_200ns_1.genblk1\[72\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[73\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[242\].delay_unit edgedetect.delay_400ns.genblk1\[242\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[243\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_34_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[153\].delay_unit clkgen.delay_200ns_1.genblk1\[153\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[154\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_51_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[541\].delay_unit edgedetect.delay_400ns.genblk1\[541\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[542\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[452\].delay_unit clkgen.delay_200ns_1.genblk1\[452\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[453\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_50_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[840\].delay_unit edgedetect.delay_400ns.genblk1\[840\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[841\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[149\].delay_unit clkgen.delay_200ns_3.genblk1\[149\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[150\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[448\].delay_unit clkgen.delay_200ns_3.genblk1\[448\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[449\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[419\].delay_unit edgedetect.delay_400ns.genblk1\[419\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[420\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[718\].delay_unit edgedetect.delay_400ns.genblk1\[718\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[719\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[2\].delay_unit edgedetect.delay_400ns.genblk1\[2\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[3\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[151\].delay_unit clkgen.delay_200ns_3.genblk1\[151\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[152\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[450\].delay_unit clkgen.delay_200ns_3.genblk1\[450\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[451\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_80_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[185\].delay_unit clkgen.delay_200ns_2.genblk1\[185\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[186\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[484\].delay_unit clkgen.delay_200ns_2.genblk1\[484\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[485\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[38\].delay_unit edgedetect.delay_400ns.genblk1\[38\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[39\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[122\].delay_unit edgedetect.delay_400ns.genblk1\[122\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[123\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_75_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[421\].delay_unit edgedetect.delay_400ns.genblk1\[421\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[422\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_56_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_1.genblk1\[332\].delay_unit clkgen.delay_200ns_1.genblk1\[332\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[333\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_45_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[720\].delay_unit edgedetect.delay_400ns.genblk1\[720\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[721\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[328\].delay_unit clkgen.delay_200ns_3.genblk1\[328\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[329\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_45_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_71 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[40\].delay_unit edgedetect.delay_400ns.genblk1\[40\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[41\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_86_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[509\].delay_unit clkgen.delay_200ns_1.genblk1\[509\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[510\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[330\].delay_unit clkgen.delay_200ns_3.genblk1\[330\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[331\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1005\].delay_unit edgedetect.delay_400ns.genblk1\[1005\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1006\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[2\].delay_unit clkgen.delay_200ns_2.genblk1\[2\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[3\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_2.genblk1\[364\].delay_unit clkgen.delay_200ns_2.genblk1\[364\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[365\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_65_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[188\].delay_unit edgedetect.delay_400ns.genblk1\[188\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[189\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[487\].delay_unit edgedetect.delay_400ns.genblk1\[487\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[488\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[398\].delay_unit clkgen.delay_200ns_1.genblk1\[398\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[399\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[786\].delay_unit edgedetect.delay_400ns.genblk1\[786\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[787\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[301\].delay_unit edgedetect.delay_400ns.genblk1\[301\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[302\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[212\].delay_unit clkgen.delay_200ns_1.genblk1\[212\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[213\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[600\].delay_unit edgedetect.delay_400ns.genblk1\[600\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[601\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_88_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[208\].delay_unit clkgen.delay_200ns_3.genblk1\[208\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[209\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[511\].delay_unit clkgen.delay_200ns_1.genblk1\[511\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[512\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[507\].delay_unit clkgen.delay_200ns_3.genblk1\[507\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[508\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_56_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[190\].delay_unit edgedetect.delay_400ns.genblk1\[190\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[191\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[396\].delay_unit clkgen.delay_200ns_3.genblk1\[396\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[397\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_67_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[210\].delay_unit clkgen.delay_200ns_3.genblk1\[210\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[211\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_1.genblk1\[11\].delay_unit clkgen.delay_200ns_1.genblk1\[11\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[12\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[244\].delay_unit clkgen.delay_200ns_2.genblk1\[244\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[245\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[367\].delay_unit edgedetect.delay_400ns.genblk1\[367\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[368\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_1.genblk1\[278\].delay_unit clkgen.delay_200ns_1.genblk1\[278\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[279\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_85_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[666\].delay_unit edgedetect.delay_400ns.genblk1\[666\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[667\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[965\].delay_unit edgedetect.delay_400ns.genblk1\[965\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[966\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[43\].delay_unit clkgen.delay_200ns_2.genblk1\[43\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[44\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1073\].delay_unit edgedetect.delay_400ns.genblk1\[1073\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1074\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[75\].delay_unit clkgen.delay_200ns_3.genblk1\[75\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[76\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_76_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[280\].delay_unit clkgen.delay_200ns_1.genblk1\[280\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[281\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[276\].delay_unit clkgen.delay_200ns_3.genblk1\[276\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[277\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[77\].delay_unit clkgen.delay_200ns_1.genblk1\[77\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[78\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[124\].delay_unit clkgen.delay_200ns_2.genblk1\[124\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[125\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkgen.delay_200ns_2.genblk1\[423\].delay_unit clkgen.delay_200ns_2.genblk1\[423\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[424\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[247\].delay_unit edgedetect.delay_400ns.genblk1\[247\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[248\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_31_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[158\].delay_unit clkgen.delay_200ns_1.genblk1\[158\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[159\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[546\].delay_unit edgedetect.delay_400ns.genblk1\[546\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[547\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[457\].delay_unit clkgen.delay_200ns_1.genblk1\[457\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[458\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[845\].delay_unit edgedetect.delay_400ns.genblk1\[845\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[846\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[160\].delay_unit clkgen.delay_200ns_1.genblk1\[160\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[161\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_76_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[156\].delay_unit clkgen.delay_200ns_3.genblk1\[156\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[157\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_64_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[7\].delay_unit edgedetect.delay_400ns.genblk1\[7\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[8\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkgen.delay_200ns_3.genblk1\[455\].delay_unit clkgen.delay_200ns_3.genblk1\[455\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[456\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_17_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[489\].delay_unit clkgen.delay_200ns_2.genblk1\[489\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[490\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[303\].delay_unit clkgen.delay_200ns_2.genblk1\[303\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[304\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[127\].delay_unit edgedetect.delay_400ns.genblk1\[127\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[128\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_82_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[426\].delay_unit edgedetect.delay_400ns.genblk1\[426\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[427\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_55_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[337\].delay_unit clkgen.delay_200ns_1.genblk1\[337\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[338\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[725\].delay_unit edgedetect.delay_400ns.genblk1\[725\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[726\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_23_268 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[192\].delay_unit clkgen.delay_200ns_2.genblk1\[192\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[193\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_78_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[491\].delay_unit clkgen.delay_200ns_2.genblk1\[491\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[492\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_58_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[45\].delay_unit edgedetect.delay_400ns.genblk1\[45\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[46\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[335\].delay_unit clkgen.delay_200ns_3.genblk1\[335\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[336\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_77_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[7\].delay_unit clkgen.delay_200ns_2.genblk1\[7\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[8\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[369\].delay_unit clkgen.delay_200ns_2.genblk1\[369\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[370\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_45_371 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[306\].delay_unit edgedetect.delay_400ns.genblk1\[306\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[307\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[217\].delay_unit clkgen.delay_200ns_1.genblk1\[217\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[218\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_87_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[605\].delay_unit edgedetect.delay_400ns.genblk1\[605\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[606\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_68_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[516\].delay_unit clkgen.delay_200ns_1.genblk1\[516\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[517\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[904\].delay_unit edgedetect.delay_400ns.genblk1\[904\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[905\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_55_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[1012\].delay_unit edgedetect.delay_400ns.genblk1\[1012\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1013\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_83_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[371\].delay_unit clkgen.delay_200ns_2.genblk1\[371\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[372\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[195\].delay_unit edgedetect.delay_400ns.genblk1\[195\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[196\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[494\].delay_unit edgedetect.delay_400ns.genblk1\[494\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[495\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[14\].delay_unit clkgen.delay_200ns_3.genblk1\[14\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[15\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[793\].delay_unit edgedetect.delay_400ns.genblk1\[793\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[794\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[215\].delay_unit clkgen.delay_200ns_3.genblk1\[215\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[216\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[16\].delay_unit clkgen.delay_200ns_1.genblk1\[16\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[17\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[514\].delay_unit clkgen.delay_200ns_3.genblk1\[514\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[515\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_231 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[249\].delay_unit clkgen.delay_200ns_2.genblk1\[249\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[250\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[48\].delay_unit clkgen.delay_200ns_2.genblk1\[48\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[49\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_80_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[1078\].delay_unit edgedetect.delay_400ns.genblk1\[1078\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1079\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_68_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[251\].delay_unit clkgen.delay_200ns_2.genblk1\[251\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[252\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[374\].delay_unit edgedetect.delay_400ns.genblk1\[374\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[375\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[285\].delay_unit clkgen.delay_200ns_1.genblk1\[285\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[286\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_61_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[673\].delay_unit edgedetect.delay_400ns.genblk1\[673\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[674\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[50\].delay_unit clkgen.delay_200ns_2.genblk1\[50\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[51\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[972\].delay_unit edgedetect.delay_400ns.genblk1\[972\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[973\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_79_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[1080\].delay_unit edgedetect.delay_400ns.genblk1\[1080\].delay_unit/A
+ VGND VGND VPWR VPWR _2_/A_N sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[129\].delay_unit clkgen.delay_200ns_2.genblk1\[129\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[130\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_62_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[428\].delay_unit clkgen.delay_200ns_2.genblk1\[428\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[429\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[82\].delay_unit clkgen.delay_200ns_3.genblk1\[82\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[83\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_3.genblk1\[283\].delay_unit clkgen.delay_200ns_3.genblk1\[283\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[284\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_38_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[84\].delay_unit clkgen.delay_200ns_1.genblk1\[84\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[85\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_65_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_2.genblk1\[131\].delay_unit clkgen.delay_200ns_2.genblk1\[131\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[132\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_88_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[430\].delay_unit clkgen.delay_200ns_2.genblk1\[430\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[431\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_88_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[254\].delay_unit edgedetect.delay_400ns.genblk1\[254\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[255\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[165\].delay_unit clkgen.delay_200ns_1.genblk1\[165\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[166\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[553\].delay_unit edgedetect.delay_400ns.genblk1\[553\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[554\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_56_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[464\].delay_unit clkgen.delay_200ns_1.genblk1\[464\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[465\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[852\].delay_unit edgedetect.delay_400ns.genblk1\[852\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[853\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[308\].delay_unit clkgen.delay_200ns_2.genblk1\[308\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[309\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_3.genblk1\[163\].delay_unit clkgen.delay_200ns_3.genblk1\[163\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[164\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[462\].delay_unit clkgen.delay_200ns_3.genblk1\[462\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[463\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_2.genblk1\[197\].delay_unit clkgen.delay_200ns_2.genblk1\[197\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[198\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_2.genblk1\[496\].delay_unit clkgen.delay_200ns_2.genblk1\[496\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[497\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[310\].delay_unit clkgen.delay_200ns_2.genblk1\[310\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[311\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[134\].delay_unit edgedetect.delay_400ns.genblk1\[134\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[135\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[433\].delay_unit edgedetect.delay_400ns.genblk1\[433\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[434\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[344\].delay_unit clkgen.delay_200ns_1.genblk1\[344\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[345\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[732\].delay_unit edgedetect.delay_400ns.genblk1\[732\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[733\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_88_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[52\].delay_unit edgedetect.delay_400ns.genblk1\[52\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[53\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_82_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[909\].delay_unit edgedetect.delay_400ns.genblk1\[909\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[910\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[342\].delay_unit clkgen.delay_200ns_3.genblk1\[342\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[343\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_23_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[1017\].delay_unit edgedetect.delay_400ns.genblk1\[1017\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1018\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_12_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[376\].delay_unit clkgen.delay_200ns_2.genblk1\[376\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[377\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[19\].delay_unit clkgen.delay_200ns_3.genblk1\[19\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[20\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[499\].delay_unit edgedetect.delay_400ns.genblk1\[499\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[500\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_85_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[798\].delay_unit edgedetect.delay_400ns.genblk1\[798\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[799\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_37_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[313\].delay_unit edgedetect.delay_400ns.genblk1\[313\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[314\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_81_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_1.genblk1\[224\].delay_unit clkgen.delay_200ns_1.genblk1\[224\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[225\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_41_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[612\].delay_unit edgedetect.delay_400ns.genblk1\[612\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[613\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[523\].delay_unit clkgen.delay_200ns_1.genblk1\[523\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[524\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[911\].delay_unit edgedetect.delay_400ns.genblk1\[911\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[912\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_3.genblk1\[519\].delay_unit clkgen.delay_200ns_3.genblk1\[519\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[520\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_89_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[21\].delay_unit clkgen.delay_200ns_3.genblk1\[21\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[22\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[222\].delay_unit clkgen.delay_200ns_3.genblk1\[222\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[223\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[23\].delay_unit clkgen.delay_200ns_1.genblk1\[23\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[24\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_55_306 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[521\].delay_unit clkgen.delay_200ns_3.genblk1\[521\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[522\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_82_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[256\].delay_unit clkgen.delay_200ns_2.genblk1\[256\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[257\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[379\].delay_unit edgedetect.delay_400ns.genblk1\[379\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[380\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[678\].delay_unit edgedetect.delay_400ns.genblk1\[678\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[679\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[55\].delay_unit clkgen.delay_200ns_2.genblk1\[55\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[56\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[977\].delay_unit edgedetect.delay_400ns.genblk1\[977\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[978\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[104\].delay_unit clkgen.delay_200ns_1.genblk1\[104\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[105\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_86_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_1.genblk1\[403\].delay_unit clkgen.delay_200ns_1.genblk1\[403\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[404\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_73_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[87\].delay_unit clkgen.delay_200ns_3.genblk1\[87\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[88\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[381\].delay_unit edgedetect.delay_400ns.genblk1\[381\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[382\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[292\].delay_unit clkgen.delay_200ns_1.genblk1\[292\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[293\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[680\].delay_unit edgedetect.delay_400ns.genblk1\[680\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[681\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_38_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[288\].delay_unit clkgen.delay_200ns_3.genblk1\[288\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[289\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[89\].delay_unit clkgen.delay_200ns_1.genblk1\[89\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[90\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_52_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[102\].delay_unit clkgen.delay_200ns_3.genblk1\[102\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[103\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_13_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[401\].delay_unit clkgen.delay_200ns_3.genblk1\[401\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[402\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[136\].delay_unit clkgen.delay_200ns_2.genblk1\[136\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[137\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[435\].delay_unit clkgen.delay_200ns_2.genblk1\[435\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[436\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[259\].delay_unit edgedetect.delay_400ns.genblk1\[259\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[260\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_68_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[558\].delay_unit edgedetect.delay_400ns.genblk1\[558\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[559\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_43_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkgen.delay_200ns_1.genblk1\[469\].delay_unit clkgen.delay_200ns_1.genblk1\[469\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[470\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[857\].delay_unit edgedetect.delay_400ns.genblk1\[857\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[858\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[290\].delay_unit clkgen.delay_200ns_3.genblk1\[290\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[291\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[91\].delay_unit clkgen.delay_200ns_1.genblk1\[91\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[92\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_12 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[261\].delay_unit edgedetect.delay_400ns.genblk1\[261\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[262\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[172\].delay_unit clkgen.delay_200ns_1.genblk1\[172\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[173\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_400ns.genblk1\[560\].delay_unit edgedetect.delay_400ns.genblk1\[560\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[561\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_1.genblk1\[471\].delay_unit clkgen.delay_200ns_1.genblk1\[471\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[472\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[168\].delay_unit clkgen.delay_200ns_3.genblk1\[168\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[169\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[467\].delay_unit clkgen.delay_200ns_3.genblk1\[467\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[468\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_460 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[315\].delay_unit clkgen.delay_200ns_2.genblk1\[315\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[316\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[139\].delay_unit edgedetect.delay_400ns.genblk1\[139\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[140\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[438\].delay_unit edgedetect.delay_400ns.genblk1\[438\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[439\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[349\].delay_unit clkgen.delay_200ns_1.genblk1\[349\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[350\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[737\].delay_unit edgedetect.delay_400ns.genblk1\[737\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[738\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_68_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[170\].delay_unit clkgen.delay_200ns_3.genblk1\[170\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[171\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_83_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[57\].delay_unit edgedetect.delay_400ns.genblk1\[57\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[58\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[141\].delay_unit edgedetect.delay_400ns.genblk1\[141\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[142\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[440\].delay_unit edgedetect.delay_400ns.genblk1\[440\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[441\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_1.genblk1\[351\].delay_unit clkgen.delay_200ns_1.genblk1\[351\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[352\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[347\].delay_unit clkgen.delay_200ns_3.genblk1\[347\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[348\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_51_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[1\].delay_unit comp_trig VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[2\].delay_unit/A
+ sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_518 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[318\].delay_unit edgedetect.delay_400ns.genblk1\[318\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[319\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[229\].delay_unit clkgen.delay_200ns_1.genblk1\[229\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[230\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[617\].delay_unit edgedetect.delay_400ns.genblk1\[617\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[618\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[528\].delay_unit clkgen.delay_200ns_1.genblk1\[528\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[529\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_31_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[916\].delay_unit edgedetect.delay_400ns.genblk1\[916\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[917\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1024\].delay_unit edgedetect.delay_400ns.genblk1\[1024\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1025\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_88_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[383\].delay_unit clkgen.delay_200ns_2.genblk1\[383\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[384\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_3.genblk1\[26\].delay_unit clkgen.delay_200ns_3.genblk1\[26\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[27\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[320\].delay_unit edgedetect.delay_400ns.genblk1\[320\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[321\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[231\].delay_unit clkgen.delay_200ns_1.genblk1\[231\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[232\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[530\].delay_unit clkgen.delay_200ns_1.genblk1\[530\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[531\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[227\].delay_unit clkgen.delay_200ns_3.genblk1\[227\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[228\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_1.genblk1\[28\].delay_unit clkgen.delay_200ns_1.genblk1\[28\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[29\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[526\].delay_unit clkgen.delay_200ns_3.genblk1\[526\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[527\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[109\].delay_unit clkgen.delay_200ns_1.genblk1\[109\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[110\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[408\].delay_unit clkgen.delay_200ns_1.genblk1\[408\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[409\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_53_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[30\].delay_unit clkgen.delay_200ns_1.genblk1\[30\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[31\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[263\].delay_unit clkgen.delay_200ns_2.genblk1\[263\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[264\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_88_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[386\].delay_unit edgedetect.delay_400ns.genblk1\[386\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[387\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[297\].delay_unit clkgen.delay_200ns_1.genblk1\[297\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[298\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_17_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[685\].delay_unit edgedetect.delay_400ns.genblk1\[685\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[686\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_83_67 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[984\].delay_unit edgedetect.delay_400ns.genblk1\[984\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[985\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_16_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[62\].delay_unit clkgen.delay_200ns_2.genblk1\[62\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[63\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[200\].delay_unit edgedetect.delay_400ns.genblk1\[200\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[201\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[111\].delay_unit clkgen.delay_200ns_1.genblk1\[111\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[112\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[410\].delay_unit clkgen.delay_200ns_1.genblk1\[410\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[411\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[107\].delay_unit clkgen.delay_200ns_3.genblk1\[107\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[108\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[406\].delay_unit clkgen.delay_200ns_3.genblk1\[406\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[407\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[94\].delay_unit clkgen.delay_200ns_3.genblk1\[94\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[95\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_50_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[295\].delay_unit clkgen.delay_200ns_3.genblk1\[295\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[296\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[96\].delay_unit clkgen.delay_200ns_1.genblk1\[96\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[97\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[143\].delay_unit clkgen.delay_200ns_2.genblk1\[143\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[144\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[442\].delay_unit clkgen.delay_200ns_2.genblk1\[442\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[443\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[266\].delay_unit edgedetect.delay_400ns.genblk1\[266\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[267\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[177\].delay_unit clkgen.delay_200ns_1.genblk1\[177\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[178\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[565\].delay_unit edgedetect.delay_400ns.genblk1\[565\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[566\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_78_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[476\].delay_unit clkgen.delay_200ns_1.genblk1\[476\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[477\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_89_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[864\].delay_unit edgedetect.delay_400ns.genblk1\[864\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[865\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_76_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_318 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[175\].delay_unit clkgen.delay_200ns_3.genblk1\[175\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[176\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[474\].delay_unit clkgen.delay_200ns_3.genblk1\[474\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[475\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_86_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_2.genblk1\[322\].delay_unit clkgen.delay_200ns_2.genblk1\[322\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[323\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[146\].delay_unit edgedetect.delay_400ns.genblk1\[146\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[147\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[445\].delay_unit edgedetect.delay_400ns.genblk1\[445\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[446\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_80_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[356\].delay_unit clkgen.delay_200ns_1.genblk1\[356\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[357\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_80_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[744\].delay_unit edgedetect.delay_400ns.genblk1\[744\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[745\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_1.genblk1\[6\].delay_unit clkgen.delay_200ns_1.genblk1\[6\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[7\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[64\].delay_unit edgedetect.delay_400ns.genblk1\[64\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[65\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_72_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[1029\].delay_unit edgedetect.delay_400ns.genblk1\[1029\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1030\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[354\].delay_unit clkgen.delay_200ns_3.genblk1\[354\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[355\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_68_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[388\].delay_unit clkgen.delay_200ns_2.genblk1\[388\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[389\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[202\].delay_unit clkgen.delay_200ns_2.genblk1\[202\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[203\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[501\].delay_unit clkgen.delay_200ns_2.genblk1\[501\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[502\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_78_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[325\].delay_unit edgedetect.delay_400ns.genblk1\[325\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[326\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[236\].delay_unit clkgen.delay_200ns_1.genblk1\[236\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[237\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_75_24 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[624\].delay_unit edgedetect.delay_400ns.genblk1\[624\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[625\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_75_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[535\].delay_unit clkgen.delay_200ns_1.genblk1\[535\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[536\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[923\].delay_unit edgedetect.delay_400ns.genblk1\[923\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[924\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[1031\].delay_unit edgedetect.delay_400ns.genblk1\[1031\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1032\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[390\].delay_unit clkgen.delay_200ns_2.genblk1\[390\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[391\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[33\].delay_unit clkgen.delay_200ns_3.genblk1\[33\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[34\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_65_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[234\].delay_unit clkgen.delay_200ns_3.genblk1\[234\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[235\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[35\].delay_unit clkgen.delay_200ns_1.genblk1\[35\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[36\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[533\].delay_unit clkgen.delay_200ns_3.genblk1\[533\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[534\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_2.genblk1\[268\].delay_unit clkgen.delay_200ns_2.genblk1\[268\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[269\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_68_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[67\].delay_unit clkgen.delay_200ns_2.genblk1\[67\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[68\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[989\].delay_unit edgedetect.delay_400ns.genblk1\[989\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[990\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[205\].delay_unit edgedetect.delay_400ns.genblk1\[205\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[206\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[116\].delay_unit clkgen.delay_200ns_1.genblk1\[116\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[117\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[504\].delay_unit edgedetect.delay_400ns.genblk1\[504\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[505\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[415\].delay_unit clkgen.delay_200ns_1.genblk1\[415\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[416\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[803\].delay_unit edgedetect.delay_400ns.genblk1\[803\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[804\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[99\].delay_unit clkgen.delay_200ns_3.genblk1\[99\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[99\].delay_unit/X sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_2.genblk1\[270\].delay_unit clkgen.delay_200ns_2.genblk1\[270\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[271\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_27_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[393\].delay_unit edgedetect.delay_400ns.genblk1\[393\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[394\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[692\].delay_unit edgedetect.delay_400ns.genblk1\[692\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[693\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[991\].delay_unit edgedetect.delay_400ns.genblk1\[991\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[992\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[114\].delay_unit clkgen.delay_200ns_3.genblk1\[114\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[115\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_65_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[413\].delay_unit clkgen.delay_200ns_3.genblk1\[413\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[414\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[148\].delay_unit clkgen.delay_200ns_2.genblk1\[148\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[149\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[447\].delay_unit clkgen.delay_200ns_2.genblk1\[447\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[448\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_88_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[869\].delay_unit edgedetect.delay_400ns.genblk1\[869\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[870\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_56_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[150\].delay_unit clkgen.delay_200ns_2.genblk1\[150\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[151\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_79_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[273\].delay_unit edgedetect.delay_400ns.genblk1\[273\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[274\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[184\].delay_unit clkgen.delay_200ns_1.genblk1\[184\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[185\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[572\].delay_unit edgedetect.delay_400ns.genblk1\[572\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[573\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_62_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_1.genblk1\[483\].delay_unit clkgen.delay_200ns_1.genblk1\[483\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[484\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_43_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[871\].delay_unit edgedetect.delay_400ns.genblk1\[871\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[872\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_62_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[479\].delay_unit clkgen.delay_200ns_3.genblk1\[479\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[480\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[327\].delay_unit clkgen.delay_200ns_2.genblk1\[327\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[328\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[749\].delay_unit edgedetect.delay_400ns.genblk1\[749\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[750\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[182\].delay_unit clkgen.delay_200ns_3.genblk1\[182\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[183\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_88_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_3.genblk1\[481\].delay_unit clkgen.delay_200ns_3.genblk1\[481\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[482\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_67_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_79 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[69\].delay_unit edgedetect.delay_400ns.genblk1\[69\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[70\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_12_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[153\].delay_unit edgedetect.delay_400ns.genblk1\[153\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[154\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_331 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[452\].delay_unit edgedetect.delay_400ns.genblk1\[452\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[453\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[363\].delay_unit clkgen.delay_200ns_1.genblk1\[363\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[364\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[751\].delay_unit edgedetect.delay_400ns.genblk1\[751\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[752\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[359\].delay_unit clkgen.delay_200ns_3.genblk1\[359\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[360\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[207\].delay_unit clkgen.delay_200ns_2.genblk1\[207\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[208\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[71\].delay_unit edgedetect.delay_400ns.genblk1\[71\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[72\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[506\].delay_unit clkgen.delay_200ns_2.genblk1\[506\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[507\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[629\].delay_unit edgedetect.delay_400ns.genblk1\[629\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[630\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_81_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[928\].delay_unit edgedetect.delay_400ns.genblk1\[928\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[929\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_81_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[361\].delay_unit clkgen.delay_200ns_3.genblk1\[361\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[362\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1036\].delay_unit edgedetect.delay_400ns.genblk1\[1036\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1037\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_78_13 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[395\].delay_unit clkgen.delay_200ns_2.genblk1\[395\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[396\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[38\].delay_unit clkgen.delay_200ns_3.genblk1\[38\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[39\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_17_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[332\].delay_unit edgedetect.delay_400ns.genblk1\[332\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[333\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[243\].delay_unit clkgen.delay_200ns_1.genblk1\[243\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[244\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_43_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[631\].delay_unit edgedetect.delay_400ns.genblk1\[631\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[632\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[930\].delay_unit edgedetect.delay_400ns.genblk1\[930\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[931\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[239\].delay_unit clkgen.delay_200ns_3.genblk1\[239\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[240\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[538\].delay_unit clkgen.delay_200ns_3.genblk1\[538\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[539\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_67_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[40\].delay_unit clkgen.delay_200ns_3.genblk1\[40\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[41\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[509\].delay_unit edgedetect.delay_400ns.genblk1\[509\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[510\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[808\].delay_unit edgedetect.delay_400ns.genblk1\[808\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[809\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_86_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[241\].delay_unit clkgen.delay_200ns_3.genblk1\[241\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[242\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[42\].delay_unit clkgen.delay_200ns_1.genblk1\[42\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[43\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_73_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[540\].delay_unit clkgen.delay_200ns_3.genblk1\[540\].delay_unit/A
+ VGND VGND VPWR VPWR clk_comp sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_54_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[275\].delay_unit clkgen.delay_200ns_2.genblk1\[275\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[276\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[398\].delay_unit edgedetect.delay_400ns.genblk1\[398\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[399\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[697\].delay_unit edgedetect.delay_400ns.genblk1\[697\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[698\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[996\].delay_unit edgedetect.delay_400ns.genblk1\[996\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[997\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[74\].delay_unit clkgen.delay_200ns_2.genblk1\[74\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[75\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[212\].delay_unit edgedetect.delay_400ns.genblk1\[212\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[213\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[123\].delay_unit clkgen.delay_200ns_1.genblk1\[123\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[124\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[511\].delay_unit edgedetect.delay_400ns.genblk1\[511\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[512\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[422\].delay_unit clkgen.delay_200ns_1.genblk1\[422\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[423\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[119\].delay_unit clkgen.delay_200ns_3.genblk1\[119\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[120\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[810\].delay_unit edgedetect.delay_400ns.genblk1\[810\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[811\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[418\].delay_unit clkgen.delay_200ns_3.genblk1\[418\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[419\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_3.genblk1\[121\].delay_unit clkgen.delay_200ns_3.genblk1\[121\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[122\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[420\].delay_unit clkgen.delay_200ns_3.genblk1\[420\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[421\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[155\].delay_unit clkgen.delay_200ns_2.genblk1\[155\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[156\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_75_36 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[454\].delay_unit clkgen.delay_200ns_2.genblk1\[454\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[455\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[278\].delay_unit edgedetect.delay_400ns.genblk1\[278\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[279\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_74_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_1.genblk1\[189\].delay_unit clkgen.delay_200ns_1.genblk1\[189\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[190\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[577\].delay_unit edgedetect.delay_400ns.genblk1\[577\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[578\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[488\].delay_unit clkgen.delay_200ns_1.genblk1\[488\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[489\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[876\].delay_unit edgedetect.delay_400ns.genblk1\[876\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[877\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[302\].delay_unit clkgen.delay_200ns_1.genblk1\[302\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[303\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_77_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_66 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[280\].delay_unit edgedetect.delay_400ns.genblk1\[280\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[281\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[10\].delay_unit edgedetect.delay_400ns.genblk1\[9\].delay_unit/X
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[11\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[191\].delay_unit clkgen.delay_200ns_1.genblk1\[191\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[192\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[490\].delay_unit clkgen.delay_200ns_1.genblk1\[490\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[491\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[187\].delay_unit clkgen.delay_200ns_3.genblk1\[187\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[188\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[486\].delay_unit clkgen.delay_200ns_3.genblk1\[486\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[487\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_56_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[300\].delay_unit clkgen.delay_200ns_3.genblk1\[300\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[301\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_12_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[334\].delay_unit clkgen.delay_200ns_2.genblk1\[334\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[335\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[158\].delay_unit edgedetect.delay_400ns.genblk1\[158\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[159\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_86_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[457\].delay_unit edgedetect.delay_400ns.genblk1\[457\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[458\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[368\].delay_unit clkgen.delay_200ns_1.genblk1\[368\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[369\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_74_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[756\].delay_unit edgedetect.delay_400ns.genblk1\[756\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[757\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[76\].delay_unit edgedetect.delay_400ns.genblk1\[76\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[77\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[160\].delay_unit edgedetect.delay_400ns.genblk1\[160\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[161\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_53_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[370\].delay_unit clkgen.delay_200ns_1.genblk1\[370\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[371\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[366\].delay_unit clkgen.delay_200ns_3.genblk1\[366\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[367\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkgen.delay_200ns_2.genblk1\[214\].delay_unit clkgen.delay_200ns_2.genblk1\[214\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[215\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[513\].delay_unit clkgen.delay_200ns_2.genblk1\[513\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[514\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[337\].delay_unit edgedetect.delay_400ns.genblk1\[337\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[338\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[248\].delay_unit clkgen.delay_200ns_1.genblk1\[248\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[249\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[636\].delay_unit edgedetect.delay_400ns.genblk1\[636\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[637\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_79_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[13\].delay_unit clkgen.delay_200ns_2.genblk1\[13\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[14\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[935\].delay_unit edgedetect.delay_400ns.genblk1\[935\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[936\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1043\].delay_unit edgedetect.delay_400ns.genblk1\[1043\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1044\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_87_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_3.genblk1\[45\].delay_unit clkgen.delay_200ns_3.genblk1\[45\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[46\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_1.genblk1\[250\].delay_unit clkgen.delay_200ns_1.genblk1\[250\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[251\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_3.genblk1\[246\].delay_unit clkgen.delay_200ns_3.genblk1\[246\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[247\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[47\].delay_unit clkgen.delay_200ns_1.genblk1\[47\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[48\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[79\].delay_unit clkgen.delay_200ns_2.genblk1\[79\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[80\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[217\].delay_unit edgedetect.delay_400ns.genblk1\[217\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[218\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[128\].delay_unit clkgen.delay_200ns_1.genblk1\[128\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[129\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_72_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[516\].delay_unit edgedetect.delay_400ns.genblk1\[516\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[517\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[427\].delay_unit clkgen.delay_200ns_1.genblk1\[427\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[428\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_16_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[815\].delay_unit edgedetect.delay_400ns.genblk1\[815\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[816\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_12_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_343 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[282\].delay_unit clkgen.delay_200ns_2.genblk1\[282\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[283\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_2.genblk1\[81\].delay_unit clkgen.delay_200ns_2.genblk1\[81\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[82\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[130\].delay_unit clkgen.delay_200ns_1.genblk1\[130\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[131\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_31_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[126\].delay_unit clkgen.delay_200ns_3.genblk1\[126\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[127\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_3.genblk1\[425\].delay_unit clkgen.delay_200ns_3.genblk1\[425\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[426\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_85_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[459\].delay_unit clkgen.delay_200ns_2.genblk1\[459\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[460\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_26_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_1.genblk1\[307\].delay_unit clkgen.delay_200ns_1.genblk1\[307\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[308\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_76_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[162\].delay_unit clkgen.delay_200ns_2.genblk1\[162\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[163\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_13_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[461\].delay_unit clkgen.delay_200ns_2.genblk1\[461\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[462\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[285\].delay_unit edgedetect.delay_400ns.genblk1\[285\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[286\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[15\].delay_unit edgedetect.delay_400ns.genblk1\[15\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[16\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[196\].delay_unit clkgen.delay_200ns_1.genblk1\[196\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[197\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[584\].delay_unit edgedetect.delay_400ns.genblk1\[584\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[585\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_68_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[495\].delay_unit clkgen.delay_200ns_1.genblk1\[495\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[496\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[883\].delay_unit edgedetect.delay_400ns.genblk1\[883\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[884\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_67_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_291 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[305\].delay_unit clkgen.delay_200ns_3.genblk1\[305\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[306\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[339\].delay_unit clkgen.delay_200ns_2.genblk1\[339\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[340\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[194\].delay_unit clkgen.delay_200ns_3.genblk1\[194\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[195\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[493\].delay_unit clkgen.delay_200ns_3.genblk1\[493\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[494\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_13_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[341\].delay_unit clkgen.delay_200ns_2.genblk1\[341\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[342\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[165\].delay_unit edgedetect.delay_400ns.genblk1\[165\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[166\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[464\].delay_unit edgedetect.delay_400ns.genblk1\[464\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[465\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[375\].delay_unit clkgen.delay_200ns_1.genblk1\[375\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[376\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[763\].delay_unit edgedetect.delay_400ns.genblk1\[763\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[764\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[219\].delay_unit clkgen.delay_200ns_2.genblk1\[219\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[220\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[83\].delay_unit edgedetect.delay_400ns.genblk1\[83\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[84\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[518\].delay_unit clkgen.delay_200ns_2.genblk1\[518\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[519\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_50_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[18\].delay_unit clkgen.delay_200ns_2.genblk1\[18\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[19\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_86_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[373\].delay_unit clkgen.delay_200ns_3.genblk1\[373\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[374\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_75_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_400ns.genblk1\[1048\].delay_unit edgedetect.delay_400ns.genblk1\[1048\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1049\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_2.genblk1\[221\].delay_unit clkgen.delay_200ns_2.genblk1\[221\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[222\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_77_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[520\].delay_unit clkgen.delay_200ns_2.genblk1\[520\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[521\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[344\].delay_unit edgedetect.delay_400ns.genblk1\[344\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[345\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_65_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[255\].delay_unit clkgen.delay_200ns_1.genblk1\[255\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[256\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_78 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[643\].delay_unit edgedetect.delay_400ns.genblk1\[643\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[644\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[942\].delay_unit edgedetect.delay_400ns.genblk1\[942\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[943\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_45_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[20\].delay_unit clkgen.delay_200ns_2.genblk1\[20\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[21\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_60_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[1050\].delay_unit edgedetect.delay_400ns.genblk1\[1050\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1051\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_68_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[52\].delay_unit clkgen.delay_200ns_3.genblk1\[52\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[53\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_24_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[253\].delay_unit clkgen.delay_200ns_3.genblk1\[253\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[254\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[54\].delay_unit clkgen.delay_200ns_1.genblk1\[54\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[55\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_47 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[287\].delay_unit clkgen.delay_200ns_2.genblk1\[287\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[288\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_2.genblk1\[101\].delay_unit clkgen.delay_200ns_2.genblk1\[101\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[102\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[400\].delay_unit clkgen.delay_200ns_2.genblk1\[400\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[401\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[224\].delay_unit edgedetect.delay_400ns.genblk1\[224\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[225\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[86\].delay_unit clkgen.delay_200ns_2.genblk1\[86\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[87\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[135\].delay_unit clkgen.delay_200ns_1.genblk1\[135\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[136\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[523\].delay_unit edgedetect.delay_400ns.genblk1\[523\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[524\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[434\].delay_unit clkgen.delay_200ns_1.genblk1\[434\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[435\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[822\].delay_unit edgedetect.delay_400ns.genblk1\[822\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[823\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_76_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[133\].delay_unit clkgen.delay_200ns_3.genblk1\[133\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[134\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_72_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[432\].delay_unit clkgen.delay_200ns_3.genblk1\[432\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[433\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[167\].delay_unit clkgen.delay_200ns_2.genblk1\[167\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[168\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[466\].delay_unit clkgen.delay_200ns_2.genblk1\[466\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[467\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_79_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[589\].delay_unit edgedetect.delay_400ns.genblk1\[589\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[590\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[888\].delay_unit edgedetect.delay_400ns.genblk1\[888\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[889\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[104\].delay_unit edgedetect.delay_400ns.genblk1\[104\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[105\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_267 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[403\].delay_unit edgedetect.delay_400ns.genblk1\[403\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[404\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[314\].delay_unit clkgen.delay_200ns_1.genblk1\[314\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[315\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[702\].delay_unit edgedetect.delay_400ns.genblk1\[702\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[703\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[292\].delay_unit edgedetect.delay_400ns.genblk1\[292\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[293\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[22\].delay_unit edgedetect.delay_400ns.genblk1\[22\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[23\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[591\].delay_unit edgedetect.delay_400ns.genblk1\[591\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[592\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_61_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[199\].delay_unit clkgen.delay_200ns_3.genblk1\[199\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[200\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[890\].delay_unit edgedetect.delay_400ns.genblk1\[890\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[891\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[498\].delay_unit clkgen.delay_200ns_3.genblk1\[498\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[499\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[312\].delay_unit clkgen.delay_200ns_3.genblk1\[312\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[313\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_76_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[346\].delay_unit clkgen.delay_200ns_2.genblk1\[346\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[347\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_25_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[469\].delay_unit edgedetect.delay_400ns.genblk1\[469\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[470\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[768\].delay_unit edgedetect.delay_400ns.genblk1\[768\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[769\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[4\].delay_unit clkgen.delay_200ns_3.genblk1\[4\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[5\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_50_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[88\].delay_unit edgedetect.delay_400ns.genblk1\[88\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[89\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_400ns.genblk1\[172\].delay_unit edgedetect.delay_400ns.genblk1\[172\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[173\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[471\].delay_unit edgedetect.delay_400ns.genblk1\[471\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[472\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_85_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[382\].delay_unit clkgen.delay_200ns_1.genblk1\[382\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[383\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[770\].delay_unit edgedetect.delay_400ns.genblk1\[770\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[771\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_26_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[378\].delay_unit clkgen.delay_200ns_3.genblk1\[378\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[379\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_34_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[226\].delay_unit clkgen.delay_200ns_2.genblk1\[226\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[227\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[90\].delay_unit edgedetect.delay_400ns.genblk1\[90\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[91\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[525\].delay_unit clkgen.delay_200ns_2.genblk1\[525\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[526\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[349\].delay_unit edgedetect.delay_400ns.genblk1\[349\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[350\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_27_30 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[648\].delay_unit edgedetect.delay_400ns.genblk1\[648\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[649\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_25_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[25\].delay_unit clkgen.delay_200ns_2.genblk1\[25\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[26\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[947\].delay_unit edgedetect.delay_400ns.genblk1\[947\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[948\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[1055\].delay_unit edgedetect.delay_400ns.genblk1\[1055\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1056\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[380\].delay_unit clkgen.delay_200ns_3.genblk1\[380\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[381\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[57\].delay_unit clkgen.delay_200ns_3.genblk1\[57\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[58\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[351\].delay_unit edgedetect.delay_400ns.genblk1\[351\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[352\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[262\].delay_unit clkgen.delay_200ns_1.genblk1\[262\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[263\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[650\].delay_unit edgedetect.delay_400ns.genblk1\[650\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[651\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[258\].delay_unit clkgen.delay_200ns_3.genblk1\[258\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[259\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_86_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_1.genblk1\[59\].delay_unit clkgen.delay_200ns_1.genblk1\[59\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[60\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_86_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[106\].delay_unit clkgen.delay_200ns_2.genblk1\[106\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[107\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[405\].delay_unit clkgen.delay_200ns_2.genblk1\[405\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[406\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[229\].delay_unit edgedetect.delay_400ns.genblk1\[229\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[230\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_89_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[528\].delay_unit edgedetect.delay_400ns.genblk1\[528\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[529\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_77_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[439\].delay_unit clkgen.delay_200ns_1.genblk1\[439\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[440\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[827\].delay_unit edgedetect.delay_400ns.genblk1\[827\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[828\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_77_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[260\].delay_unit clkgen.delay_200ns_3.genblk1\[260\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[261\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[61\].delay_unit clkgen.delay_200ns_1.genblk1\[61\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[62\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_60_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkgen.delay_200ns_2.genblk1\[294\].delay_unit clkgen.delay_200ns_2.genblk1\[294\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[295\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_80 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[231\].delay_unit edgedetect.delay_400ns.genblk1\[231\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[232\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[93\].delay_unit clkgen.delay_200ns_2.genblk1\[93\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[94\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[142\].delay_unit clkgen.delay_200ns_1.genblk1\[142\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[143\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[530\].delay_unit edgedetect.delay_400ns.genblk1\[530\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[531\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_1.genblk1\[441\].delay_unit clkgen.delay_200ns_1.genblk1\[441\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[442\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[138\].delay_unit clkgen.delay_200ns_3.genblk1\[138\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[139\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[437\].delay_unit clkgen.delay_200ns_3.genblk1\[437\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[438\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[109\].delay_unit edgedetect.delay_400ns.genblk1\[109\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[110\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[408\].delay_unit edgedetect.delay_400ns.genblk1\[408\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[409\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_24_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[319\].delay_unit clkgen.delay_200ns_1.genblk1\[319\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[320\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[707\].delay_unit edgedetect.delay_400ns.genblk1\[707\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[708\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_287 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_3.genblk1\[140\].delay_unit clkgen.delay_200ns_3.genblk1\[140\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[141\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[174\].delay_unit clkgen.delay_200ns_2.genblk1\[174\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[175\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_80_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[473\].delay_unit clkgen.delay_200ns_2.genblk1\[473\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[474\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[297\].delay_unit edgedetect.delay_400ns.genblk1\[297\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[298\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[27\].delay_unit edgedetect.delay_400ns.genblk1\[27\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[28\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[596\].delay_unit edgedetect.delay_400ns.genblk1\[596\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[597\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[895\].delay_unit edgedetect.delay_400ns.genblk1\[895\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[896\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_60_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[111\].delay_unit edgedetect.delay_400ns.genblk1\[111\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[112\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[410\].delay_unit edgedetect.delay_400ns.genblk1\[410\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[411\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[321\].delay_unit clkgen.delay_200ns_1.genblk1\[321\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[322\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[317\].delay_unit clkgen.delay_200ns_3.genblk1\[317\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[318\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_68_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_59 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[9\].delay_unit clkgen.delay_200ns_3.genblk1\[9\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[9\].delay_unit/X sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[353\].delay_unit clkgen.delay_200ns_2.genblk1\[353\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[354\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[177\].delay_unit edgedetect.delay_400ns.genblk1\[177\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[178\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_76_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[476\].delay_unit edgedetect.delay_400ns.genblk1\[476\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[477\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[387\].delay_unit clkgen.delay_200ns_1.genblk1\[387\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[388\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[775\].delay_unit edgedetect.delay_400ns.genblk1\[775\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[776\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_61_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_1.genblk1\[201\].delay_unit clkgen.delay_200ns_1.genblk1\[201\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[202\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[500\].delay_unit clkgen.delay_200ns_1.genblk1\[500\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[501\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[95\].delay_unit edgedetect.delay_400ns.genblk1\[95\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[96\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_56_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[385\].delay_unit clkgen.delay_200ns_3.genblk1\[385\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[386\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[233\].delay_unit clkgen.delay_200ns_2.genblk1\[233\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[234\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[532\].delay_unit clkgen.delay_200ns_2.genblk1\[532\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[533\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[356\].delay_unit edgedetect.delay_400ns.genblk1\[356\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[357\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[267\].delay_unit clkgen.delay_200ns_1.genblk1\[267\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[268\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[655\].delay_unit edgedetect.delay_400ns.genblk1\[655\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[656\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_2.genblk1\[32\].delay_unit clkgen.delay_200ns_2.genblk1\[32\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[33\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[954\].delay_unit edgedetect.delay_400ns.genblk1\[954\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[955\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[1062\].delay_unit edgedetect.delay_400ns.genblk1\[1062\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1063\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_26_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_3.genblk1\[64\].delay_unit clkgen.delay_200ns_3.genblk1\[64\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[65\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[265\].delay_unit clkgen.delay_200ns_3.genblk1\[265\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[266\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[66\].delay_unit clkgen.delay_200ns_1.genblk1\[66\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[67\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_16_98 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[299\].delay_unit clkgen.delay_200ns_2.genblk1\[299\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[300\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_79_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[113\].delay_unit clkgen.delay_200ns_2.genblk1\[113\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[114\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[412\].delay_unit clkgen.delay_200ns_2.genblk1\[412\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[413\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[236\].delay_unit edgedetect.delay_400ns.genblk1\[236\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[237\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_16_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[98\].delay_unit clkgen.delay_200ns_2.genblk1\[98\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[99\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[147\].delay_unit clkgen.delay_200ns_1.genblk1\[147\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[148\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[535\].delay_unit edgedetect.delay_400ns.genblk1\[535\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[536\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[446\].delay_unit clkgen.delay_200ns_1.genblk1\[446\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[447\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[834\].delay_unit edgedetect.delay_400ns.genblk1\[834\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[835\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[145\].delay_unit clkgen.delay_200ns_3.genblk1\[145\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[146\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_89_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[444\].delay_unit clkgen.delay_200ns_3.genblk1\[444\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[445\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_27_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[179\].delay_unit clkgen.delay_200ns_2.genblk1\[179\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[180\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[478\].delay_unit clkgen.delay_200ns_2.genblk1\[478\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[479\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[116\].delay_unit edgedetect.delay_400ns.genblk1\[116\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[117\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_400ns.genblk1\[415\].delay_unit edgedetect.delay_400ns.genblk1\[415\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[416\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_67_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[326\].delay_unit clkgen.delay_200ns_1.genblk1\[326\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[327\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[714\].delay_unit edgedetect.delay_400ns.genblk1\[714\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[715\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_36_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[181\].delay_unit clkgen.delay_200ns_2.genblk1\[181\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[182\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[480\].delay_unit clkgen.delay_200ns_2.genblk1\[480\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[481\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[34\].delay_unit edgedetect.delay_400ns.genblk1\[34\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[35\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[324\].delay_unit clkgen.delay_200ns_3.genblk1\[324\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[325\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_77_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[358\].delay_unit clkgen.delay_200ns_2.genblk1\[358\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[359\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[206\].delay_unit clkgen.delay_200ns_1.genblk1\[206\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[207\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_1.genblk1\[505\].delay_unit clkgen.delay_200ns_1.genblk1\[505\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[506\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_79_92 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[1001\].delay_unit edgedetect.delay_400ns.genblk1\[1001\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1002\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_68_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_428 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[360\].delay_unit clkgen.delay_200ns_2.genblk1\[360\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[361\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[184\].delay_unit edgedetect.delay_400ns.genblk1\[184\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[185\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[483\].delay_unit edgedetect.delay_400ns.genblk1\[483\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[484\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[394\].delay_unit clkgen.delay_200ns_1.genblk1\[394\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[395\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[782\].delay_unit edgedetect.delay_400ns.genblk1\[782\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[783\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_86_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[204\].delay_unit clkgen.delay_200ns_3.genblk1\[204\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[205\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_54_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_3.genblk1\[503\].delay_unit clkgen.delay_200ns_3.genblk1\[503\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[504\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_24_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[238\].delay_unit clkgen.delay_200ns_2.genblk1\[238\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[239\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_2.genblk1\[537\].delay_unit clkgen.delay_200ns_2.genblk1\[537\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[538\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[37\].delay_unit clkgen.delay_200ns_2.genblk1\[37\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[38\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_37_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[959\].delay_unit edgedetect.delay_400ns.genblk1\[959\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[960\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_65_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[1067\].delay_unit edgedetect.delay_400ns.genblk1\[1067\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1068\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[392\].delay_unit clkgen.delay_200ns_3.genblk1\[392\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[393\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_71 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[240\].delay_unit clkgen.delay_200ns_2.genblk1\[240\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[241\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[69\].delay_unit clkgen.delay_200ns_3.genblk1\[69\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[70\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_68_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[363\].delay_unit edgedetect.delay_400ns.genblk1\[363\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[364\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_36_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_1.genblk1\[274\].delay_unit clkgen.delay_200ns_1.genblk1\[274\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[275\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[662\].delay_unit edgedetect.delay_400ns.genblk1\[662\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[663\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_51_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[961\].delay_unit edgedetect.delay_400ns.genblk1\[961\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[962\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[118\].delay_unit clkgen.delay_200ns_2.genblk1\[118\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[119\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[417\].delay_unit clkgen.delay_200ns_2.genblk1\[417\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[418\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_3.genblk1\[71\].delay_unit clkgen.delay_200ns_3.genblk1\[71\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[72\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_70_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[839\].delay_unit edgedetect.delay_400ns.genblk1\[839\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[840\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[272\].delay_unit clkgen.delay_200ns_3.genblk1\[272\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[273\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_1.genblk1\[73\].delay_unit clkgen.delay_200ns_1.genblk1\[73\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[74\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_65_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[120\].delay_unit clkgen.delay_200ns_2.genblk1\[120\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[121\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[243\].delay_unit edgedetect.delay_400ns.genblk1\[243\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[244\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[154\].delay_unit clkgen.delay_200ns_1.genblk1\[154\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[155\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[542\].delay_unit edgedetect.delay_400ns.genblk1\[542\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[543\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_84_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[453\].delay_unit clkgen.delay_200ns_1.genblk1\[453\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[454\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[841\].delay_unit edgedetect.delay_400ns.genblk1\[841\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[842\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[449\].delay_unit clkgen.delay_200ns_3.genblk1\[449\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[450\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_56_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[719\].delay_unit edgedetect.delay_400ns.genblk1\[719\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[720\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_155 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[3\].delay_unit edgedetect.delay_400ns.genblk1\[3\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[4\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[152\].delay_unit clkgen.delay_200ns_3.genblk1\[152\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[153\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[451\].delay_unit clkgen.delay_200ns_3.genblk1\[451\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[452\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[186\].delay_unit clkgen.delay_200ns_2.genblk1\[186\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[187\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_2.genblk1\[485\].delay_unit clkgen.delay_200ns_2.genblk1\[485\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[486\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[39\].delay_unit edgedetect.delay_400ns.genblk1\[39\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[40\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_16_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[123\].delay_unit edgedetect.delay_400ns.genblk1\[123\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[124\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[422\].delay_unit edgedetect.delay_400ns.genblk1\[422\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[423\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[333\].delay_unit clkgen.delay_200ns_1.genblk1\[333\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[334\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[721\].delay_unit edgedetect.delay_400ns.genblk1\[721\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[722\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[329\].delay_unit clkgen.delay_200ns_3.genblk1\[329\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[330\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_69_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[41\].delay_unit edgedetect.delay_400ns.genblk1\[41\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[42\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_320 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[1006\].delay_unit edgedetect.delay_400ns.genblk1\[1006\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1007\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[331\].delay_unit clkgen.delay_200ns_3.genblk1\[331\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[332\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[3\].delay_unit clkgen.delay_200ns_2.genblk1\[3\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[4\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_16_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[365\].delay_unit clkgen.delay_200ns_2.genblk1\[365\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[366\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[189\].delay_unit edgedetect.delay_400ns.genblk1\[189\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[190\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[488\].delay_unit edgedetect.delay_400ns.genblk1\[488\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[489\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[399\].delay_unit clkgen.delay_200ns_1.genblk1\[399\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[400\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[787\].delay_unit edgedetect.delay_400ns.genblk1\[787\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[788\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[302\].delay_unit edgedetect.delay_400ns.genblk1\[302\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[303\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[213\].delay_unit clkgen.delay_200ns_1.genblk1\[213\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[214\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[601\].delay_unit edgedetect.delay_400ns.genblk1\[601\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[602\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[512\].delay_unit clkgen.delay_200ns_1.genblk1\[512\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[513\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[209\].delay_unit clkgen.delay_200ns_3.genblk1\[209\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[210\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[900\].delay_unit edgedetect.delay_400ns.genblk1\[900\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[901\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_34_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[508\].delay_unit clkgen.delay_200ns_3.genblk1\[508\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[509\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[191\].delay_unit edgedetect.delay_400ns.genblk1\[191\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[192\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_3.genblk1\[10\].delay_unit clkgen.delay_200ns_3.genblk1\[9\].delay_unit/X
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[11\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[490\].delay_unit edgedetect.delay_400ns.genblk1\[490\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[491\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_25_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[397\].delay_unit clkgen.delay_200ns_3.genblk1\[397\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[398\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[211\].delay_unit clkgen.delay_200ns_3.genblk1\[211\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[212\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[12\].delay_unit clkgen.delay_200ns_1.genblk1\[12\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[13\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[510\].delay_unit clkgen.delay_200ns_3.genblk1\[510\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[511\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[245\].delay_unit clkgen.delay_200ns_2.genblk1\[245\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[246\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[368\].delay_unit edgedetect.delay_400ns.genblk1\[368\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[369\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_51_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[279\].delay_unit clkgen.delay_200ns_1.genblk1\[279\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[280\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_31_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[667\].delay_unit edgedetect.delay_400ns.genblk1\[667\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[668\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_83_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_2.genblk1\[44\].delay_unit clkgen.delay_200ns_2.genblk1\[44\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[45\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[966\].delay_unit edgedetect.delay_400ns.genblk1\[966\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[967\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1074\].delay_unit edgedetect.delay_400ns.genblk1\[1074\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1075\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[76\].delay_unit clkgen.delay_200ns_3.genblk1\[76\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[77\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_13_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_16 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_400ns.genblk1\[370\].delay_unit edgedetect.delay_400ns.genblk1\[370\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[371\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_1.genblk1\[281\].delay_unit clkgen.delay_200ns_1.genblk1\[281\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[282\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_89_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[277\].delay_unit clkgen.delay_200ns_3.genblk1\[277\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[278\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[78\].delay_unit clkgen.delay_200ns_1.genblk1\[78\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[79\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_38_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[125\].delay_unit clkgen.delay_200ns_2.genblk1\[125\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[126\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[424\].delay_unit clkgen.delay_200ns_2.genblk1\[424\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[425\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[248\].delay_unit edgedetect.delay_400ns.genblk1\[248\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[249\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[159\].delay_unit clkgen.delay_200ns_1.genblk1\[159\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[160\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[547\].delay_unit edgedetect.delay_400ns.genblk1\[547\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[548\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[458\].delay_unit clkgen.delay_200ns_1.genblk1\[458\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[459\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[846\].delay_unit edgedetect.delay_400ns.genblk1\[846\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[847\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[80\].delay_unit clkgen.delay_200ns_1.genblk1\[80\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[81\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[250\].delay_unit edgedetect.delay_400ns.genblk1\[250\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[251\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_54_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkgen.delay_200ns_1.genblk1\[161\].delay_unit clkgen.delay_200ns_1.genblk1\[161\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[162\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[460\].delay_unit clkgen.delay_200ns_1.genblk1\[460\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[461\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[157\].delay_unit clkgen.delay_200ns_3.genblk1\[157\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[158\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[8\].delay_unit edgedetect.delay_400ns.genblk1\[8\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[9\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[456\].delay_unit clkgen.delay_200ns_3.genblk1\[456\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[457\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_499 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[304\].delay_unit clkgen.delay_200ns_2.genblk1\[304\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[305\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[128\].delay_unit edgedetect.delay_400ns.genblk1\[128\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[129\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_81_83 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[427\].delay_unit edgedetect.delay_400ns.genblk1\[427\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[428\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[338\].delay_unit clkgen.delay_200ns_1.genblk1\[338\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[339\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_400ns.genblk1\[726\].delay_unit edgedetect.delay_400ns.genblk1\[726\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[727\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[193\].delay_unit clkgen.delay_200ns_2.genblk1\[193\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[194\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_36_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[492\].delay_unit clkgen.delay_200ns_2.genblk1\[492\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[493\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[46\].delay_unit edgedetect.delay_400ns.genblk1\[46\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[47\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[130\].delay_unit edgedetect.delay_400ns.genblk1\[130\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[131\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_87_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[340\].delay_unit clkgen.delay_200ns_1.genblk1\[340\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[341\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_270 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[336\].delay_unit clkgen.delay_200ns_3.genblk1\[336\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[337\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_27_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[8\].delay_unit clkgen.delay_200ns_2.genblk1\[8\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[9\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[307\].delay_unit edgedetect.delay_400ns.genblk1\[307\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[308\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[218\].delay_unit clkgen.delay_200ns_1.genblk1\[218\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[219\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_80_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[606\].delay_unit edgedetect.delay_400ns.genblk1\[606\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[607\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[517\].delay_unit clkgen.delay_200ns_1.genblk1\[517\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[518\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[905\].delay_unit edgedetect.delay_400ns.genblk1\[905\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[906\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1013\].delay_unit edgedetect.delay_400ns.genblk1\[1013\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1014\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_88_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[372\].delay_unit clkgen.delay_200ns_2.genblk1\[372\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[373\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[196\].delay_unit edgedetect.delay_400ns.genblk1\[196\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[197\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_56_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_400ns.genblk1\[495\].delay_unit edgedetect.delay_400ns.genblk1\[495\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[496\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[15\].delay_unit clkgen.delay_200ns_3.genblk1\[15\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[16\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_24_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[794\].delay_unit edgedetect.delay_400ns.genblk1\[794\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[795\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[220\].delay_unit clkgen.delay_200ns_1.genblk1\[220\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[221\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[216\].delay_unit clkgen.delay_200ns_3.genblk1\[216\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[217\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[17\].delay_unit clkgen.delay_200ns_1.genblk1\[17\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[18\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[515\].delay_unit clkgen.delay_200ns_3.genblk1\[515\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[516\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_262 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[49\].delay_unit clkgen.delay_200ns_2.genblk1\[49\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[50\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1079\].delay_unit edgedetect.delay_400ns.genblk1\[1079\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1080\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[252\].delay_unit clkgen.delay_200ns_2.genblk1\[252\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[253\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[375\].delay_unit edgedetect.delay_400ns.genblk1\[375\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[376\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[286\].delay_unit clkgen.delay_200ns_1.genblk1\[286\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[287\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[674\].delay_unit edgedetect.delay_400ns.genblk1\[674\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[675\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[973\].delay_unit edgedetect.delay_400ns.genblk1\[973\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[974\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_84_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[51\].delay_unit clkgen.delay_200ns_2.genblk1\[51\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[52\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[100\].delay_unit clkgen.delay_200ns_1.genblk1\[99\].delay_unit/X
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[101\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_52_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_2.genblk1\[429\].delay_unit clkgen.delay_200ns_2.genblk1\[429\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[430\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[83\].delay_unit clkgen.delay_200ns_3.genblk1\[83\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[84\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_292 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[284\].delay_unit clkgen.delay_200ns_3.genblk1\[284\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[285\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[85\].delay_unit clkgen.delay_200ns_1.genblk1\[85\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[86\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[132\].delay_unit clkgen.delay_200ns_2.genblk1\[132\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[133\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_26_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[431\].delay_unit clkgen.delay_200ns_2.genblk1\[431\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[432\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_34_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[255\].delay_unit edgedetect.delay_400ns.genblk1\[255\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[256\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_1.genblk1\[166\].delay_unit clkgen.delay_200ns_1.genblk1\[166\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[167\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[554\].delay_unit edgedetect.delay_400ns.genblk1\[554\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[555\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[465\].delay_unit clkgen.delay_200ns_1.genblk1\[465\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[466\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[853\].delay_unit edgedetect.delay_400ns.genblk1\[853\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[854\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_78_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[309\].delay_unit clkgen.delay_200ns_2.genblk1\[309\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[310\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_3.genblk1\[164\].delay_unit clkgen.delay_200ns_3.genblk1\[164\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[165\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_84_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[463\].delay_unit clkgen.delay_200ns_3.genblk1\[463\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[464\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[198\].delay_unit clkgen.delay_200ns_2.genblk1\[198\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[199\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_31_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[497\].delay_unit clkgen.delay_200ns_2.genblk1\[497\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[498\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[311\].delay_unit clkgen.delay_200ns_2.genblk1\[311\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[312\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[135\].delay_unit edgedetect.delay_400ns.genblk1\[135\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[136\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[434\].delay_unit edgedetect.delay_400ns.genblk1\[434\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[435\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[345\].delay_unit clkgen.delay_200ns_1.genblk1\[345\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[346\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[733\].delay_unit edgedetect.delay_400ns.genblk1\[733\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[734\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_54_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[53\].delay_unit edgedetect.delay_400ns.genblk1\[53\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[54\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[1018\].delay_unit edgedetect.delay_400ns.genblk1\[1018\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1019\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[343\].delay_unit clkgen.delay_200ns_3.genblk1\[343\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[344\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[377\].delay_unit clkgen.delay_200ns_2.genblk1\[377\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[378\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_51_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[799\].delay_unit edgedetect.delay_400ns.genblk1\[799\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[800\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[314\].delay_unit edgedetect.delay_400ns.genblk1\[314\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[315\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[225\].delay_unit clkgen.delay_200ns_1.genblk1\[225\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[226\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[613\].delay_unit edgedetect.delay_400ns.genblk1\[613\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[614\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[524\].delay_unit clkgen.delay_200ns_1.genblk1\[524\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[525\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_86_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[912\].delay_unit edgedetect.delay_400ns.genblk1\[912\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[913\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_74_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_430 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[1020\].delay_unit edgedetect.delay_400ns.genblk1\[1020\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1021\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_54_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_206 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[22\].delay_unit clkgen.delay_200ns_3.genblk1\[22\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[23\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[223\].delay_unit clkgen.delay_200ns_3.genblk1\[223\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[224\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_60_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_95 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[24\].delay_unit clkgen.delay_200ns_1.genblk1\[24\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[25\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[522\].delay_unit clkgen.delay_200ns_3.genblk1\[522\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[523\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[257\].delay_unit clkgen.delay_200ns_2.genblk1\[257\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[258\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[679\].delay_unit edgedetect.delay_400ns.genblk1\[679\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[680\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_36_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[56\].delay_unit clkgen.delay_200ns_2.genblk1\[56\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[57\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[978\].delay_unit edgedetect.delay_400ns.genblk1\[978\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[979\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[105\].delay_unit clkgen.delay_200ns_1.genblk1\[105\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[106\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_51_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_1.genblk1\[404\].delay_unit clkgen.delay_200ns_1.genblk1\[404\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[405\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_3.genblk1\[88\].delay_unit clkgen.delay_200ns_3.genblk1\[88\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[89\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_316 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[382\].delay_unit edgedetect.delay_400ns.genblk1\[382\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[383\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_70_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[293\].delay_unit clkgen.delay_200ns_1.genblk1\[293\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[294\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[681\].delay_unit edgedetect.delay_400ns.genblk1\[681\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[682\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[289\].delay_unit clkgen.delay_200ns_3.genblk1\[289\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[290\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[980\].delay_unit edgedetect.delay_400ns.genblk1\[980\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[981\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[103\].delay_unit clkgen.delay_200ns_3.genblk1\[103\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[104\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_38_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[402\].delay_unit clkgen.delay_200ns_3.genblk1\[402\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[403\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[137\].delay_unit clkgen.delay_200ns_2.genblk1\[137\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[138\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_73_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[436\].delay_unit clkgen.delay_200ns_2.genblk1\[436\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[437\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[90\].delay_unit clkgen.delay_200ns_3.genblk1\[90\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[91\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[559\].delay_unit edgedetect.delay_400ns.genblk1\[559\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[560\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[858\].delay_unit edgedetect.delay_400ns.genblk1\[858\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[859\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[291\].delay_unit clkgen.delay_200ns_3.genblk1\[291\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[292\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_84_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_1.genblk1\[92\].delay_unit clkgen.delay_200ns_1.genblk1\[92\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[93\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_400ns.genblk1\[262\].delay_unit edgedetect.delay_400ns.genblk1\[262\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[263\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_87_363 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[173\].delay_unit clkgen.delay_200ns_1.genblk1\[173\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[174\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_75_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[561\].delay_unit edgedetect.delay_400ns.genblk1\[561\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[562\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[472\].delay_unit clkgen.delay_200ns_1.genblk1\[472\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[473\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[169\].delay_unit clkgen.delay_200ns_3.genblk1\[169\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[170\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[860\].delay_unit edgedetect.delay_400ns.genblk1\[860\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[861\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[468\].delay_unit clkgen.delay_200ns_3.genblk1\[468\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[469\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_70_296 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[316\].delay_unit clkgen.delay_200ns_2.genblk1\[316\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[317\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_78_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[439\].delay_unit edgedetect.delay_400ns.genblk1\[439\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[440\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[738\].delay_unit edgedetect.delay_400ns.genblk1\[738\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[739\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_34_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[171\].delay_unit clkgen.delay_200ns_3.genblk1\[171\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[172\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[470\].delay_unit clkgen.delay_200ns_3.genblk1\[470\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[471\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[58\].delay_unit edgedetect.delay_400ns.genblk1\[58\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[59\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_16_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[142\].delay_unit edgedetect.delay_400ns.genblk1\[142\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[143\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[441\].delay_unit edgedetect.delay_400ns.genblk1\[441\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[442\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[352\].delay_unit clkgen.delay_200ns_1.genblk1\[352\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[353\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[740\].delay_unit edgedetect.delay_400ns.genblk1\[740\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[741\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[348\].delay_unit clkgen.delay_200ns_3.genblk1\[348\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[349\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_79_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_1.genblk1\[2\].delay_unit clkgen.delay_200ns_1.genblk1\[2\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[3\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_16_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[60\].delay_unit edgedetect.delay_400ns.genblk1\[60\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[61\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[319\].delay_unit edgedetect.delay_400ns.genblk1\[319\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[320\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[618\].delay_unit edgedetect.delay_400ns.genblk1\[618\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[619\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[529\].delay_unit clkgen.delay_200ns_1.genblk1\[529\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[530\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[917\].delay_unit edgedetect.delay_400ns.genblk1\[917\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[918\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[350\].delay_unit clkgen.delay_200ns_3.genblk1\[350\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[351\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1025\].delay_unit edgedetect.delay_400ns.genblk1\[1025\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1026\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_34_296 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[384\].delay_unit clkgen.delay_200ns_2.genblk1\[384\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[385\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[27\].delay_unit clkgen.delay_200ns_3.genblk1\[27\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[28\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_84_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[321\].delay_unit edgedetect.delay_400ns.genblk1\[321\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[322\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[232\].delay_unit clkgen.delay_200ns_1.genblk1\[232\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[233\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_25_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[620\].delay_unit edgedetect.delay_400ns.genblk1\[620\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[621\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[531\].delay_unit clkgen.delay_200ns_1.genblk1\[531\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[532\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_13_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[228\].delay_unit clkgen.delay_200ns_3.genblk1\[228\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[229\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[29\].delay_unit clkgen.delay_200ns_1.genblk1\[29\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[30\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[527\].delay_unit clkgen.delay_200ns_3.genblk1\[527\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[528\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_16 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_344 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_1.genblk1\[409\].delay_unit clkgen.delay_200ns_1.genblk1\[409\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[410\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_69_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_3.genblk1\[230\].delay_unit clkgen.delay_200ns_3.genblk1\[230\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[231\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[31\].delay_unit clkgen.delay_200ns_1.genblk1\[31\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[32\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[264\].delay_unit clkgen.delay_200ns_2.genblk1\[264\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[265\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[387\].delay_unit edgedetect.delay_400ns.genblk1\[387\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[388\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[298\].delay_unit clkgen.delay_200ns_1.genblk1\[298\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[299\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[686\].delay_unit edgedetect.delay_400ns.genblk1\[686\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[687\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_89_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[985\].delay_unit edgedetect.delay_400ns.genblk1\[985\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[986\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[63\].delay_unit clkgen.delay_200ns_2.genblk1\[63\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[64\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[201\].delay_unit edgedetect.delay_400ns.genblk1\[201\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[202\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[112\].delay_unit clkgen.delay_200ns_1.genblk1\[112\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[113\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[500\].delay_unit edgedetect.delay_400ns.genblk1\[500\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[501\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[411\].delay_unit clkgen.delay_200ns_1.genblk1\[411\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[412\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[108\].delay_unit clkgen.delay_200ns_3.genblk1\[108\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[109\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_85_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[407\].delay_unit clkgen.delay_200ns_3.genblk1\[407\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[408\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_72_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[95\].delay_unit clkgen.delay_200ns_3.genblk1\[95\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[96\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_70_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[296\].delay_unit clkgen.delay_200ns_3.genblk1\[296\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[297\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[97\].delay_unit clkgen.delay_200ns_1.genblk1\[97\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[98\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_51_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[110\].delay_unit clkgen.delay_200ns_3.genblk1\[110\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[111\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[144\].delay_unit clkgen.delay_200ns_2.genblk1\[144\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[145\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_92 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[443\].delay_unit clkgen.delay_200ns_2.genblk1\[443\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[444\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[267\].delay_unit edgedetect.delay_400ns.genblk1\[267\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[268\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[178\].delay_unit clkgen.delay_200ns_1.genblk1\[178\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[179\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_82_442 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[566\].delay_unit edgedetect.delay_400ns.genblk1\[566\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[567\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_82_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[477\].delay_unit clkgen.delay_200ns_1.genblk1\[477\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[478\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_54_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[865\].delay_unit edgedetect.delay_400ns.genblk1\[865\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[866\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[180\].delay_unit clkgen.delay_200ns_1.genblk1\[180\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[181\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[176\].delay_unit clkgen.delay_200ns_3.genblk1\[176\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[177\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[475\].delay_unit clkgen.delay_200ns_3.genblk1\[475\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[476\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_83_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[323\].delay_unit clkgen.delay_200ns_2.genblk1\[323\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[324\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[147\].delay_unit edgedetect.delay_400ns.genblk1\[147\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[148\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[446\].delay_unit edgedetect.delay_400ns.genblk1\[446\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[447\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[357\].delay_unit clkgen.delay_200ns_1.genblk1\[357\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[358\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[745\].delay_unit edgedetect.delay_400ns.genblk1\[745\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[746\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_294 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[7\].delay_unit clkgen.delay_200ns_1.genblk1\[7\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[8\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_15_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[65\].delay_unit edgedetect.delay_400ns.genblk1\[65\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[66\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_78_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_100 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_3.genblk1\[355\].delay_unit clkgen.delay_200ns_3.genblk1\[355\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[356\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[389\].delay_unit clkgen.delay_200ns_2.genblk1\[389\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[390\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_88_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[203\].delay_unit clkgen.delay_200ns_2.genblk1\[203\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[204\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[502\].delay_unit clkgen.delay_200ns_2.genblk1\[502\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[503\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_37_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_456 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[326\].delay_unit edgedetect.delay_400ns.genblk1\[326\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[327\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[237\].delay_unit clkgen.delay_200ns_1.genblk1\[237\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[238\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_52_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[625\].delay_unit edgedetect.delay_400ns.genblk1\[625\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[626\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[536\].delay_unit clkgen.delay_200ns_1.genblk1\[536\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[537\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[924\].delay_unit edgedetect.delay_400ns.genblk1\[924\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[925\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1032\].delay_unit edgedetect.delay_400ns.genblk1\[1032\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1033\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_87_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_375 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[391\].delay_unit clkgen.delay_200ns_2.genblk1\[391\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[392\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[34\].delay_unit clkgen.delay_200ns_3.genblk1\[34\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[35\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_23_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[235\].delay_unit clkgen.delay_200ns_3.genblk1\[235\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[236\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[36\].delay_unit clkgen.delay_200ns_1.genblk1\[36\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[37\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[534\].delay_unit clkgen.delay_200ns_3.genblk1\[534\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[535\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[269\].delay_unit clkgen.delay_200ns_2.genblk1\[269\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[270\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_34_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[68\].delay_unit clkgen.delay_200ns_2.genblk1\[68\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[69\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[206\].delay_unit edgedetect.delay_400ns.genblk1\[206\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[207\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[117\].delay_unit clkgen.delay_200ns_1.genblk1\[117\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[118\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[505\].delay_unit edgedetect.delay_400ns.genblk1\[505\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[506\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[416\].delay_unit clkgen.delay_200ns_1.genblk1\[416\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[417\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[804\].delay_unit edgedetect.delay_400ns.genblk1\[804\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[805\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_16_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[271\].delay_unit clkgen.delay_200ns_2.genblk1\[271\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[272\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_87_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[394\].delay_unit edgedetect.delay_400ns.genblk1\[394\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[395\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[693\].delay_unit edgedetect.delay_400ns.genblk1\[693\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[694\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_16_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[70\].delay_unit clkgen.delay_200ns_2.genblk1\[70\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[71\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[992\].delay_unit edgedetect.delay_400ns.genblk1\[992\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[993\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_43_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[115\].delay_unit clkgen.delay_200ns_3.genblk1\[115\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[116\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[414\].delay_unit clkgen.delay_200ns_3.genblk1\[414\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[415\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[149\].delay_unit clkgen.delay_200ns_2.genblk1\[149\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[150\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_2.genblk1\[448\].delay_unit clkgen.delay_200ns_2.genblk1\[448\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[449\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_81_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[151\].delay_unit clkgen.delay_200ns_2.genblk1\[151\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[152\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_25_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[450\].delay_unit clkgen.delay_200ns_2.genblk1\[450\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[451\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[274\].delay_unit edgedetect.delay_400ns.genblk1\[274\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[275\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[185\].delay_unit clkgen.delay_200ns_1.genblk1\[185\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[186\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[573\].delay_unit edgedetect.delay_400ns.genblk1\[573\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[574\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[484\].delay_unit clkgen.delay_200ns_1.genblk1\[484\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[485\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[872\].delay_unit edgedetect.delay_400ns.genblk1\[872\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[873\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_68_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_63 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[328\].delay_unit clkgen.delay_200ns_2.genblk1\[328\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[329\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[183\].delay_unit clkgen.delay_200ns_3.genblk1\[183\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[184\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[482\].delay_unit clkgen.delay_200ns_3.genblk1\[482\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[483\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[330\].delay_unit clkgen.delay_200ns_2.genblk1\[330\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[331\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_38_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[154\].delay_unit edgedetect.delay_400ns.genblk1\[154\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[155\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_45_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_359 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[453\].delay_unit edgedetect.delay_400ns.genblk1\[453\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[454\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[364\].delay_unit clkgen.delay_200ns_1.genblk1\[364\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[365\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[752\].delay_unit edgedetect.delay_400ns.genblk1\[752\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[753\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_79_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[208\].delay_unit clkgen.delay_200ns_2.genblk1\[208\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[209\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[72\].delay_unit edgedetect.delay_400ns.genblk1\[72\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[73\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_51_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[507\].delay_unit clkgen.delay_200ns_2.genblk1\[507\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[508\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_81_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[929\].delay_unit edgedetect.delay_400ns.genblk1\[929\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[930\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[362\].delay_unit clkgen.delay_200ns_3.genblk1\[362\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[363\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1037\].delay_unit edgedetect.delay_400ns.genblk1\[1037\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1038\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_86_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[396\].delay_unit clkgen.delay_200ns_2.genblk1\[396\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[397\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[39\].delay_unit clkgen.delay_200ns_3.genblk1\[39\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[40\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[210\].delay_unit clkgen.delay_200ns_2.genblk1\[210\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[211\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[333\].delay_unit edgedetect.delay_400ns.genblk1\[333\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[334\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[244\].delay_unit clkgen.delay_200ns_1.genblk1\[244\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[245\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_77_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[632\].delay_unit edgedetect.delay_400ns.genblk1\[632\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[633\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[931\].delay_unit edgedetect.delay_400ns.genblk1\[931\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[932\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_85_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[539\].delay_unit clkgen.delay_200ns_3.genblk1\[539\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[540\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[41\].delay_unit clkgen.delay_200ns_3.genblk1\[41\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[42\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_68_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[809\].delay_unit edgedetect.delay_400ns.genblk1\[809\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[810\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_51_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_3.genblk1\[242\].delay_unit clkgen.delay_200ns_3.genblk1\[242\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[243\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[43\].delay_unit clkgen.delay_200ns_1.genblk1\[43\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[44\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[276\].delay_unit clkgen.delay_200ns_2.genblk1\[276\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[277\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[399\].delay_unit edgedetect.delay_400ns.genblk1\[399\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[400\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_67_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[698\].delay_unit edgedetect.delay_400ns.genblk1\[698\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[699\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[997\].delay_unit edgedetect.delay_400ns.genblk1\[997\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[998\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[75\].delay_unit clkgen.delay_200ns_2.genblk1\[75\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[76\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_51_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[213\].delay_unit edgedetect.delay_400ns.genblk1\[213\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[214\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[124\].delay_unit clkgen.delay_200ns_1.genblk1\[124\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[125\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_50_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[512\].delay_unit edgedetect.delay_400ns.genblk1\[512\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[513\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_51_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[423\].delay_unit clkgen.delay_200ns_1.genblk1\[423\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[424\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[811\].delay_unit edgedetect.delay_400ns.genblk1\[811\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[812\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[419\].delay_unit clkgen.delay_200ns_3.genblk1\[419\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[420\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[122\].delay_unit clkgen.delay_200ns_3.genblk1\[122\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[123\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_37_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[421\].delay_unit clkgen.delay_200ns_3.genblk1\[421\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[422\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_52_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_2.genblk1\[156\].delay_unit clkgen.delay_200ns_2.genblk1\[156\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[157\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[455\].delay_unit clkgen.delay_200ns_2.genblk1\[455\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[456\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[279\].delay_unit edgedetect.delay_400ns.genblk1\[279\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[280\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[578\].delay_unit edgedetect.delay_400ns.genblk1\[578\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[579\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[489\].delay_unit clkgen.delay_200ns_1.genblk1\[489\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[490\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[877\].delay_unit edgedetect.delay_400ns.genblk1\[877\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[878\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_87_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[303\].delay_unit clkgen.delay_200ns_1.genblk1\[303\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[304\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_303 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[281\].delay_unit edgedetect.delay_400ns.genblk1\[281\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[282\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_16_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[11\].delay_unit edgedetect.delay_400ns.genblk1\[11\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[12\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[192\].delay_unit clkgen.delay_200ns_1.genblk1\[192\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[193\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[580\].delay_unit edgedetect.delay_400ns.genblk1\[580\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[581\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[491\].delay_unit clkgen.delay_200ns_1.genblk1\[491\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[492\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[188\].delay_unit clkgen.delay_200ns_3.genblk1\[188\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[189\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_61_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[487\].delay_unit clkgen.delay_200ns_3.genblk1\[487\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[488\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[301\].delay_unit clkgen.delay_200ns_3.genblk1\[301\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[302\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[335\].delay_unit clkgen.delay_200ns_2.genblk1\[335\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[336\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_25_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[159\].delay_unit edgedetect.delay_400ns.genblk1\[159\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[160\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[458\].delay_unit edgedetect.delay_400ns.genblk1\[458\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[459\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[369\].delay_unit clkgen.delay_200ns_1.genblk1\[369\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[370\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[757\].delay_unit edgedetect.delay_400ns.genblk1\[757\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[758\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[190\].delay_unit clkgen.delay_200ns_3.genblk1\[190\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[191\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[77\].delay_unit edgedetect.delay_400ns.genblk1\[77\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[78\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[161\].delay_unit edgedetect.delay_400ns.genblk1\[161\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[162\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_199 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[460\].delay_unit edgedetect.delay_400ns.genblk1\[460\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[461\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[371\].delay_unit clkgen.delay_200ns_1.genblk1\[371\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[372\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_3.genblk1\[367\].delay_unit clkgen.delay_200ns_3.genblk1\[367\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[368\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[215\].delay_unit clkgen.delay_200ns_2.genblk1\[215\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[216\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_89_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[514\].delay_unit clkgen.delay_200ns_2.genblk1\[514\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[515\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_89_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[338\].delay_unit edgedetect.delay_400ns.genblk1\[338\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[339\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_84_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_1.genblk1\[249\].delay_unit clkgen.delay_200ns_1.genblk1\[249\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[250\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[637\].delay_unit edgedetect.delay_400ns.genblk1\[637\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[638\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[14\].delay_unit clkgen.delay_200ns_2.genblk1\[14\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[15\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[936\].delay_unit edgedetect.delay_400ns.genblk1\[936\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[937\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_25_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[1044\].delay_unit edgedetect.delay_400ns.genblk1\[1044\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1045\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_279 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[46\].delay_unit clkgen.delay_200ns_3.genblk1\[46\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[47\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_84_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[340\].delay_unit edgedetect.delay_400ns.genblk1\[340\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[341\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[251\].delay_unit clkgen.delay_200ns_1.genblk1\[251\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[252\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[247\].delay_unit clkgen.delay_200ns_3.genblk1\[247\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[248\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_1.genblk1\[48\].delay_unit clkgen.delay_200ns_1.genblk1\[48\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[49\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[218\].delay_unit edgedetect.delay_400ns.genblk1\[218\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[219\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[129\].delay_unit clkgen.delay_200ns_1.genblk1\[129\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[130\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[517\].delay_unit edgedetect.delay_400ns.genblk1\[517\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[518\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[428\].delay_unit clkgen.delay_200ns_1.genblk1\[428\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[429\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[816\].delay_unit edgedetect.delay_400ns.genblk1\[816\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[817\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_38_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_1.genblk1\[50\].delay_unit clkgen.delay_200ns_1.genblk1\[50\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[51\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_72_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_202 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[283\].delay_unit clkgen.delay_200ns_2.genblk1\[283\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[284\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_53_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[220\].delay_unit edgedetect.delay_400ns.genblk1\[220\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[221\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[82\].delay_unit clkgen.delay_200ns_2.genblk1\[82\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[83\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[131\].delay_unit clkgen.delay_200ns_1.genblk1\[131\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[132\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_1.genblk1\[430\].delay_unit clkgen.delay_200ns_1.genblk1\[430\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[431\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[127\].delay_unit clkgen.delay_200ns_3.genblk1\[127\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[128\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_3.genblk1\[426\].delay_unit clkgen.delay_200ns_3.genblk1\[426\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[427\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_74_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[308\].delay_unit clkgen.delay_200ns_1.genblk1\[308\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[309\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[163\].delay_unit clkgen.delay_200ns_2.genblk1\[163\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[164\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_58_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[462\].delay_unit clkgen.delay_200ns_2.genblk1\[462\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[463\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_85_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[286\].delay_unit edgedetect.delay_400ns.genblk1\[286\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[287\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[16\].delay_unit edgedetect.delay_400ns.genblk1\[16\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[17\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_45_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_1.genblk1\[197\].delay_unit clkgen.delay_200ns_1.genblk1\[197\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[198\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[585\].delay_unit edgedetect.delay_400ns.genblk1\[585\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[586\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[496\].delay_unit clkgen.delay_200ns_1.genblk1\[496\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[497\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_41_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[884\].delay_unit edgedetect.delay_400ns.genblk1\[884\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[885\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_41_374 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[100\].delay_unit edgedetect.delay_400ns.genblk1\[99\].delay_unit/X
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[101\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[310\].delay_unit clkgen.delay_200ns_1.genblk1\[310\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[311\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[306\].delay_unit clkgen.delay_200ns_3.genblk1\[306\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[307\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_374 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[195\].delay_unit clkgen.delay_200ns_3.genblk1\[195\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[196\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_87_514 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[494\].delay_unit clkgen.delay_200ns_3.genblk1\[494\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[495\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[342\].delay_unit clkgen.delay_200ns_2.genblk1\[342\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[343\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[166\].delay_unit edgedetect.delay_400ns.genblk1\[166\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[167\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[465\].delay_unit edgedetect.delay_400ns.genblk1\[465\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[466\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[376\].delay_unit clkgen.delay_200ns_1.genblk1\[376\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[377\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
X_3_ ena_in _2_/X _3_/B1_N VGND VGND VPWR VPWR _3_/X sky130_fd_sc_hd__o21ba_2
Xedgedetect.delay_400ns.genblk1\[764\].delay_unit edgedetect.delay_400ns.genblk1\[764\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[765\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[84\].delay_unit edgedetect.delay_400ns.genblk1\[84\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[85\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_69_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[519\].delay_unit clkgen.delay_200ns_2.genblk1\[519\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[520\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[19\].delay_unit clkgen.delay_200ns_2.genblk1\[19\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[20\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_3.genblk1\[374\].delay_unit clkgen.delay_200ns_3.genblk1\[374\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[375\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1049\].delay_unit edgedetect.delay_400ns.genblk1\[1049\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1050\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[222\].delay_unit clkgen.delay_200ns_2.genblk1\[222\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[223\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[521\].delay_unit clkgen.delay_200ns_2.genblk1\[521\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[522\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[345\].delay_unit edgedetect.delay_400ns.genblk1\[345\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[346\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[256\].delay_unit clkgen.delay_200ns_1.genblk1\[256\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[257\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[644\].delay_unit edgedetect.delay_400ns.genblk1\[644\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[645\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[21\].delay_unit clkgen.delay_200ns_2.genblk1\[21\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[22\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[943\].delay_unit edgedetect.delay_400ns.genblk1\[943\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[944\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[1051\].delay_unit edgedetect.delay_400ns.genblk1\[1051\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1052\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_34_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[53\].delay_unit clkgen.delay_200ns_3.genblk1\[53\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[54\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_84_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[254\].delay_unit clkgen.delay_200ns_3.genblk1\[254\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[255\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[55\].delay_unit clkgen.delay_200ns_1.genblk1\[55\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[56\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_37_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[288\].delay_unit clkgen.delay_200ns_2.genblk1\[288\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[289\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[102\].delay_unit clkgen.delay_200ns_2.genblk1\[102\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[103\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[401\].delay_unit clkgen.delay_200ns_2.genblk1\[401\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[402\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[87\].delay_unit clkgen.delay_200ns_2.genblk1\[87\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[88\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[225\].delay_unit edgedetect.delay_400ns.genblk1\[225\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[226\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[136\].delay_unit clkgen.delay_200ns_1.genblk1\[136\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[137\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[524\].delay_unit edgedetect.delay_400ns.genblk1\[524\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[525\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_73_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_1.genblk1\[435\].delay_unit clkgen.delay_200ns_1.genblk1\[435\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[436\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_16_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[823\].delay_unit edgedetect.delay_400ns.genblk1\[823\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[824\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_31_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_2.genblk1\[290\].delay_unit clkgen.delay_200ns_2.genblk1\[290\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[291\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[134\].delay_unit clkgen.delay_200ns_3.genblk1\[134\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[135\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_89_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_3.genblk1\[433\].delay_unit clkgen.delay_200ns_3.genblk1\[433\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[434\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_2.genblk1\[168\].delay_unit clkgen.delay_200ns_2.genblk1\[168\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[169\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[467\].delay_unit clkgen.delay_200ns_2.genblk1\[467\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[468\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_65_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[889\].delay_unit edgedetect.delay_400ns.genblk1\[889\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[890\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[105\].delay_unit edgedetect.delay_400ns.genblk1\[105\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[106\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[404\].delay_unit edgedetect.delay_400ns.genblk1\[404\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[405\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[315\].delay_unit clkgen.delay_200ns_1.genblk1\[315\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[316\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[703\].delay_unit edgedetect.delay_400ns.genblk1\[703\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[704\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_222 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_2.genblk1\[170\].delay_unit clkgen.delay_200ns_2.genblk1\[170\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[171\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[293\].delay_unit edgedetect.delay_400ns.genblk1\[293\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[294\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[23\].delay_unit edgedetect.delay_400ns.genblk1\[23\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[24\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[592\].delay_unit edgedetect.delay_400ns.genblk1\[592\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[593\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[891\].delay_unit edgedetect.delay_400ns.genblk1\[891\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[892\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[499\].delay_unit clkgen.delay_200ns_3.genblk1\[499\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[500\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_66_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[313\].delay_unit clkgen.delay_200ns_3.genblk1\[313\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[314\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[347\].delay_unit clkgen.delay_200ns_2.genblk1\[347\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[348\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_89_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[769\].delay_unit edgedetect.delay_400ns.genblk1\[769\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[770\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_72_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[5\].delay_unit clkgen.delay_200ns_3.genblk1\[5\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[6\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[89\].delay_unit edgedetect.delay_400ns.genblk1\[89\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[90\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_76_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[173\].delay_unit edgedetect.delay_400ns.genblk1\[173\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[174\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[472\].delay_unit edgedetect.delay_400ns.genblk1\[472\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[473\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[383\].delay_unit clkgen.delay_200ns_1.genblk1\[383\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[384\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[771\].delay_unit edgedetect.delay_400ns.genblk1\[771\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[772\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[379\].delay_unit clkgen.delay_200ns_3.genblk1\[379\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[380\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_295 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[227\].delay_unit clkgen.delay_200ns_2.genblk1\[227\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[228\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_372 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[91\].delay_unit edgedetect.delay_400ns.genblk1\[91\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[92\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[526\].delay_unit clkgen.delay_200ns_2.genblk1\[526\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[527\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[649\].delay_unit edgedetect.delay_400ns.genblk1\[649\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[650\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[26\].delay_unit clkgen.delay_200ns_2.genblk1\[26\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[27\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[948\].delay_unit edgedetect.delay_400ns.genblk1\[948\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[949\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[1056\].delay_unit edgedetect.delay_400ns.genblk1\[1056\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1057\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_85_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[381\].delay_unit clkgen.delay_200ns_3.genblk1\[381\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[382\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_58_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[58\].delay_unit clkgen.delay_200ns_3.genblk1\[58\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[59\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[352\].delay_unit edgedetect.delay_400ns.genblk1\[352\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[353\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_76_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_1.genblk1\[263\].delay_unit clkgen.delay_200ns_1.genblk1\[263\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[264\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[651\].delay_unit edgedetect.delay_400ns.genblk1\[651\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[652\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[259\].delay_unit clkgen.delay_200ns_3.genblk1\[259\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[260\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_36_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[950\].delay_unit edgedetect.delay_400ns.genblk1\[950\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[951\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[107\].delay_unit clkgen.delay_200ns_2.genblk1\[107\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[108\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[406\].delay_unit clkgen.delay_200ns_2.genblk1\[406\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[407\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_27_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[60\].delay_unit clkgen.delay_200ns_3.genblk1\[60\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[61\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_82_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[529\].delay_unit edgedetect.delay_400ns.genblk1\[529\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[530\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[828\].delay_unit edgedetect.delay_400ns.genblk1\[828\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[829\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[261\].delay_unit clkgen.delay_200ns_3.genblk1\[261\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[262\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[62\].delay_unit clkgen.delay_200ns_1.genblk1\[62\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[63\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[295\].delay_unit clkgen.delay_200ns_2.genblk1\[295\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[296\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
X_2_ _2_/A_N start_conv VGND VGND VPWR VPWR _2_/X sky130_fd_sc_hd__and2b_2
XFILLER_76_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[232\].delay_unit edgedetect.delay_400ns.genblk1\[232\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[233\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[94\].delay_unit clkgen.delay_200ns_2.genblk1\[94\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[95\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_41_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[143\].delay_unit clkgen.delay_200ns_1.genblk1\[143\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[144\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[531\].delay_unit edgedetect.delay_400ns.genblk1\[531\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[532\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[442\].delay_unit clkgen.delay_200ns_1.genblk1\[442\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[443\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[139\].delay_unit clkgen.delay_200ns_3.genblk1\[139\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[140\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[830\].delay_unit edgedetect.delay_400ns.genblk1\[830\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[831\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[438\].delay_unit clkgen.delay_200ns_3.genblk1\[438\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[439\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[409\].delay_unit edgedetect.delay_400ns.genblk1\[409\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[410\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[708\].delay_unit edgedetect.delay_400ns.genblk1\[708\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[709\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[141\].delay_unit clkgen.delay_200ns_3.genblk1\[141\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[142\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[440\].delay_unit clkgen.delay_200ns_3.genblk1\[440\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[441\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_2.genblk1\[175\].delay_unit clkgen.delay_200ns_2.genblk1\[175\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[176\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[474\].delay_unit clkgen.delay_200ns_2.genblk1\[474\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[475\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[298\].delay_unit edgedetect.delay_400ns.genblk1\[298\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[299\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[28\].delay_unit edgedetect.delay_400ns.genblk1\[28\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[29\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[597\].delay_unit edgedetect.delay_400ns.genblk1\[597\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[598\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[896\].delay_unit edgedetect.delay_400ns.genblk1\[896\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[897\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[112\].delay_unit edgedetect.delay_400ns.genblk1\[112\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[113\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_34_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[411\].delay_unit edgedetect.delay_400ns.genblk1\[411\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[412\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[322\].delay_unit clkgen.delay_200ns_1.genblk1\[322\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[323\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[710\].delay_unit edgedetect.delay_400ns.genblk1\[710\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[711\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[318\].delay_unit clkgen.delay_200ns_3.genblk1\[318\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[319\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_88_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[30\].delay_unit edgedetect.delay_400ns.genblk1\[30\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[31\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_52_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_3.genblk1\[320\].delay_unit clkgen.delay_200ns_3.genblk1\[320\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[321\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_2.genblk1\[354\].delay_unit clkgen.delay_200ns_2.genblk1\[354\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[355\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[178\].delay_unit edgedetect.delay_400ns.genblk1\[178\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[179\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[477\].delay_unit edgedetect.delay_400ns.genblk1\[477\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[478\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[388\].delay_unit clkgen.delay_200ns_1.genblk1\[388\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[389\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[776\].delay_unit edgedetect.delay_400ns.genblk1\[776\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[777\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[202\].delay_unit clkgen.delay_200ns_1.genblk1\[202\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[203\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_78_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[501\].delay_unit clkgen.delay_200ns_1.genblk1\[501\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[502\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_34_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[96\].delay_unit edgedetect.delay_400ns.genblk1\[96\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[97\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[180\].delay_unit edgedetect.delay_400ns.genblk1\[180\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[181\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[390\].delay_unit clkgen.delay_200ns_1.genblk1\[390\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[391\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[386\].delay_unit clkgen.delay_200ns_3.genblk1\[386\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[387\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_72_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[200\].delay_unit clkgen.delay_200ns_3.genblk1\[200\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[201\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkgen.delay_200ns_2.genblk1\[234\].delay_unit clkgen.delay_200ns_2.genblk1\[234\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[235\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_68_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[533\].delay_unit clkgen.delay_200ns_2.genblk1\[533\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[534\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[357\].delay_unit edgedetect.delay_400ns.genblk1\[357\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[358\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[656\].delay_unit edgedetect.delay_400ns.genblk1\[656\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[657\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[268\].delay_unit clkgen.delay_200ns_1.genblk1\[268\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[269\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_16_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[33\].delay_unit clkgen.delay_200ns_2.genblk1\[33\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[34\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[955\].delay_unit edgedetect.delay_400ns.genblk1\[955\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[956\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[1063\].delay_unit edgedetect.delay_400ns.genblk1\[1063\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1064\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[65\].delay_unit clkgen.delay_200ns_3.genblk1\[65\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[66\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_50_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[270\].delay_unit clkgen.delay_200ns_1.genblk1\[270\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[271\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[266\].delay_unit clkgen.delay_200ns_3.genblk1\[266\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[267\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_89_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[67\].delay_unit clkgen.delay_200ns_1.genblk1\[67\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[68\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_123 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[114\].delay_unit clkgen.delay_200ns_2.genblk1\[114\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[115\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_70_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[413\].delay_unit clkgen.delay_200ns_2.genblk1\[413\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[414\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[237\].delay_unit edgedetect.delay_400ns.genblk1\[237\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[238\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[99\].delay_unit clkgen.delay_200ns_2.genblk1\[99\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[99\].delay_unit/X sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[148\].delay_unit clkgen.delay_200ns_1.genblk1\[148\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[149\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[536\].delay_unit edgedetect.delay_400ns.genblk1\[536\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[537\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[447\].delay_unit clkgen.delay_200ns_1.genblk1\[447\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[448\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[835\].delay_unit edgedetect.delay_400ns.genblk1\[835\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[836\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_76_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_1.genblk1\[150\].delay_unit clkgen.delay_200ns_1.genblk1\[150\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[151\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_82_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[146\].delay_unit clkgen.delay_200ns_3.genblk1\[146\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[147\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[445\].delay_unit clkgen.delay_200ns_3.genblk1\[445\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[446\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[479\].delay_unit clkgen.delay_200ns_2.genblk1\[479\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[480\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_77_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[117\].delay_unit edgedetect.delay_400ns.genblk1\[117\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[118\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_81_490 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[416\].delay_unit edgedetect.delay_400ns.genblk1\[416\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[417\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[327\].delay_unit clkgen.delay_200ns_1.genblk1\[327\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[328\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_94 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[715\].delay_unit edgedetect.delay_400ns.genblk1\[715\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[716\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[182\].delay_unit clkgen.delay_200ns_2.genblk1\[182\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[183\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_76_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[481\].delay_unit clkgen.delay_200ns_2.genblk1\[481\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[482\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[35\].delay_unit edgedetect.delay_400ns.genblk1\[35\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[36\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_44_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[325\].delay_unit clkgen.delay_200ns_3.genblk1\[325\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[326\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_55_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[359\].delay_unit clkgen.delay_200ns_2.genblk1\[359\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[360\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_12 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1_ _1_/A VGND VGND VPWR VPWR clk_dig sky130_fd_sc_hd__inv_2
Xclkgen.delay_200ns_1.genblk1\[207\].delay_unit clkgen.delay_200ns_1.genblk1\[207\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[208\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[506\].delay_unit clkgen.delay_200ns_1.genblk1\[506\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[507\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[1002\].delay_unit edgedetect.delay_400ns.genblk1\[1002\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1003\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[361\].delay_unit clkgen.delay_200ns_2.genblk1\[361\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[362\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_69_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[185\].delay_unit edgedetect.delay_400ns.genblk1\[185\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[186\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[484\].delay_unit edgedetect.delay_400ns.genblk1\[484\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[485\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[395\].delay_unit clkgen.delay_200ns_1.genblk1\[395\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[396\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[783\].delay_unit edgedetect.delay_400ns.genblk1\[783\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[784\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[205\].delay_unit clkgen.delay_200ns_3.genblk1\[205\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[206\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[504\].delay_unit clkgen.delay_200ns_3.genblk1\[504\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[505\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_87_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[239\].delay_unit clkgen.delay_200ns_2.genblk1\[239\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[240\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[538\].delay_unit clkgen.delay_200ns_2.genblk1\[538\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[539\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[38\].delay_unit clkgen.delay_200ns_2.genblk1\[38\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[39\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1068\].delay_unit edgedetect.delay_400ns.genblk1\[1068\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1069\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[393\].delay_unit clkgen.delay_200ns_3.genblk1\[393\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[394\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_87_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[241\].delay_unit clkgen.delay_200ns_2.genblk1\[241\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[242\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[540\].delay_unit clkgen.delay_200ns_2.genblk1\[540\].delay_unit/A
+ VGND VGND VPWR VPWR _3_/B1_N sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_52_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[364\].delay_unit edgedetect.delay_400ns.genblk1\[364\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[365\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[275\].delay_unit clkgen.delay_200ns_1.genblk1\[275\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[276\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[663\].delay_unit edgedetect.delay_400ns.genblk1\[663\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[664\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[962\].delay_unit edgedetect.delay_400ns.genblk1\[962\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[963\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_69_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[40\].delay_unit clkgen.delay_200ns_2.genblk1\[40\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[41\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1070\].delay_unit edgedetect.delay_400ns.genblk1\[1070\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1071\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_37_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[119\].delay_unit clkgen.delay_200ns_2.genblk1\[119\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[120\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[418\].delay_unit clkgen.delay_200ns_2.genblk1\[418\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[419\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[72\].delay_unit clkgen.delay_200ns_3.genblk1\[72\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[73\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_14 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[273\].delay_unit clkgen.delay_200ns_3.genblk1\[273\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[274\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_73_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[74\].delay_unit clkgen.delay_200ns_1.genblk1\[74\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[75\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_320 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_2.genblk1\[121\].delay_unit clkgen.delay_200ns_2.genblk1\[121\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[122\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[420\].delay_unit clkgen.delay_200ns_2.genblk1\[420\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[421\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[244\].delay_unit edgedetect.delay_400ns.genblk1\[244\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[245\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[155\].delay_unit clkgen.delay_200ns_1.genblk1\[155\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[156\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[543\].delay_unit edgedetect.delay_400ns.genblk1\[543\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[544\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[454\].delay_unit clkgen.delay_200ns_1.genblk1\[454\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[455\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[842\].delay_unit edgedetect.delay_400ns.genblk1\[842\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[843\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_316 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_106 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[4\].delay_unit edgedetect.delay_400ns.genblk1\[4\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[5\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[153\].delay_unit clkgen.delay_200ns_3.genblk1\[153\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[154\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_3.genblk1\[452\].delay_unit clkgen.delay_200ns_3.genblk1\[452\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[453\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_75_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[187\].delay_unit clkgen.delay_200ns_2.genblk1\[187\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[188\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_17_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[486\].delay_unit clkgen.delay_200ns_2.genblk1\[486\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[487\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_12_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[300\].delay_unit clkgen.delay_200ns_2.genblk1\[300\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[301\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[124\].delay_unit edgedetect.delay_400ns.genblk1\[124\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[125\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[423\].delay_unit edgedetect.delay_400ns.genblk1\[423\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[424\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_1.genblk1\[334\].delay_unit clkgen.delay_200ns_1.genblk1\[334\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[335\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[722\].delay_unit edgedetect.delay_400ns.genblk1\[722\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[723\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_81_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_371 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[42\].delay_unit edgedetect.delay_400ns.genblk1\[42\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[43\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_400ns.genblk1\[1007\].delay_unit edgedetect.delay_400ns.genblk1\[1007\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1008\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[332\].delay_unit clkgen.delay_200ns_3.genblk1\[332\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[333\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[4\].delay_unit clkgen.delay_200ns_2.genblk1\[4\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[5\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_79_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[366\].delay_unit clkgen.delay_200ns_2.genblk1\[366\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[367\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_76_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[489\].delay_unit edgedetect.delay_400ns.genblk1\[489\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[490\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[788\].delay_unit edgedetect.delay_400ns.genblk1\[788\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[789\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_44_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[303\].delay_unit edgedetect.delay_400ns.genblk1\[303\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[304\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_12_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[214\].delay_unit clkgen.delay_200ns_1.genblk1\[214\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[215\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[602\].delay_unit edgedetect.delay_400ns.genblk1\[602\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[603\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[513\].delay_unit clkgen.delay_200ns_1.genblk1\[513\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[514\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[901\].delay_unit edgedetect.delay_400ns.genblk1\[901\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[902\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[509\].delay_unit clkgen.delay_200ns_3.genblk1\[509\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[510\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_79_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[192\].delay_unit edgedetect.delay_400ns.genblk1\[192\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[193\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_50_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[491\].delay_unit edgedetect.delay_400ns.genblk1\[491\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[492\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[11\].delay_unit clkgen.delay_200ns_3.genblk1\[11\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[12\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[790\].delay_unit edgedetect.delay_400ns.genblk1\[790\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[791\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[398\].delay_unit clkgen.delay_200ns_3.genblk1\[398\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[399\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[212\].delay_unit clkgen.delay_200ns_3.genblk1\[212\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[213\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_73_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[13\].delay_unit clkgen.delay_200ns_1.genblk1\[13\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[14\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[511\].delay_unit clkgen.delay_200ns_3.genblk1\[511\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[512\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_26_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[246\].delay_unit clkgen.delay_200ns_2.genblk1\[246\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[247\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[369\].delay_unit edgedetect.delay_400ns.genblk1\[369\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[370\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[668\].delay_unit edgedetect.delay_400ns.genblk1\[668\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[669\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[45\].delay_unit clkgen.delay_200ns_2.genblk1\[45\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[46\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[967\].delay_unit edgedetect.delay_400ns.genblk1\[967\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[968\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1075\].delay_unit edgedetect.delay_400ns.genblk1\[1075\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1076\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_64_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[77\].delay_unit clkgen.delay_200ns_3.genblk1\[77\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[78\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[371\].delay_unit edgedetect.delay_400ns.genblk1\[371\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[372\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[282\].delay_unit clkgen.delay_200ns_1.genblk1\[282\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[283\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[670\].delay_unit edgedetect.delay_400ns.genblk1\[670\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[671\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[278\].delay_unit clkgen.delay_200ns_3.genblk1\[278\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[279\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_50_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_1.genblk1\[79\].delay_unit clkgen.delay_200ns_1.genblk1\[79\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[80\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_76_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[126\].delay_unit clkgen.delay_200ns_2.genblk1\[126\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[127\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_58_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[425\].delay_unit clkgen.delay_200ns_2.genblk1\[425\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[426\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_73_255 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[249\].delay_unit edgedetect.delay_400ns.genblk1\[249\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[250\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_61_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[548\].delay_unit edgedetect.delay_400ns.genblk1\[548\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[549\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[459\].delay_unit clkgen.delay_200ns_1.genblk1\[459\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[460\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[847\].delay_unit edgedetect.delay_400ns.genblk1\[847\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[848\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_41_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[280\].delay_unit clkgen.delay_200ns_3.genblk1\[280\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[281\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[81\].delay_unit clkgen.delay_200ns_1.genblk1\[81\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[82\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[251\].delay_unit edgedetect.delay_400ns.genblk1\[251\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[252\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[162\].delay_unit clkgen.delay_200ns_1.genblk1\[162\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[163\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[550\].delay_unit edgedetect.delay_400ns.genblk1\[550\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[551\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[461\].delay_unit clkgen.delay_200ns_1.genblk1\[461\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[462\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[158\].delay_unit clkgen.delay_200ns_3.genblk1\[158\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[159\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[9\].delay_unit edgedetect.delay_400ns.genblk1\[9\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[9\].delay_unit/X sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[457\].delay_unit clkgen.delay_200ns_3.genblk1\[457\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[458\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_15_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[305\].delay_unit clkgen.delay_200ns_2.genblk1\[305\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[306\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[129\].delay_unit edgedetect.delay_400ns.genblk1\[129\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[130\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[428\].delay_unit edgedetect.delay_400ns.genblk1\[428\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[429\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_74_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_1.genblk1\[339\].delay_unit clkgen.delay_200ns_1.genblk1\[339\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[340\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[727\].delay_unit edgedetect.delay_400ns.genblk1\[727\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[728\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[160\].delay_unit clkgen.delay_200ns_3.genblk1\[160\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[161\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkgen.delay_200ns_2.genblk1\[194\].delay_unit clkgen.delay_200ns_2.genblk1\[194\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[195\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[493\].delay_unit clkgen.delay_200ns_2.genblk1\[493\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[494\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_69_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[47\].delay_unit edgedetect.delay_400ns.genblk1\[47\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[48\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_77_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[131\].delay_unit edgedetect.delay_400ns.genblk1\[131\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[132\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[430\].delay_unit edgedetect.delay_400ns.genblk1\[430\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[431\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[341\].delay_unit clkgen.delay_200ns_1.genblk1\[341\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[342\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[337\].delay_unit clkgen.delay_200ns_3.genblk1\[337\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[338\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[9\].delay_unit clkgen.delay_200ns_2.genblk1\[9\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[9\].delay_unit/X sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_87_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_26 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_100 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[308\].delay_unit edgedetect.delay_400ns.genblk1\[308\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[309\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_1.genblk1\[219\].delay_unit clkgen.delay_200ns_1.genblk1\[219\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[220\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[607\].delay_unit edgedetect.delay_400ns.genblk1\[607\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[608\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[518\].delay_unit clkgen.delay_200ns_1.genblk1\[518\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[519\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[906\].delay_unit edgedetect.delay_400ns.genblk1\[906\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[907\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_78_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[1014\].delay_unit edgedetect.delay_400ns.genblk1\[1014\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1015\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[373\].delay_unit clkgen.delay_200ns_2.genblk1\[373\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[374\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[197\].delay_unit edgedetect.delay_400ns.genblk1\[197\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[198\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[16\].delay_unit clkgen.delay_200ns_3.genblk1\[16\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[17\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[496\].delay_unit edgedetect.delay_400ns.genblk1\[496\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[497\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[795\].delay_unit edgedetect.delay_400ns.genblk1\[795\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[796\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[310\].delay_unit edgedetect.delay_400ns.genblk1\[310\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[311\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_1.genblk1\[221\].delay_unit clkgen.delay_200ns_1.genblk1\[221\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[222\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_38_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_1.genblk1\[520\].delay_unit clkgen.delay_200ns_1.genblk1\[520\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[521\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_65_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[217\].delay_unit clkgen.delay_200ns_3.genblk1\[217\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[218\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_25_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_1.genblk1\[18\].delay_unit clkgen.delay_200ns_1.genblk1\[18\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[19\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[516\].delay_unit clkgen.delay_200ns_3.genblk1\[516\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[517\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_43_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_118 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_1.genblk1\[20\].delay_unit clkgen.delay_200ns_1.genblk1\[20\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[21\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_2.genblk1\[253\].delay_unit clkgen.delay_200ns_2.genblk1\[253\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[254\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[376\].delay_unit edgedetect.delay_400ns.genblk1\[376\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[377\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[287\].delay_unit clkgen.delay_200ns_1.genblk1\[287\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[288\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[675\].delay_unit edgedetect.delay_400ns.genblk1\[675\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[676\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[974\].delay_unit edgedetect.delay_400ns.genblk1\[974\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[975\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[52\].delay_unit clkgen.delay_200ns_2.genblk1\[52\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[53\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[101\].delay_unit clkgen.delay_200ns_1.genblk1\[101\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[102\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[400\].delay_unit clkgen.delay_200ns_1.genblk1\[400\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[401\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[84\].delay_unit clkgen.delay_200ns_3.genblk1\[84\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[85\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_70_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[285\].delay_unit clkgen.delay_200ns_3.genblk1\[285\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[286\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[86\].delay_unit clkgen.delay_200ns_1.genblk1\[86\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[87\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_76_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_331 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[133\].delay_unit clkgen.delay_200ns_2.genblk1\[133\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[134\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[432\].delay_unit clkgen.delay_200ns_2.genblk1\[432\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[433\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_460 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[256\].delay_unit edgedetect.delay_400ns.genblk1\[256\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[257\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_86_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[167\].delay_unit clkgen.delay_200ns_1.genblk1\[167\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[168\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[555\].delay_unit edgedetect.delay_400ns.genblk1\[555\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[556\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[466\].delay_unit clkgen.delay_200ns_1.genblk1\[466\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[467\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[854\].delay_unit edgedetect.delay_400ns.genblk1\[854\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[855\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[165\].delay_unit clkgen.delay_200ns_3.genblk1\[165\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[166\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[464\].delay_unit clkgen.delay_200ns_3.genblk1\[464\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[465\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[199\].delay_unit clkgen.delay_200ns_2.genblk1\[199\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[200\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_68_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[498\].delay_unit clkgen.delay_200ns_2.genblk1\[498\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[499\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_76_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_2.genblk1\[312\].delay_unit clkgen.delay_200ns_2.genblk1\[312\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[313\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[136\].delay_unit edgedetect.delay_400ns.genblk1\[136\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[137\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[435\].delay_unit edgedetect.delay_400ns.genblk1\[435\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[436\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[346\].delay_unit clkgen.delay_200ns_1.genblk1\[346\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[347\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[734\].delay_unit edgedetect.delay_400ns.genblk1\[734\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[735\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_65_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[54\].delay_unit edgedetect.delay_400ns.genblk1\[54\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[55\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_50_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_400ns.genblk1\[1019\].delay_unit edgedetect.delay_400ns.genblk1\[1019\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1020\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[344\].delay_unit clkgen.delay_200ns_3.genblk1\[344\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[345\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[378\].delay_unit clkgen.delay_200ns_2.genblk1\[378\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[379\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[315\].delay_unit edgedetect.delay_400ns.genblk1\[315\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[316\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_66_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[226\].delay_unit clkgen.delay_200ns_1.genblk1\[226\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[227\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_64_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[614\].delay_unit edgedetect.delay_400ns.genblk1\[614\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[615\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_52_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkgen.delay_200ns_1.genblk1\[525\].delay_unit clkgen.delay_200ns_1.genblk1\[525\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[526\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[913\].delay_unit edgedetect.delay_400ns.genblk1\[913\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[914\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[1021\].delay_unit edgedetect.delay_400ns.genblk1\[1021\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1022\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[380\].delay_unit clkgen.delay_200ns_2.genblk1\[380\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[381\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_87_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[23\].delay_unit clkgen.delay_200ns_3.genblk1\[23\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[24\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_70_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[224\].delay_unit clkgen.delay_200ns_3.genblk1\[224\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[225\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_87_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[25\].delay_unit clkgen.delay_200ns_1.genblk1\[25\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[26\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[523\].delay_unit clkgen.delay_200ns_3.genblk1\[523\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[524\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[258\].delay_unit clkgen.delay_200ns_2.genblk1\[258\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[259\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[57\].delay_unit clkgen.delay_200ns_2.genblk1\[57\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[58\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[979\].delay_unit edgedetect.delay_400ns.genblk1\[979\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[980\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[106\].delay_unit clkgen.delay_200ns_1.genblk1\[106\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[107\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[405\].delay_unit clkgen.delay_200ns_1.genblk1\[405\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[406\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_69_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[260\].delay_unit clkgen.delay_200ns_2.genblk1\[260\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[261\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[89\].delay_unit clkgen.delay_200ns_3.genblk1\[89\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[90\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[383\].delay_unit edgedetect.delay_400ns.genblk1\[383\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[384\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[294\].delay_unit clkgen.delay_200ns_1.genblk1\[294\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[295\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[682\].delay_unit edgedetect.delay_400ns.genblk1\[682\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[683\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_87_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_38 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[981\].delay_unit edgedetect.delay_400ns.genblk1\[981\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[982\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_73_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[104\].delay_unit clkgen.delay_200ns_3.genblk1\[104\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[105\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_51_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[403\].delay_unit clkgen.delay_200ns_3.genblk1\[403\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[404\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[138\].delay_unit clkgen.delay_200ns_2.genblk1\[138\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[139\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[437\].delay_unit clkgen.delay_200ns_2.genblk1\[437\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[438\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[91\].delay_unit clkgen.delay_200ns_3.genblk1\[91\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[92\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_66_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xedgedetect.delay_400ns.genblk1\[859\].delay_unit edgedetect.delay_400ns.genblk1\[859\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[860\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_15_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[292\].delay_unit clkgen.delay_200ns_3.genblk1\[292\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[293\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[93\].delay_unit clkgen.delay_200ns_1.genblk1\[93\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[94\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_2.genblk1\[140\].delay_unit clkgen.delay_200ns_2.genblk1\[140\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[141\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_25_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[263\].delay_unit edgedetect.delay_400ns.genblk1\[263\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[264\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[174\].delay_unit clkgen.delay_200ns_1.genblk1\[174\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[175\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_80_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_400ns.genblk1\[562\].delay_unit edgedetect.delay_400ns.genblk1\[562\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[563\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[473\].delay_unit clkgen.delay_200ns_1.genblk1\[473\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[474\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[861\].delay_unit edgedetect.delay_400ns.genblk1\[861\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[862\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[469\].delay_unit clkgen.delay_200ns_3.genblk1\[469\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[470\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_68_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[317\].delay_unit clkgen.delay_200ns_2.genblk1\[317\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[318\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_12_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[739\].delay_unit edgedetect.delay_400ns.genblk1\[739\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[740\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_3.genblk1\[172\].delay_unit clkgen.delay_200ns_3.genblk1\[172\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[173\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_81_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[471\].delay_unit clkgen.delay_200ns_3.genblk1\[471\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[472\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_74_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[59\].delay_unit edgedetect.delay_400ns.genblk1\[59\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[60\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_491 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[143\].delay_unit edgedetect.delay_400ns.genblk1\[143\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[144\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[442\].delay_unit edgedetect.delay_400ns.genblk1\[442\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[443\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_1.genblk1\[353\].delay_unit clkgen.delay_200ns_1.genblk1\[353\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[354\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[741\].delay_unit edgedetect.delay_400ns.genblk1\[741\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[742\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_65_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[349\].delay_unit clkgen.delay_200ns_3.genblk1\[349\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[350\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_41_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_1.genblk1\[3\].delay_unit clkgen.delay_200ns_1.genblk1\[3\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[4\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[61\].delay_unit edgedetect.delay_400ns.genblk1\[61\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[62\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_56_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_343 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[619\].delay_unit edgedetect.delay_400ns.genblk1\[619\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[620\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_44_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[918\].delay_unit edgedetect.delay_400ns.genblk1\[918\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[919\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_12_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[351\].delay_unit clkgen.delay_200ns_3.genblk1\[351\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[352\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[1026\].delay_unit edgedetect.delay_400ns.genblk1\[1026\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1027\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[385\].delay_unit clkgen.delay_200ns_2.genblk1\[385\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[386\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[28\].delay_unit clkgen.delay_200ns_3.genblk1\[28\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[29\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_23_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_335 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[322\].delay_unit edgedetect.delay_400ns.genblk1\[322\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[323\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[233\].delay_unit clkgen.delay_200ns_1.genblk1\[233\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[234\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[621\].delay_unit edgedetect.delay_400ns.genblk1\[621\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[622\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[532\].delay_unit clkgen.delay_200ns_1.genblk1\[532\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[533\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[920\].delay_unit edgedetect.delay_400ns.genblk1\[920\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[921\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[229\].delay_unit clkgen.delay_200ns_3.genblk1\[229\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[230\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[528\].delay_unit clkgen.delay_200ns_3.genblk1\[528\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[529\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_346 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[30\].delay_unit clkgen.delay_200ns_3.genblk1\[30\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[31\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_247 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[231\].delay_unit clkgen.delay_200ns_3.genblk1\[231\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[232\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[32\].delay_unit clkgen.delay_200ns_1.genblk1\[32\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[33\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[530\].delay_unit clkgen.delay_200ns_3.genblk1\[530\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[531\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[265\].delay_unit clkgen.delay_200ns_2.genblk1\[265\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[266\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_58_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[388\].delay_unit edgedetect.delay_400ns.genblk1\[388\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[389\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[299\].delay_unit clkgen.delay_200ns_1.genblk1\[299\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[300\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[687\].delay_unit edgedetect.delay_400ns.genblk1\[687\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[688\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_67_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[986\].delay_unit edgedetect.delay_400ns.genblk1\[986\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[987\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[64\].delay_unit clkgen.delay_200ns_2.genblk1\[64\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[65\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[202\].delay_unit edgedetect.delay_400ns.genblk1\[202\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[203\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[113\].delay_unit clkgen.delay_200ns_1.genblk1\[113\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[114\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_70_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[501\].delay_unit edgedetect.delay_400ns.genblk1\[501\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[502\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[412\].delay_unit clkgen.delay_200ns_1.genblk1\[412\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[413\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[109\].delay_unit clkgen.delay_200ns_3.genblk1\[109\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[110\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[800\].delay_unit edgedetect.delay_400ns.genblk1\[800\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[801\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[408\].delay_unit clkgen.delay_200ns_3.genblk1\[408\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[409\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[96\].delay_unit clkgen.delay_200ns_3.genblk1\[96\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[97\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[390\].delay_unit edgedetect.delay_400ns.genblk1\[390\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[391\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_3.genblk1\[297\].delay_unit clkgen.delay_200ns_3.genblk1\[297\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[298\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[98\].delay_unit clkgen.delay_200ns_1.genblk1\[98\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[99\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_41_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[111\].delay_unit clkgen.delay_200ns_3.genblk1\[111\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[112\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[410\].delay_unit clkgen.delay_200ns_3.genblk1\[410\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[411\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[145\].delay_unit clkgen.delay_200ns_2.genblk1\[145\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[146\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_64_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[444\].delay_unit clkgen.delay_200ns_2.genblk1\[444\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[445\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[268\].delay_unit edgedetect.delay_400ns.genblk1\[268\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[269\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[179\].delay_unit clkgen.delay_200ns_1.genblk1\[179\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[180\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[567\].delay_unit edgedetect.delay_400ns.genblk1\[567\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[568\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[478\].delay_unit clkgen.delay_200ns_1.genblk1\[478\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[479\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[866\].delay_unit edgedetect.delay_400ns.genblk1\[866\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[867\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_87_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_430 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[270\].delay_unit edgedetect.delay_400ns.genblk1\[270\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[271\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_78_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[181\].delay_unit clkgen.delay_200ns_1.genblk1\[181\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[182\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_86_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[480\].delay_unit clkgen.delay_200ns_1.genblk1\[480\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[481\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[177\].delay_unit clkgen.delay_200ns_3.genblk1\[177\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[178\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[476\].delay_unit clkgen.delay_200ns_3.genblk1\[476\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[477\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_176 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[324\].delay_unit clkgen.delay_200ns_2.genblk1\[324\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[325\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_77_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[148\].delay_unit edgedetect.delay_400ns.genblk1\[148\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[149\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[447\].delay_unit edgedetect.delay_400ns.genblk1\[447\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[448\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[358\].delay_unit clkgen.delay_200ns_1.genblk1\[358\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[359\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[746\].delay_unit edgedetect.delay_400ns.genblk1\[746\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[747\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[8\].delay_unit clkgen.delay_200ns_1.genblk1\[8\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[9\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[66\].delay_unit edgedetect.delay_400ns.genblk1\[66\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[67\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_73_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[150\].delay_unit edgedetect.delay_400ns.genblk1\[150\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[151\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[360\].delay_unit clkgen.delay_200ns_1.genblk1\[360\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[361\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[356\].delay_unit clkgen.delay_200ns_3.genblk1\[356\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[357\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_78_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[204\].delay_unit clkgen.delay_200ns_2.genblk1\[204\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[205\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[503\].delay_unit clkgen.delay_200ns_2.genblk1\[503\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[504\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[327\].delay_unit edgedetect.delay_400ns.genblk1\[327\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[328\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_1.genblk1\[238\].delay_unit clkgen.delay_200ns_1.genblk1\[238\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[239\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[626\].delay_unit edgedetect.delay_400ns.genblk1\[626\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[627\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_1.genblk1\[537\].delay_unit clkgen.delay_200ns_1.genblk1\[537\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[538\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[925\].delay_unit edgedetect.delay_400ns.genblk1\[925\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[926\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1033\].delay_unit edgedetect.delay_400ns.genblk1\[1033\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1034\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_53_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[392\].delay_unit clkgen.delay_200ns_2.genblk1\[392\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[393\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_88_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[35\].delay_unit clkgen.delay_200ns_3.genblk1\[35\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[36\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_330 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[240\].delay_unit clkgen.delay_200ns_1.genblk1\[240\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[241\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_17_42 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[236\].delay_unit clkgen.delay_200ns_3.genblk1\[236\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[237\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[535\].delay_unit clkgen.delay_200ns_3.genblk1\[535\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[536\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[37\].delay_unit clkgen.delay_200ns_1.genblk1\[37\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[38\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_12_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[69\].delay_unit clkgen.delay_200ns_2.genblk1\[69\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[70\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_62_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[207\].delay_unit edgedetect.delay_400ns.genblk1\[207\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[208\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[118\].delay_unit clkgen.delay_200ns_1.genblk1\[118\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[119\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[506\].delay_unit edgedetect.delay_400ns.genblk1\[506\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[507\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_88_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_1.genblk1\[417\].delay_unit clkgen.delay_200ns_1.genblk1\[417\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[418\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[805\].delay_unit edgedetect.delay_400ns.genblk1\[805\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[806\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_296 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_2.genblk1\[272\].delay_unit clkgen.delay_200ns_2.genblk1\[272\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[273\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_38_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[395\].delay_unit edgedetect.delay_400ns.genblk1\[395\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[396\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[694\].delay_unit edgedetect.delay_400ns.genblk1\[694\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[695\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkgen.delay_200ns_2.genblk1\[71\].delay_unit clkgen.delay_200ns_2.genblk1\[71\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[72\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[993\].delay_unit edgedetect.delay_400ns.genblk1\[993\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[994\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[120\].delay_unit clkgen.delay_200ns_1.genblk1\[120\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[121\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[116\].delay_unit clkgen.delay_200ns_3.genblk1\[116\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[117\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_76_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[415\].delay_unit clkgen.delay_200ns_3.genblk1\[415\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[416\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_17_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_2.genblk1\[449\].delay_unit clkgen.delay_200ns_2.genblk1\[449\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[450\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_60_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_347 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[152\].delay_unit clkgen.delay_200ns_2.genblk1\[152\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[153\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[451\].delay_unit clkgen.delay_200ns_2.genblk1\[451\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[452\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[275\].delay_unit edgedetect.delay_400ns.genblk1\[275\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[276\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_1.genblk1\[186\].delay_unit clkgen.delay_200ns_1.genblk1\[186\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[187\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[574\].delay_unit edgedetect.delay_400ns.genblk1\[574\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[575\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_45_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[485\].delay_unit clkgen.delay_200ns_1.genblk1\[485\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[486\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_26_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[873\].delay_unit edgedetect.delay_400ns.genblk1\[873\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[874\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_41_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_259 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[329\].delay_unit clkgen.delay_200ns_2.genblk1\[329\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[330\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_3.genblk1\[184\].delay_unit clkgen.delay_200ns_3.genblk1\[184\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[185\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[483\].delay_unit clkgen.delay_200ns_3.genblk1\[483\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[484\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_27_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[331\].delay_unit clkgen.delay_200ns_2.genblk1\[331\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[332\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_50_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[155\].delay_unit edgedetect.delay_400ns.genblk1\[155\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[156\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[454\].delay_unit edgedetect.delay_400ns.genblk1\[454\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[455\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[365\].delay_unit clkgen.delay_200ns_1.genblk1\[365\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[366\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[753\].delay_unit edgedetect.delay_400ns.genblk1\[753\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[754\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[209\].delay_unit clkgen.delay_200ns_2.genblk1\[209\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[210\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_41_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[73\].delay_unit edgedetect.delay_400ns.genblk1\[73\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[74\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[508\].delay_unit clkgen.delay_200ns_2.genblk1\[508\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[509\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_13 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[363\].delay_unit clkgen.delay_200ns_3.genblk1\[363\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[364\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1038\].delay_unit edgedetect.delay_400ns.genblk1\[1038\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1039\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_32_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[397\].delay_unit clkgen.delay_200ns_2.genblk1\[397\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[398\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_87_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[211\].delay_unit clkgen.delay_200ns_2.genblk1\[211\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[212\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_55_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[510\].delay_unit clkgen.delay_200ns_2.genblk1\[510\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[511\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[334\].delay_unit edgedetect.delay_400ns.genblk1\[334\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[335\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[245\].delay_unit clkgen.delay_200ns_1.genblk1\[245\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[246\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_51_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[633\].delay_unit edgedetect.delay_400ns.genblk1\[633\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[634\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_51_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[10\].delay_unit clkgen.delay_200ns_2.genblk1\[9\].delay_unit/X
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[11\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[932\].delay_unit edgedetect.delay_400ns.genblk1\[932\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[933\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1040\].delay_unit edgedetect.delay_400ns.genblk1\[1040\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1041\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_87_37 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_3.genblk1\[42\].delay_unit clkgen.delay_200ns_3.genblk1\[42\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[43\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_3.genblk1\[243\].delay_unit clkgen.delay_200ns_3.genblk1\[243\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[244\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[44\].delay_unit clkgen.delay_200ns_1.genblk1\[44\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[45\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_77_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[277\].delay_unit clkgen.delay_200ns_2.genblk1\[277\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[278\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[699\].delay_unit edgedetect.delay_400ns.genblk1\[699\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[700\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[998\].delay_unit edgedetect.delay_400ns.genblk1\[998\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[999\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[76\].delay_unit clkgen.delay_200ns_2.genblk1\[76\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[77\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[214\].delay_unit edgedetect.delay_400ns.genblk1\[214\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[215\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_87_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[125\].delay_unit clkgen.delay_200ns_1.genblk1\[125\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[126\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[513\].delay_unit edgedetect.delay_400ns.genblk1\[513\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[514\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[424\].delay_unit clkgen.delay_200ns_1.genblk1\[424\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[425\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_56_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[812\].delay_unit edgedetect.delay_400ns.genblk1\[812\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[813\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_83_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[123\].delay_unit clkgen.delay_200ns_3.genblk1\[123\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[124\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[422\].delay_unit clkgen.delay_200ns_3.genblk1\[422\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[423\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[157\].delay_unit clkgen.delay_200ns_2.genblk1\[157\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[158\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_2.genblk1\[456\].delay_unit clkgen.delay_200ns_2.genblk1\[456\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[457\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[579\].delay_unit edgedetect.delay_400ns.genblk1\[579\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[580\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[878\].delay_unit edgedetect.delay_400ns.genblk1\[878\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[879\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[304\].delay_unit clkgen.delay_200ns_1.genblk1\[304\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[305\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_88_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_98 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[282\].delay_unit edgedetect.delay_400ns.genblk1\[282\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[283\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_12_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[12\].delay_unit edgedetect.delay_400ns.genblk1\[12\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[13\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[193\].delay_unit clkgen.delay_200ns_1.genblk1\[193\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[194\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[581\].delay_unit edgedetect.delay_400ns.genblk1\[581\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[582\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[189\].delay_unit clkgen.delay_200ns_3.genblk1\[189\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[190\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[492\].delay_unit clkgen.delay_200ns_1.genblk1\[492\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[493\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[880\].delay_unit edgedetect.delay_400ns.genblk1\[880\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[881\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[488\].delay_unit clkgen.delay_200ns_3.genblk1\[488\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[489\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[302\].delay_unit clkgen.delay_200ns_3.genblk1\[302\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[303\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_2.genblk1\[336\].delay_unit clkgen.delay_200ns_2.genblk1\[336\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[337\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_89_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[459\].delay_unit edgedetect.delay_400ns.genblk1\[459\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[460\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[758\].delay_unit edgedetect.delay_400ns.genblk1\[758\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[759\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_415 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_3.genblk1\[191\].delay_unit clkgen.delay_200ns_3.genblk1\[191\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[192\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[490\].delay_unit clkgen.delay_200ns_3.genblk1\[490\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[491\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_53_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_16 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[78\].delay_unit edgedetect.delay_400ns.genblk1\[78\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[79\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[162\].delay_unit edgedetect.delay_400ns.genblk1\[162\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[163\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[461\].delay_unit edgedetect.delay_400ns.genblk1\[461\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[462\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_71_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[372\].delay_unit clkgen.delay_200ns_1.genblk1\[372\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[373\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_44_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[760\].delay_unit edgedetect.delay_400ns.genblk1\[760\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[761\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_44_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_3.genblk1\[368\].delay_unit clkgen.delay_200ns_3.genblk1\[368\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[369\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[216\].delay_unit clkgen.delay_200ns_2.genblk1\[216\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[217\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_85_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[80\].delay_unit edgedetect.delay_400ns.genblk1\[80\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[81\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[515\].delay_unit clkgen.delay_200ns_2.genblk1\[515\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[516\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_62_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[339\].delay_unit edgedetect.delay_400ns.genblk1\[339\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[340\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_50_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[638\].delay_unit edgedetect.delay_400ns.genblk1\[638\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[639\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[15\].delay_unit clkgen.delay_200ns_2.genblk1\[15\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[16\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[937\].delay_unit edgedetect.delay_400ns.genblk1\[937\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[938\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[1045\].delay_unit edgedetect.delay_400ns.genblk1\[1045\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1046\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[370\].delay_unit clkgen.delay_200ns_3.genblk1\[370\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[371\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_44 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[47\].delay_unit clkgen.delay_200ns_3.genblk1\[47\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[48\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[341\].delay_unit edgedetect.delay_400ns.genblk1\[341\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[342\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[252\].delay_unit clkgen.delay_200ns_1.genblk1\[252\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[253\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_400ns.genblk1\[640\].delay_unit edgedetect.delay_400ns.genblk1\[640\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[641\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[248\].delay_unit clkgen.delay_200ns_3.genblk1\[248\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[249\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[49\].delay_unit clkgen.delay_200ns_1.genblk1\[49\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[50\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_76_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xedgedetect.delay_400ns.genblk1\[219\].delay_unit edgedetect.delay_400ns.genblk1\[219\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[220\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_67_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[518\].delay_unit edgedetect.delay_400ns.genblk1\[518\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[519\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_82_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[429\].delay_unit clkgen.delay_200ns_1.genblk1\[429\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[430\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[817\].delay_unit edgedetect.delay_400ns.genblk1\[817\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[818\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[250\].delay_unit clkgen.delay_200ns_3.genblk1\[250\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[251\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[51\].delay_unit clkgen.delay_200ns_1.genblk1\[51\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[52\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[284\].delay_unit clkgen.delay_200ns_2.genblk1\[284\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[285\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[221\].delay_unit edgedetect.delay_400ns.genblk1\[221\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[222\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[83\].delay_unit clkgen.delay_200ns_2.genblk1\[83\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[84\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_1.genblk1\[132\].delay_unit clkgen.delay_200ns_1.genblk1\[132\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[133\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[520\].delay_unit edgedetect.delay_400ns.genblk1\[520\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[521\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[431\].delay_unit clkgen.delay_200ns_1.genblk1\[431\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[432\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[128\].delay_unit clkgen.delay_200ns_3.genblk1\[128\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[129\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[427\].delay_unit clkgen.delay_200ns_3.genblk1\[427\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[428\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[309\].delay_unit clkgen.delay_200ns_1.genblk1\[309\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[310\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_87_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[130\].delay_unit clkgen.delay_200ns_3.genblk1\[130\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[131\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_55_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[164\].delay_unit clkgen.delay_200ns_2.genblk1\[164\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[165\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_23_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[463\].delay_unit clkgen.delay_200ns_2.genblk1\[463\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[464\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[287\].delay_unit edgedetect.delay_400ns.genblk1\[287\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[288\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[17\].delay_unit edgedetect.delay_400ns.genblk1\[17\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[18\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[198\].delay_unit clkgen.delay_200ns_1.genblk1\[198\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[199\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[586\].delay_unit edgedetect.delay_400ns.genblk1\[586\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[587\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_78 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[497\].delay_unit clkgen.delay_200ns_1.genblk1\[497\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[498\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[885\].delay_unit edgedetect.delay_400ns.genblk1\[885\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[886\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[101\].delay_unit edgedetect.delay_400ns.genblk1\[101\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[102\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[400\].delay_unit edgedetect.delay_400ns.genblk1\[400\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[401\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[311\].delay_unit clkgen.delay_200ns_1.genblk1\[311\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[312\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[307\].delay_unit clkgen.delay_200ns_3.genblk1\[307\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[308\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_27_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[196\].delay_unit clkgen.delay_200ns_3.genblk1\[196\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[197\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_45_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[495\].delay_unit clkgen.delay_200ns_3.genblk1\[495\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[496\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_60_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_295 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[343\].delay_unit clkgen.delay_200ns_2.genblk1\[343\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[344\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_28_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[167\].delay_unit edgedetect.delay_400ns.genblk1\[167\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[168\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_71_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[466\].delay_unit edgedetect.delay_400ns.genblk1\[466\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[467\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[377\].delay_unit clkgen.delay_200ns_1.genblk1\[377\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[378\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[765\].delay_unit edgedetect.delay_400ns.genblk1\[765\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[766\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[1\].delay_unit _3_/X VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[2\].delay_unit/A
+ sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[85\].delay_unit edgedetect.delay_400ns.genblk1\[85\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[86\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_27_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_3.genblk1\[375\].delay_unit clkgen.delay_200ns_3.genblk1\[375\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[376\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[223\].delay_unit clkgen.delay_200ns_2.genblk1\[223\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[224\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[522\].delay_unit clkgen.delay_200ns_2.genblk1\[522\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[523\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_88_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[346\].delay_unit edgedetect.delay_400ns.genblk1\[346\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[347\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_68_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[257\].delay_unit clkgen.delay_200ns_1.genblk1\[257\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[258\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[645\].delay_unit edgedetect.delay_400ns.genblk1\[645\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[646\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_83_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[22\].delay_unit clkgen.delay_200ns_2.genblk1\[22\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[23\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[944\].delay_unit edgedetect.delay_400ns.genblk1\[944\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[945\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_71_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[1052\].delay_unit edgedetect.delay_400ns.genblk1\[1052\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1053\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_12_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[54\].delay_unit clkgen.delay_200ns_3.genblk1\[54\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[55\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[255\].delay_unit clkgen.delay_200ns_3.genblk1\[255\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[256\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[56\].delay_unit clkgen.delay_200ns_1.genblk1\[56\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[57\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_2.genblk1\[289\].delay_unit clkgen.delay_200ns_2.genblk1\[289\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[290\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_427 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_2.genblk1\[103\].delay_unit clkgen.delay_200ns_2.genblk1\[103\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[104\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_38_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_302 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[402\].delay_unit clkgen.delay_200ns_2.genblk1\[402\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[403\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_41_519 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[226\].delay_unit edgedetect.delay_400ns.genblk1\[226\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[227\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[88\].delay_unit clkgen.delay_200ns_2.genblk1\[88\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[89\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[137\].delay_unit clkgen.delay_200ns_1.genblk1\[137\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[138\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[525\].delay_unit edgedetect.delay_400ns.genblk1\[525\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[526\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[436\].delay_unit clkgen.delay_200ns_1.genblk1\[436\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[437\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_79_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xedgedetect.delay_400ns.genblk1\[824\].delay_unit edgedetect.delay_400ns.genblk1\[824\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[825\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_88_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[291\].delay_unit clkgen.delay_200ns_2.genblk1\[291\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[292\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_44_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[90\].delay_unit clkgen.delay_200ns_2.genblk1\[90\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[91\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_79_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[135\].delay_unit clkgen.delay_200ns_3.genblk1\[135\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[136\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_85_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[434\].delay_unit clkgen.delay_200ns_3.genblk1\[434\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[435\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_62_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[169\].delay_unit clkgen.delay_200ns_2.genblk1\[169\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[170\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[468\].delay_unit clkgen.delay_200ns_2.genblk1\[468\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[469\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[106\].delay_unit edgedetect.delay_400ns.genblk1\[106\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[107\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[405\].delay_unit edgedetect.delay_400ns.genblk1\[405\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[406\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_26_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_1.genblk1\[316\].delay_unit clkgen.delay_200ns_1.genblk1\[316\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[317\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_53_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[704\].delay_unit edgedetect.delay_400ns.genblk1\[704\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[705\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[171\].delay_unit clkgen.delay_200ns_2.genblk1\[171\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[172\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[470\].delay_unit clkgen.delay_200ns_2.genblk1\[470\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[471\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[294\].delay_unit edgedetect.delay_400ns.genblk1\[294\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[295\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_76_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[24\].delay_unit edgedetect.delay_400ns.genblk1\[24\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[25\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[593\].delay_unit edgedetect.delay_400ns.genblk1\[593\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[594\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[892\].delay_unit edgedetect.delay_400ns.genblk1\[892\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[893\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_71_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[314\].delay_unit clkgen.delay_200ns_3.genblk1\[314\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[315\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_82_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[348\].delay_unit clkgen.delay_200ns_2.genblk1\[348\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[349\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_3.genblk1\[6\].delay_unit clkgen.delay_200ns_3.genblk1\[6\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[7\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[350\].delay_unit clkgen.delay_200ns_2.genblk1\[350\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[351\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[174\].delay_unit edgedetect.delay_400ns.genblk1\[174\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[175\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[473\].delay_unit edgedetect.delay_400ns.genblk1\[473\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[474\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[384\].delay_unit clkgen.delay_200ns_1.genblk1\[384\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[385\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_89_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[772\].delay_unit edgedetect.delay_400ns.genblk1\[772\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[773\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_17_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[228\].delay_unit clkgen.delay_200ns_2.genblk1\[228\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[229\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_56_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_400ns.genblk1\[92\].delay_unit edgedetect.delay_400ns.genblk1\[92\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[93\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[527\].delay_unit clkgen.delay_200ns_2.genblk1\[527\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[528\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_83_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[949\].delay_unit edgedetect.delay_400ns.genblk1\[949\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[950\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[27\].delay_unit clkgen.delay_200ns_2.genblk1\[27\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[28\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[1057\].delay_unit edgedetect.delay_400ns.genblk1\[1057\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1058\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[382\].delay_unit clkgen.delay_200ns_3.genblk1\[382\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[383\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[230\].delay_unit clkgen.delay_200ns_2.genblk1\[230\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[231\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[59\].delay_unit clkgen.delay_200ns_3.genblk1\[59\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[60\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_27_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[353\].delay_unit edgedetect.delay_400ns.genblk1\[353\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[354\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_499 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[264\].delay_unit clkgen.delay_200ns_1.genblk1\[264\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[265\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[652\].delay_unit edgedetect.delay_400ns.genblk1\[652\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[653\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[951\].delay_unit edgedetect.delay_400ns.genblk1\[951\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[952\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_37_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[108\].delay_unit clkgen.delay_200ns_2.genblk1\[108\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[109\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[407\].delay_unit clkgen.delay_200ns_2.genblk1\[407\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[408\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_60_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_190 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[61\].delay_unit clkgen.delay_200ns_3.genblk1\[61\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[62\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[829\].delay_unit edgedetect.delay_400ns.genblk1\[829\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[830\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_87_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[262\].delay_unit clkgen.delay_200ns_3.genblk1\[262\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[263\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_68_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_91 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_1.genblk1\[63\].delay_unit clkgen.delay_200ns_1.genblk1\[63\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[64\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_83_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[296\].delay_unit clkgen.delay_200ns_2.genblk1\[296\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[297\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_24_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[110\].delay_unit clkgen.delay_200ns_2.genblk1\[110\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[111\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[233\].delay_unit edgedetect.delay_400ns.genblk1\[233\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[234\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[95\].delay_unit clkgen.delay_200ns_2.genblk1\[95\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[96\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_1.genblk1\[144\].delay_unit clkgen.delay_200ns_1.genblk1\[144\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[145\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[532\].delay_unit edgedetect.delay_400ns.genblk1\[532\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[533\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_34_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[443\].delay_unit clkgen.delay_200ns_1.genblk1\[443\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[444\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[831\].delay_unit edgedetect.delay_400ns.genblk1\[831\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[832\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[439\].delay_unit clkgen.delay_200ns_3.genblk1\[439\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[440\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[709\].delay_unit edgedetect.delay_400ns.genblk1\[709\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[710\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[142\].delay_unit clkgen.delay_200ns_3.genblk1\[142\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[143\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[441\].delay_unit clkgen.delay_200ns_3.genblk1\[441\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[442\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[176\].delay_unit clkgen.delay_200ns_2.genblk1\[176\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[177\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[475\].delay_unit clkgen.delay_200ns_2.genblk1\[475\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[476\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[299\].delay_unit edgedetect.delay_400ns.genblk1\[299\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[300\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_71_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[29\].delay_unit edgedetect.delay_400ns.genblk1\[29\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[30\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[598\].delay_unit edgedetect.delay_400ns.genblk1\[598\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[599\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_12_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[897\].delay_unit edgedetect.delay_400ns.genblk1\[897\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[898\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[113\].delay_unit edgedetect.delay_400ns.genblk1\[113\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[114\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[412\].delay_unit edgedetect.delay_400ns.genblk1\[412\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[413\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[323\].delay_unit clkgen.delay_200ns_1.genblk1\[323\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[324\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[711\].delay_unit edgedetect.delay_400ns.genblk1\[711\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[712\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_79_458 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[319\].delay_unit clkgen.delay_200ns_3.genblk1\[319\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[320\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_58_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[31\].delay_unit edgedetect.delay_400ns.genblk1\[31\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[32\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[321\].delay_unit clkgen.delay_200ns_3.genblk1\[321\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[322\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[355\].delay_unit clkgen.delay_200ns_2.genblk1\[355\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[356\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[179\].delay_unit edgedetect.delay_400ns.genblk1\[179\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[180\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_88_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[478\].delay_unit edgedetect.delay_400ns.genblk1\[478\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[479\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_88_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[389\].delay_unit clkgen.delay_200ns_1.genblk1\[389\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[390\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[777\].delay_unit edgedetect.delay_400ns.genblk1\[777\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[778\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_56_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_1.genblk1\[203\].delay_unit clkgen.delay_200ns_1.genblk1\[203\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[204\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_44_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_1.genblk1\[502\].delay_unit clkgen.delay_200ns_1.genblk1\[502\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[503\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[97\].delay_unit edgedetect.delay_400ns.genblk1\[97\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[98\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_69_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[181\].delay_unit edgedetect.delay_400ns.genblk1\[181\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[182\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_43_380 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[480\].delay_unit edgedetect.delay_400ns.genblk1\[480\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[481\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[391\].delay_unit clkgen.delay_200ns_1.genblk1\[391\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[392\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_86_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[387\].delay_unit clkgen.delay_200ns_3.genblk1\[387\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[388\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_3.genblk1\[201\].delay_unit clkgen.delay_200ns_3.genblk1\[201\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[202\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_85_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_3.genblk1\[500\].delay_unit clkgen.delay_200ns_3.genblk1\[500\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[501\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[235\].delay_unit clkgen.delay_200ns_2.genblk1\[235\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[236\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_41_306 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[534\].delay_unit clkgen.delay_200ns_2.genblk1\[534\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[535\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[358\].delay_unit edgedetect.delay_400ns.genblk1\[358\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[359\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_68 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_12 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[269\].delay_unit clkgen.delay_200ns_1.genblk1\[269\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[270\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[657\].delay_unit edgedetect.delay_400ns.genblk1\[657\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[658\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[34\].delay_unit clkgen.delay_200ns_2.genblk1\[34\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[35\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[956\].delay_unit edgedetect.delay_400ns.genblk1\[956\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[957\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1064\].delay_unit edgedetect.delay_400ns.genblk1\[1064\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1065\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_291 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_3.genblk1\[66\].delay_unit clkgen.delay_200ns_3.genblk1\[66\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[67\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_262 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[360\].delay_unit edgedetect.delay_400ns.genblk1\[360\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[361\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[271\].delay_unit clkgen.delay_200ns_1.genblk1\[271\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[272\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_67_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[267\].delay_unit clkgen.delay_200ns_3.genblk1\[267\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[268\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[68\].delay_unit clkgen.delay_200ns_1.genblk1\[68\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[69\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[115\].delay_unit clkgen.delay_200ns_2.genblk1\[115\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[116\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_2.genblk1\[414\].delay_unit clkgen.delay_200ns_2.genblk1\[414\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[415\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[238\].delay_unit edgedetect.delay_400ns.genblk1\[238\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[239\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[149\].delay_unit clkgen.delay_200ns_1.genblk1\[149\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[150\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[537\].delay_unit edgedetect.delay_400ns.genblk1\[537\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[538\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_81_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_1.genblk1\[448\].delay_unit clkgen.delay_200ns_1.genblk1\[448\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[449\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_54_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[836\].delay_unit edgedetect.delay_400ns.genblk1\[836\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[837\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_1.genblk1\[70\].delay_unit clkgen.delay_200ns_1.genblk1\[70\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[71\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_89_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[240\].delay_unit edgedetect.delay_400ns.genblk1\[240\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[241\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[151\].delay_unit clkgen.delay_200ns_1.genblk1\[151\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[152\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[450\].delay_unit clkgen.delay_200ns_1.genblk1\[450\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[451\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[147\].delay_unit clkgen.delay_200ns_3.genblk1\[147\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[148\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_68_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[446\].delay_unit clkgen.delay_200ns_3.genblk1\[446\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[447\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_70_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[118\].delay_unit edgedetect.delay_400ns.genblk1\[118\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[119\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[417\].delay_unit edgedetect.delay_400ns.genblk1\[417\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[418\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[328\].delay_unit clkgen.delay_200ns_1.genblk1\[328\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[329\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[716\].delay_unit edgedetect.delay_400ns.genblk1\[716\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[717\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[183\].delay_unit clkgen.delay_200ns_2.genblk1\[183\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[184\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[482\].delay_unit clkgen.delay_200ns_2.genblk1\[482\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[483\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[36\].delay_unit edgedetect.delay_400ns.genblk1\[36\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[37\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[120\].delay_unit edgedetect.delay_400ns.genblk1\[120\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[121\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[330\].delay_unit clkgen.delay_200ns_1.genblk1\[330\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[331\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_60_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[326\].delay_unit clkgen.delay_200ns_3.genblk1\[326\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[327\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[208\].delay_unit clkgen.delay_200ns_1.genblk1\[208\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[209\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[507\].delay_unit clkgen.delay_200ns_1.genblk1\[507\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[508\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_106 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[1003\].delay_unit edgedetect.delay_400ns.genblk1\[1003\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1004\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[362\].delay_unit clkgen.delay_200ns_2.genblk1\[362\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[363\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_27_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[186\].delay_unit edgedetect.delay_400ns.genblk1\[186\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[187\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xedgedetect.delay_400ns.genblk1\[485\].delay_unit edgedetect.delay_400ns.genblk1\[485\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[486\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[396\].delay_unit clkgen.delay_200ns_1.genblk1\[396\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[397\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[784\].delay_unit edgedetect.delay_400ns.genblk1\[784\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[785\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[210\].delay_unit clkgen.delay_200ns_1.genblk1\[210\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[211\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_84_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[206\].delay_unit clkgen.delay_200ns_3.genblk1\[206\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[207\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_77_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[505\].delay_unit clkgen.delay_200ns_3.genblk1\[505\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[506\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[539\].delay_unit clkgen.delay_200ns_2.genblk1\[539\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[540\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[39\].delay_unit clkgen.delay_200ns_2.genblk1\[39\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[40\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1069\].delay_unit edgedetect.delay_400ns.genblk1\[1069\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1070\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[394\].delay_unit clkgen.delay_200ns_3.genblk1\[394\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[395\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_83_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[242\].delay_unit clkgen.delay_200ns_2.genblk1\[242\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[243\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[365\].delay_unit edgedetect.delay_400ns.genblk1\[365\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[366\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_58_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[276\].delay_unit clkgen.delay_200ns_1.genblk1\[276\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[277\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[664\].delay_unit edgedetect.delay_400ns.genblk1\[664\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[665\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_74_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[963\].delay_unit edgedetect.delay_400ns.genblk1\[963\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[964\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_15_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[41\].delay_unit clkgen.delay_200ns_2.genblk1\[41\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[42\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1071\].delay_unit edgedetect.delay_400ns.genblk1\[1071\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1072\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_2.genblk1\[419\].delay_unit clkgen.delay_200ns_2.genblk1\[419\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[420\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[73\].delay_unit clkgen.delay_200ns_3.genblk1\[73\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[74\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_65_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[274\].delay_unit clkgen.delay_200ns_3.genblk1\[274\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[275\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[75\].delay_unit clkgen.delay_200ns_1.genblk1\[75\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[76\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_88_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[122\].delay_unit clkgen.delay_200ns_2.genblk1\[122\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[123\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[421\].delay_unit clkgen.delay_200ns_2.genblk1\[421\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[422\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_60_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[245\].delay_unit edgedetect.delay_400ns.genblk1\[245\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[246\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[156\].delay_unit clkgen.delay_200ns_1.genblk1\[156\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[157\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[544\].delay_unit edgedetect.delay_400ns.genblk1\[544\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[545\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[455\].delay_unit clkgen.delay_200ns_1.genblk1\[455\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[456\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[843\].delay_unit edgedetect.delay_400ns.genblk1\[843\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[844\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_85_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[5\].delay_unit edgedetect.delay_400ns.genblk1\[5\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[6\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[154\].delay_unit clkgen.delay_200ns_3.genblk1\[154\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[155\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_41_318 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[453\].delay_unit clkgen.delay_200ns_3.genblk1\[453\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[454\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[188\].delay_unit clkgen.delay_200ns_2.genblk1\[188\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[189\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[487\].delay_unit clkgen.delay_200ns_2.genblk1\[487\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[488\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[301\].delay_unit clkgen.delay_200ns_2.genblk1\[301\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[302\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_17_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[125\].delay_unit edgedetect.delay_400ns.genblk1\[125\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[126\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[424\].delay_unit edgedetect.delay_400ns.genblk1\[424\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[425\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[335\].delay_unit clkgen.delay_200ns_1.genblk1\[335\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[336\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[723\].delay_unit edgedetect.delay_400ns.genblk1\[723\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[724\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_274 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[190\].delay_unit clkgen.delay_200ns_2.genblk1\[190\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[191\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_75_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[43\].delay_unit edgedetect.delay_400ns.genblk1\[43\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[44\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[1008\].delay_unit edgedetect.delay_400ns.genblk1\[1008\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1009\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[333\].delay_unit clkgen.delay_200ns_3.genblk1\[333\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[334\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[5\].delay_unit clkgen.delay_200ns_2.genblk1\[5\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[6\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_318 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[367\].delay_unit clkgen.delay_200ns_2.genblk1\[367\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[368\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[789\].delay_unit edgedetect.delay_400ns.genblk1\[789\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[790\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[304\].delay_unit edgedetect.delay_400ns.genblk1\[304\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[305\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[215\].delay_unit clkgen.delay_200ns_1.genblk1\[215\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[216\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[603\].delay_unit edgedetect.delay_400ns.genblk1\[603\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[604\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[514\].delay_unit clkgen.delay_200ns_1.genblk1\[514\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[515\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_66_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[902\].delay_unit edgedetect.delay_400ns.genblk1\[902\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[903\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_45_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[1010\].delay_unit edgedetect.delay_400ns.genblk1\[1010\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1011\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_82_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[193\].delay_unit edgedetect.delay_400ns.genblk1\[193\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[194\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[492\].delay_unit edgedetect.delay_400ns.genblk1\[492\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[493\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[12\].delay_unit clkgen.delay_200ns_3.genblk1\[12\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[13\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_55_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[791\].delay_unit edgedetect.delay_400ns.genblk1\[791\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[792\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_36_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[399\].delay_unit clkgen.delay_200ns_3.genblk1\[399\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[400\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_51_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[213\].delay_unit clkgen.delay_200ns_3.genblk1\[213\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[214\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[14\].delay_unit clkgen.delay_200ns_1.genblk1\[14\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[15\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[512\].delay_unit clkgen.delay_200ns_3.genblk1\[512\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[513\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[247\].delay_unit clkgen.delay_200ns_2.genblk1\[247\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[248\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_86_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[669\].delay_unit edgedetect.delay_400ns.genblk1\[669\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[670\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[46\].delay_unit clkgen.delay_200ns_2.genblk1\[46\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[47\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[968\].delay_unit edgedetect.delay_400ns.genblk1\[968\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[969\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_52_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_99 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[1076\].delay_unit edgedetect.delay_400ns.genblk1\[1076\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1077\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_519 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[78\].delay_unit clkgen.delay_200ns_3.genblk1\[78\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[79\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[372\].delay_unit edgedetect.delay_400ns.genblk1\[372\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[373\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[283\].delay_unit clkgen.delay_200ns_1.genblk1\[283\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[284\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_61_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[671\].delay_unit edgedetect.delay_400ns.genblk1\[671\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[672\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[279\].delay_unit clkgen.delay_200ns_3.genblk1\[279\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[280\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[970\].delay_unit edgedetect.delay_400ns.genblk1\[970\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[971\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_83_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[127\].delay_unit clkgen.delay_200ns_2.genblk1\[127\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[128\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[426\].delay_unit clkgen.delay_200ns_2.genblk1\[426\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[427\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[80\].delay_unit clkgen.delay_200ns_3.genblk1\[80\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[81\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[549\].delay_unit edgedetect.delay_400ns.genblk1\[549\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[550\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_78_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_400ns.genblk1\[848\].delay_unit edgedetect.delay_400ns.genblk1\[848\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[849\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[281\].delay_unit clkgen.delay_200ns_3.genblk1\[281\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[282\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_15_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[82\].delay_unit clkgen.delay_200ns_1.genblk1\[82\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[83\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_12_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_77_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[252\].delay_unit edgedetect.delay_400ns.genblk1\[252\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[253\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_65_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[163\].delay_unit clkgen.delay_200ns_1.genblk1\[163\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[164\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_273 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_295 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[551\].delay_unit edgedetect.delay_400ns.genblk1\[551\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[552\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[462\].delay_unit clkgen.delay_200ns_1.genblk1\[462\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[463\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[850\].delay_unit edgedetect.delay_400ns.genblk1\[850\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[851\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[159\].delay_unit clkgen.delay_200ns_3.genblk1\[159\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[160\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[458\].delay_unit clkgen.delay_200ns_3.genblk1\[458\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[459\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_68_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[306\].delay_unit clkgen.delay_200ns_2.genblk1\[306\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[307\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[429\].delay_unit edgedetect.delay_400ns.genblk1\[429\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[430\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[728\].delay_unit edgedetect.delay_400ns.genblk1\[728\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[729\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_3.genblk1\[161\].delay_unit clkgen.delay_200ns_3.genblk1\[161\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[162\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_58_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[460\].delay_unit clkgen.delay_200ns_3.genblk1\[460\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[461\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[195\].delay_unit clkgen.delay_200ns_2.genblk1\[195\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[196\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[494\].delay_unit clkgen.delay_200ns_2.genblk1\[494\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[495\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_70_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[48\].delay_unit edgedetect.delay_400ns.genblk1\[48\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[49\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_400ns.genblk1\[132\].delay_unit edgedetect.delay_400ns.genblk1\[132\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[133\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[431\].delay_unit edgedetect.delay_400ns.genblk1\[431\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[432\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_1.genblk1\[342\].delay_unit clkgen.delay_200ns_1.genblk1\[342\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[343\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[730\].delay_unit edgedetect.delay_400ns.genblk1\[730\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[731\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_24_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_3.genblk1\[338\].delay_unit clkgen.delay_200ns_3.genblk1\[338\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[339\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_38_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[50\].delay_unit edgedetect.delay_400ns.genblk1\[50\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[51\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_76_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[309\].delay_unit edgedetect.delay_400ns.genblk1\[309\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[310\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_69_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_46 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[608\].delay_unit edgedetect.delay_400ns.genblk1\[608\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[609\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_71_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_1.genblk1\[519\].delay_unit clkgen.delay_200ns_1.genblk1\[519\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[520\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[907\].delay_unit edgedetect.delay_400ns.genblk1\[907\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[908\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_44_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[340\].delay_unit clkgen.delay_200ns_3.genblk1\[340\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[341\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1015\].delay_unit edgedetect.delay_400ns.genblk1\[1015\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1016\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_60_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[374\].delay_unit clkgen.delay_200ns_2.genblk1\[374\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[375\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_79_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[198\].delay_unit edgedetect.delay_400ns.genblk1\[198\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[199\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_75_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[17\].delay_unit clkgen.delay_200ns_3.genblk1\[17\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[18\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[497\].delay_unit edgedetect.delay_400ns.genblk1\[497\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[498\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[796\].delay_unit edgedetect.delay_400ns.genblk1\[796\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[797\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_62_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[311\].delay_unit edgedetect.delay_400ns.genblk1\[311\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[312\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[222\].delay_unit clkgen.delay_200ns_1.genblk1\[222\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[223\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[610\].delay_unit edgedetect.delay_400ns.genblk1\[610\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[611\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[218\].delay_unit clkgen.delay_200ns_3.genblk1\[218\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[219\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[521\].delay_unit clkgen.delay_200ns_1.genblk1\[521\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[522\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[19\].delay_unit clkgen.delay_200ns_1.genblk1\[19\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[20\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[517\].delay_unit clkgen.delay_200ns_3.genblk1\[517\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[518\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[220\].delay_unit clkgen.delay_200ns_3.genblk1\[220\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[221\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_1.genblk1\[21\].delay_unit clkgen.delay_200ns_1.genblk1\[21\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[22\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_72_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[254\].delay_unit clkgen.delay_200ns_2.genblk1\[254\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[255\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[377\].delay_unit edgedetect.delay_400ns.genblk1\[377\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[378\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[288\].delay_unit clkgen.delay_200ns_1.genblk1\[288\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[289\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[676\].delay_unit edgedetect.delay_400ns.genblk1\[676\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[677\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[975\].delay_unit edgedetect.delay_400ns.genblk1\[975\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[976\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_67_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[53\].delay_unit clkgen.delay_200ns_2.genblk1\[53\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[54\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[102\].delay_unit clkgen.delay_200ns_1.genblk1\[102\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[103\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_1.genblk1\[401\].delay_unit clkgen.delay_200ns_1.genblk1\[401\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[402\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_50_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[85\].delay_unit clkgen.delay_200ns_3.genblk1\[85\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[86\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_1.genblk1\[290\].delay_unit clkgen.delay_200ns_1.genblk1\[290\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[291\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_81_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[286\].delay_unit clkgen.delay_200ns_3.genblk1\[286\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[287\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_25_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[87\].delay_unit clkgen.delay_200ns_1.genblk1\[87\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[88\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_3.genblk1\[100\].delay_unit clkgen.delay_200ns_3.genblk1\[99\].delay_unit/X
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[101\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_77_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[134\].delay_unit clkgen.delay_200ns_2.genblk1\[134\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[135\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[433\].delay_unit clkgen.delay_200ns_2.genblk1\[433\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[434\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_17_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[257\].delay_unit edgedetect.delay_400ns.genblk1\[257\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[258\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[168\].delay_unit clkgen.delay_200ns_1.genblk1\[168\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[169\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_82_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[556\].delay_unit edgedetect.delay_400ns.genblk1\[556\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[557\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_60_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_1.genblk1\[467\].delay_unit clkgen.delay_200ns_1.genblk1\[467\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[468\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[855\].delay_unit edgedetect.delay_400ns.genblk1\[855\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[856\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_68_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[170\].delay_unit clkgen.delay_200ns_1.genblk1\[170\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[171\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[166\].delay_unit clkgen.delay_200ns_3.genblk1\[166\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[167\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_3.genblk1\[465\].delay_unit clkgen.delay_200ns_3.genblk1\[465\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[466\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_36_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[499\].delay_unit clkgen.delay_200ns_2.genblk1\[499\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[500\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[313\].delay_unit clkgen.delay_200ns_2.genblk1\[313\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[314\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[137\].delay_unit edgedetect.delay_400ns.genblk1\[137\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[138\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_77_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[436\].delay_unit edgedetect.delay_400ns.genblk1\[436\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[437\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_89_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_1.genblk1\[347\].delay_unit clkgen.delay_200ns_1.genblk1\[347\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[348\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[735\].delay_unit edgedetect.delay_400ns.genblk1\[735\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[736\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_45_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[55\].delay_unit edgedetect.delay_400ns.genblk1\[55\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[56\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_68_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[345\].delay_unit clkgen.delay_200ns_3.genblk1\[345\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[346\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_59 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_322 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[379\].delay_unit clkgen.delay_200ns_2.genblk1\[379\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[380\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_400ns.genblk1\[316\].delay_unit edgedetect.delay_400ns.genblk1\[316\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[317\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkgen.delay_200ns_1.genblk1\[227\].delay_unit clkgen.delay_200ns_1.genblk1\[227\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[228\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[615\].delay_unit edgedetect.delay_400ns.genblk1\[615\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[616\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[526\].delay_unit clkgen.delay_200ns_1.genblk1\[526\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[527\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_88_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[914\].delay_unit edgedetect.delay_400ns.genblk1\[914\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[915\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_88_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[1022\].delay_unit edgedetect.delay_400ns.genblk1\[1022\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1023\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[381\].delay_unit clkgen.delay_200ns_2.genblk1\[381\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[382\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_21_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[24\].delay_unit clkgen.delay_200ns_3.genblk1\[24\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[25\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_68_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[225\].delay_unit clkgen.delay_200ns_3.genblk1\[225\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[226\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[26\].delay_unit clkgen.delay_200ns_1.genblk1\[26\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[27\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_24_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[524\].delay_unit clkgen.delay_200ns_3.genblk1\[524\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[525\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_24_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[259\].delay_unit clkgen.delay_200ns_2.genblk1\[259\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[260\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[58\].delay_unit clkgen.delay_200ns_2.genblk1\[58\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[59\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[107\].delay_unit clkgen.delay_200ns_1.genblk1\[107\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[108\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_74_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_1.genblk1\[406\].delay_unit clkgen.delay_200ns_1.genblk1\[406\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[407\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_88_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_2.genblk1\[261\].delay_unit clkgen.delay_200ns_2.genblk1\[261\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[262\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[384\].delay_unit edgedetect.delay_400ns.genblk1\[384\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[385\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_34_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_1.genblk1\[295\].delay_unit clkgen.delay_200ns_1.genblk1\[295\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[296\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[683\].delay_unit edgedetect.delay_400ns.genblk1\[683\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[684\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_61_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_2.genblk1\[60\].delay_unit clkgen.delay_200ns_2.genblk1\[60\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[61\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[982\].delay_unit edgedetect.delay_400ns.genblk1\[982\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[983\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[105\].delay_unit clkgen.delay_200ns_3.genblk1\[105\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[106\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[404\].delay_unit clkgen.delay_200ns_3.genblk1\[404\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[405\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[139\].delay_unit clkgen.delay_200ns_2.genblk1\[139\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[140\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_84_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[438\].delay_unit clkgen.delay_200ns_2.genblk1\[438\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[439\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_37_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_3.genblk1\[92\].delay_unit clkgen.delay_200ns_3.genblk1\[92\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[93\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[293\].delay_unit clkgen.delay_200ns_3.genblk1\[293\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[294\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_79_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_1.genblk1\[94\].delay_unit clkgen.delay_200ns_1.genblk1\[94\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[95\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_75_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[141\].delay_unit clkgen.delay_200ns_2.genblk1\[141\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[142\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[440\].delay_unit clkgen.delay_200ns_2.genblk1\[440\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[441\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[264\].delay_unit edgedetect.delay_400ns.genblk1\[264\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[265\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[175\].delay_unit clkgen.delay_200ns_1.genblk1\[175\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[176\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[563\].delay_unit edgedetect.delay_400ns.genblk1\[563\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[564\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_1.genblk1\[474\].delay_unit clkgen.delay_200ns_1.genblk1\[474\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[475\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[862\].delay_unit edgedetect.delay_400ns.genblk1\[862\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[863\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[318\].delay_unit clkgen.delay_200ns_2.genblk1\[318\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[319\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_3.genblk1\[173\].delay_unit clkgen.delay_200ns_3.genblk1\[173\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[174\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_71_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_3.genblk1\[472\].delay_unit clkgen.delay_200ns_3.genblk1\[472\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[473\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_75_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[320\].delay_unit clkgen.delay_200ns_2.genblk1\[320\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[321\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[144\].delay_unit edgedetect.delay_400ns.genblk1\[144\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[145\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_84_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[443\].delay_unit edgedetect.delay_400ns.genblk1\[443\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[444\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[354\].delay_unit clkgen.delay_200ns_1.genblk1\[354\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[355\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[742\].delay_unit edgedetect.delay_400ns.genblk1\[742\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[743\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[4\].delay_unit clkgen.delay_200ns_1.genblk1\[4\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[5\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[62\].delay_unit edgedetect.delay_400ns.genblk1\[62\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[63\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[919\].delay_unit edgedetect.delay_400ns.genblk1\[919\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[920\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[352\].delay_unit clkgen.delay_200ns_3.genblk1\[352\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[353\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1027\].delay_unit edgedetect.delay_400ns.genblk1\[1027\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1028\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[386\].delay_unit clkgen.delay_200ns_2.genblk1\[386\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[387\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[29\].delay_unit clkgen.delay_200ns_3.genblk1\[29\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[30\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[200\].delay_unit clkgen.delay_200ns_2.genblk1\[200\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[201\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[323\].delay_unit edgedetect.delay_400ns.genblk1\[323\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[324\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[234\].delay_unit clkgen.delay_200ns_1.genblk1\[234\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[235\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[622\].delay_unit edgedetect.delay_400ns.genblk1\[622\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[623\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_63_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[533\].delay_unit clkgen.delay_200ns_1.genblk1\[533\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[534\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[921\].delay_unit edgedetect.delay_400ns.genblk1\[921\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[922\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[529\].delay_unit clkgen.delay_200ns_3.genblk1\[529\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[530\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_31_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[31\].delay_unit clkgen.delay_200ns_3.genblk1\[31\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[32\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[232\].delay_unit clkgen.delay_200ns_3.genblk1\[232\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[233\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[33\].delay_unit clkgen.delay_200ns_1.genblk1\[33\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[34\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_511 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[531\].delay_unit clkgen.delay_200ns_3.genblk1\[531\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[532\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[266\].delay_unit clkgen.delay_200ns_2.genblk1\[266\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[267\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_45_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[389\].delay_unit edgedetect.delay_400ns.genblk1\[389\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[390\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_26_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_223 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[688\].delay_unit edgedetect.delay_400ns.genblk1\[688\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[689\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_13_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[987\].delay_unit edgedetect.delay_400ns.genblk1\[987\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[988\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[65\].delay_unit clkgen.delay_200ns_2.genblk1\[65\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[66\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[203\].delay_unit edgedetect.delay_400ns.genblk1\[203\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[204\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[114\].delay_unit clkgen.delay_200ns_1.genblk1\[114\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[115\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[502\].delay_unit edgedetect.delay_400ns.genblk1\[502\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[503\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[413\].delay_unit clkgen.delay_200ns_1.genblk1\[413\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[414\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[801\].delay_unit edgedetect.delay_400ns.genblk1\[801\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[802\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[409\].delay_unit clkgen.delay_200ns_3.genblk1\[409\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[410\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_83_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[97\].delay_unit clkgen.delay_200ns_3.genblk1\[97\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[98\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[391\].delay_unit edgedetect.delay_400ns.genblk1\[391\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[392\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[690\].delay_unit edgedetect.delay_400ns.genblk1\[690\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[691\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[298\].delay_unit clkgen.delay_200ns_3.genblk1\[298\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[299\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[99\].delay_unit clkgen.delay_200ns_1.genblk1\[99\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[99\].delay_unit/X sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[112\].delay_unit clkgen.delay_200ns_3.genblk1\[112\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[113\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[411\].delay_unit clkgen.delay_200ns_3.genblk1\[411\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[412\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[146\].delay_unit clkgen.delay_200ns_2.genblk1\[146\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[147\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[445\].delay_unit clkgen.delay_200ns_2.genblk1\[445\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[446\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_88_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[269\].delay_unit edgedetect.delay_400ns.genblk1\[269\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[270\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_77_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[568\].delay_unit edgedetect.delay_400ns.genblk1\[568\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[569\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[479\].delay_unit clkgen.delay_200ns_1.genblk1\[479\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[480\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_80_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[867\].delay_unit edgedetect.delay_400ns.genblk1\[867\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[868\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_65_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[271\].delay_unit edgedetect.delay_400ns.genblk1\[271\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[272\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[182\].delay_unit clkgen.delay_200ns_1.genblk1\[182\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[183\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[570\].delay_unit edgedetect.delay_400ns.genblk1\[570\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[571\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[481\].delay_unit clkgen.delay_200ns_1.genblk1\[481\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[482\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[178\].delay_unit clkgen.delay_200ns_3.genblk1\[178\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[179\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[477\].delay_unit clkgen.delay_200ns_3.genblk1\[477\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[478\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_359 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_2.genblk1\[325\].delay_unit clkgen.delay_200ns_2.genblk1\[325\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[326\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[149\].delay_unit edgedetect.delay_400ns.genblk1\[149\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[150\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[448\].delay_unit edgedetect.delay_400ns.genblk1\[448\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[449\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[359\].delay_unit clkgen.delay_200ns_1.genblk1\[359\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[360\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[747\].delay_unit edgedetect.delay_400ns.genblk1\[747\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[748\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_3.genblk1\[180\].delay_unit clkgen.delay_200ns_3.genblk1\[180\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[181\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[9\].delay_unit clkgen.delay_200ns_1.genblk1\[9\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[9\].delay_unit/X sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[67\].delay_unit edgedetect.delay_400ns.genblk1\[67\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[68\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[151\].delay_unit edgedetect.delay_400ns.genblk1\[151\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[152\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[450\].delay_unit edgedetect.delay_400ns.genblk1\[450\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[451\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_84_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[361\].delay_unit clkgen.delay_200ns_1.genblk1\[361\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[362\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[357\].delay_unit clkgen.delay_200ns_3.genblk1\[357\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[358\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_12_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[205\].delay_unit clkgen.delay_200ns_2.genblk1\[205\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[206\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_87_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[504\].delay_unit clkgen.delay_200ns_2.genblk1\[504\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[505\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_35_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_400ns.genblk1\[328\].delay_unit edgedetect.delay_400ns.genblk1\[328\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[329\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[239\].delay_unit clkgen.delay_200ns_1.genblk1\[239\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[240\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[627\].delay_unit edgedetect.delay_400ns.genblk1\[627\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[628\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[538\].delay_unit clkgen.delay_200ns_1.genblk1\[538\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[539\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_70_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[926\].delay_unit edgedetect.delay_400ns.genblk1\[926\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[927\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1034\].delay_unit edgedetect.delay_400ns.genblk1\[1034\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1035\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_2.genblk1\[393\].delay_unit clkgen.delay_200ns_2.genblk1\[393\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[394\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkgen.delay_200ns_3.genblk1\[36\].delay_unit clkgen.delay_200ns_3.genblk1\[36\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[37\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_61_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[330\].delay_unit edgedetect.delay_400ns.genblk1\[330\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[331\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[241\].delay_unit clkgen.delay_200ns_1.genblk1\[241\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[242\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[540\].delay_unit clkgen.delay_200ns_1.genblk1\[540\].delay_unit/A
+ VGND VGND VPWR VPWR _1_/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[237\].delay_unit clkgen.delay_200ns_3.genblk1\[237\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[238\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[536\].delay_unit clkgen.delay_200ns_3.genblk1\[536\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[537\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[38\].delay_unit clkgen.delay_200ns_1.genblk1\[38\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[39\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_76_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[208\].delay_unit edgedetect.delay_400ns.genblk1\[208\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[209\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[119\].delay_unit clkgen.delay_200ns_1.genblk1\[119\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[120\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[507\].delay_unit edgedetect.delay_400ns.genblk1\[507\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[508\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[418\].delay_unit clkgen.delay_200ns_1.genblk1\[418\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[419\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_67_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[806\].delay_unit edgedetect.delay_400ns.genblk1\[806\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[807\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[40\].delay_unit clkgen.delay_200ns_1.genblk1\[40\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[41\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_43_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[273\].delay_unit clkgen.delay_200ns_2.genblk1\[273\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[274\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[396\].delay_unit edgedetect.delay_400ns.genblk1\[396\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[397\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[695\].delay_unit edgedetect.delay_400ns.genblk1\[695\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[696\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[72\].delay_unit clkgen.delay_200ns_2.genblk1\[72\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[73\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[994\].delay_unit edgedetect.delay_400ns.genblk1\[994\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[995\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[210\].delay_unit edgedetect.delay_400ns.genblk1\[210\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[211\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_66_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_1.genblk1\[121\].delay_unit clkgen.delay_200ns_1.genblk1\[121\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[122\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[420\].delay_unit clkgen.delay_200ns_1.genblk1\[420\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[421\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_34_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[117\].delay_unit clkgen.delay_200ns_3.genblk1\[117\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[118\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[416\].delay_unit clkgen.delay_200ns_3.genblk1\[416\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[417\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[153\].delay_unit clkgen.delay_200ns_2.genblk1\[153\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[154\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[452\].delay_unit clkgen.delay_200ns_2.genblk1\[452\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[453\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_51_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[276\].delay_unit edgedetect.delay_400ns.genblk1\[276\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[277\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_51_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[187\].delay_unit clkgen.delay_200ns_1.genblk1\[187\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[188\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_31_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[575\].delay_unit edgedetect.delay_400ns.genblk1\[575\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[576\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[486\].delay_unit clkgen.delay_200ns_1.genblk1\[486\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[487\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[874\].delay_unit edgedetect.delay_400ns.genblk1\[874\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[875\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[300\].delay_unit clkgen.delay_200ns_1.genblk1\[300\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[301\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[185\].delay_unit clkgen.delay_200ns_3.genblk1\[185\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[186\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[484\].delay_unit clkgen.delay_200ns_3.genblk1\[484\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[485\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_45_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[332\].delay_unit clkgen.delay_200ns_2.genblk1\[332\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[333\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[156\].delay_unit edgedetect.delay_400ns.genblk1\[156\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[157\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_68_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[455\].delay_unit edgedetect.delay_400ns.genblk1\[455\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[456\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[366\].delay_unit clkgen.delay_200ns_1.genblk1\[366\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[367\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[754\].delay_unit edgedetect.delay_400ns.genblk1\[754\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[755\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_51_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[74\].delay_unit edgedetect.delay_400ns.genblk1\[74\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[75\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[509\].delay_unit clkgen.delay_200ns_2.genblk1\[509\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[510\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_27_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_290 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[364\].delay_unit clkgen.delay_200ns_3.genblk1\[364\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[365\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1039\].delay_unit edgedetect.delay_400ns.genblk1\[1039\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1040\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[398\].delay_unit clkgen.delay_200ns_2.genblk1\[398\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[399\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[212\].delay_unit clkgen.delay_200ns_2.genblk1\[212\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[213\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_53_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[511\].delay_unit clkgen.delay_200ns_2.genblk1\[511\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[512\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[335\].delay_unit edgedetect.delay_400ns.genblk1\[335\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[336\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[246\].delay_unit clkgen.delay_200ns_1.genblk1\[246\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[247\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_88_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[634\].delay_unit edgedetect.delay_400ns.genblk1\[634\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[635\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_68_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[11\].delay_unit clkgen.delay_200ns_2.genblk1\[11\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[12\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[933\].delay_unit edgedetect.delay_400ns.genblk1\[933\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[934\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_83_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[1041\].delay_unit edgedetect.delay_400ns.genblk1\[1041\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1042\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_12_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[43\].delay_unit clkgen.delay_200ns_3.genblk1\[43\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[44\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_87_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[244\].delay_unit clkgen.delay_200ns_3.genblk1\[244\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[245\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_70_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_1.genblk1\[45\].delay_unit clkgen.delay_200ns_1.genblk1\[45\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[46\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[278\].delay_unit clkgen.delay_200ns_2.genblk1\[278\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[279\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[215\].delay_unit edgedetect.delay_400ns.genblk1\[215\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[216\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[77\].delay_unit clkgen.delay_200ns_2.genblk1\[77\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[78\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[999\].delay_unit edgedetect.delay_400ns.genblk1\[999\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[999\].delay_unit/X sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[126\].delay_unit clkgen.delay_200ns_1.genblk1\[126\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[127\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[514\].delay_unit edgedetect.delay_400ns.genblk1\[514\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[515\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_61_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[425\].delay_unit clkgen.delay_200ns_1.genblk1\[425\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[426\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[813\].delay_unit edgedetect.delay_400ns.genblk1\[813\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[814\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[280\].delay_unit clkgen.delay_200ns_2.genblk1\[280\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[281\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_56_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_374 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[124\].delay_unit clkgen.delay_200ns_3.genblk1\[124\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[125\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[423\].delay_unit clkgen.delay_200ns_3.genblk1\[423\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[424\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[158\].delay_unit clkgen.delay_200ns_2.genblk1\[158\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[159\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[457\].delay_unit clkgen.delay_200ns_2.genblk1\[457\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[458\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_31_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[879\].delay_unit edgedetect.delay_400ns.genblk1\[879\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[880\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[305\].delay_unit clkgen.delay_200ns_1.genblk1\[305\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[306\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_38_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_374 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[160\].delay_unit clkgen.delay_200ns_2.genblk1\[160\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[161\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[283\].delay_unit edgedetect.delay_400ns.genblk1\[283\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[284\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[13\].delay_unit edgedetect.delay_400ns.genblk1\[13\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[14\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[194\].delay_unit clkgen.delay_200ns_1.genblk1\[194\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[195\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[582\].delay_unit edgedetect.delay_400ns.genblk1\[582\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[583\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_17_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_1.genblk1\[493\].delay_unit clkgen.delay_200ns_1.genblk1\[493\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[494\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[881\].delay_unit edgedetect.delay_400ns.genblk1\[881\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[882\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_55_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[489\].delay_unit clkgen.delay_200ns_3.genblk1\[489\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[490\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_72_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[303\].delay_unit clkgen.delay_200ns_3.genblk1\[303\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[304\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[337\].delay_unit clkgen.delay_200ns_2.genblk1\[337\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[338\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[759\].delay_unit edgedetect.delay_400ns.genblk1\[759\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[760\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[192\].delay_unit clkgen.delay_200ns_3.genblk1\[192\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[193\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[491\].delay_unit clkgen.delay_200ns_3.genblk1\[491\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[492\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[79\].delay_unit edgedetect.delay_400ns.genblk1\[79\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[80\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[163\].delay_unit edgedetect.delay_400ns.genblk1\[163\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[164\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_10_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[462\].delay_unit edgedetect.delay_400ns.genblk1\[462\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[463\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[373\].delay_unit clkgen.delay_200ns_1.genblk1\[373\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[374\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[761\].delay_unit edgedetect.delay_400ns.genblk1\[761\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[762\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_89_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_3.genblk1\[369\].delay_unit clkgen.delay_200ns_3.genblk1\[369\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[370\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[217\].delay_unit clkgen.delay_200ns_2.genblk1\[217\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[218\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[81\].delay_unit edgedetect.delay_400ns.genblk1\[81\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[82\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_2.genblk1\[516\].delay_unit clkgen.delay_200ns_2.genblk1\[516\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[517\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_31_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[639\].delay_unit edgedetect.delay_400ns.genblk1\[639\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[640\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[938\].delay_unit edgedetect.delay_400ns.genblk1\[938\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[939\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[16\].delay_unit clkgen.delay_200ns_2.genblk1\[16\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[17\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1046\].delay_unit edgedetect.delay_400ns.genblk1\[1046\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1047\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_36_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[371\].delay_unit clkgen.delay_200ns_3.genblk1\[371\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[372\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_23_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[48\].delay_unit clkgen.delay_200ns_3.genblk1\[48\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[49\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_86_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[342\].delay_unit edgedetect.delay_400ns.genblk1\[342\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[343\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_27_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[253\].delay_unit clkgen.delay_200ns_1.genblk1\[253\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[254\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_14_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[641\].delay_unit edgedetect.delay_400ns.genblk1\[641\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[642\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[249\].delay_unit clkgen.delay_200ns_3.genblk1\[249\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[250\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[940\].delay_unit edgedetect.delay_400ns.genblk1\[940\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[941\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[50\].delay_unit clkgen.delay_200ns_3.genblk1\[50\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[51\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_60_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[519\].delay_unit edgedetect.delay_400ns.genblk1\[519\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[520\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[818\].delay_unit edgedetect.delay_400ns.genblk1\[818\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[819\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_5_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[251\].delay_unit clkgen.delay_200ns_3.genblk1\[251\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[252\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_1.genblk1\[52\].delay_unit clkgen.delay_200ns_1.genblk1\[52\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[53\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_83_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_2.genblk1\[285\].delay_unit clkgen.delay_200ns_2.genblk1\[285\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[286\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_36_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_2.genblk1\[84\].delay_unit clkgen.delay_200ns_2.genblk1\[84\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[85\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[222\].delay_unit edgedetect.delay_400ns.genblk1\[222\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[223\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[133\].delay_unit clkgen.delay_200ns_1.genblk1\[133\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[134\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[521\].delay_unit edgedetect.delay_400ns.genblk1\[521\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[522\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_86_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_1.genblk1\[432\].delay_unit clkgen.delay_200ns_1.genblk1\[432\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[433\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[129\].delay_unit clkgen.delay_200ns_3.genblk1\[129\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[130\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_86_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[820\].delay_unit edgedetect.delay_400ns.genblk1\[820\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[821\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_67_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[428\].delay_unit clkgen.delay_200ns_3.genblk1\[428\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[429\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_70_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[131\].delay_unit clkgen.delay_200ns_3.genblk1\[131\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[132\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[430\].delay_unit clkgen.delay_200ns_3.genblk1\[430\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[431\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_52_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[165\].delay_unit clkgen.delay_200ns_2.genblk1\[165\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[166\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[464\].delay_unit clkgen.delay_200ns_2.genblk1\[464\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[465\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[288\].delay_unit edgedetect.delay_400ns.genblk1\[288\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[289\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_83_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkgen.delay_200ns_1.genblk1\[199\].delay_unit clkgen.delay_200ns_1.genblk1\[199\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[200\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_68_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[18\].delay_unit edgedetect.delay_400ns.genblk1\[18\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[19\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_83_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[587\].delay_unit edgedetect.delay_400ns.genblk1\[587\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[588\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[498\].delay_unit clkgen.delay_200ns_1.genblk1\[498\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[499\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[886\].delay_unit edgedetect.delay_400ns.genblk1\[886\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[887\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[102\].delay_unit edgedetect.delay_400ns.genblk1\[102\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[103\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_33_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[401\].delay_unit edgedetect.delay_400ns.genblk1\[401\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[402\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_1.genblk1\[312\].delay_unit clkgen.delay_200ns_1.genblk1\[312\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[313\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[700\].delay_unit edgedetect.delay_400ns.genblk1\[700\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[701\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[308\].delay_unit clkgen.delay_200ns_3.genblk1\[308\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[309\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[290\].delay_unit edgedetect.delay_400ns.genblk1\[290\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[291\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[20\].delay_unit edgedetect.delay_400ns.genblk1\[20\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[21\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_7_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[197\].delay_unit clkgen.delay_200ns_3.genblk1\[197\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[198\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[496\].delay_unit clkgen.delay_200ns_3.genblk1\[496\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[497\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[310\].delay_unit clkgen.delay_200ns_3.genblk1\[310\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[311\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_65_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[344\].delay_unit clkgen.delay_200ns_2.genblk1\[344\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[345\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[168\].delay_unit edgedetect.delay_400ns.genblk1\[168\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[169\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[467\].delay_unit edgedetect.delay_400ns.genblk1\[467\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[468\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[378\].delay_unit clkgen.delay_200ns_1.genblk1\[378\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[379\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[766\].delay_unit edgedetect.delay_400ns.genblk1\[766\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[767\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_84_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_206 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[2\].delay_unit clkgen.delay_200ns_3.genblk1\[2\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[3\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_60_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[86\].delay_unit edgedetect.delay_400ns.genblk1\[86\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[87\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_69_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[170\].delay_unit edgedetect.delay_400ns.genblk1\[170\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[171\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_1.genblk1\[380\].delay_unit clkgen.delay_200ns_1.genblk1\[380\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[381\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_55_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[376\].delay_unit clkgen.delay_200ns_3.genblk1\[376\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[377\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[224\].delay_unit clkgen.delay_200ns_2.genblk1\[224\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[225\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_38_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[523\].delay_unit clkgen.delay_200ns_2.genblk1\[523\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[524\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_19_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[347\].delay_unit edgedetect.delay_400ns.genblk1\[347\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[348\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_34_386 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[258\].delay_unit clkgen.delay_200ns_1.genblk1\[258\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[259\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_61_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[646\].delay_unit edgedetect.delay_400ns.genblk1\[646\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[647\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[23\].delay_unit clkgen.delay_200ns_2.genblk1\[23\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[24\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_30_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[945\].delay_unit edgedetect.delay_400ns.genblk1\[945\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[946\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1053\].delay_unit edgedetect.delay_400ns.genblk1\[1053\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1054\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_69_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[55\].delay_unit clkgen.delay_200ns_3.genblk1\[55\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[56\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_71_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_1.genblk1\[260\].delay_unit clkgen.delay_200ns_1.genblk1\[260\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[261\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[256\].delay_unit clkgen.delay_200ns_3.genblk1\[256\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[257\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[57\].delay_unit clkgen.delay_200ns_1.genblk1\[57\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[58\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[104\].delay_unit clkgen.delay_200ns_2.genblk1\[104\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[105\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[403\].delay_unit clkgen.delay_200ns_2.genblk1\[403\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[404\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[227\].delay_unit edgedetect.delay_400ns.genblk1\[227\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[228\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_2.genblk1\[89\].delay_unit clkgen.delay_200ns_2.genblk1\[89\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[90\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[138\].delay_unit clkgen.delay_200ns_1.genblk1\[138\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[139\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[526\].delay_unit edgedetect.delay_400ns.genblk1\[526\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[527\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[437\].delay_unit clkgen.delay_200ns_1.genblk1\[437\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[438\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_66_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[825\].delay_unit edgedetect.delay_400ns.genblk1\[825\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[826\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XPHY_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[292\].delay_unit clkgen.delay_200ns_2.genblk1\[292\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[293\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_89_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[91\].delay_unit clkgen.delay_200ns_2.genblk1\[91\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[92\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[140\].delay_unit clkgen.delay_200ns_1.genblk1\[140\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[141\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_25_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_3.genblk1\[136\].delay_unit clkgen.delay_200ns_3.genblk1\[136\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[137\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[435\].delay_unit clkgen.delay_200ns_3.genblk1\[435\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[436\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[469\].delay_unit clkgen.delay_200ns_2.genblk1\[469\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[470\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_150 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[107\].delay_unit edgedetect.delay_400ns.genblk1\[107\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[108\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[406\].delay_unit edgedetect.delay_400ns.genblk1\[406\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[407\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[317\].delay_unit clkgen.delay_200ns_1.genblk1\[317\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[318\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[705\].delay_unit edgedetect.delay_400ns.genblk1\[705\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[706\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_86_348 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[172\].delay_unit clkgen.delay_200ns_2.genblk1\[172\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[173\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[471\].delay_unit clkgen.delay_200ns_2.genblk1\[471\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[472\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[295\].delay_unit edgedetect.delay_400ns.genblk1\[295\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[296\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[25\].delay_unit edgedetect.delay_400ns.genblk1\[25\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[26\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[594\].delay_unit edgedetect.delay_400ns.genblk1\[594\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[595\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[893\].delay_unit edgedetect.delay_400ns.genblk1\[893\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[894\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_89_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[315\].delay_unit clkgen.delay_200ns_3.genblk1\[315\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[316\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_41_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[349\].delay_unit clkgen.delay_200ns_2.genblk1\[349\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[350\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_36_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[7\].delay_unit clkgen.delay_200ns_3.genblk1\[7\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[8\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[351\].delay_unit clkgen.delay_200ns_2.genblk1\[351\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[352\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_59_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[175\].delay_unit edgedetect.delay_400ns.genblk1\[175\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[176\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_82_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[474\].delay_unit edgedetect.delay_400ns.genblk1\[474\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[475\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[385\].delay_unit clkgen.delay_200ns_1.genblk1\[385\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[386\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[773\].delay_unit edgedetect.delay_400ns.genblk1\[773\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[774\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_23_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_344 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[229\].delay_unit clkgen.delay_200ns_2.genblk1\[229\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[230\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_37_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[93\].delay_unit edgedetect.delay_400ns.genblk1\[93\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[94\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[528\].delay_unit clkgen.delay_200ns_2.genblk1\[528\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[529\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_41_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[28\].delay_unit clkgen.delay_200ns_2.genblk1\[28\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[29\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1058\].delay_unit edgedetect.delay_400ns.genblk1\[1058\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1059\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_45_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[383\].delay_unit clkgen.delay_200ns_3.genblk1\[383\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[384\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_68_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_318 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_292 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[231\].delay_unit clkgen.delay_200ns_2.genblk1\[231\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[232\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[530\].delay_unit clkgen.delay_200ns_2.genblk1\[530\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[531\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[354\].delay_unit edgedetect.delay_400ns.genblk1\[354\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[355\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_58_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[265\].delay_unit clkgen.delay_200ns_1.genblk1\[265\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[266\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[653\].delay_unit edgedetect.delay_400ns.genblk1\[653\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[654\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_47_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[952\].delay_unit edgedetect.delay_400ns.genblk1\[952\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[953\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[30\].delay_unit clkgen.delay_200ns_2.genblk1\[30\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[31\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_82_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[1060\].delay_unit edgedetect.delay_400ns.genblk1\[1060\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1061\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_70_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[109\].delay_unit clkgen.delay_200ns_2.genblk1\[109\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[110\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[408\].delay_unit clkgen.delay_200ns_2.genblk1\[408\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[409\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[62\].delay_unit clkgen.delay_200ns_3.genblk1\[62\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[63\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_38_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_292 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[263\].delay_unit clkgen.delay_200ns_3.genblk1\[263\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[264\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[64\].delay_unit clkgen.delay_200ns_1.genblk1\[64\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[65\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[297\].delay_unit clkgen.delay_200ns_2.genblk1\[297\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[298\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_84_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[111\].delay_unit clkgen.delay_200ns_2.genblk1\[111\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[112\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[410\].delay_unit clkgen.delay_200ns_2.genblk1\[410\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[411\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_52_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_218 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[234\].delay_unit edgedetect.delay_400ns.genblk1\[234\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[235\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[96\].delay_unit clkgen.delay_200ns_2.genblk1\[96\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[97\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[145\].delay_unit clkgen.delay_200ns_1.genblk1\[145\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[146\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_60_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[533\].delay_unit edgedetect.delay_400ns.genblk1\[533\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[534\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[444\].delay_unit clkgen.delay_200ns_1.genblk1\[444\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[445\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[832\].delay_unit edgedetect.delay_400ns.genblk1\[832\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[833\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_79_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_3.genblk1\[143\].delay_unit clkgen.delay_200ns_3.genblk1\[143\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[144\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[442\].delay_unit clkgen.delay_200ns_3.genblk1\[442\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[443\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_46_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[177\].delay_unit clkgen.delay_200ns_2.genblk1\[177\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[178\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_34_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkgen.delay_200ns_2.genblk1\[476\].delay_unit clkgen.delay_200ns_2.genblk1\[476\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[477\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_89_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[599\].delay_unit edgedetect.delay_400ns.genblk1\[599\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[600\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xedgedetect.delay_400ns.genblk1\[898\].delay_unit edgedetect.delay_400ns.genblk1\[898\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[899\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[114\].delay_unit edgedetect.delay_400ns.genblk1\[114\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[115\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_57_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[413\].delay_unit edgedetect.delay_400ns.genblk1\[413\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[414\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[324\].delay_unit clkgen.delay_200ns_1.genblk1\[324\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[325\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[712\].delay_unit edgedetect.delay_400ns.genblk1\[712\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[713\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_37_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[32\].delay_unit edgedetect.delay_400ns.genblk1\[32\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[33\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_48_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_3.genblk1\[322\].delay_unit clkgen.delay_200ns_3.genblk1\[322\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[323\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkgen.delay_200ns_2.genblk1\[356\].delay_unit clkgen.delay_200ns_2.genblk1\[356\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[357\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_66_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[479\].delay_unit edgedetect.delay_400ns.genblk1\[479\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[480\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[778\].delay_unit edgedetect.delay_400ns.genblk1\[778\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[779\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_41_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_1.genblk1\[204\].delay_unit clkgen.delay_200ns_1.genblk1\[204\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[205\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[503\].delay_unit clkgen.delay_200ns_1.genblk1\[503\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[504\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[98\].delay_unit edgedetect.delay_400ns.genblk1\[98\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[99\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_53_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_379 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[182\].delay_unit edgedetect.delay_400ns.genblk1\[182\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[183\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_31_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[481\].delay_unit edgedetect.delay_400ns.genblk1\[481\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[482\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[392\].delay_unit clkgen.delay_200ns_1.genblk1\[392\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[393\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[780\].delay_unit edgedetect.delay_400ns.genblk1\[780\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[781\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[388\].delay_unit clkgen.delay_200ns_3.genblk1\[388\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[389\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_36_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[202\].delay_unit clkgen.delay_200ns_3.genblk1\[202\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[203\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_16_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_3.genblk1\[501\].delay_unit clkgen.delay_200ns_3.genblk1\[501\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[502\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_8_350 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[236\].delay_unit clkgen.delay_200ns_2.genblk1\[236\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[237\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[535\].delay_unit clkgen.delay_200ns_2.genblk1\[535\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[536\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[359\].delay_unit edgedetect.delay_400ns.genblk1\[359\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[360\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[658\].delay_unit edgedetect.delay_400ns.genblk1\[658\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[659\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_39_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[35\].delay_unit clkgen.delay_200ns_2.genblk1\[35\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[36\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[957\].delay_unit edgedetect.delay_400ns.genblk1\[957\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[958\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_42_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[1065\].delay_unit edgedetect.delay_400ns.genblk1\[1065\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1066\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_22_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[390\].delay_unit clkgen.delay_200ns_3.genblk1\[390\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[391\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_6_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[67\].delay_unit clkgen.delay_200ns_3.genblk1\[67\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[68\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_41_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[361\].delay_unit edgedetect.delay_400ns.genblk1\[361\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[362\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[272\].delay_unit clkgen.delay_200ns_1.genblk1\[272\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[273\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[660\].delay_unit edgedetect.delay_400ns.genblk1\[660\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[661\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_9_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_3.genblk1\[268\].delay_unit clkgen.delay_200ns_3.genblk1\[268\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[269\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[69\].delay_unit clkgen.delay_200ns_1.genblk1\[69\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[70\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_3_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[116\].delay_unit clkgen.delay_200ns_2.genblk1\[116\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[117\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_36_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[415\].delay_unit clkgen.delay_200ns_2.genblk1\[415\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[416\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[239\].delay_unit edgedetect.delay_400ns.genblk1\[239\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[240\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[538\].delay_unit edgedetect.delay_400ns.genblk1\[538\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[539\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[449\].delay_unit clkgen.delay_200ns_1.genblk1\[449\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[450\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[837\].delay_unit edgedetect.delay_400ns.genblk1\[837\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[838\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[270\].delay_unit clkgen.delay_200ns_3.genblk1\[270\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[271\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_86_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[71\].delay_unit clkgen.delay_200ns_1.genblk1\[71\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[72\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_82_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xedgedetect.delay_400ns.genblk1\[241\].delay_unit edgedetect.delay_400ns.genblk1\[241\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[242\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_2_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[152\].delay_unit clkgen.delay_200ns_1.genblk1\[152\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[153\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[540\].delay_unit edgedetect.delay_400ns.genblk1\[540\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[541\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[451\].delay_unit clkgen.delay_200ns_1.genblk1\[451\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[452\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[148\].delay_unit clkgen.delay_200ns_3.genblk1\[148\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[149\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_61_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[447\].delay_unit clkgen.delay_200ns_3.genblk1\[447\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[448\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_41_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[119\].delay_unit edgedetect.delay_400ns.genblk1\[119\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[120\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_49_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[418\].delay_unit edgedetect.delay_400ns.genblk1\[418\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[419\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_64_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[329\].delay_unit clkgen.delay_200ns_1.genblk1\[329\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[330\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[717\].delay_unit edgedetect.delay_400ns.genblk1\[717\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[718\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[1\].delay_unit start_conv VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[2\].delay_unit/A
+ sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[150\].delay_unit clkgen.delay_200ns_3.genblk1\[150\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[151\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[184\].delay_unit clkgen.delay_200ns_2.genblk1\[184\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[185\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_58_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[483\].delay_unit clkgen.delay_200ns_2.genblk1\[483\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[484\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[37\].delay_unit edgedetect.delay_400ns.genblk1\[37\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[38\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_55_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[121\].delay_unit edgedetect.delay_400ns.genblk1\[121\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[122\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_488 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xedgedetect.delay_400ns.genblk1\[420\].delay_unit edgedetect.delay_400ns.genblk1\[420\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[421\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[331\].delay_unit clkgen.delay_200ns_1.genblk1\[331\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[332\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[327\].delay_unit clkgen.delay_200ns_3.genblk1\[327\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[328\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_78_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_374 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_322 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[209\].delay_unit clkgen.delay_200ns_1.genblk1\[209\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[210\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[508\].delay_unit clkgen.delay_200ns_1.genblk1\[508\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[509\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_84_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[1004\].delay_unit edgedetect.delay_400ns.genblk1\[1004\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1005\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_44_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_2.genblk1\[1\].delay_unit clk_dig VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[2\].delay_unit/A
+ sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_20_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[363\].delay_unit clkgen.delay_200ns_2.genblk1\[363\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[364\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_69_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[187\].delay_unit edgedetect.delay_400ns.genblk1\[187\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[188\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[486\].delay_unit edgedetect.delay_400ns.genblk1\[486\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[487\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_87_241 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[397\].delay_unit clkgen.delay_200ns_1.genblk1\[397\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[398\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[785\].delay_unit edgedetect.delay_400ns.genblk1\[785\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[786\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_85_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[300\].delay_unit edgedetect.delay_400ns.genblk1\[300\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[301\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_1.genblk1\[211\].delay_unit clkgen.delay_200ns_1.genblk1\[211\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[212\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_43_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_3.genblk1\[207\].delay_unit clkgen.delay_200ns_3.genblk1\[207\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[208\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[510\].delay_unit clkgen.delay_200ns_1.genblk1\[510\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[511\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[506\].delay_unit clkgen.delay_200ns_3.genblk1\[506\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[507\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_11_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[395\].delay_unit clkgen.delay_200ns_3.genblk1\[395\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[396\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_89_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_1.genblk1\[10\].delay_unit clkgen.delay_200ns_1.genblk1\[9\].delay_unit/X
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[11\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_69_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[243\].delay_unit clkgen.delay_200ns_2.genblk1\[243\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[244\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_52_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xedgedetect.delay_400ns.genblk1\[366\].delay_unit edgedetect.delay_400ns.genblk1\[366\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[367\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[277\].delay_unit clkgen.delay_200ns_1.genblk1\[277\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[278\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[665\].delay_unit edgedetect.delay_400ns.genblk1\[665\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[666\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_4_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[964\].delay_unit edgedetect.delay_400ns.genblk1\[964\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[965\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_2.genblk1\[42\].delay_unit clkgen.delay_200ns_2.genblk1\[42\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[43\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_0_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[1072\].delay_unit edgedetect.delay_400ns.genblk1\[1072\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[1073\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_29_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[74\].delay_unit clkgen.delay_200ns_3.genblk1\[74\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[75\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_61_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_3.genblk1\[275\].delay_unit clkgen.delay_200ns_3.genblk1\[275\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[276\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_66_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkgen.delay_200ns_1.genblk1\[76\].delay_unit clkgen.delay_200ns_1.genblk1\[76\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[77\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_34_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkgen.delay_200ns_2.genblk1\[123\].delay_unit clkgen.delay_200ns_2.genblk1\[123\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[124\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_1_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkgen.delay_200ns_2.genblk1\[422\].delay_unit clkgen.delay_200ns_2.genblk1\[422\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_2.genblk1\[423\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XTAP_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xedgedetect.delay_400ns.genblk1\[246\].delay_unit edgedetect.delay_400ns.genblk1\[246\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[247\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[157\].delay_unit clkgen.delay_200ns_1.genblk1\[157\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[158\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_45_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xedgedetect.delay_400ns.genblk1\[545\].delay_unit edgedetect.delay_400ns.genblk1\[545\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[546\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_1.genblk1\[456\].delay_unit clkgen.delay_200ns_1.genblk1\[456\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_1.genblk1\[457\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_15_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xedgedetect.delay_400ns.genblk1\[844\].delay_unit edgedetect.delay_400ns.genblk1\[844\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[845\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
XFILLER_40_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkgen.delay_200ns_3.genblk1\[155\].delay_unit clkgen.delay_200ns_3.genblk1\[155\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[156\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xedgedetect.delay_400ns.genblk1\[6\].delay_unit edgedetect.delay_400ns.genblk1\[6\].delay_unit/A
+ VGND VGND VPWR VPWR edgedetect.delay_400ns.genblk1\[7\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
Xclkgen.delay_200ns_3.genblk1\[454\].delay_unit clkgen.delay_200ns_3.genblk1\[454\].delay_unit/A
+ VGND VGND VPWR VPWR clkgen.delay_200ns_3.genblk1\[455\].delay_unit/A sky130_fd_sc_hd__clkdlybuf4s50_2
.ends
